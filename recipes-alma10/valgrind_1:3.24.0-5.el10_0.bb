# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "valgrind"
PE = "1"
PV = "3.24.0"
PR = "5.el10_0"
PACKAGES = "valgrind valgrind-devel"
PROVIDES = "rpm/valgrind rpm/valgrind-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/valgrind-3.24.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d608c309be64d7802d45a306de2b8869fc9adaa256fe3689e82bfd819cca919"

URI_valgrind = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/valgrind-3.24.0-5.el10_0.x86_64_v2.rpm;name=valgrind;unpack=0"
SRC_URI += "${URI_valgrind}"
SRC_URI[valgrind.sha256sum] = "c86c9142ff29aafe7d2ee26932e00ae465b2e03266cfaebed15110cb4f31154b"
RDEPENDS:valgrind = " \
 glibc \
 perl-interpreter \
 libgcc \
 python3 \
"

URI_valgrind-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/valgrind-devel-3.24.0-5.el10_0.x86_64_v2.rpm;name=valgrind-devel;unpack=0"
SRC_URI += "${URI_valgrind-devel}"
SRC_URI[valgrind-devel.sha256sum] = "1e6a820565967da01197f7da67f7e5cc93e8366a1907803e9a4fec093e3b22d2"
RDEPENDS:valgrind-devel = " \
 valgrind \
 pkgconf-pkg-config \
"
