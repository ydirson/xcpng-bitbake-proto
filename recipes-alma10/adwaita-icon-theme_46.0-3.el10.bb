# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "adwaita-icon-theme"
PE = "0"
PV = "46.0"
PR = "3.el10"
PACKAGES = "adwaita-cursor-theme adwaita-icon-theme adwaita-icon-theme-devel"
PROVIDES = "rpm/adwaita-cursor-theme rpm/adwaita-icon-theme rpm/adwaita-icon-theme-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/adwaita-icon-theme-46.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43bd13a54305a57347cbca0f4537d4eee99eb6a98e23287ff0df81097cd53658"

URI_adwaita-cursor-theme = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/adwaita-cursor-theme-46.0-3.el10.noarch.rpm;name=adwaita-cursor-theme;unpack=0"
SRC_URI += "${URI_adwaita-cursor-theme}"
SRC_URI[adwaita-cursor-theme.sha256sum] = "7e25f6824df6fa6ea7b6089ff13f1ccd7ef3144e5468597999f80660e06960cf"
RDEPENDS:adwaita-cursor-theme = ""

URI_adwaita-icon-theme = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/adwaita-icon-theme-46.0-3.el10.noarch.rpm;name=adwaita-icon-theme;unpack=0"
SRC_URI += "${URI_adwaita-icon-theme}"
SRC_URI[adwaita-icon-theme.sha256sum] = "dd6f404c3762d257d5135e85e4f9dfcbd33fa9d35c276e1a62b84b0abbf40cb9"
RDEPENDS:adwaita-icon-theme = " \
 bash \
 adwaita-cursor-theme \
"

URI_adwaita-icon-theme-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/adwaita-icon-theme-devel-46.0-3.el10.noarch.rpm;name=adwaita-icon-theme-devel;unpack=0"
SRC_URI += "${URI_adwaita-icon-theme-devel}"
SRC_URI[adwaita-icon-theme-devel.sha256sum] = "e9551ba09e1a98117e1dcc9156b5f4b6bfc850f7dcd9419e904360a02635d3d2"
RDEPENDS:adwaita-icon-theme-devel = " \
 adwaita-icon-theme \
 pkgconf-pkg-config \
"
