# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "moditect"
PE = "0"
PV = "1.1.0"
PR = "4.el10"
PACKAGES = "moditect moditect-javadoc"
PROVIDES = "rpm/moditect rpm/moditect-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/moditect-1.1.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e74cb12556798fa1e1a2ed66f45866bebcba77368237e998480e2cb54d24fac1"

URI_moditect = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/moditect-1.1.0-4.el10.noarch.rpm;name=moditect;unpack=0"
SRC_URI += "${URI_moditect}"
SRC_URI[moditect.sha256sum] = "e6caf046afc56582d350673601a1592bc9fd9c15d3044d7fa91ed6a705afafba"
RDEPENDS:moditect = " \
 objectweb-asm \
 javapackages-filesystem \
 javaparser \
 beust-jcommander \
 maven-resolver \
"

URI_moditect-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/moditect-javadoc-1.1.0-4.el10.noarch.rpm;name=moditect-javadoc;unpack=0"
SRC_URI += "${URI_moditect-javadoc}"
SRC_URI[moditect-javadoc.sha256sum] = "041340388694b31e5a56e2e6279311c177ba98ef58809a5a68b54f7e506bef25"
RDEPENDS:moditect-javadoc = " \
 javapackages-filesystem \
"
