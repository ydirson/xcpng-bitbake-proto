# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "maven-shade-plugin"
PE = "0"
PV = "3.5.1"
PR = "4.el10"
PACKAGES = "maven-shade-plugin maven-shade-plugin-javadoc"
PROVIDES = "rpm/maven-shade-plugin rpm/maven-shade-plugin-javadoc"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/maven-shade-plugin-3.5.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91d0284a1b67dc09cec2b908ebc4d9d2f48eca4062c82f27a7f7a5e3ff07a752"

URI_maven-shade-plugin = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/maven-shade-plugin-3.5.1-4.el10.noarch.rpm;name=maven-shade-plugin;unpack=0"
SRC_URI += "${URI_maven-shade-plugin}"
SRC_URI[maven-shade-plugin.sha256sum] = "41fd17a4a0643c6402a24c6270d52f0b51711662ac49853ef59c6c14490205da"
RDEPENDS:maven-shade-plugin = " \
 jdom2 \
 objectweb-asm \
 apache-commons-io \
 plexus-utils \
 javapackages-filesystem \
 apache-commons-collections4 \
 slf4j \
 maven-dependency-tree \
 java-21-openjdk-headless \
 jdependency \
"

URI_maven-shade-plugin-javadoc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/maven-shade-plugin-javadoc-3.5.1-4.el10.noarch.rpm;name=maven-shade-plugin-javadoc;unpack=0"
SRC_URI += "${URI_maven-shade-plugin-javadoc}"
SRC_URI[maven-shade-plugin-javadoc.sha256sum] = "b744645b4b27b83fa79898158305d681d97db2f67d1b7a9060954f078e3927a8"
RDEPENDS:maven-shade-plugin-javadoc = " \
 javapackages-filesystem \
"
