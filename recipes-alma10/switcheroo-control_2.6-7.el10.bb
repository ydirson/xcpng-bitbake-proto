# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "switcheroo-control"
PE = "0"
PV = "2.6"
PR = "7.el10"
PACKAGES = "switcheroo-control switcheroo-control-docs"
PROVIDES = "rpm/switcheroo-control rpm/switcheroo-control-docs"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/switcheroo-control-2.6-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1df3b314c75c5fb9d57672ed162d4d766bc6ff0954ef89830cf18973d925f35"

URI_switcheroo-control = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/switcheroo-control-2.6-7.el10.x86_64_v2.rpm;name=switcheroo-control;unpack=0"
SRC_URI += "${URI_switcheroo-control}"
SRC_URI[switcheroo-control.sha256sum] = "840861b96ba080f09da369b79d61114676ce16b0b76ae9e8bf29d10841b13818"
RDEPENDS:switcheroo-control = " \
 python3 \
 systemd \
 libgcc \
 libgudev \
 bash \
 glib2 \
 glibc \
"

URI_switcheroo-control-docs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/switcheroo-control-docs-2.6-7.el10.noarch.rpm;name=switcheroo-control-docs;unpack=0"
SRC_URI += "${URI_switcheroo-control-docs}"
SRC_URI[switcheroo-control-docs.sha256sum] = "4423f8c31675995af828b879e850b88224ec59599f2c723003dd843c5138c5b3"
RDEPENDS:switcheroo-control-docs = ""
