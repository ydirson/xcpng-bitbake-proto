# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "fcoe-utils"
PE = "0"
PV = "1.0.34"
PR = "11.gitb233050.el10"
PACKAGES = "fcoe-utils"
PROVIDES = "rpm/fcoe-utils"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/fcoe-utils-1.0.34-11.gitb233050.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "295b8893eab58d4a4be6e66b2878f271269931e1c7839c05601ac984227e40c1"

URI_fcoe-utils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/fcoe-utils-1.0.34-11.gitb233050.el10.x86_64_v2.rpm;name=fcoe-utils;unpack=0"
SRC_URI += "${URI_fcoe-utils}"
SRC_URI[fcoe-utils.sha256sum] = "661afab72c730521d09b1fb708a6fe2f461e5b0631dd17a06c31d7c98e03996a"
RDEPENDS:fcoe-utils = " \
 libpciaccess \
 systemd \
 device-mapper-multipath \
 iproute \
 bash \
 glibc \
 lldpad \
"
