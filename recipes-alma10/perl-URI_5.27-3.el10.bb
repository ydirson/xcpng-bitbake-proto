# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-URI"
PE = "0"
PV = "5.27"
PR = "3.el10"
PACKAGES = "perl-URI perl-URI-tests"
PROVIDES = "rpm/perl-URI rpm/perl-URI-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-URI-5.27-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "679995741d83dfec30c48cfd9914ec9b8ea332de6fe3bceeb8fedca877fd4229"

URI_perl-URI = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-URI-5.27-3.el10.noarch.rpm;name=perl-URI;unpack=0"
SRC_URI += "${URI_perl-URI}"
SRC_URI[perl-URI.sha256sum] = "51ed5bd277ee0aa043344af04a50d7eee219e764ace8df42a552fc0593f82817"
RDEPENDS:perl-URI = " \
 perl-libnet \
 perl-constant \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-URI \
 perl-Encode \
 perl-overload \
 perl-PathTools \
 perl-parent \
 perl-Exporter \
 perl-Data-Dumper \
 perl-base \
 perl-MIME-Base64 \
"

URI_perl-URI-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-URI-tests-5.27-3.el10.noarch.rpm;name=perl-URI-tests;unpack=0"
SRC_URI += "${URI_perl-URI-tests}"
SRC_URI[perl-URI-tests.sha256sum] = "f2368a852a0b49dcd96ff71ca03cca57c450ae7c226f1295b97f05dcb01b06e9"
RDEPENDS:perl-URI-tests = " \
 perl-libnet \
 perl-Test-Harness \
 perl-libs \
 perl-ExtUtils-MakeMaker \
 perl-URI \
 perl-Test-Warnings \
 perl-Test-Simple \
 perl-Storable \
 perl-Encode \
 perl-PathTools \
 bash \
 perl-Test-Needs \
 perl-interpreter \
 perl-Data-Dumper \
 perl-Test-Fatal \
 perl-File-Temp \
"
