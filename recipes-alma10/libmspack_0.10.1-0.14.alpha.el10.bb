# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libmspack"
PE = "0"
PV = "0.10.1"
PR = "0.14.alpha.el10"
PACKAGES = "libmspack libmspack-devel"
PROVIDES = "rpm/libmspack rpm/libmspack-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libmspack-0.10.1-0.14.alpha.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04a711acf72ec717c1f1fb2a35a1259ce911b89e9d4cce3745c956c0e927a823"

URI_libmspack = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libmspack-0.10.1-0.14.alpha.el10.x86_64_v2.rpm;name=libmspack;unpack=0"
SRC_URI += "${URI_libmspack}"
SRC_URI[libmspack.sha256sum] = "fabc588f64539d34fccdf68b27081f9a6a6bbabe6d6172d89f836bf28f025a5e"
RDEPENDS:libmspack = " \
 glibc \
"

URI_libmspack-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libmspack-devel-0.10.1-0.14.alpha.el10.x86_64_v2.rpm;name=libmspack-devel;unpack=0"
SRC_URI += "${URI_libmspack-devel}"
SRC_URI[libmspack-devel.sha256sum] = "b6e80ec6afda3b28d4ff68105adba65dd05ca96ef291f3cf447ae4949dfe0ed1"
RDEPENDS:libmspack-devel = " \
 libmspack \
 pkgconf-pkg-config \
"
