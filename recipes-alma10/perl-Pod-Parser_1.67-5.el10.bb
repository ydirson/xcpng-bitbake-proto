# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Pod-Parser"
PE = "0"
PV = "1.67"
PR = "5.el10"
PACKAGES = "perl-Pod-Parser"
PROVIDES = "rpm/perl-Pod-Parser"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Pod-Parser-1.67-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ceea01daae99ee9c949cf970e4017ea6e083bcce2a5e27452917030d2ef91474"

URI_perl-Pod-Parser = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Pod-Parser-1.67-5.el10.noarch.rpm;name=perl-Pod-Parser;unpack=0"
SRC_URI += "${URI_perl-Pod-Parser}"
SRC_URI[perl-Pod-Parser.sha256sum] = "9816f28f61fd837590a99f9cd9898edfd0b8f12065149f37cddcf0b69373cef9"
RDEPENDS:perl-Pod-Parser = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-interpreter \
 perl-Getopt-Long \
 perl-Pod-Parser \
 perl-PathTools \
 perl-File-Find \
 perl-Exporter \
 perl-Pod-Usage \
"
