# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libnetfilter_cttimeout"
PE = "0"
PV = "1.0.0"
PR = "27.el10"
PACKAGES = "libnetfilter_cttimeout libnetfilter_cttimeout-devel"
PROVIDES = "rpm/libnetfilter_cttimeout rpm/libnetfilter_cttimeout-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libnetfilter_cttimeout-1.0.0-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2993f28d9722db6d0518539f1be04e48bb92727f6311f00b82daa1af1941f41a"

URI_libnetfilter_cttimeout = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libnetfilter_cttimeout-1.0.0-27.el10.x86_64_v2.rpm;name=libnetfilter_cttimeout;unpack=0"
SRC_URI += "${URI_libnetfilter_cttimeout}"
SRC_URI[libnetfilter_cttimeout.sha256sum] = "fdb6b64395cb0d93fd69ac89dccb6e4d469d46e2915e0b1d078f569f2ddfe5bd"
RDEPENDS:libnetfilter_cttimeout = " \
 glibc \
 libmnl \
"

URI_libnetfilter_cttimeout-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libnetfilter_cttimeout-devel-1.0.0-27.el10.x86_64_v2.rpm;name=libnetfilter_cttimeout-devel;unpack=0"
SRC_URI += "${URI_libnetfilter_cttimeout-devel}"
SRC_URI[libnetfilter_cttimeout-devel.sha256sum] = "03da01108d33bf214876284ea0c06047cf65d724cc4c4b28d7e3c9507d42c746"
RDEPENDS:libnetfilter_cttimeout-devel = " \
 libnetfilter_cttimeout \
 kernel-headers \
 pkgconf-pkg-config \
 libmnl-devel \
"
