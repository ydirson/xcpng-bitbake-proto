# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tree-pkg"
PE = "0"
PV = "2.1.0"
PR = "8.el10"
PACKAGES = "tree"
PROVIDES = "rpm/tree"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/tree-pkg-2.1.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74bd1881014b961ab7bcf76904571b9071bc63c01863b9052f424c9cae9513df"

URI_tree = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/tree-2.1.0-8.el10.x86_64_v2.rpm;name=tree;unpack=0"
SRC_URI += "${URI_tree}"
SRC_URI[tree.sha256sum] = "4c4e44b277d89c01fc9d7eadd0b5b71c28e3b512b71ee1f140e94c269b565f23"
RDEPENDS:tree = " \
 glibc \
"
