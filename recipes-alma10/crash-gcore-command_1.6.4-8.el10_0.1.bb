# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "crash-gcore-command"
PE = "0"
PV = "1.6.4"
PR = "8.el10_0.1"
PACKAGES = "crash-gcore-command"
PROVIDES = "rpm/crash-gcore-command"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/crash-gcore-command-1.6.4-8.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f9f8d394f81e3db2d11b6661b2928a8500b9d90ac0f4c7dfdbffa34db18657f"

URI_crash-gcore-command = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/crash-gcore-command-1.6.4-8.el10_0.1.x86_64_v2.rpm;name=crash-gcore-command;unpack=0"
SRC_URI += "${URI_crash-gcore-command}"
SRC_URI[crash-gcore-command.sha256sum] = "a1d174ce13a2a9ac71f536455b2ff97168c7befa78626d5fce627b3dd09e0ac0"
RDEPENDS:crash-gcore-command = " \
 glibc \
 crash \
"
