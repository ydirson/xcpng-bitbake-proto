# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Role-Tiny"
PE = "0"
PV = "2.002004"
PR = "14.el10"
PACKAGES = "perl-Role-Tiny perl-Role-Tiny-tests"
PROVIDES = "rpm/perl-Role-Tiny rpm/perl-Role-Tiny-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Role-Tiny-2.002004-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a57ef9a627679473d671897ebadd4a3cbd8f2fe0a36482c08ff4bae1c04ef01f"

URI_perl-Role-Tiny = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Role-Tiny-2.002004-14.el10.noarch.rpm;name=perl-Role-Tiny;unpack=0"
SRC_URI += "${URI_perl-Role-Tiny}"
SRC_URI[perl-Role-Tiny.sha256sum] = "afcfcba8a92363855d47d0746a69623015f33283f572855381d4c79a6b3d74a1"
RDEPENDS:perl-Role-Tiny = " \
 perl-libs \
 perl-Carp \
 perl-mro \
 perl-Class-Method-Modifiers \
 perl-Role-Tiny \
 perl-Exporter \
"

URI_perl-Role-Tiny-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Role-Tiny-tests-2.002004-14.el10.noarch.rpm;name=perl-Role-Tiny-tests;unpack=0"
SRC_URI += "${URI_perl-Role-Tiny-tests}"
SRC_URI[perl-Role-Tiny-tests.sha256sum] = "428b371739601a793dbcc6b873f852e484f0a034bdef5db11896b25c023d4151"
RDEPENDS:perl-Role-Tiny-tests = " \
 perl-constant \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-overload \
 bash \
 perl-base \
 perl-Role-Tiny \
 perl-B \
 perl-interpreter \
 perl-Exporter \
 perl-lib \
"
