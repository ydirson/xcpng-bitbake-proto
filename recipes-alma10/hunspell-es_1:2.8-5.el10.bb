# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-es"
PE = "1"
PV = "2.8"
PR = "5.el10"
PACKAGES = "hunspell-es hunspell-es-AR hunspell-es-BO hunspell-es-CL hunspell-es-CO hunspell-es-CR hunspell-es-CU hunspell-es-DO hunspell-es-EC hunspell-es-ES hunspell-es-GQ hunspell-es-GT hunspell-es-HN hunspell-es-MX hunspell-es-NI hunspell-es-PA hunspell-es-PE hunspell-es-PR hunspell-es-PY hunspell-es-SV hunspell-es-US hunspell-es-UY hunspell-es-VE"
PROVIDES = "rpm/hunspell-es rpm/hunspell-es-AR rpm/hunspell-es-BO rpm/hunspell-es-CL rpm/hunspell-es-CO rpm/hunspell-es-CR rpm/hunspell-es-CU rpm/hunspell-es-DO rpm/hunspell-es-EC rpm/hunspell-es-ES rpm/hunspell-es-GQ rpm/hunspell-es-GT rpm/hunspell-es-HN rpm/hunspell-es-MX rpm/hunspell-es-NI rpm/hunspell-es-PA rpm/hunspell-es-PE rpm/hunspell-es-PR rpm/hunspell-es-PY rpm/hunspell-es-SV rpm/hunspell-es-US rpm/hunspell-es-UY rpm/hunspell-es-VE"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-es-2.8-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b9745ab14a740f80fdeb4572adc34dff64094840b8d8b5515759cbd02831575"

URI_hunspell-es = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-es-2.8-5.el10.noarch.rpm;name=hunspell-es;unpack=0"
SRC_URI += "${URI_hunspell-es}"
SRC_URI[hunspell-es.sha256sum] = "dcebb58b93ac71db81bd66a193b98ac0609a22471a7144f1760b339095e540bf"
RDEPENDS:hunspell-es = " \
 hunspell-es-AR \
 hunspell-es-BO \
 hunspell-es-CL \
 hunspell-es-CO \
 hunspell-es-CR \
 hunspell-es-CU \
 hunspell-es-DO \
 hunspell-es-EC \
 hunspell-es-ES \
 hunspell-es-GQ \
 hunspell-es-GT \
 hunspell-es-HN \
 hunspell-es-MX \
 hunspell-es-NI \
 hunspell-es-PA \
 hunspell-es-PE \
 hunspell-es-PR \
 hunspell-es-PY \
 hunspell-es-SV \
 hunspell-es-US \
 hunspell-es-UY \
 hunspell-es-VE \
 hunspell-filesystem \
"

URI_hunspell-es-AR = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-es-AR-2.8-5.el10.noarch.rpm;name=hunspell-es-AR;unpack=0"
SRC_URI += "${URI_hunspell-es-AR}"
SRC_URI[hunspell-es-AR.sha256sum] = "a0480bb844bc8d5bc44e7809080596938cd7942cfa915d24f3613461fb975207"
RDEPENDS:hunspell-es-AR = " \
 hunspell \
"

URI_hunspell-es-BO = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-es-BO-2.8-5.el10.noarch.rpm;name=hunspell-es-BO;unpack=0"
SRC_URI += "${URI_hunspell-es-BO}"
SRC_URI[hunspell-es-BO.sha256sum] = "bde1fe17313357ea6c08feb64dd81fc5667cebe94612fdd8d215c15ee0005d08"
RDEPENDS:hunspell-es-BO = " \
 hunspell \
"

URI_hunspell-es-CL = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-es-CL-2.8-5.el10.noarch.rpm;name=hunspell-es-CL;unpack=0"
SRC_URI += "${URI_hunspell-es-CL}"
SRC_URI[hunspell-es-CL.sha256sum] = "15571b3ef2af02aa267457eec77f55abc3d235e75d0ac8a5e7c482f672dabf2e"
RDEPENDS:hunspell-es-CL = " \
 hunspell \
"

URI_hunspell-es-CO = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-es-CO-2.8-5.el10.noarch.rpm;name=hunspell-es-CO;unpack=0"
SRC_URI += "${URI_hunspell-es-CO}"
SRC_URI[hunspell-es-CO.sha256sum] = "22491f7c3c4cd2f5287996d8689818693c2cef23a2fdeff232d004f94f466a8c"
RDEPENDS:hunspell-es-CO = " \
 hunspell \
"

URI_hunspell-es-CR = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-es-CR-2.8-5.el10.noarch.rpm;name=hunspell-es-CR;unpack=0"
SRC_URI += "${URI_hunspell-es-CR}"
SRC_URI[hunspell-es-CR.sha256sum] = "4a4f67911e25bd5df6a65eb86c1818be2d442c31830f3d8e08f22a3c724a5f48"
RDEPENDS:hunspell-es-CR = " \
 hunspell \
"

URI_hunspell-es-CU = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-es-CU-2.8-5.el10.noarch.rpm;name=hunspell-es-CU;unpack=0"
SRC_URI += "${URI_hunspell-es-CU}"
SRC_URI[hunspell-es-CU.sha256sum] = "e6453d9dbebe498e944d39b54d66772fefadb6483cbfbf5be8734c297b1aeb13"
RDEPENDS:hunspell-es-CU = " \
 hunspell \
"

URI_hunspell-es-DO = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-es-DO-2.8-5.el10.noarch.rpm;name=hunspell-es-DO;unpack=0"
SRC_URI += "${URI_hunspell-es-DO}"
SRC_URI[hunspell-es-DO.sha256sum] = "342b1fe46a21cbd55eb80813668d80c42c26e1b6daa9cbe75d8af89b74f1bb19"
RDEPENDS:hunspell-es-DO = " \
 hunspell \
"

URI_hunspell-es-EC = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-es-EC-2.8-5.el10.noarch.rpm;name=hunspell-es-EC;unpack=0"
SRC_URI += "${URI_hunspell-es-EC}"
SRC_URI[hunspell-es-EC.sha256sum] = "eb56b3e385fdc94aa9cda02c2b75efab255c4d5d2af1627eed955b2a92b7e2ba"
RDEPENDS:hunspell-es-EC = " \
 hunspell \
"

URI_hunspell-es-ES = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-es-ES-2.8-5.el10.noarch.rpm;name=hunspell-es-ES;unpack=0"
SRC_URI += "${URI_hunspell-es-ES}"
SRC_URI[hunspell-es-ES.sha256sum] = "d69fc9fe1857b2f18793fb54fb9d7587abc68f32b9d13e86e2309491fc95b628"
RDEPENDS:hunspell-es-ES = " \
 hunspell \
"

URI_hunspell-es-GQ = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-es-GQ-2.8-5.el10.noarch.rpm;name=hunspell-es-GQ;unpack=0"
SRC_URI += "${URI_hunspell-es-GQ}"
SRC_URI[hunspell-es-GQ.sha256sum] = "923a6e23f616528daa2090d72cacb013db99cc48aa41fb8892350f823845cfe9"
RDEPENDS:hunspell-es-GQ = " \
 hunspell \
"

URI_hunspell-es-GT = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-es-GT-2.8-5.el10.noarch.rpm;name=hunspell-es-GT;unpack=0"
SRC_URI += "${URI_hunspell-es-GT}"
SRC_URI[hunspell-es-GT.sha256sum] = "6e9b198f0f89bc96957f6471fa5ce56c9410a9cd597b790d3aa1a90616c98600"
RDEPENDS:hunspell-es-GT = " \
 hunspell \
"

URI_hunspell-es-HN = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-es-HN-2.8-5.el10.noarch.rpm;name=hunspell-es-HN;unpack=0"
SRC_URI += "${URI_hunspell-es-HN}"
SRC_URI[hunspell-es-HN.sha256sum] = "9c5c32400a3358b333721611fd34748879807887d6909449931aa2850009bd69"
RDEPENDS:hunspell-es-HN = " \
 hunspell \
"

URI_hunspell-es-MX = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-es-MX-2.8-5.el10.noarch.rpm;name=hunspell-es-MX;unpack=0"
SRC_URI += "${URI_hunspell-es-MX}"
SRC_URI[hunspell-es-MX.sha256sum] = "619fed73ebc27dffe96ef3b19a415f78c962c47ab4ebfd6b58bb291ead6c462a"
RDEPENDS:hunspell-es-MX = " \
 hunspell \
"

URI_hunspell-es-NI = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-es-NI-2.8-5.el10.noarch.rpm;name=hunspell-es-NI;unpack=0"
SRC_URI += "${URI_hunspell-es-NI}"
SRC_URI[hunspell-es-NI.sha256sum] = "d7b7295e3f316961699ef3598cb2f89fcaba2ae3015b42d8b2ef39ddc0c5015b"
RDEPENDS:hunspell-es-NI = " \
 hunspell \
"

URI_hunspell-es-PA = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-es-PA-2.8-5.el10.noarch.rpm;name=hunspell-es-PA;unpack=0"
SRC_URI += "${URI_hunspell-es-PA}"
SRC_URI[hunspell-es-PA.sha256sum] = "4cb7cd41e882a1faa9447fed64ca131c5c4269db8533ec1fb48c0534ad23c9b9"
RDEPENDS:hunspell-es-PA = " \
 hunspell \
"

URI_hunspell-es-PE = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-es-PE-2.8-5.el10.noarch.rpm;name=hunspell-es-PE;unpack=0"
SRC_URI += "${URI_hunspell-es-PE}"
SRC_URI[hunspell-es-PE.sha256sum] = "1b049b1c896168dd1b979db0d8d7446c5122f8174437942c8bddb7b7f9ecc122"
RDEPENDS:hunspell-es-PE = " \
 hunspell \
"

URI_hunspell-es-PR = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-es-PR-2.8-5.el10.noarch.rpm;name=hunspell-es-PR;unpack=0"
SRC_URI += "${URI_hunspell-es-PR}"
SRC_URI[hunspell-es-PR.sha256sum] = "9e13b1cf7dd1f728fb6f2132aec5179fd35fccbaa4f85b116682b53e08aa376e"
RDEPENDS:hunspell-es-PR = " \
 hunspell \
"

URI_hunspell-es-PY = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-es-PY-2.8-5.el10.noarch.rpm;name=hunspell-es-PY;unpack=0"
SRC_URI += "${URI_hunspell-es-PY}"
SRC_URI[hunspell-es-PY.sha256sum] = "7a2c7b77ee9b272084ff1fcfd815d4c6ccabb2e54319245fcf17b61fb00d8656"
RDEPENDS:hunspell-es-PY = " \
 hunspell \
"

URI_hunspell-es-SV = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-es-SV-2.8-5.el10.noarch.rpm;name=hunspell-es-SV;unpack=0"
SRC_URI += "${URI_hunspell-es-SV}"
SRC_URI[hunspell-es-SV.sha256sum] = "5e2b90d7cbf965f79b0b5681a1dc388c24a0aa9bcf8f4a0402c9e7a653312dbb"
RDEPENDS:hunspell-es-SV = " \
 hunspell \
"

URI_hunspell-es-US = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-es-US-2.8-5.el10.noarch.rpm;name=hunspell-es-US;unpack=0"
SRC_URI += "${URI_hunspell-es-US}"
SRC_URI[hunspell-es-US.sha256sum] = "348842d982077264dd20be4d03606f2e858828b1461cda15e8d9c393b4ecdd3d"
RDEPENDS:hunspell-es-US = " \
 hunspell \
"

URI_hunspell-es-UY = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-es-UY-2.8-5.el10.noarch.rpm;name=hunspell-es-UY;unpack=0"
SRC_URI += "${URI_hunspell-es-UY}"
SRC_URI[hunspell-es-UY.sha256sum] = "fd40cd63fbd539aa447e50186aa81bd35675173fce26cad66d4b76cfaf44be87"
RDEPENDS:hunspell-es-UY = " \
 hunspell \
"

URI_hunspell-es-VE = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-es-VE-2.8-5.el10.noarch.rpm;name=hunspell-es-VE;unpack=0"
SRC_URI += "${URI_hunspell-es-VE}"
SRC_URI[hunspell-es-VE.sha256sum] = "4db74706e7e7fc915e95bcd85a6caf733874e6f962dcebce963b58524762531b"
RDEPENDS:hunspell-es-VE = " \
 hunspell \
"
