# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-testpath"
PE = "0"
PV = "0.6.0"
PR = "12.el10"
PACKAGES = "python-testpath-doc python3-testpath"
PROVIDES = "rpm/python-testpath-doc rpm/python3-testpath"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/python-testpath-0.6.0-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40cf5d7d36b70c64d75c4b4c555992e191b060e5885ac565202edba044a0a916"

URI_python-testpath-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python-testpath-doc-0.6.0-12.el10.noarch.rpm;name=python-testpath-doc;unpack=0"
SRC_URI += "${URI_python-testpath-doc}"
SRC_URI[python-testpath-doc.sha256sum] = "1a9fd42cf87afca17c46b1f32861cb79190c8dc2fc3c4556451aa9565efb031d"
RDEPENDS:python-testpath-doc = ""

URI_python3-testpath = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-testpath-0.6.0-12.el10.noarch.rpm;name=python3-testpath;unpack=0"
SRC_URI += "${URI_python3-testpath}"
SRC_URI[python3-testpath.sha256sum] = "40e80d4265c1a9b7a6c70fcba9a692b566fc5e9af03b1b32c3ba2d231ba7f1f1"
RDEPENDS:python3-testpath = " \
 python3 \
"
