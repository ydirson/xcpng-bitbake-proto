# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Sub-Exporter-Progressive"
PE = "0"
PV = "0.001013"
PR = "27.el10"
PACKAGES = "perl-Sub-Exporter-Progressive perl-Sub-Exporter-Progressive-tests"
PROVIDES = "rpm/perl-Sub-Exporter-Progressive rpm/perl-Sub-Exporter-Progressive-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Sub-Exporter-Progressive-0.001013-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "401218e87c17bd29c1982405892a3989a3a0af381d42ea600dccba21a1805b6a"

URI_perl-Sub-Exporter-Progressive = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Sub-Exporter-Progressive-0.001013-27.el10.noarch.rpm;name=perl-Sub-Exporter-Progressive;unpack=0"
SRC_URI += "${URI_perl-Sub-Exporter-Progressive}"
SRC_URI[perl-Sub-Exporter-Progressive.sha256sum] = "d2351f70c32b95e0fd397c3084f033284a3db6651512bc0cc947d04ae9e97b39"
RDEPENDS:perl-Sub-Exporter-Progressive = " \
 perl-Exporter \
 perl-libs \
 perl-Carp \
 perl-Sub-Exporter \
"

URI_perl-Sub-Exporter-Progressive-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Sub-Exporter-Progressive-tests-0.001013-27.el10.noarch.rpm;name=perl-Sub-Exporter-Progressive-tests;unpack=0"
SRC_URI += "${URI_perl-Sub-Exporter-Progressive-tests}"
SRC_URI[perl-Sub-Exporter-Progressive-tests.sha256sum] = "a4e0d022ce96dbb9191e5448e4b6bad3194aae293c3437f88380215cfa0d60dd"
RDEPENDS:perl-Sub-Exporter-Progressive-tests = " \
 perl-constant \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 bash \
 perl-Sub-Exporter-Progressive \
 perl-interpreter \
 perl-lib \
"
