# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "graphite2"
PE = "0"
PV = "1.3.14"
PR = "17.el10"
PACKAGES = "graphite2 graphite2-devel"
PROVIDES = "rpm/graphite2 rpm/graphite2-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/graphite2-1.3.14-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1daa1a4e056719d085574887fb1271a0d4adda34ca1c67e97bbda246b5a35207"

URI_graphite2 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/graphite2-1.3.14-17.el10.x86_64_v2.rpm;name=graphite2;unpack=0"
SRC_URI += "${URI_graphite2}"
SRC_URI[graphite2.sha256sum] = "71343dc73b8f9d334178629770459d7fc9c912e43859b68190fe469ab6a48d42"
RDEPENDS:graphite2 = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_graphite2-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/graphite2-devel-1.3.14-17.el10.x86_64_v2.rpm;name=graphite2-devel;unpack=0"
SRC_URI += "${URI_graphite2-devel}"
SRC_URI[graphite2-devel.sha256sum] = "916deb379429c74b56be8dbe2ff52f1023b35d293b5354a15fabb5b8f96d6cd1"
RDEPENDS:graphite2-devel = " \
 graphite2 \
 pkgconf-pkg-config \
"
