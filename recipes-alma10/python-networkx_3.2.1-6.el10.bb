# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-networkx"
PE = "0"
PV = "3.2.1"
PR = "6.el10"
PACKAGES = "python3-networkx"
PROVIDES = "rpm/python3-networkx"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-networkx-3.2.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16e644acf2e9c518f28fe636fb2732a653d6d5bf9e5ef10621eef00d5d0ea240"

URI_python3-networkx = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-networkx-3.2.1-6.el10.noarch.rpm;name=python3-networkx;unpack=0"
SRC_URI += "${URI_python3-networkx}"
SRC_URI[python3-networkx.sha256sum] = "81c77cb45aacb2ab1f5956c2ffc83787f08bc95969e0ccdf05fe6f477ced5c19"
RDEPENDS:python3-networkx = " \
 python3 \
"
