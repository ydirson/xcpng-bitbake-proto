# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "e2fsprogs"
PE = "0"
PV = "1.47.1"
PR = "3.el10"
PACKAGES = "e2fsprogs e2fsprogs-libs libcom_err libss e2fsprogs-devel libcom_err-devel e2fsprogs-static e2scrub libss-devel"
PROVIDES = "rpm/e2fsprogs rpm/e2fsprogs-libs rpm/libcom_err rpm/libss rpm/e2fsprogs-devel rpm/libcom_err-devel rpm/e2fsprogs-static rpm/e2scrub rpm/libss-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/e2fsprogs-1.47.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2679d07112522d4f444eb327393876eb968c997eac409398695bf40fcb37640a"

URI_e2fsprogs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/e2fsprogs-1.47.1-3.el10.x86_64_v2.rpm;name=e2fsprogs;unpack=0"
SRC_URI += "${URI_e2fsprogs}"
SRC_URI[e2fsprogs.sha256sum] = "c2b54eb8ca2686ff118b03eda3e0dfc2b86bf9792c42a6efa5c88744a88783dc"
RDEPENDS:e2fsprogs = " \
 libuuid \
 e2fsprogs-libs \
 libss \
 fuse3-libs \
 libblkid \
 libcom_err \
 glibc \
"

URI_e2fsprogs-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/e2fsprogs-libs-1.47.1-3.el10.x86_64_v2.rpm;name=e2fsprogs-libs;unpack=0"
SRC_URI += "${URI_e2fsprogs-libs}"
SRC_URI[e2fsprogs-libs.sha256sum] = "b61dd0426509b7591b6a4ab88754a29112d0178bc1fb12a1efc311308decbcea"
RDEPENDS:e2fsprogs-libs = " \
 glibc \
 libcom_err \
"

URI_libcom_err = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libcom_err-1.47.1-3.el10.x86_64_v2.rpm;name=libcom_err;unpack=0"
SRC_URI += "${URI_libcom_err}"
SRC_URI[libcom_err.sha256sum] = "4989a4c3e49ede1a3618394c1d2757be545e1d81ffaac16bd58ab521dd554e27"
RDEPENDS:libcom_err = " \
 glibc \
"

URI_libss = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libss-1.47.1-3.el10.x86_64_v2.rpm;name=libss;unpack=0"
SRC_URI += "${URI_libss}"
SRC_URI[libss.sha256sum] = "26240c08977ff0e56c54d3f0b01047e25b0b9e6288a72e7fe35d9fb02676bd38"
RDEPENDS:libss = " \
 glibc \
 libcom_err \
"

URI_e2fsprogs-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/e2fsprogs-devel-1.47.1-3.el10.x86_64_v2.rpm;name=e2fsprogs-devel;unpack=0"
SRC_URI += "${URI_e2fsprogs-devel}"
SRC_URI[e2fsprogs-devel.sha256sum] = "cc4a4b86f5c4ef60f6f7f9c20f1aab51606cb969daf311ae82d386eaf2ec5cfc"
RDEPENDS:e2fsprogs-devel = " \
 e2fsprogs-libs \
 gawk \
 pkgconf-pkg-config \
 libcom_err-devel \
"

URI_libcom_err-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libcom_err-devel-1.47.1-3.el10.x86_64_v2.rpm;name=libcom_err-devel;unpack=0"
SRC_URI += "${URI_libcom_err-devel}"
SRC_URI[libcom_err-devel.sha256sum] = "15b104356e613df4a33363f2b6d32105c7fc3ce7a95b8404afdf40aa79a5eabf"
RDEPENDS:libcom_err-devel = " \
 libcom_err \
 bash \
 pkgconf-pkg-config \
"

URI_e2fsprogs-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/e2fsprogs-static-1.47.1-3.el10.x86_64_v2.rpm;name=e2fsprogs-static;unpack=0"
SRC_URI += "${URI_e2fsprogs-static}"
SRC_URI[e2fsprogs-static.sha256sum] = "ff5c2059909a685d89d04507ec30c5ae536508246b8eed9e6e6f8b52d1b194ff"
RDEPENDS:e2fsprogs-static = ""

URI_e2scrub = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/e2scrub-1.47.1-3.el10.x86_64_v2.rpm;name=e2scrub;unpack=0"
SRC_URI += "${URI_e2scrub}"
SRC_URI[e2scrub.sha256sum] = "c85ccdc0702176e36ad50085af12b6f71d12bd723b1ed3e44507198d18820d11"
RDEPENDS:e2scrub = " \
 e2fsprogs \
 systemd \
 lvm2 \
 util-linux \
 bash \
"

URI_libss-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libss-devel-1.47.1-3.el10.x86_64_v2.rpm;name=libss-devel;unpack=0"
SRC_URI += "${URI_libss-devel}"
SRC_URI[libss-devel.sha256sum] = "098a8063c71280f9e159262f5121d91ba817c6c9bce1aebd16982b4cf3b9a255"
RDEPENDS:libss-devel = " \
 libss \
 bash \
 pkgconf-pkg-config \
 libcom_err-devel \
"
