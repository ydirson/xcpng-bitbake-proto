# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ltrace"
PE = "0"
PV = "0.7.91"
PR = "52.el10"
PACKAGES = "ltrace"
PROVIDES = "rpm/ltrace"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ltrace-0.7.91-52.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "849881be9daa1200d877fd70da3af18248d4ffe6efe9e3383d493fc305727149"

URI_ltrace = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ltrace-0.7.91-52.el10.x86_64_v2.rpm;name=ltrace;unpack=0"
SRC_URI += "${URI_ltrace}"
SRC_URI[ltrace.sha256sum] = "36502f556825d113cc3e91112961d54c61be5698f90dde1cf9be9dacaa29df28"
RDEPENDS:ltrace = " \
 elfutils-libelf \
 elfutils-libs \
 libstdc++ \
 glibc \
 libselinux \
"
