# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "maven-source-plugin"
PE = "0"
PV = "3.3.0"
PR = "7.el10"
PACKAGES = "maven-source-plugin maven-source-plugin-javadoc"
PROVIDES = "rpm/maven-source-plugin rpm/maven-source-plugin-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/maven-source-plugin-3.3.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59a7c1aa50fc7859661c9b3eed9dc9532865c8a54c188a4a2c1263b46c12b60c"

URI_maven-source-plugin = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-source-plugin-3.3.0-7.el10.noarch.rpm;name=maven-source-plugin;unpack=0"
SRC_URI += "${URI_maven-source-plugin}"
SRC_URI[maven-source-plugin.sha256sum] = "251fe1769b7117f79b9a8316d66951102b4d5af73bb8b969d1e39e652a740e49"
RDEPENDS:maven-source-plugin = " \
 plexus-archiver \
 plexus-utils \
 javapackages-filesystem \
 maven-archiver \
"

URI_maven-source-plugin-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-source-plugin-javadoc-3.3.0-7.el10.noarch.rpm;name=maven-source-plugin-javadoc;unpack=0"
SRC_URI += "${URI_maven-source-plugin-javadoc}"
SRC_URI[maven-source-plugin-javadoc.sha256sum] = "c87251fa64077c6cfeca3a56079940d995b4e10327302da2a1b917345345c7b9"
RDEPENDS:maven-source-plugin-javadoc = " \
 javapackages-filesystem \
"
