# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dos2unix"
PE = "0"
PV = "7.5.2"
PR = "3.el10"
PACKAGES = "dos2unix"
PROVIDES = "rpm/dos2unix"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/dos2unix-7.5.2-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4ef8a5a10c35f9fd81efd6f265591ddbac482c0578d1321ddd078e7e4362121"

URI_dos2unix = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/dos2unix-7.5.2-3.el10.x86_64_v2.rpm;name=dos2unix;unpack=0"
SRC_URI += "${URI_dos2unix}"
SRC_URI[dos2unix.sha256sum] = "8e5283448eb748e33d46a9d0e3e76803fdbb8476c52a16961809e81381734e8d"
RDEPENDS:dos2unix = " \
 glibc \
"
