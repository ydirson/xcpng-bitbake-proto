# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tpm2-tss"
PE = "0"
PV = "4.1.3"
PR = "5.el10"
PACKAGES = "tpm2-tss tpm2-tss-fapi tpm2-tss-devel"
PROVIDES = "rpm/tpm2-tss rpm/tpm2-tss-fapi rpm/tpm2-tss-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/tpm2-tss-4.1.3-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5cabf0439a57af675af7517217e9c3371f885549d9b9b7c5a4793496f0262500"

URI_tpm2-tss = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/tpm2-tss-4.1.3-5.el10.x86_64_v2.rpm;name=tpm2-tss;unpack=0"
SRC_URI += "${URI_tpm2-tss}"
SRC_URI[tpm2-tss.sha256sum] = "e766b03a9ad582b23fa1167b82fb3ed85302475580830cf50955319246190532"
RDEPENDS:tpm2-tss = " \
 libuuid \
 shadow-utils \
 openssl-libs \
 json-c \
 bash \
 glibc \
"

URI_tpm2-tss-fapi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/tpm2-tss-fapi-4.1.3-5.el10.x86_64_v2.rpm;name=tpm2-tss-fapi;unpack=0"
SRC_URI += "${URI_tpm2-tss-fapi}"
SRC_URI[tpm2-tss-fapi.sha256sum] = "658978f43bf5b473a4901f4627628b24cb7f908d2a4e9ad641d9191521b375ca"
RDEPENDS:tpm2-tss-fapi = " \
 libuuid \
 openssl-libs \
 json-c \
 libcurl \
 glibc \
 tpm2-tss \
"

URI_tpm2-tss-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/tpm2-tss-devel-4.1.3-5.el10.x86_64_v2.rpm;name=tpm2-tss-devel;unpack=0"
SRC_URI += "${URI_tpm2-tss-devel}"
SRC_URI[tpm2-tss-devel.sha256sum] = "c656e4f166ce41aae552fc5a865cd36f615bf2b9ee80529f260bfc61e1a2bc5a"
RDEPENDS:tpm2-tss-devel = " \
 pkgconf-pkg-config \
 libuuid-devel \
 openssl-devel \
 tpm2-tss-devel \
 tpm2-tss \
 libcurl-devel \
 tpm2-tss-fapi \
 json-c-devel \
"
