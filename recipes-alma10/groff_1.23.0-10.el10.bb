# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "groff"
PE = "0"
PV = "1.23.0"
PR = "10.el10"
PACKAGES = "groff-base groff groff-doc groff-perl groff-x11"
PROVIDES = "rpm/groff-base rpm/groff rpm/groff-doc rpm/groff-perl rpm/groff-x11"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/groff-1.23.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87f4c97bf8a52df512800693f5f1bbb67b3fe7fb0267d65330fe0460bc88ac7d"

URI_groff-base = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/groff-base-1.23.0-10.el10.x86_64_v2.rpm;name=groff-base;unpack=0"
SRC_URI += "${URI_groff-base}"
SRC_URI[groff-base.sha256sum] = "46e0e7b3ae9c88d5bbb8640a66d1203b3759c2a3ad6ae9505d377a19aac5614a"
RDEPENDS:groff-base = " \
 libgcc \
 libstdc++ \
 bash \
 glibc \
 alternatives \
"

URI_groff = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/groff-1.23.0-10.el10.x86_64_v2.rpm;name=groff;unpack=0"
SRC_URI += "${URI_groff}"
SRC_URI[groff.sha256sum] = "e22e111655b6425866b3cdc4d2ff50bcf33da5a7e4455852d3f980d47d3b13d1"
RDEPENDS:groff = " \
 coreutils \
 libgcc \
 groff-base \
 libstdc++ \
 bash \
 glibc \
 alternatives \
"

URI_groff-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/groff-doc-1.23.0-10.el10.noarch.rpm;name=groff-doc;unpack=0"
SRC_URI += "${URI_groff-doc}"
SRC_URI[groff-doc.sha256sum] = "7afdb1bc90de864089d5f7f48c9cdca3f505382048e72e3f0e406a48fbd0f277"
RDEPENDS:groff-doc = " \
 groff \
"

URI_groff-perl = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/groff-perl-1.23.0-10.el10.x86_64_v2.rpm;name=groff-perl;unpack=0"
SRC_URI += "${URI_groff-perl}"
SRC_URI[groff-perl.sha256sum] = "30f30554127daf4ac9cd373cd3a030a9f8ef634d93b3fafe59583eaffc2bd3fe"
RDEPENDS:groff-perl = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-Math-Complex \
 perl-FindBin \
 perl-Getopt-Long \
 perl-File-Basename \
 perl-POSIX \
 groff-base \
 perl-File-Copy \
 perl-PathTools \
 perl-File-HomeDir \
 perl-interpreter \
 perl-File-Path \
 perl-Data-Dumper \
 perl-File-Temp \
"

URI_groff-x11 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/groff-x11-1.23.0-10.el10.x86_64_v2.rpm;name=groff-x11;unpack=0"
SRC_URI += "${URI_groff-x11}"
SRC_URI[groff-x11.sha256sum] = "62db60841153e3b0cb4b528a8536a53f554f4e742d8ba6668632c981dd01bda7"
RDEPENDS:groff-x11 = " \
 libXmu \
 groff-base \
 libX11 \
 libXt \
 libXaw \
 glibc \
"
