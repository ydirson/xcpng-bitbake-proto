# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libtpms"
PE = "0"
PV = "0.9.6"
PR = "11.el10_0"
PACKAGES = "libtpms libtpms-devel"
PROVIDES = "rpm/libtpms rpm/libtpms-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libtpms-0.9.6-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec426831dac3d5067d7d35683815c247efcd0ec7b5ec4d559f1787c37fbea823"

URI_libtpms = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libtpms-0.9.6-11.el10_0.x86_64_v2.rpm;name=libtpms;unpack=0"
SRC_URI += "${URI_libtpms}"
SRC_URI[libtpms.sha256sum] = "2a2609c94d85fb6857d4b2635db4b9f694adb51394f355d8adce8cccec322d4c"
RDEPENDS:libtpms = " \
 glibc \
 openssl-libs \
"

URI_libtpms-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libtpms-devel-0.9.6-11.el10_0.x86_64_v2.rpm;name=libtpms-devel;unpack=0"
SRC_URI += "${URI_libtpms-devel}"
SRC_URI[libtpms-devel.sha256sum] = "e94d5f34a4c998b4ed1154d574ea91503202a4d687be47583453cf435e08860b"
RDEPENDS:libtpms-devel = " \
 pkgconf-pkg-config \
 libtpms \
"
