# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libtiff"
PE = "0"
PV = "4.6.0"
PR = "6.el10_0.1"
PACKAGES = "libtiff libtiff-devel libtiff-tools libtiff-static"
PROVIDES = "rpm/libtiff rpm/libtiff-devel rpm/libtiff-tools rpm/libtiff-static"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libtiff-4.6.0-6.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3eb3fc867f4bce2b38cdbf7d60427af4d635c37dd4638e650484306d0e6eec03"

URI_libtiff = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libtiff-4.6.0-6.el10_0.1.x86_64_v2.rpm;name=libtiff;unpack=0"
SRC_URI += "${URI_libtiff}"
SRC_URI[libtiff.sha256sum] = "122de85508347ea88b188867311746788fde26758a6340b4f4d0bf97f3c4432e"
RDEPENDS:libtiff = " \
 zlib-ng-compat \
 liblerc \
 libgcc \
 libwebp \
 libzstd \
 libstdc++ \
 jbigkit-libs \
 glibc \
 libjpeg-turbo \
"

URI_libtiff-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libtiff-devel-4.6.0-6.el10_0.1.x86_64_v2.rpm;name=libtiff-devel;unpack=0"
SRC_URI += "${URI_libtiff-devel}"
SRC_URI[libtiff-devel.sha256sum] = "67b8506c78ae271159846b2ca2c7bc78aa75aaf63b6c64bf6b62bad98e66e1fe"
RDEPENDS:libtiff-devel = " \
 zlib-ng-compat-devel \
 libzstd-devel \
 libwebp-devel \
 pkgconf-pkg-config \
 libjpeg-turbo-devel \
 libtiff \
"

URI_libtiff-tools = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libtiff-tools-4.6.0-6.el10_0.1.x86_64_v2.rpm;name=libtiff-tools;unpack=0"
SRC_URI += "${URI_libtiff-tools}"
SRC_URI[libtiff-tools.sha256sum] = "fc56e721789c8983a71d619df00b4dfd50e8b237d99add9d25a992d0410da968"
RDEPENDS:libtiff-tools = " \
 glibc \
 libtiff \
"

URI_libtiff-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libtiff-static-4.6.0-6.el10_0.1.x86_64_v2.rpm;name=libtiff-static;unpack=0"
SRC_URI += "${URI_libtiff-static}"
SRC_URI[libtiff-static.sha256sum] = "2188ad107674dc737bd10b783157165dd317dc440f621e280801ac120b45d53e"
RDEPENDS:libtiff-static = " \
 libtiff-devel \
"
