# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rubygem-rspec-mocks"
PE = "0"
PV = "3.13.0"
PR = "3.el10"
PACKAGES = "rubygem-rspec-mocks rubygem-rspec-mocks-doc"
PROVIDES = "rpm/rubygem-rspec-mocks rpm/rubygem-rspec-mocks-doc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/rubygem-rspec-mocks-3.13.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65ece9972543b167878e53205467105d49c0d379b0f06a7c4e372dd9b2daaf18"

URI_rubygem-rspec-mocks = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/rubygem-rspec-mocks-3.13.0-3.el10.noarch.rpm;name=rubygem-rspec-mocks;unpack=0"
SRC_URI += "${URI_rubygem-rspec-mocks}"
SRC_URI[rubygem-rspec-mocks.sha256sum] = "ede93478799f104d3ea32dc411c1fb75492282566f9577b98fbedddc355f6ed7"
RDEPENDS:rubygem-rspec-mocks = " \
 rubygems \
 rubygem-rspec-support \
 rubygem-diff-lcs \
"

URI_rubygem-rspec-mocks-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-rspec-mocks-doc-3.13.0-3.el10.noarch.rpm;name=rubygem-rspec-mocks-doc;unpack=0"
SRC_URI += "${URI_rubygem-rspec-mocks-doc}"
SRC_URI[rubygem-rspec-mocks-doc.sha256sum] = "4b1db2fb5b4d9b04905e98b4e310506bfcecbc29755323598d2ecab52f526c73"
RDEPENDS:rubygem-rspec-mocks-doc = " \
 rubygem-rspec-mocks \
"
