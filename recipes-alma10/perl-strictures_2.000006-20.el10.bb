# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-strictures"
PE = "0"
PV = "2.000006"
PR = "20.el10"
PACKAGES = "perl-strictures"
PROVIDES = "rpm/perl-strictures"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-strictures-2.000006-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8706cd1eb4a05244051a06a1202fad9198e890f3885f3656a8d435d35d912b1"

URI_perl-strictures = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-strictures-2.000006-20.el10.noarch.rpm;name=perl-strictures;unpack=0"
SRC_URI += "${URI_perl-strictures}"
SRC_URI[perl-strictures.sha256sum] = "650fe92778671bce86584df5cc66460bb5caf099b3f21bc1c176b9ae3b861615"
RDEPENDS:perl-strictures = " \
 perl-libs \
 perl-Carp \
"
