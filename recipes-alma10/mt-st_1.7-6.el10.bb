# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mt-st"
PE = "0"
PV = "1.7"
PR = "6.el10"
PACKAGES = "mt-st"
PROVIDES = "rpm/mt-st"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mt-st-1.7-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3218c170036f6c48458bcd703c6f9c6e7ff18e359e644b26b25b575ba698df7"

URI_mt-st = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mt-st-1.7-6.el10.x86_64_v2.rpm;name=mt-st;unpack=0"
SRC_URI += "${URI_mt-st}"
SRC_URI[mt-st.sha256sum] = "2ef638b5dfaee1684665b0edf5512b216553afcced7297d9fe32d34d25bc3186"
RDEPENDS:mt-st = " \
 glibc \
 systemd \
 bash \
"
