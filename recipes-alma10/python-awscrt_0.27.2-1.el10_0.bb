# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-awscrt"
PE = "0"
PV = "0.27.2"
PR = "1.el10_0"
PACKAGES = "python3-awscrt"
PROVIDES = "rpm/python3-awscrt"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-awscrt-0.27.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "67905b384eb5f5f578ef2e8cbf5f5e2ceb698ac65fc4b07570f31e572d7cfbd9"

URI_python3-awscrt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-awscrt-0.27.2-1.el10_0.x86_64_v2.rpm;name=python3-awscrt;unpack=0"
SRC_URI += "${URI_python3-awscrt}"
SRC_URI[python3-awscrt.sha256sum] = "4bec01d1f107345dabac13f95b8f89123d5c69f3817cff140f3a334e06e2cc0d"
RDEPENDS:python3-awscrt = " \
 glibc \
 openssl-libs \
 libgcc \
 python3 \
"
