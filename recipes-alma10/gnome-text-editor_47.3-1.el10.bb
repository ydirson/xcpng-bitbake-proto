# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-text-editor"
PE = "0"
PV = "47.3"
PR = "1.el10"
PACKAGES = "gnome-text-editor"
PROVIDES = "rpm/gnome-text-editor"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-text-editor-47.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11891fb7e3b93b3102e08e60b1291b693287226580ad805ef4621feba734d560"

URI_gnome-text-editor = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-text-editor-47.3-1.el10.x86_64_v2.rpm;name=gnome-text-editor;unpack=0"
SRC_URI += "${URI_gnome-text-editor}"
SRC_URI[gnome-text-editor.sha256sum] = "6e273feca93c9cb25882b2403ff93b07841dfdd5ae51fc55ac36dc3105fc5b39"
RDEPENDS:gnome-text-editor = " \
 enchant2 \
 libspelling \
 libgcc \
 pango \
 editorconfig-libs \
 cairo \
 glib2 \
 glibc \
 gtk4 \
 libadwaita \
 gtksourceview5 \
"
