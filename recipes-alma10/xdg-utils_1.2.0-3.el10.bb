# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xdg-utils"
PE = "0"
PV = "1.2.0"
PR = "3.el10"
PACKAGES = "xdg-utils"
PROVIDES = "rpm/xdg-utils"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xdg-utils-1.2.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab6c40628f28a65373c9c9da0d1bdac425d32853173b90f8750201e8b14e3309"

URI_xdg-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xdg-utils-1.2.0-3.el10.noarch.rpm;name=xdg-utils;unpack=0"
SRC_URI += "${URI_xdg-utils}"
SRC_URI[xdg-utils.sha256sum] = "7e8c7816af247f49d350df7d72ecea5d6791586d6381bf3a2a1627d3787eb662"
RDEPENDS:xdg-utils = " \
 coreutils \
 desktop-file-utils \
 bash \
 which \
"
