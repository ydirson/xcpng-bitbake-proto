# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-File-Remove"
PE = "0"
PV = "1.61"
PR = "10.el10"
PACKAGES = "perl-File-Remove perl-File-Remove-tests"
PROVIDES = "rpm/perl-File-Remove rpm/perl-File-Remove-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-File-Remove-1.61-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6284ae4a92e2d910497f478c215034b0bb3703a640af68e7978b8a128608bf7"

URI_perl-File-Remove = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-File-Remove-1.61-10.el10.noarch.rpm;name=perl-File-Remove;unpack=0"
SRC_URI += "${URI_perl-File-Remove}"
SRC_URI[perl-File-Remove.sha256sum] = "d921ee7f0735297a526e661eef60630bdd1fdaf3e2d45d5a5f1ed90afef90ef7"
RDEPENDS:perl-File-Remove = " \
 perl-constant \
 perl-libs \
 perl-vars \
 perl-PathTools \
 perl-File-Path \
"

URI_perl-File-Remove-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-File-Remove-tests-1.61-10.el10.noarch.rpm;name=perl-File-Remove-tests;unpack=0"
SRC_URI += "${URI_perl-File-Remove-tests}"
SRC_URI[perl-File-Remove-tests.sha256sum] = "4da1b68b07cc6bce3fedcae842b7ab8cfd6b7b102514200e0e1c551184d447b7"
RDEPENDS:perl-File-Remove-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-IO \
 perl-IPC-Open3 \
 perl-File-Copy \
 bash \
 perl-PathTools \
 perl-interpreter \
 perl-File-Path \
 perl-File-Remove \
"
