# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tzdata"
PE = "0"
PV = "2025b"
PR = "1.el10"
PACKAGES = "tzdata tzdata-java"
PROVIDES = "rpm/tzdata rpm/tzdata-java"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/tzdata-2025b-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "add1048114cdc7245e96143576e7bf5dfc9788ab825b3ecfb111bc5b82814e46"

URI_tzdata = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/tzdata-2025b-1.el10.noarch.rpm;name=tzdata;unpack=0"
SRC_URI += "${URI_tzdata}"
SRC_URI[tzdata.sha256sum] = "a1d9fa359dbd922237680eac553ac44749a40e1cc545a9384afcaafe66500779"
RDEPENDS:tzdata = ""

URI_tzdata-java = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tzdata-java-2025b-1.el10.noarch.rpm;name=tzdata-java;unpack=0"
SRC_URI += "${URI_tzdata-java}"
SRC_URI[tzdata-java.sha256sum] = "4e442e51e89d98b998d85d867741f12598219cc68fb08b53254d7a6982c5e791"
RDEPENDS:tzdata-java = ""
