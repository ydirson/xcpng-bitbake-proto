# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Sys-Syslog"
PE = "0"
PV = "0.36"
PR = "512.el10"
PACKAGES = "perl-Sys-Syslog perl-Sys-Syslog-tests"
PROVIDES = "rpm/perl-Sys-Syslog rpm/perl-Sys-Syslog-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Sys-Syslog-0.36-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44618afd0e07d4aabe897036b1fc1cae592f3a4ac424c49b5ff874715c4f9a25"

URI_perl-Sys-Syslog = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Sys-Syslog-0.36-512.el10.x86_64_v2.rpm;name=perl-Sys-Syslog;unpack=0"
SRC_URI += "${URI_perl-Sys-Syslog}"
SRC_URI[perl-Sys-Syslog.sha256sum] = "71f1ab6575a812434095ab2f3d81685eaa7eef7a32d588b6134233fd612b0b97"
RDEPENDS:perl-Sys-Syslog = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-Socket \
 perl-Fcntl \
 perl-POSIX \
 perl-File-Basename \
 glibc \
 perl-Exporter \
"

URI_perl-Sys-Syslog-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Sys-Syslog-tests-0.36-512.el10.x86_64_v2.rpm;name=perl-Sys-Syslog-tests;unpack=0"
SRC_URI += "${URI_perl-Sys-Syslog-tests}"
SRC_URI[perl-Sys-Syslog-tests.sha256sum] = "db7b8e571517e67fa6a6ce4b60bbe8ef85cd2bcdf9e5471595bae05e32429f7a"
RDEPENDS:perl-Sys-Syslog-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-FileHandle \
 perl-Socket \
 bash \
 perl-PathTools \
 perl-Sys-Syslog \
 perl-interpreter \
"
