# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Encode-Locale"
PE = "0"
PV = "1.05"
PR = "31.el10"
PACKAGES = "perl-Encode-Locale perl-Encode-Locale-tests"
PROVIDES = "rpm/perl-Encode-Locale rpm/perl-Encode-Locale-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Encode-Locale-1.05-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd2d67caeb30f8b4463ff14967ed522cb58f6e4dffa054cfcc69af066057becd"

URI_perl-Encode-Locale = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Encode-Locale-1.05-31.el10.noarch.rpm;name=perl-Encode-Locale;unpack=0"
SRC_URI += "${URI_perl-Encode-Locale}"
SRC_URI[perl-Encode-Locale.sha256sum] = "1a7846226ee2dcb29ae55648f9f991b81c784771583e5d0fbcd7e56eff95cfbf"
RDEPENDS:perl-Encode-Locale = " \
 perl-libs \
 perl-I18N-Langinfo \
 perl-Encode \
 perl-Exporter \
 perl-base \
"

URI_perl-Encode-Locale-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Encode-Locale-tests-1.05-31.el10.noarch.rpm;name=perl-Encode-Locale-tests;unpack=0"
SRC_URI += "${URI_perl-Encode-Locale-tests}"
SRC_URI[perl-Encode-Locale-tests.sha256sum] = "fed744df999e1f24b9b0ffacecf1c81a05eb89d40fb198cd2f06c82552358e66"
RDEPENDS:perl-Encode-Locale-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Encode-Locale \
 bash \
 perl-interpreter \
"
