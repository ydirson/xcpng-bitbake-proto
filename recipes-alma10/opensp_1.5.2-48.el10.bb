# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "opensp"
PE = "0"
PV = "1.5.2"
PR = "48.el10"
PACKAGES = "opensp opensp-devel"
PROVIDES = "rpm/opensp rpm/opensp-devel"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/opensp-1.5.2-48.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "475489658432611249a3ff1a690078414262aac677ed988d05ea3bc1a5488b77"

URI_opensp = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/opensp-1.5.2-48.el10.x86_64_v2.rpm;name=opensp;unpack=0"
SRC_URI += "${URI_opensp}"
SRC_URI[opensp.sha256sum] = "e7c3cf200058883dcb2ae23e5a51f1392b0e92cd7c56a16fbbcda54f28ce0766"
RDEPENDS:opensp = " \
 glibc \
 sgml-common \
 libgcc \
 libstdc++ \
"

URI_opensp-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/opensp-devel-1.5.2-48.el10.x86_64_v2.rpm;name=opensp-devel;unpack=0"
SRC_URI += "${URI_opensp-devel}"
SRC_URI[opensp-devel.sha256sum] = "17d6eb373d3ce6b88627090a0c6121ce0df84ea821867a9c69d6b30ed787068d"
RDEPENDS:opensp-devel = " \
 opensp \
"
