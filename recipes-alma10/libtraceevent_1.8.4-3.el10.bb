# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libtraceevent"
PE = "0"
PV = "1.8.4"
PR = "3.el10"
PACKAGES = "libtraceevent libtraceevent-devel"
PROVIDES = "rpm/libtraceevent rpm/libtraceevent-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libtraceevent-1.8.4-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f99a6feeec92c50070a226790c52a843e6b8ab915c3e66428955741fa1638f3"

URI_libtraceevent = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libtraceevent-1.8.4-3.el10.x86_64_v2.rpm;name=libtraceevent;unpack=0"
SRC_URI += "${URI_libtraceevent}"
SRC_URI[libtraceevent.sha256sum] = "3de3a39d29a127a8afec3a93619e33d36e1b2532b78ecc5ada66466e5da1e5ee"
RDEPENDS:libtraceevent = " \
 glibc \
"

URI_libtraceevent-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libtraceevent-devel-1.8.4-3.el10.x86_64_v2.rpm;name=libtraceevent-devel;unpack=0"
SRC_URI += "${URI_libtraceevent-devel}"
SRC_URI[libtraceevent-devel.sha256sum] = "b03e7eb1009ac4ff5cc99046a9bfbcd7951e3166aef3f1c4a920b6675c7507ea"
RDEPENDS:libtraceevent-devel = " \
 libtraceevent \
 pkgconf-pkg-config \
"
