# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "grubby"
PE = "0"
PV = "8.40"
PR = "77.el10"
PACKAGES = "grubby"
PROVIDES = "rpm/grubby"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/grubby-8.40-77.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ec2b61541f2619824d3a415a17db614abdd0811c8838349011f61e6f68cd150"

URI_grubby = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/grubby-8.40-77.el10.x86_64_v2.rpm;name=grubby;unpack=0"
SRC_URI += "${URI_grubby}"
SRC_URI[grubby.sha256sum] = "cb41b7cc7b9f673867d7b2a1b7586283878d9e28ad3c7249fe643123a2af65e9"
RDEPENDS:grubby = " \
 grub2-tools-minimal \
 util-linux \
 bash \
 findutils \
 grub2-tools \
"
