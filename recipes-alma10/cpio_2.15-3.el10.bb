# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cpio"
PE = "0"
PV = "2.15"
PR = "3.el10"
PACKAGES = "cpio"
PROVIDES = "rpm/cpio"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/cpio-2.15-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6b9e143f13312a5a24715253d418b51eb0a380d4ea26085de943e9fe6622985"

URI_cpio = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cpio-2.15-3.el10.x86_64_v2.rpm;name=cpio;unpack=0"
SRC_URI += "${URI_cpio}"
SRC_URI[cpio.sha256sum] = "3aa2a0b7fb2afba03aafec58e5daefaa2db76b43fc0f886a6413c0326d551fd1"
RDEPENDS:cpio = " \
 glibc \
"
