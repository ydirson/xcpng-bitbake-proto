# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "librepo"
PE = "0"
PV = "1.18.0"
PR = "6.el10_0"
PACKAGES = "librepo python3-librepo librepo-devel"
PROVIDES = "rpm/librepo rpm/python3-librepo rpm/librepo-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/librepo-1.18.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28074465c1375d3505350ef4dc87cb5cdad0744262f0f121a9472ab491814097"

URI_librepo = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/librepo-1.18.0-6.el10_0.x86_64_v2.rpm;name=librepo;unpack=0"
SRC_URI += "${URI_librepo}"
SRC_URI[librepo.sha256sum] = "b008f1175dec61514a5e0766524c3de5dd94965d390d43ee79557a46e87bec31"
RDEPENDS:librepo = " \
 openssl-libs \
 libgcc \
 libxml2 \
 glib2 \
 libcurl \
 glibc \
 rpm-libs \
"

URI_python3-librepo = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-librepo-1.18.0-6.el10_0.x86_64_v2.rpm;name=python3-librepo;unpack=0"
SRC_URI += "${URI_python3-librepo}"
SRC_URI[python3-librepo.sha256sum] = "ff2448292a4f314ec9bf5614014b20f195784c8011bcc126661fb9c9b0cef3f2"
RDEPENDS:python3-librepo = " \
 python3 \
 libgcc \
 python3-libs \
 librepo \
 glib2 \
 glibc \
"

URI_librepo-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/librepo-devel-1.18.0-6.el10_0.x86_64_v2.rpm;name=librepo-devel;unpack=0"
SRC_URI += "${URI_librepo-devel}"
SRC_URI[librepo-devel.sha256sum] = "a9949556b37a8974117b642a6b66780c237ac251f4b2e81e1340fd991f61bdc3"
RDEPENDS:librepo-devel = " \
 libxml2-devel \
 glib2-devel \
 pkgconf-pkg-config \
 openssl-devel \
 librepo \
 libcurl-devel \
"
