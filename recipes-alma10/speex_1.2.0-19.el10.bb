# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "speex"
PE = "0"
PV = "1.2.0"
PR = "19.el10"
PACKAGES = "speex speex-devel speex-tools"
PROVIDES = "rpm/speex rpm/speex-devel rpm/speex-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/speex-1.2.0-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7eb9e75248d913d45b897aede07126e7230df337c3420127894244ab60dc9627"

URI_speex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/speex-1.2.0-19.el10.x86_64_v2.rpm;name=speex;unpack=0"
SRC_URI += "${URI_speex}"
SRC_URI[speex.sha256sum] = "859c73b205b9a35ba3528a9c832597bfc15ee2eba9037e1d64adf2b11414787a"
RDEPENDS:speex = " \
 glibc \
"

URI_speex-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/speex-devel-1.2.0-19.el10.x86_64_v2.rpm;name=speex-devel;unpack=0"
SRC_URI += "${URI_speex-devel}"
SRC_URI[speex-devel.sha256sum] = "186c118f11a360c26d7a2d53366ff682df710ecc65aaf9e29492be9744657bea"
RDEPENDS:speex-devel = " \
 speex \
 pkgconf-pkg-config \
"

URI_speex-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/speex-tools-1.2.0-19.el10.x86_64_v2.rpm;name=speex-tools;unpack=0"
SRC_URI += "${URI_speex-tools}"
SRC_URI[speex-tools.sha256sum] = "0807c56c1f3609f4e0a72ab6521ef1d568400c21428f87696a715a023fe79eb1"
RDEPENDS:speex-tools = " \
 glibc \
 speex \
 libogg \
 speexdsp \
"
