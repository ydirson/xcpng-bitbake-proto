# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "varnish"
PE = "0"
PV = "7.6.1"
PR = "2.el10_0.1"
PACKAGES = "varnish varnish-docs varnish-devel"
PROVIDES = "rpm/varnish rpm/varnish-docs rpm/varnish-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/varnish-7.6.1-2.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc8e571cbf7136b6cab1dd2b32a0a0e397b187cf40ad6df1cca149b61c381380"

URI_varnish = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/varnish-7.6.1-2.el10_0.1.x86_64_v2.rpm;name=varnish;unpack=0"
SRC_URI += "${URI_varnish}"
SRC_URI[varnish.sha256sum] = "e3eff6dafa83b74fdbfdc41ddca6c14c785e625dc09b8a0918a8936cdbf053c1"
RDEPENDS:varnish = " \
 logrotate \
 shadow-utils \
 systemd \
 util-linux \
 redhat-rpm-config \
 libgcc \
 ncurses \
 bash \
 ncurses-libs \
 pcre2 \
 gcc \
 glibc \
 libedit \
"

URI_varnish-docs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/varnish-docs-7.6.1-2.el10_0.1.x86_64_v2.rpm;name=varnish-docs;unpack=0"
SRC_URI += "${URI_varnish-docs}"
SRC_URI[varnish-docs.sha256sum] = "f154792874d8b60378df156fbde0ddd0371435bf73f58a160e99674e83daf30d"
RDEPENDS:varnish-docs = ""

URI_varnish-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/varnish-devel-7.6.1-2.el10_0.1.x86_64_v2.rpm;name=varnish-devel;unpack=0"
SRC_URI += "${URI_varnish-devel}"
SRC_URI[varnish-devel.sha256sum] = "45abb669803d5b68d5d69650cec46584bd6cff41bf71b51391521c8a05b9fddf"
RDEPENDS:varnish-devel = " \
 python3 \
 pkgconf-pkg-config \
 varnish \
"
