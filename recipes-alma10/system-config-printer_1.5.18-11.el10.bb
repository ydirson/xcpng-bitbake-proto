# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "system-config-printer"
PE = "0"
PV = "1.5.18"
PR = "11.el10"
PACKAGES = "system-config-printer-libs system-config-printer-udev"
PROVIDES = "rpm/system-config-printer-libs rpm/system-config-printer-udev"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/system-config-printer-1.5.18-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f78105d97d4b8e7fe55a2ef164588b20d29e9a7f88a907d4eec76da7c79ee62"

URI_system-config-printer-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/system-config-printer-libs-1.5.18-11.el10.noarch.rpm;name=system-config-printer-libs;unpack=0"
SRC_URI += "${URI_system-config-printer-libs}"
SRC_URI[system-config-printer-libs.sha256sum] = "41e1254df1b1667546a8a0a679dd4563649b224a65a7a24e656b4a4da76d1067"
RDEPENDS:system-config-printer-libs = " \
 python3 \
 python3-gobject \
 gobject-introspection \
 python3-dbus \
 python3-cups \
 bash \
 gtk3 \
 libnotify \
"

URI_system-config-printer-udev = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/system-config-printer-udev-1.5.18-11.el10.x86_64_v2.rpm;name=system-config-printer-udev;unpack=0"
SRC_URI += "${URI_system-config-printer-udev}"
SRC_URI[system-config-printer-udev.sha256sum] = "dbf68bebc55a66172fdc00ebb2a2c59eb2b4d40e3c020822e1ad751ad495b570"
RDEPENDS:system-config-printer-udev = " \
 python3 \
 systemd-libs \
 system-config-printer-libs \
 cups-libs \
 glib2 \
 glibc \
 libusb1 \
"
