# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hdparm"
PE = "0"
PV = "9.65"
PR = "6.el10"
PACKAGES = "hdparm"
PROVIDES = "rpm/hdparm"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/hdparm-9.65-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36d50b27e71e87166238b8bc2bf894a2423a6ba099649847d49b98e20fc9a9db"

URI_hdparm = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/hdparm-9.65-6.el10.x86_64_v2.rpm;name=hdparm;unpack=0"
SRC_URI += "${URI_hdparm}"
SRC_URI[hdparm.sha256sum] = "a178332d4e4d08e84caa223aa99fa02183c17be4ee4d15a14b7bdd04dcb30bd4"
RDEPENDS:hdparm = " \
 glibc \
"
