# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-dbus-python-client-gen"
PE = "0"
PV = "0.8.3"
PR = "7.el10"
PACKAGES = "python3-dbus-python-client-gen"
PROVIDES = "rpm/python3-dbus-python-client-gen"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-dbus-python-client-gen-0.8.3-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8d17215bfaf457ecbeee066d6f5c5f8aef1eb3137160df0b9893ebb2e72bb09"

URI_python3-dbus-python-client-gen = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-dbus-python-client-gen-0.8.3-7.el10.noarch.rpm;name=python3-dbus-python-client-gen;unpack=0"
SRC_URI += "${URI_python3-dbus-python-client-gen}"
SRC_URI[python3-dbus-python-client-gen.sha256sum] = "22b751a0c9154148687c07709b005763bfb7b5a53f81b1acfc16487de0802a9a"
RDEPENDS:python3-dbus-python-client-gen = " \
 python3 \
 python3-into-dbus-python \
 python3-dbus \
"
