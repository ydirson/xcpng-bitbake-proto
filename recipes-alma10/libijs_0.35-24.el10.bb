# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libijs"
PE = "0"
PV = "0.35"
PR = "24.el10"
PACKAGES = "libijs libijs-devel libijs-doc"
PROVIDES = "rpm/libijs rpm/libijs-devel rpm/libijs-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libijs-0.35-24.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "98fb63db5b8a036346a1fd7b3657dc0d711837e5ace1ed6ec4def6b51c5a28cf"

URI_libijs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libijs-0.35-24.el10.x86_64_v2.rpm;name=libijs;unpack=0"
SRC_URI += "${URI_libijs}"
SRC_URI[libijs.sha256sum] = "bfe65e7d076b745768234d3966ccd5e45c2767cc13da6034ea55453b2656c49d"
RDEPENDS:libijs = " \
 glibc \
"

URI_libijs-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libijs-devel-0.35-24.el10.x86_64_v2.rpm;name=libijs-devel;unpack=0"
SRC_URI += "${URI_libijs-devel}"
SRC_URI[libijs-devel.sha256sum] = "e850d8aceae4bee42d1267e70b239ed06f55e8215fcd0672a42794e3f14d5d13"
RDEPENDS:libijs-devel = " \
 pkgconf-pkg-config \
 libijs \
"

URI_libijs-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libijs-doc-0.35-24.el10.noarch.rpm;name=libijs-doc;unpack=0"
SRC_URI += "${URI_libijs-doc}"
SRC_URI[libijs-doc.sha256sum] = "c40072f453ea2f99dcabc4bd813356ebf4cc5300d9db62ad7970b2a2bd8c4f10"
RDEPENDS:libijs-doc = " \
 libijs \
"
