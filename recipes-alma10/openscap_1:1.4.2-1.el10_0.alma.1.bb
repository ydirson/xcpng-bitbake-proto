# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "openscap"
PE = "1"
PV = "1.4.2"
PR = "1.el10_0.alma.1"
PACKAGES = "openscap openscap-engine-sce openscap-scanner openscap-utils"
PROVIDES = "rpm/openscap rpm/openscap-engine-sce rpm/openscap-scanner rpm/openscap-utils"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/openscap-1.4.2-1.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0f51930bc05075606b47e4ccb42efb85e93f8d079205de15932f1dd908fda7d"

URI_openscap = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/openscap-1.4.2-1.el10_0.alma.1.x86_64_v2.rpm;name=openscap;unpack=0"
SRC_URI += "${URI_openscap}"
SRC_URI[openscap.sha256sum] = "7e2f52df7719d268bc2255f55868fb0715ef279153a9952f3d47782f16e6488e"
RDEPENDS:openscap = " \
 nss \
 procps-ng \
 dbus \
 dbus-libs \
 libselinux \
 xmlsec1 \
 xmlsec1-openssl \
 libacl \
 libblkid \
 libcap \
 libcurl \
 openldap \
 libgcc \
 libxml2 \
 libyaml \
 pcre2 \
 bash \
 libxslt \
 bzip2-libs \
 glib2 \
 popt \
 glibc \
 rpm-libs \
"

URI_openscap-engine-sce = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/openscap-engine-sce-1.4.2-1.el10_0.alma.1.x86_64_v2.rpm;name=openscap-engine-sce;unpack=0"
SRC_URI += "${URI_openscap-engine-sce}"
SRC_URI[openscap-engine-sce.sha256sum] = "105015534b699caad6aefb683c6c8e850b5d90798d8dc51b72b83ba34a7bcc34"
RDEPENDS:openscap-engine-sce = " \
 glibc \
 openscap \
"

URI_openscap-scanner = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/openscap-scanner-1.4.2-1.el10_0.alma.1.x86_64_v2.rpm;name=openscap-scanner;unpack=0"
SRC_URI += "${URI_openscap-scanner}"
SRC_URI[openscap-scanner.sha256sum] = "cffa63359f27b9d6dab5bad3339fd39e1cd984212f327816fc4b421a3011ccc3"
RDEPENDS:openscap-scanner = " \
 glibc \
 openscap \
 bash \
 libcurl \
"

URI_openscap-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/openscap-utils-1.4.2-1.el10_0.alma.1.x86_64_v2.rpm;name=openscap-utils;unpack=0"
SRC_URI += "${URI_openscap-utils}"
SRC_URI[openscap-utils.sha256sum] = "dd63a1f3250916497c0794acbbc9fafd8b035fe5fcbc592d56f6b0fca31270ae"
RDEPENDS:openscap-utils = " \
 python3 \
 openscap \
 openscap-scanner \
 rpm-build \
 bash \
 rpmdevtools \
"
