# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libgtop2"
PE = "0"
PV = "2.41.2"
PR = "5.el10"
PACKAGES = "libgtop2 libgtop2-devel"
PROVIDES = "rpm/libgtop2 rpm/libgtop2-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libgtop2-2.41.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "693c3328c2dca90c31bd9c2c37cdbbab598e7c5e5ae59a90e9d09f935dd7d4c6"

URI_libgtop2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libgtop2-2.41.2-5.el10.x86_64_v2.rpm;name=libgtop2;unpack=0"
SRC_URI += "${URI_libgtop2}"
SRC_URI[libgtop2.sha256sum] = "a337f92584f2e344020ddbac6f6c4cd39ee8e0bd820639827ca1b407db39b93f"
RDEPENDS:libgtop2 = " \
 glibc \
 glib2 \
"

URI_libgtop2-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libgtop2-devel-2.41.2-5.el10.x86_64_v2.rpm;name=libgtop2-devel;unpack=0"
SRC_URI += "${URI_libgtop2-devel}"
SRC_URI[libgtop2-devel.sha256sum] = "174f0e62c6f06933487f503f329b7acd6d73e5933cb6a4bc19ac35c1e45ea422"
RDEPENDS:libgtop2-devel = " \
 glib2-devel \
 libgtop2 \
 pkgconf-pkg-config \
"
