# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "git-lfs"
PE = "0"
PV = "3.6.1"
PR = "2.el10_0"
PACKAGES = "git-lfs"
PROVIDES = "rpm/git-lfs"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/git-lfs-3.6.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2e5ab2292214ae44393c7ca2187afbcc7ec21887864573fc11897f4bb0d8b16"

URI_git-lfs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/git-lfs-3.6.1-2.el10_0.x86_64_v2.rpm;name=git-lfs;unpack=0"
SRC_URI += "${URI_git-lfs}"
SRC_URI[git-lfs.sha256sum] = "0ddc4048140681e92918b5c2013902f0aee004ccc17e21817794281d7a44921e"
RDEPENDS:git-lfs = " \
 glibc \
 bash \
 git-core \
"
