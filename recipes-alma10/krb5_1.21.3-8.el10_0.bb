# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "krb5"
PE = "0"
PV = "1.21.3"
PR = "8.el10_0"
PACKAGES = "krb5-libs krb5-pkinit krb5-server krb5-server-ldap krb5-workstation libkadm5 krb5-devel krb5-tests"
PROVIDES = "rpm/krb5-libs rpm/krb5-pkinit rpm/krb5-server rpm/krb5-server-ldap rpm/krb5-workstation rpm/libkadm5 rpm/krb5-devel rpm/krb5-tests"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/krb5-1.21.3-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43360e2a26bd460e76e25b1b8cdf45683de0eef262878e44bc73fd585928ecb9"

URI_krb5-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/krb5-libs-1.21.3-8.el10_0.x86_64_v2.rpm;name=krb5-libs;unpack=0"
SRC_URI += "${URI_krb5-libs}"
SRC_URI[krb5-libs.sha256sum] = "ff2435dc320daaa17d0c8cf07eef1fa48a3f55d77fff81d3c83865727f2b3fd9"
RDEPENDS:krb5-libs = " \
 libverto \
 crypto-policies \
 keyutils-libs \
 openssl-libs \
 gawk \
 libselinux \
 libcom_err \
 glibc \
 coreutils \
 sed \
"

URI_krb5-pkinit = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/krb5-pkinit-1.21.3-8.el10_0.x86_64_v2.rpm;name=krb5-pkinit;unpack=0"
SRC_URI += "${URI_krb5-pkinit}"
SRC_URI[krb5-pkinit.sha256sum] = "9c7424646e87c10bf72b33792ec2133c86f454b6f2c2863d2eabb076a56a9098"
RDEPENDS:krb5-pkinit = " \
 keyutils-libs \
 openssl-libs \
 krb5-libs \
 libcom_err \
 glibc \
"

URI_krb5-server = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/krb5-server-1.21.3-8.el10_0.x86_64_v2.rpm;name=krb5-server;unpack=0"
SRC_URI += "${URI_krb5-server}"
SRC_URI[krb5-server.sha256sum] = "f14cce1b4531ab49a6a119428edc81a45ccf23b876096a63f57123494bd3c260"
RDEPENDS:krb5-server = " \
 libkadm5 \
 logrotate \
 systemd \
 libverto \
 libss \
 libverto-libev \
 keyutils-libs \
 openssl-libs \
 krb5-libs \
 libcom_err \
 bash \
 krb5-pkinit \
 words \
 glibc \
 libselinux \
 lmdb-libs \
"

URI_krb5-server-ldap = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/krb5-server-ldap-1.21.3-8.el10_0.x86_64_v2.rpm;name=krb5-server-ldap;unpack=0"
SRC_URI += "${URI_krb5-server-ldap}"
SRC_URI[krb5-server-ldap.sha256sum] = "c98b732e2c8723e9f8166c7375956e30783f3b7f1ca061e473206ddab222d378"
RDEPENDS:krb5-server-ldap = " \
 libkadm5 \
 keyutils-libs \
 openssl-libs \
 krb5-libs \
 libcom_err \
 krb5-server \
 glibc \
 openldap \
"

URI_krb5-workstation = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/krb5-workstation-1.21.3-8.el10_0.x86_64_v2.rpm;name=krb5-workstation;unpack=0"
SRC_URI += "${URI_krb5-workstation}"
SRC_URI[krb5-workstation.sha256sum] = "10e4b226923904583ac85fd9b3e1369d4edd96c6df0b38af78ca734adb0f53be"
RDEPENDS:krb5-workstation = " \
 libkadm5 \
 libss \
 pam-libs \
 krb5-libs \
 libcom_err \
 bash \
 krb5-pkinit \
 glibc \
"

URI_libkadm5 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libkadm5-1.21.3-8.el10_0.x86_64_v2.rpm;name=libkadm5;unpack=0"
SRC_URI += "${URI_libkadm5}"
SRC_URI[libkadm5.sha256sum] = "6d00e0ea106543ed9ca91de4d8671cb10e849a203e6575e20003c60836f424fa"
RDEPENDS:libkadm5 = " \
 keyutils-libs \
 openssl-libs \
 krb5-libs \
 libcom_err \
 glibc \
"

URI_krb5-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/krb5-devel-1.21.3-8.el10_0.x86_64_v2.rpm;name=krb5-devel;unpack=0"
SRC_URI += "${URI_krb5-devel}"
SRC_URI[krb5-devel.sha256sum] = "cad4f1b1fbfd275ed34ea5c72d20fda29fe8cf30443cba157c9cf13d4b634996"
RDEPENDS:krb5-devel = " \
 libkadm5 \
 pkgconf-pkg-config \
 krb5-libs \
 libselinux-devel \
 bash \
 libcom_err-devel \
 keyutils-libs-devel \
 krb5-devel \
 libverto-devel \
"

URI_krb5-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/krb5-tests-1.21.3-8.el10_0.x86_64_v2.rpm;name=krb5-tests;unpack=0"
SRC_URI += "${URI_krb5-tests}"
SRC_URI[krb5-tests.sha256sum] = "e3beb9c7d5a3deeb0cc2d0247978d1b91aac31fce99ec3779bf2b60c342517cd"
RDEPENDS:krb5-tests = " \
 resolv_wrapper \
 crypto-policies \
 keyutils \
 iproute \
 pam-devel \
 libcom_err-devel \
 net-tools \
 python3-kdcproxy \
 libverto-devel \
 rpcbind \
 words \
 sed \
 gcc-c++ \
 libss-devel \
 softhsm \
 opensc \
 libverto-libev \
 openldap-devel \
 redhat-rpm-config \
 openssl-devel \
 bash \
 libselinux-devel \
 lmdb-devel \
 keyutils-libs-devel \
 logrotate \
 coreutils \
 libcmocka-devel \
 gawk \
 hostname \
 gettext \
 procps-ng \
 dejagnu \
 perl-interpreter \
"
