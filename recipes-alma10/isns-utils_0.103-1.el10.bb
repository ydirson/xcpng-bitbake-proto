# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "isns-utils"
PE = "0"
PV = "0.103"
PR = "1.el10"
PACKAGES = "isns-utils isns-utils-libs isns-utils-devel"
PROVIDES = "rpm/isns-utils rpm/isns-utils-libs rpm/isns-utils-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/isns-utils-0.103-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2a105a8f5af71179ce5f4b391eef443f57fa02773415ae3868102da6d3578a5"

URI_isns-utils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/isns-utils-0.103-1.el10.x86_64_v2.rpm;name=isns-utils;unpack=0"
SRC_URI += "${URI_isns-utils}"
SRC_URI[isns-utils.sha256sum] = "f5d897ecdb6c4c2f6bd7611bd5e3703c608ff653cdf8b97a6f8d412f6f74c647"
RDEPENDS:isns-utils = " \
 glibc \
 systemd \
 bash \
 isns-utils-libs \
"

URI_isns-utils-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/isns-utils-libs-0.103-1.el10.x86_64_v2.rpm;name=isns-utils-libs;unpack=0"
SRC_URI += "${URI_isns-utils-libs}"
SRC_URI[isns-utils-libs.sha256sum] = "53e6bbb5a556c861978423a955d896a1ded9017f49d639f8381e96a3830d9972"
RDEPENDS:isns-utils-libs = " \
 glibc \
"

URI_isns-utils-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/isns-utils-devel-0.103-1.el10.x86_64_v2.rpm;name=isns-utils-devel;unpack=0"
SRC_URI += "${URI_isns-utils-devel}"
SRC_URI[isns-utils-devel.sha256sum] = "de46772f5d10a85a7e3473ad041bc0956815905290f70c3c1fa01761e46d69f9"
RDEPENDS:isns-utils-devel = " \
 pkgconf-pkg-config \
 isns-utils-libs \
"
