# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "log4j"
PE = "0"
PV = "2.20.0"
PR = "9.el10"
PACKAGES = "log4j log4j-jcl log4j-slf4j log4j-bom log4j-javadoc log4j-web"
PROVIDES = "rpm/log4j rpm/log4j-jcl rpm/log4j-slf4j rpm/log4j-bom rpm/log4j-javadoc rpm/log4j-web"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/log4j-2.20.0-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a20bb82ce2c526df51ff4b74a8f734d555a53bd18549a12c4511b121831a4cec"

URI_log4j = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/log4j-2.20.0-9.el10.noarch.rpm;name=log4j;unpack=0"
SRC_URI += "${URI_log4j}"
SRC_URI[log4j.sha256sum] = "bb047fb7bb656e50da7733d1be468a404abc4d9cdf3c7b4b9fcad1adf5f137ce"
RDEPENDS:log4j = " \
 javapackages-filesystem \
"

URI_log4j-jcl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/log4j-jcl-2.20.0-9.el10.noarch.rpm;name=log4j-jcl;unpack=0"
SRC_URI += "${URI_log4j-jcl}"
SRC_URI[log4j-jcl.sha256sum] = "a1ae3b0f9154ee8fe0db1cf74ba56dce83a2c0fab1bbc8d993daaaa3ff0b0245"
RDEPENDS:log4j-jcl = " \
 log4j \
 javapackages-filesystem \
 apache-commons-logging \
"

URI_log4j-slf4j = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/log4j-slf4j-2.20.0-9.el10.noarch.rpm;name=log4j-slf4j;unpack=0"
SRC_URI += "${URI_log4j-slf4j}"
SRC_URI[log4j-slf4j.sha256sum] = "8cc5ddc2dfa40cdfe8abe288c9d9160c2f4d48652ea9cbf4fd7fa38f974a3a67"
RDEPENDS:log4j-slf4j = " \
 log4j \
 javapackages-filesystem \
 slf4j \
"

URI_log4j-bom = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/log4j-bom-2.20.0-9.el10.noarch.rpm;name=log4j-bom;unpack=0"
SRC_URI += "${URI_log4j-bom}"
SRC_URI[log4j-bom.sha256sum] = "c0bc1fa487c37b34eaf3a7664f2c8d5ee1253e35c5b869b4430e878faed7d704"
RDEPENDS:log4j-bom = " \
 javapackages-filesystem \
"

URI_log4j-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/log4j-javadoc-2.20.0-9.el10.noarch.rpm;name=log4j-javadoc;unpack=0"
SRC_URI += "${URI_log4j-javadoc}"
SRC_URI[log4j-javadoc.sha256sum] = "5c8fac65b41e90049d039d7e35d4554eaeb1d929b4b3adebe52ae81e4c2f3151"
RDEPENDS:log4j-javadoc = " \
 javapackages-filesystem \
"

URI_log4j-web = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/log4j-web-2.20.0-9.el10.noarch.rpm;name=log4j-web;unpack=0"
SRC_URI += "${URI_log4j-web}"
SRC_URI[log4j-web.sha256sum] = "3682897a0774e22cdf80e853abe0f7b8d779cf3c0e8473d67099c7a15b2d34f1"
RDEPENDS:log4j-web = " \
 log4j \
 javapackages-filesystem \
"
