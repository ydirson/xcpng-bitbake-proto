# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-CPAN-Meta-Requirements"
PE = "0"
PV = "2.143"
PR = "11.el10"
PACKAGES = "perl-CPAN-Meta-Requirements perl-CPAN-Meta-Requirements-tests"
PROVIDES = "rpm/perl-CPAN-Meta-Requirements rpm/perl-CPAN-Meta-Requirements-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-CPAN-Meta-Requirements-2.143-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f044d595949c209ee1be89a6e1e8565dc11bfe6fcd1abd123927408487abd2b"

URI_perl-CPAN-Meta-Requirements = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-CPAN-Meta-Requirements-2.143-11.el10.noarch.rpm;name=perl-CPAN-Meta-Requirements;unpack=0"
SRC_URI += "${URI_perl-CPAN-Meta-Requirements}"
SRC_URI[perl-CPAN-Meta-Requirements.sha256sum] = "cbc09bf15c43597169d02fe51d9b9842bc1d57e3bffcad81c2653a696b27e558"
RDEPENDS:perl-CPAN-Meta-Requirements = " \
 perl-CPAN-Meta-Requirements \
 perl-libs \
 perl-Carp \
 perl-version \
 perl-B \
"

URI_perl-CPAN-Meta-Requirements-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-CPAN-Meta-Requirements-tests-2.143-11.el10.noarch.rpm;name=perl-CPAN-Meta-Requirements-tests;unpack=0"
SRC_URI += "${URI_perl-CPAN-Meta-Requirements-tests}"
SRC_URI[perl-CPAN-Meta-Requirements-tests.sha256sum] = "15a6ae4ea8fa63271e1de472e95a47e8204f479281d7167a3b5065674782cd63"
RDEPENDS:perl-CPAN-Meta-Requirements-tests = " \
 perl-CPAN-Meta-Requirements \
 perl-Test-Harness \
 perl-libs \
 perl-ExtUtils-MakeMaker \
 perl-Test-Simple \
 perl-version \
 perl-PathTools \
 bash \
 perl-interpreter \
"
