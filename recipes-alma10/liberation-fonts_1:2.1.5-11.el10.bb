# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "liberation-fonts"
PE = "1"
PV = "2.1.5"
PR = "11.el10"
PACKAGES = "liberation-fonts liberation-fonts-common liberation-mono-fonts liberation-sans-fonts liberation-serif-fonts"
PROVIDES = "rpm/liberation-fonts rpm/liberation-fonts-common rpm/liberation-mono-fonts rpm/liberation-sans-fonts rpm/liberation-serif-fonts"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/liberation-fonts-2.1.5-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64a05d289b77196ddf854ae29792702e4ef70bcc17916079d2ebb07866de953a"

URI_liberation-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/liberation-fonts-2.1.5-11.el10.noarch.rpm;name=liberation-fonts;unpack=0"
SRC_URI += "${URI_liberation-fonts}"
SRC_URI[liberation-fonts.sha256sum] = "06b9346053e9db6b5e77c4aa992a98f3664d9b1a8c48cc179eaee5092da53ba2"
RDEPENDS:liberation-fonts = " \
 liberation-sans-fonts \
 liberation-serif-fonts \
 liberation-mono-fonts \
"

URI_liberation-fonts-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/liberation-fonts-common-2.1.5-11.el10.noarch.rpm;name=liberation-fonts-common;unpack=0"
SRC_URI += "${URI_liberation-fonts-common}"
SRC_URI[liberation-fonts-common.sha256sum] = "28b9fe7aa4ab266b287f77eccf0c32f296e459dc194a44157ab7bcb67f6c047a"
RDEPENDS:liberation-fonts-common = " \
 fonts-filesystem \
"

URI_liberation-mono-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/liberation-mono-fonts-2.1.5-11.el10.noarch.rpm;name=liberation-mono-fonts;unpack=0"
SRC_URI += "${URI_liberation-mono-fonts}"
SRC_URI[liberation-mono-fonts.sha256sum] = "07fb9dcd2aa5ab46248895075e5245994b5901d8ea0e72b1c300cb1ac50e1847"
RDEPENDS:liberation-mono-fonts = " \
 liberation-fonts-common \
"

URI_liberation-sans-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/liberation-sans-fonts-2.1.5-11.el10.noarch.rpm;name=liberation-sans-fonts;unpack=0"
SRC_URI += "${URI_liberation-sans-fonts}"
SRC_URI[liberation-sans-fonts.sha256sum] = "f8eab0a83445461c8417268398656e6384ba269fbd18c20ce6ede70b8f46b0f5"
RDEPENDS:liberation-sans-fonts = " \
 liberation-fonts-common \
"

URI_liberation-serif-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/liberation-serif-fonts-2.1.5-11.el10.noarch.rpm;name=liberation-serif-fonts;unpack=0"
SRC_URI += "${URI_liberation-serif-fonts}"
SRC_URI[liberation-serif-fonts.sha256sum] = "39d25dc73ecb08d9456faeb9fb98b8b0661c59d1a34ca584c47116b03dc605a8"
RDEPENDS:liberation-serif-fonts = " \
 liberation-fonts-common \
"
