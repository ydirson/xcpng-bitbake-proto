# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-rjsmin"
PE = "0"
PV = "1.2.1"
PR = "9.el10"
PACKAGES = "python-rjsmin-docs python3-rjsmin"
PROVIDES = "rpm/python-rjsmin-docs rpm/python3-rjsmin"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/python-rjsmin-1.2.1-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "894173ee12ad7281ecf26397e9d38c132735e1d46f848274272322eab4195fbb"

URI_python-rjsmin-docs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python-rjsmin-docs-1.2.1-9.el10.x86_64_v2.rpm;name=python-rjsmin-docs;unpack=0"
SRC_URI += "${URI_python-rjsmin-docs}"
SRC_URI[python-rjsmin-docs.sha256sum] = "195d79388008f07f774af6ac5d1cdd2dcca09e0be0f9909162d323a7579e63dc"
RDEPENDS:python-rjsmin-docs = ""

URI_python3-rjsmin = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-rjsmin-1.2.1-9.el10.x86_64_v2.rpm;name=python3-rjsmin;unpack=0"
SRC_URI += "${URI_python3-rjsmin}"
SRC_URI[python3-rjsmin.sha256sum] = "3ec16c7937c21d64f5eade633bdb2a7e8e398c9476ada38530c92793133eec19"
RDEPENDS:python3-rjsmin = " \
 glibc \
 python3 \
"
