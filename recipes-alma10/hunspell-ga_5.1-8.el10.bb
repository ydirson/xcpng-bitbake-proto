# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-ga"
PE = "0"
PV = "5.1"
PR = "8.el10"
PACKAGES = "hunspell-ga"
PROVIDES = "rpm/hunspell-ga"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-ga-5.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab7421a80e33239c3071fed78ed2c3cde6d35353292478b488dc3a9446c7b0c4"

URI_hunspell-ga = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-ga-5.1-8.el10.noarch.rpm;name=hunspell-ga;unpack=0"
SRC_URI += "${URI_hunspell-ga}"
SRC_URI[hunspell-ga.sha256sum] = "2f70c9e2c76c191523600991e81f84394a301a29f1a396c5e4971f3084d58033"
RDEPENDS:hunspell-ga = " \
 hunspell-filesystem \
"
