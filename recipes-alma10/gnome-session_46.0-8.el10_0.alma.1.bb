# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-session"
PE = "0"
PV = "46.0"
PR = "8.el10_0.alma.1"
PACKAGES = "gnome-session gnome-session-wayland-session"
PROVIDES = "rpm/gnome-session rpm/gnome-session-wayland-session"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-session-46.0-8.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23acc1106f021210537a05b685a041cda3c78549a798f94710c58ce70ee8b4a7"

URI_gnome-session = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-session-46.0-8.el10_0.alma.1.x86_64_v2.rpm;name=gnome-session;unpack=0"
SRC_URI += "${URI_gnome-session}"
SRC_URI[gnome-session.sha256sum] = "e7fa09abcde4fc4b3c06a515b988d984e18761ac10e06ce79a9abf349ff05791"
RDEPENDS:gnome-session = " \
 systemd-libs \
 libICE \
 libSM \
 libX11 \
 dbus \
 libXcomposite \
 gnome-control-center-filesystem \
 libepoxy \
 gnome-desktop3 \
 json-glib \
 dconf \
 almalinux-logos \
 libglvnd-egl \
 libglvnd-gles \
 libglvnd-glx \
 libgcc \
 bash \
 gsettings-desktop-schemas \
 glib2 \
 gtk3 \
 glibc \
"

URI_gnome-session-wayland-session = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-session-wayland-session-46.0-8.el10_0.alma.1.x86_64_v2.rpm;name=gnome-session-wayland-session;unpack=0"
SRC_URI += "${URI_gnome-session-wayland-session}"
SRC_URI[gnome-session-wayland-session.sha256sum] = "75a9b8eedfaef3aaa90afbcbae5d9e425041c6ef47d8d22e12fd316c8c91b5bf"
RDEPENDS:gnome-session-wayland-session = " \
 gnome-session \
 gnome-shell \
 xorg-x11-server-Xwayland \
"
