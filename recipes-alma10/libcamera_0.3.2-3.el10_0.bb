# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libcamera"
PE = "0"
PV = "0.3.2"
PR = "3.el10_0"
PACKAGES = "libcamera libcamera-devel libcamera-doc libcamera-gstreamer libcamera-ipa libcamera-qcam libcamera-tools libcamera-v4l2 python3-libcamera"
PROVIDES = "rpm/libcamera rpm/libcamera-devel rpm/libcamera-doc rpm/libcamera-gstreamer rpm/libcamera-ipa rpm/libcamera-qcam rpm/libcamera-tools rpm/libcamera-v4l2 rpm/python3-libcamera"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libcamera-0.3.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbe69912d554aced0f22a653840be8911161f29ea01633ecb2d70f9cdd309df8"

URI_libcamera = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libcamera-0.3.2-3.el10_0.x86_64_v2.rpm;name=libcamera;unpack=0"
SRC_URI += "${URI_libcamera}"
SRC_URI[libcamera.sha256sum] = "d8d9a7fbe299370406586c018b8eb8a8e5d889a046c2d9db603931b303e56f63"
RDEPENDS:libcamera = " \
 gnutls \
 systemd-libs \
 libgcc \
 libyaml \
 libstdc++ \
 glibc \
"

URI_libcamera-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libcamera-devel-0.3.2-3.el10_0.x86_64_v2.rpm;name=libcamera-devel;unpack=0"
SRC_URI += "${URI_libcamera-devel}"
SRC_URI[libcamera-devel.sha256sum] = "3f0709c44b74de385d28426f2ac432fb4b3760d6dceab16d293068d3f965eed2"
RDEPENDS:libcamera-devel = " \
 pkgconf-pkg-config \
 libcamera \
 libcamera-devel \
"

URI_libcamera-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libcamera-doc-0.3.2-3.el10_0.x86_64_v2.rpm;name=libcamera-doc;unpack=0"
SRC_URI += "${URI_libcamera-doc}"
SRC_URI[libcamera-doc.sha256sum] = "3ed4e50f00e7d28c909a2c5e9fb93878caa55cee6118df506fc3c220953fb40a"
RDEPENDS:libcamera-doc = ""

URI_libcamera-gstreamer = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libcamera-gstreamer-0.3.2-3.el10_0.x86_64_v2.rpm;name=libcamera-gstreamer;unpack=0"
SRC_URI += "${URI_libcamera-gstreamer}"
SRC_URI[libcamera-gstreamer.sha256sum] = "a8207f78f72ae4ee8489d3bc092559c26fa1bf25064677094649eebc23c0cddb"
RDEPENDS:libcamera-gstreamer = " \
 libcamera \
 gstreamer1 \
 libgcc \
 gstreamer1-plugins-base \
 libstdc++ \
 glib2 \
 glibc \
"

URI_libcamera-ipa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libcamera-ipa-0.3.2-3.el10_0.x86_64_v2.rpm;name=libcamera-ipa;unpack=0"
SRC_URI += "${URI_libcamera-ipa}"
SRC_URI[libcamera-ipa.sha256sum] = "052d089aebb2f5ed6390b0deb65e7d92b6cea5b540c09fa017c496cb99718bed"
RDEPENDS:libcamera-ipa = " \
 glibc \
 libgcc \
 libstdc++ \
 libcamera \
"

URI_libcamera-qcam = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libcamera-qcam-0.3.2-3.el10_0.x86_64_v2.rpm;name=libcamera-qcam;unpack=0"
SRC_URI += "${URI_libcamera-qcam}"
SRC_URI[libcamera-qcam.sha256sum] = "a89083055a120bc72b6e88cf1b877b4db422f2a0072dd48fe75e3a5df133dd82"
RDEPENDS:libcamera-qcam = " \
 libcamera \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
 libtiff \
"

URI_libcamera-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libcamera-tools-0.3.2-3.el10_0.x86_64_v2.rpm;name=libcamera-tools;unpack=0"
SRC_URI += "${URI_libcamera-tools}"
SRC_URI[libcamera-tools.sha256sum] = "386a1dbac91be25bc84bea02be8b6263595fc75fc95fe5ef3bd99334578adcfd"
RDEPENDS:libcamera-tools = " \
 libevent \
 libcamera \
 libgcc \
 libyaml \
 libstdc++ \
 SDL2 \
 glibc \
 libjpeg-turbo \
 libdrm \
 libtiff \
"

URI_libcamera-v4l2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libcamera-v4l2-0.3.2-3.el10_0.x86_64_v2.rpm;name=libcamera-v4l2;unpack=0"
SRC_URI += "${URI_libcamera-v4l2}"
SRC_URI[libcamera-v4l2.sha256sum] = "d273d9cf0c5dbd59b8d0bdedaf0f2dfa57cd830cdf56c550bb80ef9f19c8edf7"
RDEPENDS:libcamera-v4l2 = " \
 libcamera \
 libgcc \
 libstdc++ \
 bash \
 glibc \
"

URI_python3-libcamera = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-libcamera-0.3.2-3.el10_0.x86_64_v2.rpm;name=python3-libcamera;unpack=0"
SRC_URI += "${URI_python3-libcamera}"
SRC_URI[python3-libcamera.sha256sum] = "f919a334325ae2d37f10add528c358b7239c66919870bf0eba5c727f056eea12"
RDEPENDS:python3-libcamera = " \
 python3 \
 libcamera \
 libgcc \
 libstdc++ \
 glibc \
"
