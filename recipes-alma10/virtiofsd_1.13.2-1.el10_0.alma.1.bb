# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "virtiofsd"
PE = "0"
PV = "1.13.2"
PR = "1.el10_0.alma.1"
PACKAGES = "virtiofsd"
PROVIDES = "rpm/virtiofsd"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/virtiofsd-1.13.2-1.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9fa101b95d4c5c9ba516e50fdd944e87ebed4f30615ad8ff999bd888e6882687"

URI_virtiofsd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/virtiofsd-1.13.2-1.el10_0.alma.1.x86_64_v2.rpm;name=virtiofsd;unpack=0"
SRC_URI += "${URI_virtiofsd}"
SRC_URI[virtiofsd.sha256sum] = "f7b8f333581394cfeb6b82a98a4ca3be8ee8b3fdab7b89feec398274f53ab347"
RDEPENDS:virtiofsd = " \
 shadow-utils \
 libgcc \
 libcap-ng \
 libseccomp \
 glibc \
 qemu-kvm-common \
"
