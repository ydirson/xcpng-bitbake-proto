# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Config-Perl-V"
PE = "0"
PV = "0.36"
PR = "512.el10"
PACKAGES = "perl-Config-Perl-V perl-Config-Perl-V-tests"
PROVIDES = "rpm/perl-Config-Perl-V rpm/perl-Config-Perl-V-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Config-Perl-V-0.36-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffc14fc6240ecfc893776f91e9855b8a047d2cf7bb26794d9a35ff66ff1f5779"

URI_perl-Config-Perl-V = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Config-Perl-V-0.36-512.el10.noarch.rpm;name=perl-Config-Perl-V;unpack=0"
SRC_URI += "${URI_perl-Config-Perl-V}"
SRC_URI[perl-Config-Perl-V.sha256sum] = "762b3771c54f9523b873f07e5b034be70f92a09c9db386a99ed8212aae9c608e"
RDEPENDS:perl-Config-Perl-V = " \
 perl-Exporter \
 perl-libs \
 perl-vars \
"

URI_perl-Config-Perl-V-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Config-Perl-V-tests-0.36-512.el10.noarch.rpm;name=perl-Config-Perl-V-tests;unpack=0"
SRC_URI += "${URI_perl-Config-Perl-V-tests}"
SRC_URI[perl-Config-Perl-V-tests.sha256sum] = "7f38ac44def394cc5f4b286223ba0fb96cc8ec29db5dfe8c470abe72f4d76502"
RDEPENDS:perl-Config-Perl-V-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Digest-MD5 \
 perl-Config-Perl-V \
 bash \
 perl-interpreter \
 perl-Test-NoWarnings \
"
