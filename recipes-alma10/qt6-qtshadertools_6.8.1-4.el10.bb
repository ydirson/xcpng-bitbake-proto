# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtshadertools"
PE = "0"
PV = "6.8.1"
PR = "4.el10"
PACKAGES = "qt6-qtshadertools qt6-qtshadertools-devel qt6-qtshadertools-tests"
PROVIDES = "rpm/qt6-qtshadertools rpm/qt6-qtshadertools-devel rpm/qt6-qtshadertools-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtshadertools-6.8.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e67ffa7424b9ac3f827b65ee2a4f58387630b8d78faa72cdb20df752fe035d48"

URI_qt6-qtshadertools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtshadertools-6.8.1-4.el10.x86_64_v2.rpm;name=qt6-qtshadertools;unpack=0"
SRC_URI += "${URI_qt6-qtshadertools}"
SRC_URI[qt6-qtshadertools.sha256sum] = "e17b3a552ddf342dbe14d062f9022058da905c90a9f9ee4a965a2e136f281a66"
RDEPENDS:qt6-qtshadertools = " \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
 spirv-tools-libs \
"

URI_qt6-qtshadertools-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtshadertools-devel-6.8.1-4.el10.x86_64_v2.rpm;name=qt6-qtshadertools-devel;unpack=0"
SRC_URI += "${URI_qt6-qtshadertools-devel}"
SRC_URI[qt6-qtshadertools-devel.sha256sum] = "26b30d94ada99583e3352522aeaf8d2a4236f426d34c71ab629259323d550f32"
RDEPENDS:qt6-qtshadertools-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 spirv-tools \
 qt6-qtshadertools \
"

URI_qt6-qtshadertools-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtshadertools-tests-6.8.1-4.el10.x86_64_v2.rpm;name=qt6-qtshadertools-tests;unpack=0"
SRC_URI += "${URI_qt6-qtshadertools-tests}"
SRC_URI[qt6-qtshadertools-tests.sha256sum] = "af6741a54a46f173df9a6881d90fdb3718394ce2466ecac1d24a15c26b86bef0"
RDEPENDS:qt6-qtshadertools-tests = " \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
 qt6-qtshadertools \
"
