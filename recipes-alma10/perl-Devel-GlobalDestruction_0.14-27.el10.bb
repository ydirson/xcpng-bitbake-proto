# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Devel-GlobalDestruction"
PE = "0"
PV = "0.14"
PR = "27.el10"
PACKAGES = "perl-Devel-GlobalDestruction perl-Devel-GlobalDestruction-tests"
PROVIDES = "rpm/perl-Devel-GlobalDestruction rpm/perl-Devel-GlobalDestruction-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Devel-GlobalDestruction-0.14-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72482a611f65338df7294999b2d20b6f5dbab7bc0734c88307cf11e71fc29403"

URI_perl-Devel-GlobalDestruction = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Devel-GlobalDestruction-0.14-27.el10.noarch.rpm;name=perl-Devel-GlobalDestruction;unpack=0"
SRC_URI += "${URI_perl-Devel-GlobalDestruction}"
SRC_URI[perl-Devel-GlobalDestruction.sha256sum] = "42ea06db4fc26ab92d59a9327936c474ac5c75dfa0bda42f47193863c769eb66"
RDEPENDS:perl-Devel-GlobalDestruction = " \
 perl-libs \
 perl-Sub-Exporter-Progressive \
"

URI_perl-Devel-GlobalDestruction-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Devel-GlobalDestruction-tests-0.14-27.el10.noarch.rpm;name=perl-Devel-GlobalDestruction-tests;unpack=0"
SRC_URI += "${URI_perl-Devel-GlobalDestruction-tests}"
SRC_URI[perl-Devel-GlobalDestruction-tests.sha256sum] = "a1ffe9a3a7b1292c2a3c4cc94e6bd427372e69cf13591d2e4895338a86fa7767"
RDEPENDS:perl-Devel-GlobalDestruction-tests = " \
 perl-threads \
 perl-threads-shared \
 perl-Test-Harness \
 perl-libs \
 perl-FindBin \
 perl-POSIX \
 perl-IPC-Open3 \
 bash \
 perl-Devel-GlobalDestruction \
 perl-interpreter \
"
