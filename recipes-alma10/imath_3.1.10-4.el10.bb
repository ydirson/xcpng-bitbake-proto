# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "imath"
PE = "0"
PV = "3.1.10"
PR = "4.el10"
PACKAGES = "imath python3-imath imath-devel"
PROVIDES = "rpm/imath rpm/python3-imath rpm/imath-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/imath-3.1.10-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0295c1b24a796dbc8ce548a9019016215f1da37d6b5f72ce80d6efb3c11bb365"

URI_imath = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/imath-3.1.10-4.el10.x86_64_v2.rpm;name=imath;unpack=0"
SRC_URI += "${URI_imath}"
SRC_URI[imath.sha256sum] = "62d6f930c3603288fa09e0d61f75481753457e7dc1a183aac68fa69e3908ad10"
RDEPENDS:imath = " \
 glibc \
 libstdc++ \
"

URI_python3-imath = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-imath-3.1.10-4.el10.x86_64_v2.rpm;name=python3-imath;unpack=0"
SRC_URI += "${URI_python3-imath}"
SRC_URI[python3-imath.sha256sum] = "9ef22c616f21101f854018891b909ab8edac5d072059f565276ce45d51c505ae"
RDEPENDS:python3-imath = " \
 python3 \
 imath \
 libgcc \
 boost-python3 \
 python3-libs \
 libstdc++ \
 glibc \
"

URI_imath-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/imath-devel-3.1.10-4.el10.x86_64_v2.rpm;name=imath-devel;unpack=0"
SRC_URI += "${URI_imath-devel}"
SRC_URI[imath-devel.sha256sum] = "69cb993377dc95a785003ca7317fd059ce180fd87bf478b653a1c0bba890171d"
RDEPENDS:imath-devel = " \
 imath \
 cmake-filesystem \
 python3-imath \
 pkgconf-pkg-config \
 python3-devel \
 boost-devel \
"
