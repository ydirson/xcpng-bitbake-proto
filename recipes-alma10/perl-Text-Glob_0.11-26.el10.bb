# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Text-Glob"
PE = "0"
PV = "0.11"
PR = "26.el10"
PACKAGES = "perl-Text-Glob perl-Text-Glob-tests"
PROVIDES = "rpm/perl-Text-Glob rpm/perl-Text-Glob-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Text-Glob-0.11-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b144763484b83865993dadd94e6c013fde23fbc28e5b3e22e72c61226d0e0d51"

URI_perl-Text-Glob = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Text-Glob-0.11-26.el10.noarch.rpm;name=perl-Text-Glob;unpack=0"
SRC_URI += "${URI_perl-Text-Glob}"
SRC_URI[perl-Text-Glob.sha256sum] = "310cfa9b6f4c386904656354c718e82a8ee8c2b24da4d6822024529409bd05f6"
RDEPENDS:perl-Text-Glob = " \
 perl-constant \
 perl-Exporter \
 perl-libs \
 perl-vars \
"

URI_perl-Text-Glob-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Text-Glob-tests-0.11-26.el10.noarch.rpm;name=perl-Text-Glob-tests;unpack=0"
SRC_URI += "${URI_perl-Text-Glob-tests}"
SRC_URI[perl-Text-Glob-tests.sha256sum] = "4c541b37ece6fafdf48297a48a2db84171a82f0ab75f4fadace1fbb46409b9e6"
RDEPENDS:perl-Text-Glob-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Text-Glob \
 bash \
 perl-interpreter \
"
