# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libXaw"
PE = "0"
PV = "1.0.15"
PR = "5.el10"
PACKAGES = "libXaw libXaw-devel"
PROVIDES = "rpm/libXaw rpm/libXaw-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libXaw-1.0.15-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3cc1aeca75d8254f0f9a89e124b43615741c1d6368e366b865d1d1dee74aa0c1"

URI_libXaw = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXaw-1.0.15-5.el10.x86_64_v2.rpm;name=libXaw;unpack=0"
SRC_URI += "${URI_libXaw}"
SRC_URI[libXaw.sha256sum] = "6d0935e7de0328c553dedd96443c7c766a326cd8fc3d642637499a050d6316ff"
RDEPENDS:libXaw = " \
 libXmu \
 libXpm \
 libX11 \
 libXt \
 glibc \
 libXext \
"

URI_libXaw-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXaw-devel-1.0.15-5.el10.x86_64_v2.rpm;name=libXaw-devel;unpack=0"
SRC_URI += "${URI_libXaw-devel}"
SRC_URI[libXaw-devel.sha256sum] = "e525352f34c8a8689984bcf44bb415a294da678cee758e14fecf14d95c2589c6"
RDEPENDS:libXaw-devel = " \
 libXext-devel \
 libXmu-devel \
 pkgconf-pkg-config \
 libXpm-devel \
 libX11-devel \
 xorg-x11-proto-devel \
 libXt-devel \
 libXaw \
"
