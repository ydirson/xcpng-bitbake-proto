# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-MRO-Compat"
PE = "0"
PV = "0.15"
PR = "12.el10"
PACKAGES = "perl-MRO-Compat perl-MRO-Compat-tests"
PROVIDES = "rpm/perl-MRO-Compat rpm/perl-MRO-Compat-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-MRO-Compat-0.15-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5dcda64f958ed36d7d9efe60510a05bf027b81be8efeb796c0879592a6bd4d63"

URI_perl-MRO-Compat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-MRO-Compat-0.15-12.el10.noarch.rpm;name=perl-MRO-Compat;unpack=0"
SRC_URI += "${URI_perl-MRO-Compat}"
SRC_URI[perl-MRO-Compat.sha256sum] = "9075cd518291789985bede42efb324c2bd850796236e995e427123a874ce71c1"
RDEPENDS:perl-MRO-Compat = " \
 perl-libs \
"

URI_perl-MRO-Compat-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-MRO-Compat-tests-0.15-12.el10.noarch.rpm;name=perl-MRO-Compat-tests;unpack=0"
SRC_URI += "${URI_perl-MRO-Compat-tests}"
SRC_URI[perl-MRO-Compat-tests.sha256sum] = "1ea2557ae7bf6720c03ace22bf5285c5fcade538e05bc1d3aea9e3eab4ab6ef1"
RDEPENDS:perl-MRO-Compat-tests = " \
 perl-MRO-Compat \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 bash \
 perl-interpreter \
"
