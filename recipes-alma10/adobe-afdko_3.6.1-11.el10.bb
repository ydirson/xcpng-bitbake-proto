# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "adobe-afdko"
PE = "0"
PV = "3.6.1"
PR = "11.el10"
PACKAGES = "adobe-afdko"
PROVIDES = "rpm/adobe-afdko"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/adobe-afdko-3.6.1-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e760597cdd20cd25fdce9ba7e7009b0bff6931196a7987b1e0be70d4c975e3d"

URI_adobe-afdko = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/adobe-afdko-3.6.1-11.el10.x86_64_v2.rpm;name=adobe-afdko;unpack=0"
SRC_URI += "${URI_adobe-afdko}"
SRC_URI[adobe-afdko.sha256sum] = "df12a95abacd4083939e50c32697c42c1bf85046cfb3d924d81367f68f68a421"
RDEPENDS:adobe-afdko = " \
 glibc \
"
