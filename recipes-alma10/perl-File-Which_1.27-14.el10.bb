# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-File-Which"
PE = "0"
PV = "1.27"
PR = "14.el10"
PACKAGES = "perl-File-Which perl-File-Which-tests"
PROVIDES = "rpm/perl-File-Which rpm/perl-File-Which-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-File-Which-1.27-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e91963e0f6ad731ae1e7a18c1598bb9f82f06cc0d17dc995022bc032cef9f0a6"

URI_perl-File-Which = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-File-Which-1.27-14.el10.noarch.rpm;name=perl-File-Which;unpack=0"
SRC_URI += "${URI_perl-File-Which}"
SRC_URI[perl-File-Which.sha256sum] = "0da102b77913fa5a2ab14160ea1df00cf4edefc16602543eefe3ceac1077f61d"
RDEPENDS:perl-File-Which = " \
 perl-constant \
 perl-libs \
 perl-PathTools \
 perl-Exporter \
 perl-base \
"

URI_perl-File-Which-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-File-Which-tests-1.27-14.el10.noarch.rpm;name=perl-File-Which-tests;unpack=0"
SRC_URI += "${URI_perl-File-Which-tests}"
SRC_URI[perl-File-Which-tests.sha256sum] = "0f7a900f85bea52ceb0b094f98eaafdadf82f92186625eac3872ac87b23b5ce9"
RDEPENDS:perl-File-Which-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 bash \
 perl-Env \
 perl-interpreter \
 perl-File-Which \
"
