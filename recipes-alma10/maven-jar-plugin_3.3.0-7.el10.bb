# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "maven-jar-plugin"
PE = "0"
PV = "3.3.0"
PR = "7.el10"
PACKAGES = "maven-jar-plugin maven-jar-plugin-javadoc"
PROVIDES = "rpm/maven-jar-plugin rpm/maven-jar-plugin-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/maven-jar-plugin-3.3.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a107979c4c03fc72f5b832fbd46355c60379bb88edeca9331d21d24d9b10632"

URI_maven-jar-plugin = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-jar-plugin-3.3.0-7.el10.noarch.rpm;name=maven-jar-plugin;unpack=0"
SRC_URI += "${URI_maven-jar-plugin}"
SRC_URI[maven-jar-plugin.sha256sum] = "b3ee3f6344204c89aa930506d422865114fe5693055d35a7589ba5b4a83fde15"
RDEPENDS:maven-jar-plugin = " \
 plexus-utils \
 javapackages-filesystem \
 maven-archiver \
 maven-file-management \
"

URI_maven-jar-plugin-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-jar-plugin-javadoc-3.3.0-7.el10.noarch.rpm;name=maven-jar-plugin-javadoc;unpack=0"
SRC_URI += "${URI_maven-jar-plugin-javadoc}"
SRC_URI[maven-jar-plugin-javadoc.sha256sum] = "ec0fa5fb5b36518f4499f4ae31a73e49db33ea3b89cbc6477377a750b6401090"
RDEPENDS:maven-jar-plugin-javadoc = " \
 javapackages-filesystem \
"
