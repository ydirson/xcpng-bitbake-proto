# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sharutils"
PE = "0"
PV = "4.15.2"
PR = "28.el10"
PACKAGES = "sharutils"
PROVIDES = "rpm/sharutils"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/sharutils-4.15.2-28.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "632808084d78412b6e39cc5bc3e485d6eb016a22c7518d6eb8195f5e98172f45"

URI_sharutils = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/sharutils-4.15.2-28.el10.x86_64_v2.rpm;name=sharutils;unpack=0"
SRC_URI += "${URI_sharutils}"
SRC_URI[sharutils.sha256sum] = "7f77022575897a2b7ab27bfc96358cfc2e646187cf641321fcddeca2b5f4170d"
RDEPENDS:sharutils = " \
 glibc \
"
