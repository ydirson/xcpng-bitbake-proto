# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "madan-fonts"
PE = "0"
PV = "2.000"
PR = "40.el10"
PACKAGES = "madan-fonts"
PROVIDES = "rpm/madan-fonts"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/madan-fonts-2.000-40.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b886ac0a430de32e44172e233acec0a64520ae162bbde462a935f27d168ed6a7"

URI_madan-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/madan-fonts-2.000-40.el10.noarch.rpm;name=madan-fonts;unpack=0"
SRC_URI += "${URI_madan-fonts}"
SRC_URI[madan-fonts.sha256sum] = "88d1924615985a413d4cf4965deac03da5a570e28602477b36676c697a0b81c2"
RDEPENDS:madan-fonts = " \
 fonts-filesystem \
"
