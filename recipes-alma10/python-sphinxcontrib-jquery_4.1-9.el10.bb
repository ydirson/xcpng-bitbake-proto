# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-sphinxcontrib-jquery"
PE = "0"
PV = "4.1"
PR = "9.el10"
PACKAGES = "python3-sphinxcontrib-jquery"
PROVIDES = "rpm/python3-sphinxcontrib-jquery"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/python-sphinxcontrib-jquery-4.1-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca7d20dc1574879f7d16339d5ab2f000e65908026d48bdd786d3ee85332962bf"

URI_python3-sphinxcontrib-jquery = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-sphinxcontrib-jquery-4.1-9.el10.noarch.rpm;name=python3-sphinxcontrib-jquery;unpack=0"
SRC_URI += "${URI_python3-sphinxcontrib-jquery}"
SRC_URI[python3-sphinxcontrib-jquery.sha256sum] = "92f69f21fe38a8ec3962dc861c200146b20a5453299cde7f900b2fe21e02195e"
RDEPENDS:python3-sphinxcontrib-jquery = " \
 python3 \
 python3-sphinx \
"
