# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-TimeDate"
PE = "1"
PV = "2.33"
PR = "16.el10"
PACKAGES = "perl-TimeDate perl-TimeDate-tests"
PROVIDES = "rpm/perl-TimeDate rpm/perl-TimeDate-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-TimeDate-2.33-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b8ad441efd649c55768da75393a32e4d9c1d9c94b6416decb4a27f69cadcd3e"

URI_perl-TimeDate = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-TimeDate-2.33-16.el10.noarch.rpm;name=perl-TimeDate;unpack=0"
SRC_URI += "${URI_perl-TimeDate}"
SRC_URI[perl-TimeDate.sha256sum] = "663717344a27119689607b8c67283fc4ecaf3a28be65f363ef3dd11d678a3597"
RDEPENDS:perl-TimeDate = " \
 perl-TimeDate \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-Exporter \
 perl-base \
 perl-Time-Local \
"

URI_perl-TimeDate-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-TimeDate-tests-2.33-16.el10.noarch.rpm;name=perl-TimeDate-tests;unpack=0"
SRC_URI += "${URI_perl-TimeDate-tests}"
SRC_URI[perl-TimeDate-tests.sha256sum] = "eba97c4a64670be8f0958c81089f2d2a13ccdae258cfbcbde1723e015badf114"
RDEPENDS:perl-TimeDate-tests = " \
 perl-TimeDate \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 bash \
 perl-interpreter \
 perl-Time-Local \
"
