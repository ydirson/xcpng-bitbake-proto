# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-typogrify"
PE = "0"
PV = "2.0.7"
PR = "20.el10"
PACKAGES = "python3-typogrify"
PROVIDES = "rpm/python3-typogrify"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/python-typogrify-2.0.7-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c454d6ba4487d38d6a9b187cae73ea94cf3878fd102e1535f61f9458f447cdda"

URI_python3-typogrify = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-typogrify-2.0.7-20.el10.noarch.rpm;name=python3-typogrify;unpack=0"
SRC_URI += "${URI_python3-typogrify}"
SRC_URI[python3-typogrify.sha256sum] = "b081b4ea1889bc5aa86b815795f44dca77d8079b6fad53cc7efabc7975af779e"
RDEPENDS:python3-typogrify = " \
 python3 \
 python3-smartypants \
"
