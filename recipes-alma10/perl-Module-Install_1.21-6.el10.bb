# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Module-Install"
PE = "0"
PV = "1.21"
PR = "6.el10"
PACKAGES = "perl-Module-Install perl-Module-Install-tests"
PROVIDES = "rpm/perl-Module-Install rpm/perl-Module-Install-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Module-Install-1.21-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f7af1dea2f370b7effdc8a1adc1422e42b05482c604eedc9c4fbcc8c90fce9e"

URI_perl-Module-Install = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Module-Install-1.21-6.el10.noarch.rpm;name=perl-Module-Install;unpack=0"
SRC_URI += "${URI_perl-Module-Install}"
SRC_URI[perl-Module-Install.sha256sum] = "f330f49849544d4c950a18adf8125e8de829ce3f15bab5a66ecee2f21363b268"
RDEPENDS:perl-Module-Install = " \
 perl-libs \
 perl-FileHandle \
 perl-Module-Install \
 perl-FindBin \
 perl-Socket \
 perl-Module-ScanDeps \
 perl-Archive-Zip \
 perl-CPAN \
 perl-CPAN-Meta \
 perl-Carp \
 perl-vars \
 perl-YAML-Tiny \
 perl-Devel-PPPort \
 perl-Module-Build \
 perl-Module-CoreList \
 perl-ExtUtils-MakeMaker \
 perl-ExtUtils-Manifest \
 perl-Fcntl \
 perl-File-Basename \
 perl-PathTools \
 perl-File-Find \
 perl-File-Path \
 perl-File-Remove \
 perl-File-Temp \
"

URI_perl-Module-Install-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Module-Install-tests-1.21-6.el10.noarch.rpm;name=perl-Module-Install-tests;unpack=0"
SRC_URI += "${URI_perl-Module-Install-tests}"
SRC_URI[perl-Module-Install-tests.sha256sum] = "16d49a1214ee5ba3f5b2dc705e0dca2fa918a0db8f0a3876473e239a384231ff"
RDEPENDS:perl-Module-Install-tests = " \
 perl-CPAN-Meta \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-vars \
 perl-ExtUtils-MakeMaker \
 perl-Module-Install \
 perl-File-Temp \
 perl-Symbol \
 bash \
 perl-PathTools \
 perl-autodie \
 perl-interpreter \
 perl-File-Path \
 perl-lib \
"
