# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "apache-commons-beanutils"
PE = "0"
PV = "1.9.4"
PR = "21.el10_0"
PACKAGES = "apache-commons-beanutils apache-commons-beanutils-javadoc"
PROVIDES = "rpm/apache-commons-beanutils rpm/apache-commons-beanutils-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/apache-commons-beanutils-1.9.4-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83da17e8a2d57e6fae25752a8e6e975153fad9cd9f7af9d5436d4002a8229c67"

URI_apache-commons-beanutils = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/apache-commons-beanutils-1.9.4-21.el10_0.noarch.rpm;name=apache-commons-beanutils;unpack=0"
SRC_URI += "${URI_apache-commons-beanutils}"
SRC_URI[apache-commons-beanutils.sha256sum] = "4059e83bd50b918c71843552d88feb350b7b2efd37d4d1f85f281258f57bdba1"
RDEPENDS:apache-commons-beanutils = " \
 apache-commons-collections \
 javapackages-filesystem \
 apache-commons-logging \
"

URI_apache-commons-beanutils-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/apache-commons-beanutils-javadoc-1.9.4-21.el10_0.noarch.rpm;name=apache-commons-beanutils-javadoc;unpack=0"
SRC_URI += "${URI_apache-commons-beanutils-javadoc}"
SRC_URI[apache-commons-beanutils-javadoc.sha256sum] = "b87046c6aefd71b034500295acb0a9bf964dcd44c15debd74be8fabf18b2b32b"
RDEPENDS:apache-commons-beanutils-javadoc = " \
 javapackages-filesystem \
"
