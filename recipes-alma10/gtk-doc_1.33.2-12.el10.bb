# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gtk-doc"
PE = "0"
PV = "1.33.2"
PR = "12.el10"
PACKAGES = "gtk-doc"
PROVIDES = "rpm/gtk-doc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/gtk-doc-1.33.2-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed96e37be631326af03da26f5815945811adbeea7e34945d3cb546e8bd2f15c0"

URI_gtk-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gtk-doc-1.33.2-12.el10.x86_64_v2.rpm;name=gtk-doc;unpack=0"
SRC_URI += "${URI_gtk-doc}"
SRC_URI[gtk-doc.sha256sum] = "27f2e3122bbd4bc9af032d204a83e6a9acd66c507a5d3c1df30d9c91a11fd4e3"
RDEPENDS:gtk-doc = " \
 python3 \
 docbook-utils \
 cmake-filesystem \
 libxslt \
 pkgconf-pkg-config \
 docbook-style-xsl \
 python3-pygments \
 bash \
 python3-lxml \
"
