# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Class-XSAccessor"
PE = "0"
PV = "1.19"
PR = "37.el10"
PACKAGES = "perl-Class-XSAccessor perl-Class-XSAccessor-tests"
PROVIDES = "rpm/perl-Class-XSAccessor rpm/perl-Class-XSAccessor-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Class-XSAccessor-1.19-37.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "213c1dc814d2c9b7807103daefe09c111a2c75a01347e58f6cff21e7e60391ab"

URI_perl-Class-XSAccessor = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Class-XSAccessor-1.19-37.el10.x86_64_v2.rpm;name=perl-Class-XSAccessor;unpack=0"
SRC_URI += "${URI_perl-Class-XSAccessor}"
SRC_URI[perl-Class-XSAccessor.sha256sum] = "b6dfc35a9e226100294de385831736c0809880ecbe3b9f80d0cac9e0e8b2f144"
RDEPENDS:perl-Class-XSAccessor = " \
 glibc \
 perl-Class-XSAccessor \
 perl-libs \
 perl-Carp \
"

URI_perl-Class-XSAccessor-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Class-XSAccessor-tests-1.19-37.el10.x86_64_v2.rpm;name=perl-Class-XSAccessor-tests;unpack=0"
SRC_URI += "${URI_perl-Class-XSAccessor-tests}"
SRC_URI[perl-Class-XSAccessor-tests.sha256sum] = "2759b3e0e338d4c49444504a3bae5bcb53af96d34e7f0c59bf325d380d2bb476"
RDEPENDS:perl-Class-XSAccessor-tests = " \
 perl-constant \
 perl-threads \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Class-XSAccessor \
 bash \
 perl-interpreter \
 perl-Data-Dumper \
 perl-Time-HiRes \
"
