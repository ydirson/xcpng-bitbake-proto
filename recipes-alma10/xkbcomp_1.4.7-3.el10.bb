# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xkbcomp"
PE = "0"
PV = "1.4.7"
PR = "3.el10"
PACKAGES = "xkbcomp xkbcomp-devel"
PROVIDES = "rpm/xkbcomp rpm/xkbcomp-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xkbcomp-1.4.7-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92f3acc8993a70b007f5771c9b2104190ea20a2a90ef43d87d8f1e2195924488"

URI_xkbcomp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xkbcomp-1.4.7-3.el10.x86_64_v2.rpm;name=xkbcomp;unpack=0"
SRC_URI += "${URI_xkbcomp}"
SRC_URI[xkbcomp.sha256sum] = "51f45c401c1990a76ca6c3889d7ea02e11188d659d2312134e1ab4b14e159433"
RDEPENDS:xkbcomp = " \
 glibc \
 libxkbfile \
 libX11 \
"

URI_xkbcomp-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/xkbcomp-devel-1.4.7-3.el10.x86_64_v2.rpm;name=xkbcomp-devel;unpack=0"
SRC_URI += "${URI_xkbcomp-devel}"
SRC_URI[xkbcomp-devel.sha256sum] = "6b2051b998ea80a27dac97999de1ff535620d83a68e15e15783a61b425e5b5e4"
RDEPENDS:xkbcomp-devel = " \
 xkbcomp \
 pkgconf-pkg-config \
"
