# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tinycdb"
PE = "0"
PV = "0.80"
PR = "4.el10"
PACKAGES = "tinycdb tinycdb-devel"
PROVIDES = "rpm/tinycdb rpm/tinycdb-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tinycdb-0.80-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12313ff2c67e513aadddea1fc12aa3f3bb5aef1626441dd246549c970ae740f5"

URI_tinycdb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tinycdb-0.80-4.el10.x86_64_v2.rpm;name=tinycdb;unpack=0"
SRC_URI += "${URI_tinycdb}"
SRC_URI[tinycdb.sha256sum] = "869264a9fa665c422fcba530d3fb61def41b0dd8cb59076af3156ec50aecffa2"
RDEPENDS:tinycdb = " \
 glibc \
"

URI_tinycdb-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/tinycdb-devel-0.80-4.el10.x86_64_v2.rpm;name=tinycdb-devel;unpack=0"
SRC_URI += "${URI_tinycdb-devel}"
SRC_URI[tinycdb-devel.sha256sum] = "0c0fae225188ee2f165ae60982c545c2d0d621692c67b2caf27989aed2ef8cfe"
RDEPENDS:tinycdb-devel = " \
 tinycdb \
 pkgconf-pkg-config \
"
