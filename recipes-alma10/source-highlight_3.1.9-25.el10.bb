# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "source-highlight"
PE = "0"
PV = "3.1.9"
PR = "25.el10"
PACKAGES = "source-highlight source-highlight-devel"
PROVIDES = "rpm/source-highlight rpm/source-highlight-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/source-highlight-3.1.9-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc42a9045c0754923ae84369ffcc7a22fc1d49a588cfdce3cd405d3bca1534d7"

URI_source-highlight = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/source-highlight-3.1.9-25.el10.x86_64_v2.rpm;name=source-highlight;unpack=0"
SRC_URI += "${URI_source-highlight}"
SRC_URI[source-highlight.sha256sum] = "97bc57330b336358c6ec8185dd420750a33aec797fd23d9df96ddf4d2b56b03a"
RDEPENDS:source-highlight = " \
 libgcc \
 boost-regex \
 libstdc++ \
 bash \
 glibc \
"

URI_source-highlight-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/source-highlight-devel-3.1.9-25.el10.x86_64_v2.rpm;name=source-highlight-devel;unpack=0"
SRC_URI += "${URI_source-highlight-devel}"
SRC_URI[source-highlight-devel.sha256sum] = "97a3a50fde91cc86f19d33e4a22d756a513da4fd8f127a8c52121d7eb1d47a93"
RDEPENDS:source-highlight-devel = " \
 source-highlight \
 pkgconf-pkg-config \
 boost-devel \
"
