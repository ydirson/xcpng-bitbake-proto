# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "texi2html"
PE = "0"
PV = "5.0"
PR = "24.el10"
PACKAGES = "texi2html"
PROVIDES = "rpm/texi2html"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/texi2html-5.0-24.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fda205d960562801046256c9d1233251af1c592ff78020e01a42124696bf9db4"

URI_texi2html = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/texi2html-5.0-24.el10.noarch.rpm;name=texi2html;unpack=0"
SRC_URI += "${URI_texi2html}"
SRC_URI[texi2html.sha256sum] = "65b3afa5cf2eb493b717517eaaf7eadfb98b949d7586439a7993f867a3d231d9"
RDEPENDS:texi2html = " \
 perl-libs \
 perl-interpreter \
 perl-vars \
 latex2html \
 perl-Unicode-EastAsianWidth \
 perl-Getopt-Long \
 perl-File-Basename \
 perl-POSIX \
 perl-Text-Unidecode \
 perl-PathTools \
 perl-Exporter \
 perl-Data-Dumper \
 perl-libintl-perl \
"
