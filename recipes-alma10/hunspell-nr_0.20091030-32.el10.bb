# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-nr"
PE = "0"
PV = "0.20091030"
PR = "32.el10"
PACKAGES = "hunspell-nr"
PROVIDES = "rpm/hunspell-nr"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-nr-0.20091030-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52a10fe7b66d80225750ab8daa15eceee7f363736d61572648da0a095d780c67"

URI_hunspell-nr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-nr-0.20091030-32.el10.noarch.rpm;name=hunspell-nr;unpack=0"
SRC_URI += "${URI_hunspell-nr}"
SRC_URI[hunspell-nr.sha256sum] = "c28f7781ec6ae79bd626cd4abe1b2ece7ce985a9a552867897b070d9b98c26a8"
RDEPENDS:hunspell-nr = " \
 hunspell \
"
