# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gjs"
PE = "0"
PV = "1.80.2"
PR = "11.el10"
PACKAGES = "gjs gjs-devel gjs-tests"
PROVIDES = "rpm/gjs rpm/gjs-devel rpm/gjs-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gjs-1.80.2-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "13ca3c1591e921e12d42205a46d5242a656c7693c21f548c311448e0076a0d20"

URI_gjs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gjs-1.80.2-11.el10.x86_64_v2.rpm;name=gjs;unpack=0"
SRC_URI += "${URI_gjs}"
SRC_URI[gjs.sha256sum] = "b27ad26c9d8235534b663a6aaa9fbe4c990ac7d64cbd8e86d06f615f4812e4ac"
RDEPENDS:gjs = " \
 zlib-ng-compat \
 gobject-introspection \
 libffi \
 libgcc \
 readline \
 libX11 \
 libstdc++ \
 glib2 \
 cairo \
 cairo-gobject \
 glibc \
 libicu \
"

URI_gjs-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gjs-devel-1.80.2-11.el10.x86_64_v2.rpm;name=gjs-devel;unpack=0"
SRC_URI += "${URI_gjs-devel}"
SRC_URI[gjs-devel.sha256sum] = "be59e9cd9a12d486ff42213e73fc037d9486f80e1b118d62f5c39fd6220105a8"
RDEPENDS:gjs-devel = " \
 gjs \
 glib2-devel \
 pkgconf-pkg-config \
 cairo-devel \
 gobject-introspection-devel \
 cairo-gobject-devel \
 libffi-devel \
"

URI_gjs-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gjs-tests-1.80.2-11.el10.x86_64_v2.rpm;name=gjs-tests;unpack=0"
SRC_URI += "${URI_gjs-tests}"
SRC_URI[gjs-tests.sha256sum] = "578f662a719ac2db11d200f9cad7ac8b57a2cec91485a5cc39771d81cce27cad"
RDEPENDS:gjs-tests = " \
 gjs \
 gobject-introspection \
 libgcc \
 libstdc++ \
 bash \
 glib2 \
 cairo \
 cairo-gobject \
 glibc \
"
