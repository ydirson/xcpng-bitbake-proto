# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "maven-verifier-plugin"
PE = "0"
PV = "1.1"
PR = "6.el10"
PACKAGES = "maven-verifier-plugin maven-verifier-plugin-javadoc"
PROVIDES = "rpm/maven-verifier-plugin rpm/maven-verifier-plugin-javadoc"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/maven-verifier-plugin-1.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "689bdbfebecc5bd1a98d90c75b1e35bd19348e111b6b9e6de1370cadfc2837a7"

URI_maven-verifier-plugin = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/maven-verifier-plugin-1.1-6.el10.noarch.rpm;name=maven-verifier-plugin;unpack=0"
SRC_URI += "${URI_maven-verifier-plugin}"
SRC_URI[maven-verifier-plugin.sha256sum] = "dfaf64d444144fb5479d748d26d3d55b2d86179f7d576d70264d71d6f74a2f8c"
RDEPENDS:maven-verifier-plugin = " \
 plexus-utils \
 javapackages-filesystem \
 java-21-openjdk-headless \
"

URI_maven-verifier-plugin-javadoc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/maven-verifier-plugin-javadoc-1.1-6.el10.noarch.rpm;name=maven-verifier-plugin-javadoc;unpack=0"
SRC_URI += "${URI_maven-verifier-plugin-javadoc}"
SRC_URI[maven-verifier-plugin-javadoc.sha256sum] = "1f3e4e754cbcaf0bf3eb9baed522f4b0781e8cbd264d9e7fd3574f1a4d074993"
RDEPENDS:maven-verifier-plugin-javadoc = " \
 javapackages-filesystem \
"
