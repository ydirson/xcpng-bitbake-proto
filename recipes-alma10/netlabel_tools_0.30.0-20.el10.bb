# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "netlabel_tools"
PE = "0"
PV = "0.30.0"
PR = "20.el10"
PACKAGES = "netlabel_tools"
PROVIDES = "rpm/netlabel_tools"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/netlabel_tools-0.30.0-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "113e5efe900cd3460f351dc51f32d10d8bfb97cbe832fad3689de38d1cdc15ef"

URI_netlabel_tools = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/netlabel_tools-0.30.0-20.el10.x86_64_v2.rpm;name=netlabel_tools;unpack=0"
SRC_URI += "${URI_netlabel_tools}"
SRC_URI[netlabel_tools.sha256sum] = "a04d7b3c794ac94f70abc176ba78a723224b92afc2a482256697c669ce2b0ce6"
RDEPENDS:netlabel_tools = " \
 glibc \
 systemd \
 bash \
 libnl3 \
"
