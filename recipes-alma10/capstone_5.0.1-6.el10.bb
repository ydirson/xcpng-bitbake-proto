# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "capstone"
PE = "0"
PV = "5.0.1"
PR = "6.el10"
PACKAGES = "capstone capstone-devel capstone-java python3-capstone"
PROVIDES = "rpm/capstone rpm/capstone-devel rpm/capstone-java rpm/python3-capstone"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/capstone-5.0.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7197b7009fd96390d910336fb99d78770cbddf38687bcb52ab8b602af9aea0f8"

URI_capstone = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/capstone-5.0.1-6.el10.x86_64_v2.rpm;name=capstone;unpack=0"
SRC_URI += "${URI_capstone}"
SRC_URI[capstone.sha256sum] = "e184c34cd74e7d34b72bc4849b07166ef67e214af3d5db8b4bb8f47f6d819d34"
RDEPENDS:capstone = " \
 glibc \
"

URI_capstone-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/capstone-devel-5.0.1-6.el10.x86_64_v2.rpm;name=capstone-devel;unpack=0"
SRC_URI += "${URI_capstone-devel}"
SRC_URI[capstone-devel.sha256sum] = "1fd3a4a6f357496c17dbc697dfbd8298f967af22241b8009a0245d9e3b5782a3"
RDEPENDS:capstone-devel = " \
 capstone \
 pkgconf-pkg-config \
"

URI_capstone-java = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/capstone-java-5.0.1-6.el10.noarch.rpm;name=capstone-java;unpack=0"
SRC_URI += "${URI_capstone-java}"
SRC_URI[capstone-java.sha256sum] = "57bbd122f20723c0ed85a9f5f35a1e2571be5102ca8ed16ab851fe8ac75e219d"
RDEPENDS:capstone-java = " \
 capstone \
"

URI_python3-capstone = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-capstone-5.0.1-6.el10.noarch.rpm;name=python3-capstone;unpack=0"
SRC_URI += "${URI_python3-capstone}"
SRC_URI[python3-capstone.sha256sum] = "37095d9cb8d6189137ed9e0597b9c73c424d844bbc65a2b4216ce75c5799d454"
RDEPENDS:python3-capstone = " \
 python3 \
 capstone \
"
