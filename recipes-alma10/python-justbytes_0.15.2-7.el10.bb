# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-justbytes"
PE = "0"
PV = "0.15.2"
PR = "7.el10"
PACKAGES = "python3-justbytes"
PROVIDES = "rpm/python3-justbytes"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-justbytes-0.15.2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62098e0eec0cc58ba32ae3905f404e590ed02b8719c114db71c5ba910b56e418"

URI_python3-justbytes = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-justbytes-0.15.2-7.el10.noarch.rpm;name=python3-justbytes;unpack=0"
SRC_URI += "${URI_python3-justbytes}"
SRC_URI[python3-justbytes.sha256sum] = "089c3921909f7016893a79b109272f1036b1d09dcc3c07c050bac272ff3c5429"
RDEPENDS:python3-justbytes = " \
 python3 \
 python3-justbases \
"
