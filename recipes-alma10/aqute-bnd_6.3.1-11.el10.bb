# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "aqute-bnd"
PE = "0"
PV = "6.3.1"
PR = "11.el10"
PACKAGES = "aqute-bnd aqute-bnd-javadoc aqute-bndlib"
PROVIDES = "rpm/aqute-bnd rpm/aqute-bnd-javadoc rpm/aqute-bndlib"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/aqute-bnd-6.3.1-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4462ec46938821d7b4269ea5b06fcaf1cadcb07874559a06f357adc0053eba5b"

URI_aqute-bnd = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/aqute-bnd-6.3.1-11.el10.noarch.rpm;name=aqute-bnd;unpack=0"
SRC_URI += "${URI_aqute-bnd}"
SRC_URI[aqute-bnd.sha256sum] = "7e9fbdcbea0cb65a39125a89dda614f3c538c3517206a99fd7b40a089f708ee3"
RDEPENDS:aqute-bnd = " \
 aqute-bndlib \
 javapackages-filesystem \
 javapackages-tools \
 bash \
 slf4j \
 ant-lib \
 osgi-annotation \
"

URI_aqute-bnd-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/aqute-bnd-javadoc-6.3.1-11.el10.noarch.rpm;name=aqute-bnd-javadoc;unpack=0"
SRC_URI += "${URI_aqute-bnd-javadoc}"
SRC_URI[aqute-bnd-javadoc.sha256sum] = "73cac28a410a3c6386e23e3fa24671d8fc0723fb3567e5d82625d0b21b80ddac"
RDEPENDS:aqute-bnd-javadoc = " \
 javapackages-filesystem \
"

URI_aqute-bndlib = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/aqute-bndlib-6.3.1-11.el10.noarch.rpm;name=aqute-bndlib;unpack=0"
SRC_URI += "${URI_aqute-bndlib}"
SRC_URI[aqute-bndlib.sha256sum] = "d4fd269de309e3ba56aa470a75ee80aa87ee156aa1175d3faf6970f533714b37"
RDEPENDS:aqute-bndlib = " \
 javapackages-filesystem \
 slf4j \
 osgi-annotation \
 osgi-compendium \
 aqute-bnd \
 osgi-core \
"
