# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "geoclue2"
PE = "0"
PV = "2.7.2"
PR = "1.el10"
PACKAGES = "geoclue2 geoclue2-libs geoclue2-demos geoclue2-devel"
PROVIDES = "rpm/geoclue2 rpm/geoclue2-libs rpm/geoclue2-demos rpm/geoclue2-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/geoclue2-2.7.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20568fe4510485b6a2799f977d404487f21a32de9865f923787c7975218d57a9"

URI_geoclue2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/geoclue2-2.7.2-1.el10.x86_64_v2.rpm;name=geoclue2;unpack=0"
SRC_URI += "${URI_geoclue2}"
SRC_URI[geoclue2.sha256sum] = "eba96720c743f5ac7a6d9fcda592d1ef52a2dc8f91f4c25368af9d5e1356912d"
RDEPENDS:geoclue2 = " \
 shadow-utils \
 libsoup3 \
 ModemManager-glib \
 libgcc \
 json-glib \
 avahi-glib \
 avahi-libs \
 bash \
 glib2 \
 dbus \
 glibc \
 libnotify \
"

URI_geoclue2-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/geoclue2-libs-2.7.2-1.el10.x86_64_v2.rpm;name=geoclue2-libs;unpack=0"
SRC_URI += "${URI_geoclue2-libs}"
SRC_URI[geoclue2-libs.sha256sum] = "ebcb0925e8d71e72c30a0bffe2e63f904d99884ced757e0a6d76a7618beb6752"
RDEPENDS:geoclue2-libs = " \
 glibc \
 libgcc \
 glib2 \
"

URI_geoclue2-demos = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/geoclue2-demos-2.7.2-1.el10.x86_64_v2.rpm;name=geoclue2-demos;unpack=0"
SRC_URI += "${URI_geoclue2-demos}"
SRC_URI[geoclue2-demos.sha256sum] = "127766ea4f31ae6c2b51b966014fceffa341fe799c17f345a52fcd02287a3e57"
RDEPENDS:geoclue2-demos = " \
 glibc \
 libgcc \
 glib2 \
 geoclue2-libs \
"

URI_geoclue2-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/geoclue2-devel-2.7.2-1.el10.x86_64_v2.rpm;name=geoclue2-devel;unpack=0"
SRC_URI += "${URI_geoclue2-devel}"
SRC_URI[geoclue2-devel.sha256sum] = "2fa8d84b2f4863d7e70b09225b9285820a610dd3a0c6cb88626b2d76b306bd80"
RDEPENDS:geoclue2-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 geoclue2-libs \
"
