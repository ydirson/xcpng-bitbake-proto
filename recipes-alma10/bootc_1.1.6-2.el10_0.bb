# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "bootc"
PE = "0"
PV = "1.1.6"
PR = "2.el10_0"
PACKAGES = "bootc system-reinstall-bootc"
PROVIDES = "rpm/bootc rpm/system-reinstall-bootc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/bootc-1.1.6-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2f76085f1ed3a947b964f54268d33fb3758ac27cda3246d3b2b1c83b0c780c2"

URI_bootc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/bootc-1.1.6-2.el10_0.x86_64_v2.rpm;name=bootc;unpack=0"
SRC_URI += "${URI_bootc}"
SRC_URI[bootc.sha256sum] = "bf85e8e773b07e4e0ef44a36bc798c5ea4b3da8a9c6aa0431f3591c7b2b5e63d"
RDEPENDS:bootc = " \
 ostree-libs \
 zlib-ng-compat \
 openssl-libs \
 libgcc \
 composefs \
 libzstd \
 skopeo \
 bash \
 glib2 \
 glibc \
 ostree \
 podman \
"

URI_system-reinstall-bootc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/system-reinstall-bootc-1.1.6-2.el10_0.x86_64_v2.rpm;name=system-reinstall-bootc;unpack=0"
SRC_URI += "${URI_system-reinstall-bootc}"
SRC_URI[system-reinstall-bootc.sha256sum] = "de97c4519e6cef86ededfca9f80245f1a6dd9307870fe34e1cc12626a3ba269b"
RDEPENDS:system-reinstall-bootc = " \
 glibc \
 libgcc \
 bash \
"
