# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "spice-gtk"
PE = "0"
PV = "0.42"
PR = "3.el10"
PACKAGES = "spice-glib spice-glib-devel spice-gtk spice-gtk-tools spice-gtk3 spice-gtk3-devel spice-gtk3-vala"
PROVIDES = "rpm/spice-glib rpm/spice-glib-devel rpm/spice-gtk rpm/spice-gtk-tools rpm/spice-gtk3 rpm/spice-gtk3-devel rpm/spice-gtk3-vala"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/spice-gtk-0.42-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "379e071fdf26d6156c8ad100d748cbea402fe5149fc01595ada092896818d0b6"

URI_spice-glib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/spice-glib-0.42-3.el10.x86_64_v2.rpm;name=spice-glib;unpack=0"
SRC_URI += "${URI_spice-glib}"
SRC_URI[spice-glib.sha256sum] = "6314de3e8dae4f5628a9db2bd514431f2bf6be5d2bb8878f535661b87209bad1"
RDEPENDS:spice-glib = " \
 libcacard \
 cyrus-sasl-lib \
 libacl \
 usbredir \
 json-glib \
 libcap-ng \
 libphodav \
 libusb1 \
 zlib-ng-compat \
 openssl-libs \
 opus \
 pixman \
 libsoup3 \
 gstreamer1 \
 lz4-libs \
 gstreamer1-plugins-base \
 polkit-libs \
 glib2 \
 glibc \
 libjpeg-turbo \
"

URI_spice-glib-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/spice-glib-devel-0.42-3.el10.x86_64_v2.rpm;name=spice-glib-devel;unpack=0"
SRC_URI += "${URI_spice-glib-devel}"
SRC_URI[spice-glib-devel.sha256sum] = "72baa4a8b4667ee81e23c62d7911c329e518f762d16d58026853848d60fd2980"
RDEPENDS:spice-glib-devel = " \
 glib2-devel \
 libcacard-devel \
 libusb1-devel \
 lz4-devel \
 cyrus-sasl-devel \
 usbredir-devel \
 libphodav-devel \
 json-glib-devel \
 zlib-ng-compat-devel \
 spice-glib \
 openssl-devel \
 spice-protocol \
 opus-devel \
 pixman-devel \
 libsoup3-devel \
 gstreamer1-devel \
 pkgconf-pkg-config \
 gstreamer1-plugins-base-devel \
 gobject-introspection-devel \
 libjpeg-turbo-devel \
"

URI_spice-gtk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/spice-gtk-0.42-3.el10.x86_64_v2.rpm;name=spice-gtk;unpack=0"
SRC_URI += "${URI_spice-gtk}"
SRC_URI[spice-gtk.sha256sum] = "dbd723fd9897b56cf0f54f2c6ed42f60102dee5c06b4c504667924fbdef61aa4"
RDEPENDS:spice-gtk = " \
 spice-glib \
"

URI_spice-gtk-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/spice-gtk-tools-0.42-3.el10.x86_64_v2.rpm;name=spice-gtk-tools;unpack=0"
SRC_URI += "${URI_spice-gtk-tools}"
SRC_URI[spice-gtk-tools.sha256sum] = "1bc15ac5b1a5063b48d7b81cd1d4e7ac5aa891e1dbd1c1400e86009d7c9877b7"
RDEPENDS:spice-gtk-tools = " \
 gstreamer1 \
 libwayland-server \
 spice-glib \
 spice-gtk3 \
 glib2 \
 gtk3 \
 glibc \
"

URI_spice-gtk3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/spice-gtk3-0.42-3.el10.x86_64_v2.rpm;name=spice-gtk3;unpack=0"
SRC_URI += "${URI_spice-gtk3}"
SRC_URI[spice-gtk3.sha256sum] = "c1eebfa27d2da6973bb0acff083d19cf467a12530dd142db6213d0eb9a2b0878"
RDEPENDS:spice-gtk3 = " \
 libwayland-client \
 gstreamer1 \
 libepoxy \
 libwayland-server \
 spice-glib \
 gstreamer1-plugins-base \
 gdk-pixbuf2 \
 libX11 \
 libphodav \
 cairo \
 glib2 \
 gtk3 \
 glibc \
"

URI_spice-gtk3-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/spice-gtk3-devel-0.42-3.el10.x86_64_v2.rpm;name=spice-gtk3-devel;unpack=0"
SRC_URI += "${URI_spice-gtk3-devel}"
SRC_URI[spice-gtk3-devel.sha256sum] = "5920da600d7811cd1469dada662d6253c284e8f199062fea52ce8e1b0defe26e"
RDEPENDS:spice-gtk3-devel = " \
 glib2-devel \
 libcacard-devel \
 libusb1-devel \
 libX11-devel \
 lz4-devel \
 libepoxy-devel \
 cyrus-sasl-devel \
 usbredir-devel \
 libphodav-devel \
 json-glib-devel \
 zlib-ng-compat-devel \
 spice-glib-devel \
 spice-gtk3 \
 openssl-devel \
 spice-protocol \
 opus-devel \
 pixman-devel \
 wayland-devel \
 libsoup3-devel \
 gstreamer1-devel \
 pkgconf-pkg-config \
 gstreamer1-plugins-base-devel \
 gobject-introspection-devel \
 gtk3-devel \
 libjpeg-turbo-devel \
"

URI_spice-gtk3-vala = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/spice-gtk3-vala-0.42-3.el10.x86_64_v2.rpm;name=spice-gtk3-vala;unpack=0"
SRC_URI += "${URI_spice-gtk3-vala}"
SRC_URI[spice-gtk3-vala.sha256sum] = "f2c26945d17ff8205d5747c2ad8369cd1df38a9f8cbb152dab117a9554bea422"
RDEPENDS:spice-gtk3-vala = " \
 spice-gtk3 \
 spice-gtk3-devel \
"
