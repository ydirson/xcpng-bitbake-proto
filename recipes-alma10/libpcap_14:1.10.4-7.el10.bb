# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libpcap"
PE = "14"
PV = "1.10.4"
PR = "7.el10"
PACKAGES = "libpcap libpcap-devel"
PROVIDES = "rpm/libpcap rpm/libpcap-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libpcap-1.10.4-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00f59192c18361e2f95b2bbb9d11561f3d3a9e98333cd928141d362eaf80b680"

URI_libpcap = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libpcap-1.10.4-7.el10.x86_64_v2.rpm;name=libpcap;unpack=0"
SRC_URI += "${URI_libpcap}"
SRC_URI[libpcap.sha256sum] = "ed48eb9883dc7f05a871b94b8b16333865e94dfdeaeb7710b0e1d48c213de725"
RDEPENDS:libpcap = " \
 glibc \
 libibverbs \
"

URI_libpcap-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libpcap-devel-1.10.4-7.el10.x86_64_v2.rpm;name=libpcap-devel;unpack=0"
SRC_URI += "${URI_libpcap-devel}"
SRC_URI[libpcap-devel.sha256sum] = "c97126a0fa73a295ed7941997ba244cb675ac02ea93bcf2e2be2444a0c3e2be8"
RDEPENDS:libpcap-devel = " \
 libpcap \
 bash \
 pkgconf-pkg-config \
 rdma-core-devel \
"
