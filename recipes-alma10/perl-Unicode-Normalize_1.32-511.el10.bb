# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Unicode-Normalize"
PE = "0"
PV = "1.32"
PR = "511.el10"
PACKAGES = "perl-Unicode-Normalize perl-Unicode-Normalize-tests"
PROVIDES = "rpm/perl-Unicode-Normalize rpm/perl-Unicode-Normalize-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Unicode-Normalize-1.32-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f47b4833e214aab058902c89d75ba20ab086f16eeefd08e1b72291a7996ba600"

URI_perl-Unicode-Normalize = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Unicode-Normalize-1.32-511.el10.x86_64_v2.rpm;name=perl-Unicode-Normalize;unpack=0"
SRC_URI += "${URI_perl-Unicode-Normalize}"
SRC_URI[perl-Unicode-Normalize.sha256sum] = "cab6a60b1d3d541f5f9390d37ca63e459078c5726e25d42fcd44cbb6885e5e06"
RDEPENDS:perl-Unicode-Normalize = " \
 glibc \
 perl-Exporter \
 perl-libs \
 perl-Carp \
"

URI_perl-Unicode-Normalize-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Unicode-Normalize-tests-1.32-511.el10.x86_64_v2.rpm;name=perl-Unicode-Normalize-tests;unpack=0"
SRC_URI += "${URI_perl-Unicode-Normalize-tests}"
SRC_URI[perl-Unicode-Normalize-tests.sha256sum] = "463f06427c65934856d0ba1d853371e767939eb6c55f72f20d4e423c177c20cc"
RDEPENDS:perl-Unicode-Normalize-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Unicode-Normalize \
 bash \
 perl-interpreter \
"
