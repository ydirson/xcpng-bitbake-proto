# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xdg-desktop-portal"
PE = "0"
PV = "1.20.0"
PR = "1.el10_0"
PACKAGES = "xdg-desktop-portal xdg-desktop-portal-devel"
PROVIDES = "rpm/xdg-desktop-portal rpm/xdg-desktop-portal-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xdg-desktop-portal-1.20.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c31e50da601497a175145e28b1e12561105d07cc966e9874aa211c08fc018011"

URI_xdg-desktop-portal = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xdg-desktop-portal-1.20.0-1.el10_0.x86_64_v2.rpm;name=xdg-desktop-portal;unpack=0"
SRC_URI += "${URI_xdg-desktop-portal}"
SRC_URI[xdg-desktop-portal.sha256sum] = "0e70ccced87e218e25309b302ce2c95a399045096bdb4f0394a57e120dca5452"
RDEPENDS:xdg-desktop-portal = " \
 systemd-libs \
 gstreamer1 \
 fuse3-libs \
 fuse3 \
 libgcc \
 json-glib \
 gstreamer1-plugins-base \
 gdk-pixbuf2 \
 libgudev \
 bash \
 glib2 \
 dbus \
 geoclue2 \
 glibc \
 pipewire-libs \
 libportal \
 libdex \
"

URI_xdg-desktop-portal-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xdg-desktop-portal-devel-1.20.0-1.el10_0.x86_64_v2.rpm;name=xdg-desktop-portal-devel;unpack=0"
SRC_URI += "${URI_xdg-desktop-portal-devel}"
SRC_URI[xdg-desktop-portal-devel.sha256sum] = "e894c4254af16d356412eee61ad416471bba1ce38dd3804c0dbb1e49e92f9946"
RDEPENDS:xdg-desktop-portal-devel = " \
 xdg-desktop-portal \
 pkgconf-pkg-config \
"
