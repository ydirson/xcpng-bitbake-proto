# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-PkgConfig"
PE = "0"
PV = "1.16"
PR = "26.el10"
PACKAGES = "perl-ExtUtils-PkgConfig"
PROVIDES = "rpm/perl-ExtUtils-PkgConfig"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-ExtUtils-PkgConfig-1.16-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1cb3e8e361d83321dbf181fabf0ab8bb59abf9302758ae94a56e6687b48758bf"

URI_perl-ExtUtils-PkgConfig = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-ExtUtils-PkgConfig-1.16-26.el10.noarch.rpm;name=perl-ExtUtils-PkgConfig;unpack=0"
SRC_URI += "${URI_perl-ExtUtils-PkgConfig}"
SRC_URI[perl-ExtUtils-PkgConfig.sha256sum] = "bee7a984fa98c7a85bd1b76d8440a759304d82df54a95d5a4b4d27817395ceda"
RDEPENDS:perl-ExtUtils-PkgConfig = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 pkgconf-pkg-config \
 perl-English \
"
