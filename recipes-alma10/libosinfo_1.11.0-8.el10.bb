# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libosinfo"
PE = "0"
PV = "1.11.0"
PR = "8.el10"
PACKAGES = "libosinfo libosinfo-devel"
PROVIDES = "rpm/libosinfo rpm/libosinfo-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libosinfo-1.11.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "420cec299c20393b344039976486f4d0d3dbf3ec3176a70584d85ad716c21b95"

URI_libosinfo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libosinfo-1.11.0-8.el10.x86_64_v2.rpm;name=libosinfo;unpack=0"
SRC_URI += "${URI_libosinfo}"
SRC_URI[libosinfo.sha256sum] = "3d34c159318d044514638cabe4a78564455112515fdbd5e099b2f67b1784b1f9"
RDEPENDS:libosinfo = " \
 libsoup3 \
 libxslt \
 libgcc \
 libxml2 \
 hwdata \
 glib2 \
 glibc \
 osinfo-db \
 osinfo-db-tools \
"

URI_libosinfo-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libosinfo-devel-1.11.0-8.el10.x86_64_v2.rpm;name=libosinfo-devel;unpack=0"
SRC_URI += "${URI_libosinfo-devel}"
SRC_URI[libosinfo-devel.sha256sum] = "8d3a644690762140aafa65886c52be38dbb2e46f2d9c593ec1fe740c1bb183ba"
RDEPENDS:libosinfo-devel = " \
 libosinfo \
 glib2-devel \
 pkgconf-pkg-config \
"
