# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "symlinks"
PE = "0"
PV = "1.7"
PR = "13.el10"
PACKAGES = "symlinks"
PROVIDES = "rpm/symlinks"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/symlinks-1.7-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7c1d7627fdd114aff1f9d50d3e4072c75bc7148ac5f7f8cf30c72e09cacfa1f"

URI_symlinks = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/symlinks-1.7-13.el10.x86_64_v2.rpm;name=symlinks;unpack=0"
SRC_URI += "${URI_symlinks}"
SRC_URI[symlinks.sha256sum] = "2f75993270d8c93fe017967897c3e4320c7c9fae457a42f2c6cd9727ad7df959"
RDEPENDS:symlinks = " \
 glibc \
"
