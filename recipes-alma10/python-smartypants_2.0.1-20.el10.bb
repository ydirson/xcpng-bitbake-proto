# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-smartypants"
PE = "0"
PV = "2.0.1"
PR = "20.el10"
PACKAGES = "python-smartypants-doc python3-smartypants"
PROVIDES = "rpm/python-smartypants-doc rpm/python3-smartypants"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/python-smartypants-2.0.1-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3d6fbbb41f58dba078da53d345fb744ebcdc3e4f5d74e6276b70c728b338878"

URI_python-smartypants-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python-smartypants-doc-2.0.1-20.el10.noarch.rpm;name=python-smartypants-doc;unpack=0"
SRC_URI += "${URI_python-smartypants-doc}"
SRC_URI[python-smartypants-doc.sha256sum] = "6116c7a7ae94004622d7da103203d9a07cd445c690eacf1d478b393ec8eb9a7d"
RDEPENDS:python-smartypants-doc = ""

URI_python3-smartypants = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-smartypants-2.0.1-20.el10.noarch.rpm;name=python3-smartypants;unpack=0"
SRC_URI += "${URI_python3-smartypants}"
SRC_URI[python3-smartypants.sha256sum] = "08dfbd743fa6e790f1db44296542795c27910e175063ef73f515c9a8e8737e9c"
RDEPENDS:python3-smartypants = " \
 python3 \
 python3-setuptools \
"
