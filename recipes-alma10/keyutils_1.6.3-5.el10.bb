# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "keyutils"
PE = "0"
PV = "1.6.3"
PR = "5.el10"
PACKAGES = "keyutils keyutils-libs keyutils-libs-devel"
PROVIDES = "rpm/keyutils rpm/keyutils-libs rpm/keyutils-libs-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/keyutils-1.6.3-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f96ebb838cec9d288aa4b9629af73126861a05970c6aea26b5b95ca6a3b78900"

URI_keyutils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/keyutils-1.6.3-5.el10.x86_64_v2.rpm;name=keyutils;unpack=0"
SRC_URI += "${URI_keyutils}"
SRC_URI[keyutils.sha256sum] = "438d1f71ea507db0319d2a22968cc0d243b29e9ec418d9b2452c0e352818fe1c"
RDEPENDS:keyutils = " \
 glibc \
 keyutils-libs \
 bash \
"

URI_keyutils-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/keyutils-libs-1.6.3-5.el10.x86_64_v2.rpm;name=keyutils-libs;unpack=0"
SRC_URI += "${URI_keyutils-libs}"
SRC_URI[keyutils-libs.sha256sum] = "ee3a85de8a0736af01c12c07fbe1ee43648d179a1faac9675c2269485a468c6a"
RDEPENDS:keyutils-libs = " \
 glibc \
"

URI_keyutils-libs-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/keyutils-libs-devel-1.6.3-5.el10.x86_64_v2.rpm;name=keyutils-libs-devel;unpack=0"
SRC_URI += "${URI_keyutils-libs-devel}"
SRC_URI[keyutils-libs-devel.sha256sum] = "f4db7ab62f93c22022cb75422e67f45fc6b2d5056dc764314718e41b5fe7debe"
RDEPENDS:keyutils-libs-devel = " \
 keyutils-libs \
 pkgconf-pkg-config \
"
