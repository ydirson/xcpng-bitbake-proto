# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "microdnf"
PE = "0"
PV = "3.10.1"
PR = "1.el10"
PACKAGES = "microdnf"
PROVIDES = "rpm/microdnf"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/microdnf-3.10.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f8dae2f9005c8e808fd9fc43802cf68147602f54ef8db9c45c9f8213889efcf"

URI_microdnf = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/microdnf-3.10.1-1.el10.x86_64_v2.rpm;name=microdnf;unpack=0"
SRC_URI += "${URI_microdnf}"
SRC_URI[microdnf.sha256sum] = "3aa3b23db616429a1533d583e1e8bfbcd1a6358a5a3dbb236c6282836730d5f2"
RDEPENDS:microdnf = " \
 libpeas1 \
 libgcc \
 dnf-data \
 glib2 \
 glibc \
 libdnf \
 rpm-libs \
 libsmartcols \
"
