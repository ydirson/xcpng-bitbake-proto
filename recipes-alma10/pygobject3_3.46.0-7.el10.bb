# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pygobject3"
PE = "0"
PV = "3.46.0"
PR = "7.el10"
PACKAGES = "python3-gobject-base python3-gobject-base-noarch python3-gobject python3-gobject-devel"
PROVIDES = "rpm/python3-gobject-base rpm/python3-gobject-base-noarch rpm/python3-gobject rpm/python3-gobject-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/pygobject3-3.46.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b893ca8f0144e5c250abe807eadb78ba469d51da94ef9bfa3287556ab8711ae"

URI_python3-gobject-base = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-gobject-base-3.46.0-7.el10.x86_64_v2.rpm;name=python3-gobject-base;unpack=0"
SRC_URI += "${URI_python3-gobject-base}"
SRC_URI[python3-gobject-base.sha256sum] = "99529acd903327bdc2f3d8b8596a902180200db9974c1cea1bb0e75f63f90d72"
RDEPENDS:python3-gobject-base = " \
 python3 \
 gobject-introspection \
 libffi \
 glib2 \
 python3-gobject-base-noarch \
 glibc \
"

URI_python3-gobject-base-noarch = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-gobject-base-noarch-3.46.0-7.el10.noarch.rpm;name=python3-gobject-base-noarch;unpack=0"
SRC_URI += "${URI_python3-gobject-base-noarch}"
SRC_URI[python3-gobject-base-noarch.sha256sum] = "8964c1908c4a51047dea2d36d0ef9ee62e70110e50ac1114d95a5ec68d27c7e0"
RDEPENDS:python3-gobject-base-noarch = " \
 python3 \
 python3-gobject-base \
"

URI_python3-gobject = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-gobject-3.46.0-7.el10.x86_64_v2.rpm;name=python3-gobject;unpack=0"
SRC_URI += "${URI_python3-gobject}"
SRC_URI[python3-gobject.sha256sum] = "2b6ecaa9d1a6010434c3a22bf3c032fd75b0c6afc935f62992804a41db76f3cc"
RDEPENDS:python3-gobject = " \
 python3 \
 python3-cairo \
 cairo \
 glib2 \
 cairo-gobject \
 glibc \
 python3-gobject-base \
"

URI_python3-gobject-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-gobject-devel-3.46.0-7.el10.x86_64_v2.rpm;name=python3-gobject-devel;unpack=0"
SRC_URI += "${URI_python3-gobject-devel}"
SRC_URI[python3-gobject-devel.sha256sum] = "f5f176b86071740d87690c600707a32a609af9849cbfa9b9b122aa8777f1f77f"
RDEPENDS:python3-gobject-devel = " \
 python3-gobject \
 glib2-devel \
 pkgconf-pkg-config \
 gobject-introspection-devel \
 libffi-devel \
"
