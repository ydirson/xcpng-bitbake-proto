# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "freeglut"
PE = "0"
PV = "3.4.0"
PR = "9.el10"
PACKAGES = "freeglut freeglut-devel"
PROVIDES = "rpm/freeglut rpm/freeglut-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/freeglut-3.4.0-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e438f7e62e71c86e2e96851ff503dcc00b35d2c671790e8df1e3ccf9304acdd"

URI_freeglut = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/freeglut-3.4.0-9.el10.x86_64_v2.rpm;name=freeglut;unpack=0"
SRC_URI += "${URI_freeglut}"
SRC_URI[freeglut.sha256sum] = "6d67f9e203d1324a977e52787606a69622e2e782bf0daec94ff08df106749925"
RDEPENDS:freeglut = " \
 glibc \
 libglvnd-glx \
 libX11 \
 libXi \
"

URI_freeglut-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/freeglut-devel-3.4.0-9.el10.x86_64_v2.rpm;name=freeglut-devel;unpack=0"
SRC_URI += "${URI_freeglut-devel}"
SRC_URI[freeglut-devel.sha256sum] = "a7626e5b3bb390de4c40c2d4f03a7955adf63068165c88f061021a647a6d6d3c"
RDEPENDS:freeglut-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 mesa-libGL-devel \
 mesa-libGLU-devel \
 freeglut \
"
