# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-settings-daemon"
PE = "0"
PV = "47.2"
PR = "5.el10.alma.1"
PACKAGES = "gnome-settings-daemon gnome-settings-daemon-server-defaults gnome-settings-daemon-devel"
PROVIDES = "rpm/gnome-settings-daemon rpm/gnome-settings-daemon-server-defaults rpm/gnome-settings-daemon-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-settings-daemon-47.2-5.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dfcf6e2fb41aa663ab164d03c3b0bae6a443acc853ae1ff05e15548d9f351da5"

URI_gnome-settings-daemon = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-settings-daemon-47.2-5.el10.alma.1.x86_64_v2.rpm;name=gnome-settings-daemon;unpack=0"
SRC_URI += "${URI_gnome-settings-daemon}"
SRC_URI[gnome-settings-daemon.sha256sum] = "d3bd51d069357b637deda548a407e76aa95eb2482aee9ab69a85e7be1ef6d28a"
RDEPENDS:gnome-settings-daemon = " \
 ModemManager-glib \
 systemd-libs \
 cups-libs \
 pango \
 fontconfig \
 libX11 \
 libcanberra \
 libcanberra-gtk3 \
 upower-libs \
 NetworkManager-libnm \
 libXext \
 libnotify \
 libXfixes \
 libXi \
 gnome-desktop3 \
 cairo \
 gcr-libs \
 alsa-lib \
 iio-sensor-proxy \
 libwacom \
 libwayland-client \
 pulseaudio-libs \
 libgcc \
 pulseaudio-libs-glib2 \
 p11-kit \
 libgudev \
 bash \
 geoclue2 \
 geoclue2-libs \
 geocode-glib \
 libgweather \
 gsettings-desktop-schemas \
 polkit-libs \
 colord \
 glib2 \
 gtk3 \
 colord-libs \
 glibc \
"

URI_gnome-settings-daemon-server-defaults = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-settings-daemon-server-defaults-47.2-5.el10.alma.1.x86_64_v2.rpm;name=gnome-settings-daemon-server-defaults;unpack=0"
SRC_URI += "${URI_gnome-settings-daemon-server-defaults}"
SRC_URI[gnome-settings-daemon-server-defaults.sha256sum] = "da7872678c760a312633056e4315b8f3c349f7d3b3ebc4c8026c6c27b4b96a99"
RDEPENDS:gnome-settings-daemon-server-defaults = " \
 gnome-settings-daemon \
"

URI_gnome-settings-daemon-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gnome-settings-daemon-devel-47.2-5.el10.alma.1.x86_64_v2.rpm;name=gnome-settings-daemon-devel;unpack=0"
SRC_URI += "${URI_gnome-settings-daemon-devel}"
SRC_URI[gnome-settings-daemon-devel.sha256sum] = "f7c55c3843db48c9d96c43f6c2890def11eec7ab8cee32aa26b6f19224981260"
RDEPENDS:gnome-settings-daemon-devel = " \
 pkgconf-pkg-config \
 gnome-settings-daemon \
"
