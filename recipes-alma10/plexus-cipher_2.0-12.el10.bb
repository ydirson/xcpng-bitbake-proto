# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "plexus-cipher"
PE = "0"
PV = "2.0"
PR = "12.el10"
PACKAGES = "plexus-cipher plexus-cipher-javadoc"
PROVIDES = "rpm/plexus-cipher rpm/plexus-cipher-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/plexus-cipher-2.0-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "044cd66b88ed14beddc6279600c2658bb33429126baad9066888300b776dd9e0"

URI_plexus-cipher = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/plexus-cipher-2.0-12.el10.noarch.rpm;name=plexus-cipher;unpack=0"
SRC_URI += "${URI_plexus-cipher}"
SRC_URI[plexus-cipher.sha256sum] = "d74084b3dfd37f7bb979bd7c454d9f1bc1ffb8921a6dab88cc27ed4fe4189c40"
RDEPENDS:plexus-cipher = " \
 atinject \
 javapackages-filesystem \
"

URI_plexus-cipher-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-cipher-javadoc-2.0-12.el10.noarch.rpm;name=plexus-cipher-javadoc;unpack=0"
SRC_URI += "${URI_plexus-cipher-javadoc}"
SRC_URI[plexus-cipher-javadoc.sha256sum] = "4c207ff6605e6b975f2e91088d35820f904cfd422206f707fa0bd7bac913ad4f"
RDEPENDS:plexus-cipher-javadoc = " \
 javapackages-filesystem \
"
