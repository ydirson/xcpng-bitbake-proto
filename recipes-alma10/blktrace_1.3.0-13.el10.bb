# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "blktrace"
PE = "0"
PV = "1.3.0"
PR = "13.el10"
PACKAGES = "blktrace iowatcher"
PROVIDES = "rpm/blktrace rpm/iowatcher"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/blktrace-1.3.0-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e69fe7af6793f1edf1e51e122246ae9eaf42a006bea49faddcbfbb7d7d3e01e"

URI_blktrace = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/blktrace-1.3.0-13.el10.x86_64_v2.rpm;name=blktrace;unpack=0"
SRC_URI += "${URI_blktrace}"
SRC_URI[blktrace.sha256sum] = "34ec28dbc403db1bae67e82b048f601d92c51f8c881e64424128f4b93d481ee2"
RDEPENDS:blktrace = " \
 python3 \
 libaio \
 librsvg2-tools \
 bash \
 glibc \
"

URI_iowatcher = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/iowatcher-1.3.0-13.el10.x86_64_v2.rpm;name=iowatcher;unpack=0"
SRC_URI += "${URI_iowatcher}"
SRC_URI[iowatcher.sha256sum] = "61367ec6a782131573371c0dee08dca9d68b64c874c04d1804cdbeea03e86cb8"
RDEPENDS:iowatcher = " \
 glibc \
 blktrace \
 theora-tools \
 sysstat \
"
