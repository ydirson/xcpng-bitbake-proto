# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xmvn"
PE = "0"
PV = "4.3.0"
PR = "3.el10"
PACKAGES = "xmvn xmvn-core xmvn-javadoc xmvn-minimal xmvn-mojo xmvn-toolchain-openjdk21 xmvn-tools"
PROVIDES = "rpm/xmvn rpm/xmvn-core rpm/xmvn-javadoc rpm/xmvn-minimal rpm/xmvn-mojo rpm/xmvn-toolchain-openjdk21 rpm/xmvn-tools"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/xmvn-4.3.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc81391a882f858f5c29acb5a170748958bbda62ec18edb1187d0c339097baa8"

URI_xmvn = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xmvn-4.3.0-3.el10.noarch.rpm;name=xmvn;unpack=0"
SRC_URI += "${URI_xmvn}"
SRC_URI[xmvn.sha256sum] = "320710b00cc1cd2d99868443da656473cd780b0c047f77eb61a0473f39420afd"
RDEPENDS:xmvn = " \
 xmvn-minimal \
 maven \
"

URI_xmvn-core = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xmvn-core-4.3.0-3.el10.noarch.rpm;name=xmvn-core;unpack=0"
SRC_URI += "${URI_xmvn-core}"
SRC_URI[xmvn-core.sha256sum] = "15a47307e58b3c2d30d6fdad83d9e15b759cc629c62b33a9abef40e416b5fbdd"
RDEPENDS:xmvn-core = " \
 javapackages-filesystem \
"

URI_xmvn-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xmvn-javadoc-4.3.0-3.el10.noarch.rpm;name=xmvn-javadoc;unpack=0"
SRC_URI += "${URI_xmvn-javadoc}"
SRC_URI[xmvn-javadoc.sha256sum] = "5a67b8bbf3e8d9a433c876ae62a3c3007af366abd2feeb9dec18b5e12381a751"
RDEPENDS:xmvn-javadoc = ""

URI_xmvn-minimal = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xmvn-minimal-4.3.0-3.el10.noarch.rpm;name=xmvn-minimal;unpack=0"
SRC_URI += "${URI_xmvn-minimal}"
SRC_URI[xmvn-minimal.sha256sum] = "df741d8fc829e6beca5ded4bbf512c041bfe38fcf54ec927ec39af7e24194232"
RDEPENDS:xmvn-minimal = " \
 apache-commons-cli \
 apache-commons-compress \
 google-guice \
 objectweb-asm \
 xmvn-tools \
 javapackages-filesystem \
 maven-unbound \
 sisu \
 slf4j \
 beust-jcommander \
 maven-lib \
 maven-resolver \
 maven-wagon \
 atinject \
 bash \
 plexus-cipher \
 plexus-classworlds \
 plexus-containers-component-annotations \
 plexus-interpolation \
 plexus-sec-dispatcher \
 plexus-utils \
 xmvn-core \
 guava \
"

URI_xmvn-mojo = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xmvn-mojo-4.3.0-3.el10.noarch.rpm;name=xmvn-mojo;unpack=0"
SRC_URI += "${URI_xmvn-mojo}"
SRC_URI[xmvn-mojo.sha256sum] = "eeb50434bb03005bfb2b308f69ed4f3d6e7ee9284c6574d2c2dc4e34bc1ddea0"
RDEPENDS:xmvn-mojo = " \
 objectweb-asm \
 maven-resolver \
 javapackages-filesystem \
 xmvn-core \
"

URI_xmvn-toolchain-openjdk21 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xmvn-toolchain-openjdk21-4.3.0-3.el10.noarch.rpm;name=xmvn-toolchain-openjdk21;unpack=0"
SRC_URI += "${URI_xmvn-toolchain-openjdk21}"
SRC_URI[xmvn-toolchain-openjdk21.sha256sum] = "73d7bb573693a4aaa3a7425586b1538656bda191ac324cb3d42dab85ea220f01"
RDEPENDS:xmvn-toolchain-openjdk21 = " \
 java-21-openjdk-devel \
 xmvn-minimal \
 javapackages-tools \
"

URI_xmvn-tools = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xmvn-tools-4.3.0-3.el10.noarch.rpm;name=xmvn-tools;unpack=0"
SRC_URI += "${URI_xmvn-tools}"
SRC_URI[xmvn-tools.sha256sum] = "5505df7c208c75f92edc3d83b6a59c6e09500eb2fc42caebfc9106f450ebeee6"
RDEPENDS:xmvn-tools = " \
 objectweb-asm \
 apache-commons-compress \
 javapackages-filesystem \
 bash \
 slf4j \
 beust-jcommander \
 xmvn-core \
"
