# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "yggdrasil-worker-package-manager"
PE = "0"
PV = "0.2.3"
PR = "3.el10"
PACKAGES = "yggdrasil-worker-package-manager"
PROVIDES = "rpm/yggdrasil-worker-package-manager"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/yggdrasil-worker-package-manager-0.2.3-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d8b7afb42b77aff9c28802ba6b7e16e0722f8ac1695e8e48e24122a1f18c490"

URI_yggdrasil-worker-package-manager = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/yggdrasil-worker-package-manager-0.2.3-3.el10.x86_64_v2.rpm;name=yggdrasil-worker-package-manager;unpack=0"
SRC_URI += "${URI_yggdrasil-worker-package-manager}"
SRC_URI[yggdrasil-worker-package-manager.sha256sum] = "9e23e3fa87ec6127e716e3c2f67b4e7defdc81c1d064b57c1e1d4fb4342eae1f"
RDEPENDS:yggdrasil-worker-package-manager = " \
 glibc \
 bash \
"
