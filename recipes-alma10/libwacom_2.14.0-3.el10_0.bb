# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libwacom"
PE = "0"
PV = "2.14.0"
PR = "3.el10_0"
PACKAGES = "libwacom libwacom-data libwacom-devel libwacom-utils"
PROVIDES = "rpm/libwacom rpm/libwacom-data rpm/libwacom-devel rpm/libwacom-utils"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libwacom-2.14.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54353ef0448ddaf25227a50461db61ea075e5faea75694183f9be0be00d86a2a"

URI_libwacom = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libwacom-2.14.0-3.el10_0.x86_64_v2.rpm;name=libwacom;unpack=0"
SRC_URI += "${URI_libwacom}"
SRC_URI[libwacom.sha256sum] = "1a87d0fa35144e4abcc80b2eae48cdceba11740eac487fdd66a9f56931a87505"
RDEPENDS:libwacom = " \
 python3 \
 libwacom-data \
 libgudev \
 libevdev \
 glib2 \
 glibc \
"

URI_libwacom-data = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libwacom-data-2.14.0-3.el10_0.noarch.rpm;name=libwacom-data;unpack=0"
SRC_URI += "${URI_libwacom-data}"
SRC_URI[libwacom-data.sha256sum] = "6c6757f5a74cc7cf7e4204f0b5b5e7325cdb55033fef06b89f0b8b82e449db74"
RDEPENDS:libwacom-data = ""

URI_libwacom-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libwacom-devel-2.14.0-3.el10_0.x86_64_v2.rpm;name=libwacom-devel;unpack=0"
SRC_URI += "${URI_libwacom-devel}"
SRC_URI[libwacom-devel.sha256sum] = "45582149a098f7c167389e8b3810fad76a7fdde1d134658f542a9a9392ee5ffa"
RDEPENDS:libwacom-devel = " \
 glib2-devel \
 libwacom \
 pkgconf-pkg-config \
 libevdev-devel \
 libgudev-devel \
"

URI_libwacom-utils = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libwacom-utils-2.14.0-3.el10_0.x86_64_v2.rpm;name=libwacom-utils;unpack=0"
SRC_URI += "${URI_libwacom-utils}"
SRC_URI[libwacom-utils.sha256sum] = "87fe72a11726d349c7e744b023af68709a93188725dd1c85f816424921e1681a"
RDEPENDS:libwacom-utils = " \
 python3 \
 python3-pyudev \
 python3-libevdev \
 libwacom \
 glib2 \
 glibc \
"
