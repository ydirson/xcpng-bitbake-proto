# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gdbm"
PE = "1"
PV = "1.23"
PR = "12.el10_0"
PACKAGES = "gdbm gdbm-libs gdbm-devel"
PROVIDES = "rpm/gdbm rpm/gdbm-libs rpm/gdbm-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/gdbm-1.23-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9afddc4b0b1e29c311d5bb8b96b82b3824a27f62c2d5a42a466bfd3208d8739c"

URI_gdbm = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/gdbm-1.23-12.el10_0.x86_64_v2.rpm;name=gdbm;unpack=0"
SRC_URI += "${URI_gdbm}"
SRC_URI[gdbm.sha256sum] = "04c2ffdc96a621e37fb0c7e87d1d7f98844d996b6382293195217c8f862d473c"
RDEPENDS:gdbm = " \
 glibc \
 readline \
 gdbm-libs \
"

URI_gdbm-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/gdbm-libs-1.23-12.el10_0.x86_64_v2.rpm;name=gdbm-libs;unpack=0"
SRC_URI += "${URI_gdbm-libs}"
SRC_URI[gdbm-libs.sha256sum] = "7765df2bf2c2ddda06205e8e7ffd8b55f5dc090426b740daf5b32b9bcb09a6bf"
RDEPENDS:gdbm-libs = " \
 glibc \
"

URI_gdbm-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gdbm-devel-1.23-12.el10_0.x86_64_v2.rpm;name=gdbm-devel;unpack=0"
SRC_URI += "${URI_gdbm-devel}"
SRC_URI[gdbm-devel.sha256sum] = "3be5895ac4fb15168bfd2f85b68151891c2a12a13f988feb96cd90f315068300"
RDEPENDS:gdbm-devel = " \
 gdbm \
 info \
 gdbm-libs \
"
