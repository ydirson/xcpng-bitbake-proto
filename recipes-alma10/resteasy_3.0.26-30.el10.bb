# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "resteasy"
PE = "0"
PV = "3.0.26"
PR = "30.el10"
PACKAGES = "pki-resteasy-client pki-resteasy-core pki-resteasy-jackson2-provider pki-resteasy-servlet-initializer"
PROVIDES = "rpm/pki-resteasy-client rpm/pki-resteasy-core rpm/pki-resteasy-jackson2-provider rpm/pki-resteasy-servlet-initializer"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/resteasy-3.0.26-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0af04fc2cfd935cfe228db45158cc5fe6227e41ff0f3f95329849bb7714c71b9"

URI_pki-resteasy-client = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/pki-resteasy-client-3.0.26-30.el10.noarch.rpm;name=pki-resteasy-client;unpack=0"
SRC_URI += "${URI_pki-resteasy-client}"
SRC_URI[pki-resteasy-client.sha256sum] = "85911555e25528955eb075f24616427cdbf8a3c0af976db752824f8257caa42c"
RDEPENDS:pki-resteasy-client = " \
 pki-resteasy-core \
 javapackages-filesystem \
 java-21-openjdk-headless \
 jboss-logging \
 jboss-logging-tools \
"

URI_pki-resteasy-core = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/pki-resteasy-core-3.0.26-30.el10.noarch.rpm;name=pki-resteasy-core;unpack=0"
SRC_URI += "${URI_pki-resteasy-core}"
SRC_URI[pki-resteasy-core.sha256sum] = "2b1832d9d8916aa2226a483b646dfe145c3efe7850d08fda5b48a7b8e61d2cae"
RDEPENDS:pki-resteasy-core = " \
 httpcomponents-client \
 jakarta-activation \
 jakarta-annotations \
 apache-commons-io \
 javapackages-filesystem \
 tomcat-servlet-4.0-api \
 jaxb-api \
 jboss-jaxrs-2.0-api \
 jboss-logging \
 jboss-logging-tools \
 java-21-openjdk-headless \
"

URI_pki-resteasy-jackson2-provider = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/pki-resteasy-jackson2-provider-3.0.26-30.el10.noarch.rpm;name=pki-resteasy-jackson2-provider;unpack=0"
SRC_URI += "${URI_pki-resteasy-jackson2-provider}"
SRC_URI[pki-resteasy-jackson2-provider.sha256sum] = "a283e6788c6359fcebef4c643cc4f8a2a82280283abdbf105b1a7b9fdbe46c26"
RDEPENDS:pki-resteasy-jackson2-provider = " \
 javapackages-filesystem \
 tomcat-servlet-4.0-api \
 jackson-annotations \
 jackson-core \
 jackson-databind \
 jackson-jaxrs-json-provider \
 java-21-openjdk-headless \
"

URI_pki-resteasy-servlet-initializer = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/pki-resteasy-servlet-initializer-3.0.26-30.el10.noarch.rpm;name=pki-resteasy-servlet-initializer;unpack=0"
SRC_URI += "${URI_pki-resteasy-servlet-initializer}"
SRC_URI[pki-resteasy-servlet-initializer.sha256sum] = "80908aa50c576bf221206477df80dfa829b186c97d1897450e4e494e480f5b1e"
RDEPENDS:pki-resteasy-servlet-initializer = " \
 pki-resteasy-core \
 javapackages-filesystem \
 tomcat-servlet-4.0-api \
 jaxb-api \
 jboss-jaxrs-2.0-api \
 jboss-logging \
 jboss-logging-tools \
 java-21-openjdk-headless \
"
