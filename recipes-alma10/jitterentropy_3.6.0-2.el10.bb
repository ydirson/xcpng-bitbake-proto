# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jitterentropy"
PE = "0"
PV = "3.6.0"
PR = "2.el10"
PACKAGES = "jitterentropy jitterentropy-devel"
PROVIDES = "rpm/jitterentropy rpm/jitterentropy-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/jitterentropy-3.6.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "315c300475fe657c9558c32f90a11b892786d1572b67dc924a2fb61da9969376"

URI_jitterentropy = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/jitterentropy-3.6.0-2.el10.x86_64_v2.rpm;name=jitterentropy;unpack=0"
SRC_URI += "${URI_jitterentropy}"
SRC_URI[jitterentropy.sha256sum] = "3a068b6c76543d3a51e7aff72eb78918657adf2dc6eb0a87384b4adbfb84c089"
RDEPENDS:jitterentropy = " \
 glibc \
"

URI_jitterentropy-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jitterentropy-devel-3.6.0-2.el10.x86_64_v2.rpm;name=jitterentropy-devel;unpack=0"
SRC_URI += "${URI_jitterentropy-devel}"
SRC_URI[jitterentropy-devel.sha256sum] = "c9d04d17553d8aca47e0f2bb8c5a02bee5d2f41da112b7d36ef9e4a7a4f478ee"
RDEPENDS:jitterentropy-devel = " \
 jitterentropy \
"
