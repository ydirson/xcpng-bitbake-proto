# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libfastjson"
PE = "0"
PV = "1.2304.0"
PR = "6.el10"
PACKAGES = "libfastjson libfastjson-devel"
PROVIDES = "rpm/libfastjson rpm/libfastjson-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libfastjson-1.2304.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f18663a2e284b3136306cc3f3374f49f35eaa1497e1231949973b4e20e24f8e"

URI_libfastjson = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libfastjson-1.2304.0-6.el10.x86_64_v2.rpm;name=libfastjson;unpack=0"
SRC_URI += "${URI_libfastjson}"
SRC_URI[libfastjson.sha256sum] = "3e8025e83ebf029ec73c04f00a88a88d80724604a37e2cce93746e988a85c17a"
RDEPENDS:libfastjson = " \
 glibc \
"

URI_libfastjson-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libfastjson-devel-1.2304.0-6.el10.x86_64_v2.rpm;name=libfastjson-devel;unpack=0"
SRC_URI += "${URI_libfastjson-devel}"
SRC_URI[libfastjson-devel.sha256sum] = "dbf6830662d9b1b110638bb98b949e503d4b103d38329ba519171079f97069c2"
RDEPENDS:libfastjson-devel = " \
 libfastjson \
 pkgconf-pkg-config \
"
