# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rpm-mpi-hooks"
PE = "0"
PV = "8"
PR = "10.el10"
PACKAGES = "rpm-mpi-hooks"
PROVIDES = "rpm/rpm-mpi-hooks"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/rpm-mpi-hooks-8-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20c7432b7aa6a958ba2dac2c78970214fc519b00dbca114034acaaad984e4902"

URI_rpm-mpi-hooks = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rpm-mpi-hooks-8-10.el10.noarch.rpm;name=rpm-mpi-hooks;unpack=0"
SRC_URI += "${URI_rpm-mpi-hooks}"
SRC_URI[rpm-mpi-hooks.sha256sum] = "3b1d2a3a9381e196a2b79593d07ec832cb143db62b0a3a9d11a967e8ba385d18"
RDEPENDS:rpm-mpi-hooks = " \
 environment-modules \
 filesystem \
 bash \
"
