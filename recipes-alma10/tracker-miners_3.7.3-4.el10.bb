# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tracker-miners"
PE = "0"
PV = "3.7.3"
PR = "4.el10"
PACKAGES = "tracker-miners"
PROVIDES = "rpm/tracker-miners"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tracker-miners-3.7.3-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b866872b1b065c5ec2d7144f97273ee1a59babbe59108bf2cc5442ad4b1386fd"

URI_tracker-miners = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tracker-miners-3.7.3-4.el10.x86_64_v2.rpm;name=tracker-miners;unpack=0"
SRC_URI += "${URI_tracker-miners}"
SRC_URI[tracker-miners.sha256sum] = "9351f55d7ecbe5bc21b4e8522c68c30e7fd891f7cada3b8fdffeac464acd7ca6"
RDEPENDS:tracker-miners = " \
 libpng \
 libtracker-sparql \
 poppler-glib \
 upower-libs \
 libseccomp \
 libosinfo \
 libblkid \
 exempi \
 libexif \
 libgexiv2 \
 libgcc \
 libxml2 \
 bash \
 libgsf \
 libicu \
 tracker \
 libgxps \
 giflib \
 gstreamer1 \
 gstreamer1-plugins-base \
 libiptcdata \
 glib2 \
 glibc \
 libjpeg-turbo \
 libtiff \
"
