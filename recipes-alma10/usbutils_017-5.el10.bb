# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "usbutils"
PE = "0"
PV = "017"
PR = "5.el10"
PACKAGES = "usbutils"
PROVIDES = "rpm/usbutils"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/usbutils-017-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63b72221efdb27ae21a6252f36606a6a1136f0050c4cb8049a93b808f031d55d"

URI_usbutils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/usbutils-017-5.el10.x86_64_v2.rpm;name=usbutils;unpack=0"
SRC_URI += "${URI_usbutils}"
SRC_URI[usbutils.sha256sum] = "bf26700d9e9709a99c482a8b2d30d3a1a12e04cac849f529864f0cda49592f04"
RDEPENDS:usbutils = " \
 python3 \
 systemd-libs \
 hwdata \
 bash \
 glibc \
 libusb1 \
"
