# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hivex"
PE = "0"
PV = "1.3.24"
PR = "2.el10"
PACKAGES = "hivex hivex-libs perl-hivex hivex-devel ocaml-hivex ocaml-hivex-devel python3-hivex ruby-hivex"
PROVIDES = "rpm/hivex rpm/hivex-libs rpm/perl-hivex rpm/hivex-devel rpm/ocaml-hivex rpm/ocaml-hivex-devel rpm/python3-hivex rpm/ruby-hivex"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hivex-1.3.24-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97f7329361dffef3cb36b9a1218edbcaf3528126ee02d6e74fd8e8e425d0ee10"

URI_hivex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hivex-1.3.24-2.el10.x86_64_v2.rpm;name=hivex;unpack=0"
SRC_URI += "${URI_hivex}"
SRC_URI[hivex.sha256sum] = "a54d215ad559891743d2921957ad56c12a006efc17938b0ba495c0e8fa54a75b"
RDEPENDS:hivex = " \
 readline \
 libxml2 \
 bash \
 glibc \
 hivex-libs \
"

URI_hivex-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hivex-libs-1.3.24-2.el10.x86_64_v2.rpm;name=hivex-libs;unpack=0"
SRC_URI += "${URI_hivex-libs}"
SRC_URI[hivex-libs.sha256sum] = "9f526ab56f7e583ba0cf0e6b614e770fa2a82ed4581a75b7fa49ea2fc212fdf9"
RDEPENDS:hivex-libs = " \
 glibc \
"

URI_perl-hivex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-hivex-1.3.24-2.el10.x86_64_v2.rpm;name=perl-hivex;unpack=0"
SRC_URI += "${URI_perl-hivex}"
SRC_URI[perl-hivex.sha256sum] = "25666383ef65e0c9ec1b7255ab0431bdf2284801b4f126a076cf098139f02d69"
RDEPENDS:perl-hivex = " \
 perl-libs \
 perl-Carp \
 perl-interpreter \
 perl-vars \
 perl-Getopt-Long \
 perl-Encode \
 glibc \
 perl-Exporter \
 hivex-libs \
 perl-Pod-Usage \
"

URI_hivex-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/hivex-devel-1.3.24-2.el10.x86_64_v2.rpm;name=hivex-devel;unpack=0"
SRC_URI += "${URI_hivex-devel}"
SRC_URI[hivex-devel.sha256sum] = "a7913bdfb15485dd6775d661def54443f2477375d9672158ceba35d2f06ba363"
RDEPENDS:hivex-devel = " \
 hivex-libs \
 pkgconf-pkg-config \
"

URI_ocaml-hivex = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-hivex-1.3.24-2.el10.x86_64_v2.rpm;name=ocaml-hivex;unpack=0"
SRC_URI += "${URI_ocaml-hivex}"
SRC_URI[ocaml-hivex.sha256sum] = "125fdd9f1488befa69fd2bbba778f8d321700ccdae4ed44e2b0dd8e3a243d281"
RDEPENDS:ocaml-hivex = " \
 glibc \
 ocaml-runtime \
 hivex-libs \
"

URI_ocaml-hivex-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-hivex-devel-1.3.24-2.el10.x86_64_v2.rpm;name=ocaml-hivex-devel;unpack=0"
SRC_URI += "${URI_ocaml-hivex-devel}"
SRC_URI[ocaml-hivex-devel.sha256sum] = "b105b53995dd2fcc924f122a34c11f35a833dd15ac3bad1e388e9a09ab3cd0ed"
RDEPENDS:ocaml-hivex-devel = " \
 ocaml-runtime \
 ocaml-hivex \
 ocaml \
 hivex-devel \
"

URI_python3-hivex = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-hivex-1.3.24-2.el10.x86_64_v2.rpm;name=python3-hivex;unpack=0"
SRC_URI += "${URI_python3-hivex}"
SRC_URI[python3-hivex.sha256sum] = "356d98352a5bb249429c20430be639c15cb0f03358524bd3e05be1cab68b563b"
RDEPENDS:python3-hivex = " \
 glibc \
 hivex-libs \
 python3 \
"

URI_ruby-hivex = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ruby-hivex-1.3.24-2.el10.x86_64_v2.rpm;name=ruby-hivex;unpack=0"
SRC_URI += "${URI_ruby-hivex}"
SRC_URI[ruby-hivex.sha256sum] = "0c4aa8879ae79b832d8b14ffacf19674faf19d3bcb2b7e2065c93dc5992f773f"
RDEPENDS:ruby-hivex = " \
 glibc \
 ruby-libs \
 hivex-libs \
 ruby \
"
