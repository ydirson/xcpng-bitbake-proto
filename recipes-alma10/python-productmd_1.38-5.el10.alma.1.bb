# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-productmd"
PE = "0"
PV = "1.38"
PR = "5.el10.alma.1"
PACKAGES = "python3-productmd"
PROVIDES = "rpm/python3-productmd"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-productmd-1.38-5.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65d98f8fd3d4dc03ce5247fd9ab8d3f155e5090cf7ead9cdbeb4f3cf8aba9e93"

URI_python3-productmd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-productmd-1.38-5.el10.alma.1.noarch.rpm;name=python3-productmd;unpack=0"
SRC_URI += "${URI_python3-productmd}"
SRC_URI[python3-productmd.sha256sum] = "6d311973021c7d7d3b7cb18dd87ed9941226cdc8b7e60f01fb944ce64f4e2678"
RDEPENDS:python3-productmd = " \
 python3 \
 python3-six \
"
