# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-pl"
PE = "0"
PV = "0.20060726"
PR = "33.el10"
PACKAGES = "hyphen-pl"
PROVIDES = "rpm/hyphen-pl"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-pl-0.20060726-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2bcdd6436e3ba996db87b62da5fd7986c75024728f69b574e9b403f40ab3285"

URI_hyphen-pl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-pl-0.20060726-33.el10.noarch.rpm;name=hyphen-pl;unpack=0"
SRC_URI += "${URI_hyphen-pl}"
SRC_URI[hyphen-pl.sha256sum] = "1dbe3de7653fc8656b6f0eb777a8f2f0fd0f00151dec3681e10cdad7aeb7fa05"
RDEPENDS:hyphen-pl = " \
 hyphen \
"
