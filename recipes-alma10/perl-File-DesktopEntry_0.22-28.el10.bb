# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-File-DesktopEntry"
PE = "0"
PV = "0.22"
PR = "28.el10"
PACKAGES = "perl-File-DesktopEntry perl-File-DesktopEntry-tests"
PROVIDES = "rpm/perl-File-DesktopEntry rpm/perl-File-DesktopEntry-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-File-DesktopEntry-0.22-28.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8fc22ed46b9aca955abb27f810c358b3e20eea7fb4bb65612719c3b3dfb4e10"

URI_perl-File-DesktopEntry = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-File-DesktopEntry-0.22-28.el10.noarch.rpm;name=perl-File-DesktopEntry;unpack=0"
SRC_URI += "${URI_perl-File-DesktopEntry}"
SRC_URI[perl-File-DesktopEntry.sha256sum] = "c2e4163d6e70708413b338566ec7b285a15a0d9bca035bd6d407f10ddbf79adf"
RDEPENDS:perl-File-DesktopEntry = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-URI \
 perl-Encode \
 perl-PathTools \
 perl-File-BaseDir \
 perl-File-Path \
"

URI_perl-File-DesktopEntry-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-File-DesktopEntry-tests-0.22-28.el10.noarch.rpm;name=perl-File-DesktopEntry-tests;unpack=0"
SRC_URI += "${URI_perl-File-DesktopEntry-tests}"
SRC_URI[perl-File-DesktopEntry-tests.sha256sum] = "7c96d140e0154a9379fafbc7dbc4197dfff1cbcd6ba2b8ccaa493e0582db817a"
RDEPENDS:perl-File-DesktopEntry-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 bash \
 perl-File-DesktopEntry \
 perl-interpreter \
"
