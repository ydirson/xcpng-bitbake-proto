# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Net-SSLeay"
PE = "0"
PV = "1.94"
PR = "7.el10"
PACKAGES = "perl-Net-SSLeay perl-Net-SSLeay-tests"
PROVIDES = "rpm/perl-Net-SSLeay rpm/perl-Net-SSLeay-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Net-SSLeay-1.94-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e69f5a047c36d4edb79bb2cc7084ba49a2196202680c7455a5b99a9e441adcab"

URI_perl-Net-SSLeay = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Net-SSLeay-1.94-7.el10.x86_64_v2.rpm;name=perl-Net-SSLeay;unpack=0"
SRC_URI += "${URI_perl-Net-SSLeay}"
SRC_URI[perl-Net-SSLeay.sha256sum] = "9d2a5946943d31e25b8312d60fa1f7c6cd0d467b1c1ace743867d825bdda7079"
RDEPENDS:perl-Net-SSLeay = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-Net-SSLeay \
 perl-Socket \
 openssl-libs \
 perl-Errno \
 perl-AutoLoader \
 glibc \
 perl-Exporter \
 perl-MIME-Base64 \
"

URI_perl-Net-SSLeay-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Net-SSLeay-tests-1.94-7.el10.x86_64_v2.rpm;name=perl-Net-SSLeay-tests;unpack=0"
SRC_URI += "${URI_perl-Net-SSLeay-tests}"
SRC_URI[perl-Net-SSLeay-tests.sha256sum] = "3c06d8222e08d43f2e5e3d966c3e8891f8fe7d247fbec5d097fe39050472c5eb"
RDEPENDS:perl-Net-SSLeay-tests = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-SelectSaver \
 perl-FindBin \
 perl-Socket \
 perl-Storable \
 perl-Symbol \
 perl-threads \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Carp \
 perl-IO \
 bash \
 perl-English \
 perl-Exporter \
 perl-base \
 perl-Net-SSLeay \
 perl-File-Basename \
 perl-PathTools \
 perl-interpreter \
 perl-lib \
"
