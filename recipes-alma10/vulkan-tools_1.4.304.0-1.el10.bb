# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "vulkan-tools"
PE = "0"
PV = "1.4.304.0"
PR = "1.el10"
PACKAGES = "vulkan-tools"
PROVIDES = "rpm/vulkan-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/vulkan-tools-1.4.304.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee95d2378d480ce32e5ddd2f21d039b92fcb99e4c9134e1416bb32b0bebca103"

URI_vulkan-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/vulkan-tools-1.4.304.0-1.el10.x86_64_v2.rpm;name=vulkan-tools;unpack=0"
SRC_URI += "${URI_vulkan-tools}"
SRC_URI[vulkan-tools.sha256sum] = "8b9bdc6c46e478faf29757bca85902d4177dff82c2a83e651978263c4f03962a"
RDEPENDS:vulkan-tools = " \
 libwayland-client \
 libgcc \
 libX11 \
 libxcb \
 libstdc++ \
 glibc \
"
