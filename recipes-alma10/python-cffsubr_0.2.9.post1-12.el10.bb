# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-cffsubr"
PE = "0"
PV = "0.2.9.post1"
PR = "12.el10"
PACKAGES = "python3-cffsubr"
PROVIDES = "rpm/python3-cffsubr"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/python-cffsubr-0.2.9.post1-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c88b86ba5499afb7d2cd541af13228481c6c91c69820fb884302ce8b0ab942d"

URI_python3-cffsubr = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-cffsubr-0.2.9.post1-12.el10.noarch.rpm;name=python3-cffsubr;unpack=0"
SRC_URI += "${URI_python3-cffsubr}"
SRC_URI[python3-cffsubr.sha256sum] = "d8c2993d810e0baa8dad51f925a16d9824151a37b86c018370c394e631b3dd67"
RDEPENDS:python3-cffsubr = " \
 python3 \
 adobe-afdko \
 python3-fonttools \
"
