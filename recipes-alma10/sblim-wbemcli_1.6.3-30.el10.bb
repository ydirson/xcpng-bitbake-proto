# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sblim-wbemcli"
PE = "0"
PV = "1.6.3"
PR = "30.el10"
PACKAGES = "sblim-wbemcli"
PROVIDES = "rpm/sblim-wbemcli"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/sblim-wbemcli-1.6.3-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e618bfad53b6d19713d53e4a938d949a38f25a0a12cf9a7685d60a9907137576"

URI_sblim-wbemcli = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sblim-wbemcli-1.6.3-30.el10.x86_64_v2.rpm;name=sblim-wbemcli;unpack=0"
SRC_URI += "${URI_sblim-wbemcli}"
SRC_URI[sblim-wbemcli.sha256sum] = "81fce9826e78b71b19a41897dc2aa2bab7921a76fb351e6919810caa875aa35a"
RDEPENDS:sblim-wbemcli = " \
 libgcc \
 curl \
 libstdc++ \
 libcurl \
 glibc \
"
