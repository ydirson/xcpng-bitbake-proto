# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jdeparser"
PE = "0"
PV = "2.0.3"
PR = "17.el10"
PACKAGES = "jdeparser"
PROVIDES = "rpm/jdeparser"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/jdeparser-2.0.3-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e22da1d17adb9405db283f5c3ebfd3e53a46071be4d5f43185f167c08b211558"

URI_jdeparser = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/jdeparser-2.0.3-17.el10.noarch.rpm;name=jdeparser;unpack=0"
SRC_URI += "${URI_jdeparser}"
SRC_URI[jdeparser.sha256sum] = "577d6d0391fcd6a893fae218a8f7ec9c80413ee1b958d84f1ef20ecc417c16d8"
RDEPENDS:jdeparser = " \
 javapackages-filesystem \
 java-21-openjdk-headless \
"
