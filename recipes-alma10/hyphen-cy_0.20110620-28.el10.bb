# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-cy"
PE = "0"
PV = "0.20110620"
PR = "28.el10"
PACKAGES = "hyphen-cy"
PROVIDES = "rpm/hyphen-cy"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-cy-0.20110620-28.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "283b1c79c4956c3cb852aeeef922ec1818d818e825987cb166bb236bbe617adf"

URI_hyphen-cy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-cy-0.20110620-28.el10.noarch.rpm;name=hyphen-cy;unpack=0"
SRC_URI += "${URI_hyphen-cy}"
SRC_URI[hyphen-cy.sha256sum] = "a278972757f4b61ac41f5424463dd60f3ca8f7011e0de82f7bfd5172b927f94b"
RDEPENDS:hyphen-cy = " \
 hyphen \
"
