# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Test-Exception"
PE = "0"
PV = "0.43"
PR = "29.el10"
PACKAGES = "perl-Test-Exception perl-Test-Exception-tests"
PROVIDES = "rpm/perl-Test-Exception rpm/perl-Test-Exception-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Test-Exception-0.43-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "544ebe14afb64ef41bf9fd18609f781dfda3a828294647ffb63f2a72496a4fc1"

URI_perl-Test-Exception = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Test-Exception-0.43-29.el10.noarch.rpm;name=perl-Test-Exception;unpack=0"
SRC_URI += "${URI_perl-Test-Exception}"
SRC_URI[perl-Test-Exception.sha256sum] = "f4ef982f6a310b086caa1f251d6c493ae1af219aa2b6974cf611867f1d6271bb"
RDEPENDS:perl-Test-Exception = " \
 perl-Test-Simple \
 perl-libs \
 perl-Carp \
 perl-Sub-Uplevel \
 perl-Exporter \
 perl-base \
"

URI_perl-Test-Exception-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Test-Exception-tests-0.43-29.el10.noarch.rpm;name=perl-Test-Exception-tests;unpack=0"
SRC_URI += "${URI_perl-Test-Exception-tests}"
SRC_URI[perl-Test-Exception-tests.sha256sum] = "32118ca9b8448bb9f9f58ffd3670c49e723bb0bc390989a3b469013e1c9181b6"
RDEPENDS:perl-Test-Exception-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-overload \
 bash \
 perl-Sub-Uplevel \
 perl-interpreter \
 perl-Test-Exception \
 perl-base \
"
