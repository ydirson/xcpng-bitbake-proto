# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libXdamage"
PE = "0"
PV = "1.1.6"
PR = "5.el10"
PACKAGES = "libXdamage libXdamage-devel"
PROVIDES = "rpm/libXdamage rpm/libXdamage-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libXdamage-1.1.6-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aeb960b35f959fc8b14e1bfebb7c1a7e211d08d82719a930544b6ed346dc1002"

URI_libXdamage = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXdamage-1.1.6-5.el10.x86_64_v2.rpm;name=libXdamage;unpack=0"
SRC_URI += "${URI_libXdamage}"
SRC_URI[libXdamage.sha256sum] = "c388e8fcd564bac273b11d690cbf3064e82643d2051ed28d65a82ec0eccff2c2"
RDEPENDS:libXdamage = " \
 glibc \
 libXfixes \
 libX11 \
"

URI_libXdamage-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXdamage-devel-1.1.6-5.el10.x86_64_v2.rpm;name=libXdamage-devel;unpack=0"
SRC_URI += "${URI_libXdamage-devel}"
SRC_URI[libXdamage-devel.sha256sum] = "8c32c1e1e9689728fd7ca464d7dc535b85c59aa0672576f93c7468666ae631a8"
RDEPENDS:libXdamage-devel = " \
 libXfixes-devel \
 pkgconf-pkg-config \
 libX11-devel \
 xorg-x11-proto-devel \
 libXdamage \
"
