# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "google-roboto-slab-fonts"
PE = "0"
PV = "1.100263"
PR = "0.25.20150923git.el10"
PACKAGES = "google-roboto-slab-fonts"
PROVIDES = "rpm/google-roboto-slab-fonts"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/google-roboto-slab-fonts-1.100263-0.25.20150923git.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ebcb404d724fab096dad240d42b5013286918462a2f4eedff2c52844a16658e8"

URI_google-roboto-slab-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-roboto-slab-fonts-1.100263-0.25.20150923git.el10.noarch.rpm;name=google-roboto-slab-fonts;unpack=0"
SRC_URI += "${URI_google-roboto-slab-fonts}"
SRC_URI[google-roboto-slab-fonts.sha256sum] = "95217ce712783fbe09ebc493be39f2f032ad705c4585be4802fe6aa3cc782a09"
RDEPENDS:google-roboto-slab-fonts = " \
 fonts-filesystem \
"
