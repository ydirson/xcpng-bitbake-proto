# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Digest-SHA"
PE = "1"
PV = "6.04"
PR = "512.el10"
PACKAGES = "perl-Digest-SHA perl-Digest-SHA-tests"
PROVIDES = "rpm/perl-Digest-SHA rpm/perl-Digest-SHA-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Digest-SHA-6.04-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c2bf097c83f77f1f2ccb8fac7a531c26d9fd1baea9beeaf808f38b501fbcf44"

URI_perl-Digest-SHA = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Digest-SHA-6.04-512.el10.x86_64_v2.rpm;name=perl-Digest-SHA;unpack=0"
SRC_URI += "${URI_perl-Digest-SHA}"
SRC_URI[perl-Digest-SHA.sha256sum] = "a4a3abd9436ebd5ccee6d131fcca0fef32ffe33b28b96c1b8d717ea9af7be934"
RDEPENDS:perl-Digest-SHA = " \
 perl-libs \
 perl-Carp \
 perl-interpreter \
 perl-vars \
 perl-Digest \
 perl-Digest-SHA \
 perl-Fcntl \
 perl-Getopt-Long \
 perl-PathTools \
 glibc \
 perl-Exporter \
"

URI_perl-Digest-SHA-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Digest-SHA-tests-6.04-512.el10.x86_64_v2.rpm;name=perl-Digest-SHA-tests;unpack=0"
SRC_URI += "${URI_perl-Digest-SHA-tests}"
SRC_URI[perl-Digest-SHA-tests.sha256sum] = "ceadfddf01faa2f583863306f4d3dc1ac485218ffc15bf60c460dbb279dfe08a"
RDEPENDS:perl-Digest-SHA-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-vars \
 perl-FileHandle \
 perl-Digest-SHA \
 bash \
 perl-interpreter \
"
