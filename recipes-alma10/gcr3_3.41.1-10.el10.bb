# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gcr3"
PE = "0"
PV = "3.41.1"
PR = "10.el10"
PACKAGES = "gcr3 gcr3-base gcr3-devel"
PROVIDES = "rpm/gcr3 rpm/gcr3-base rpm/gcr3-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gcr3-3.41.1-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39c08c37d9d299b3d007c5a62203c703d03fa106210b6fce6839cc849b795380"

URI_gcr3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gcr3-3.41.1-10.el10.x86_64_v2.rpm;name=gcr3;unpack=0"
SRC_URI += "${URI_gcr3}"
SRC_URI[gcr3.sha256sum] = "062bde94bdbc62bb2fc9729d34ed7a848aed34854912fc0da95bc037b587d2eb"
RDEPENDS:gcr3 = " \
 gcr3-base \
 openssh-clients \
 pango \
 gdk-pixbuf2 \
 cairo \
 glib2 \
 gtk3 \
 glibc \
"

URI_gcr3-base = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gcr3-base-3.41.1-10.el10.x86_64_v2.rpm;name=gcr3-base;unpack=0"
SRC_URI += "${URI_gcr3-base}"
SRC_URI[gcr3-base.sha256sum] = "5be5b64fdf37e634903f5ca27844a35de4997cb8da67667195755e7906e8d2e7"
RDEPENDS:gcr3-base = " \
 glibc \
 libgcrypt \
 glib2 \
 p11-kit \
"

URI_gcr3-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gcr3-devel-3.41.1-10.el10.x86_64_v2.rpm;name=gcr3-devel;unpack=0"
SRC_URI += "${URI_gcr3-devel}"
SRC_URI[gcr3-devel.sha256sum] = "a10bad341fce18e4be6c95fca2e35edeb4a6a610d5c654f78673bc07d50088ef"
RDEPENDS:gcr3-devel = " \
 gcr3 \
 gcr3-base \
 p11-kit-devel \
 glib2-devel \
 pkgconf-pkg-config \
 gcr3-devel \
 gtk3-devel \
"
