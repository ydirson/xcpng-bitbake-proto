# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "intltool"
PE = "0"
PV = "0.51.0"
PR = "29.el10"
PACKAGES = "intltool"
PROVIDES = "rpm/intltool"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/intltool-0.51.0-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6e928032ad8343d2f7441a71dc319ecfcf0597072187e3d7ce505dccb11fc49"

URI_intltool = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/intltool-0.51.0-29.el10.noarch.rpm;name=intltool;unpack=0"
SRC_URI += "${URI_intltool}"
SRC_URI[intltool.sha256sum] = "7b75a69d18f6bf82d34a2f4ccba4b982e86a8d42262d95a73d9cf9679652886c"
RDEPENDS:intltool = " \
 patch \
 perl-libs \
 automake \
 perl-Text-Tabs+Wrap \
 perl-Getopt-Long \
 perl-File-Basename \
 perl-Encode \
 perl-XML-Parser \
 perl-File-Copy \
 bash \
 perl-PathTools \
 perl-File-Find \
 perl-interpreter \
 gettext-devel \
"
