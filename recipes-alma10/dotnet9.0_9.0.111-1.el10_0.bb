# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dotnet9.0"
PE = "0"
PV = "9.0.111"
PR = "1.el10_0"
PACKAGES = "aspnetcore-runtime-9.0 aspnetcore-runtime-dbg-9.0 aspnetcore-targeting-pack-9.0 dotnet-apphost-pack-9.0 dotnet-host dotnet-hostfxr-9.0 dotnet-runtime-9.0 dotnet-runtime-dbg-9.0 dotnet-sdk-9.0 dotnet-sdk-aot-9.0 dotnet-sdk-dbg-9.0 dotnet-targeting-pack-9.0 dotnet-templates-9.0 netstandard-targeting-pack-2.1 dotnet-sdk-9.0-source-built-artifacts"
PROVIDES = "rpm/aspnetcore-runtime-9.0 rpm/aspnetcore-runtime-dbg-9.0 rpm/aspnetcore-targeting-pack-9.0 rpm/dotnet-apphost-pack-9.0 rpm/dotnet-host rpm/dotnet-hostfxr-9.0 rpm/dotnet-runtime-9.0 rpm/dotnet-runtime-dbg-9.0 rpm/dotnet-sdk-9.0 rpm/dotnet-sdk-aot-9.0 rpm/dotnet-sdk-dbg-9.0 rpm/dotnet-targeting-pack-9.0 rpm/dotnet-templates-9.0 rpm/netstandard-targeting-pack-2.1 rpm/dotnet-sdk-9.0-source-built-artifacts"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/dotnet9.0-9.0.111-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9091c41e20e8086db2a846496661e35e3ec1837859369b92d75bd71c6de97f63"

URI_aspnetcore-runtime-9.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-9.0-9.0.10-1.el10_0.x86_64_v2.rpm;name=aspnetcore-runtime-9.0;unpack=0"
SRC_URI += "${URI_aspnetcore-runtime-9.0}"
SRC_URI[aspnetcore-runtime-9.0.sha256sum] = "d59b137543b3cce5fe666bcfc578c83aca81d7df56a92b8dca06e7b6e605e8ff"
RDEPENDS:aspnetcore-runtime-9.0 = " \
 dotnet-runtime-9.0 \
"

URI_aspnetcore-runtime-dbg-9.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-dbg-9.0-9.0.10-1.el10_0.x86_64_v2.rpm;name=aspnetcore-runtime-dbg-9.0;unpack=0"
SRC_URI += "${URI_aspnetcore-runtime-dbg-9.0}"
SRC_URI[aspnetcore-runtime-dbg-9.0.sha256sum] = "eda6e751db5d580e494e480710efd3e1f8ad876430770eeef176101930306c5c"
RDEPENDS:aspnetcore-runtime-dbg-9.0 = " \
 aspnetcore-runtime-9.0 \
"

URI_aspnetcore-targeting-pack-9.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/aspnetcore-targeting-pack-9.0-9.0.10-1.el10_0.x86_64_v2.rpm;name=aspnetcore-targeting-pack-9.0;unpack=0"
SRC_URI += "${URI_aspnetcore-targeting-pack-9.0}"
SRC_URI[aspnetcore-targeting-pack-9.0.sha256sum] = "d878190308e20fc670729a253498598658d599d8dd18574ec1c6100c249a4259"
RDEPENDS:aspnetcore-targeting-pack-9.0 = " \
 dotnet-host \
"

URI_dotnet-apphost-pack-9.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dotnet-apphost-pack-9.0-9.0.10-1.el10_0.x86_64_v2.rpm;name=dotnet-apphost-pack-9.0;unpack=0"
SRC_URI += "${URI_dotnet-apphost-pack-9.0}"
SRC_URI[dotnet-apphost-pack-9.0.sha256sum] = "dbcfd4fae4635d7002f9947f4adb32ec85cda619c031b34adcf25ba14b66ed40"
RDEPENDS:dotnet-apphost-pack-9.0 = " \
 zlib-ng-compat \
 openssl-libs \
 libgcc \
 libbrotli \
 libstdc++ \
 glibc \
 dotnet-host \
"

URI_dotnet-host = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dotnet-host-9.0.10-1.el10_0.x86_64_v2.rpm;name=dotnet-host;unpack=0"
SRC_URI += "${URI_dotnet-host}"
SRC_URI[dotnet-host.sha256sum] = "4c3d5e4ac9913094b1161bc80059e885bd6da6bf1f47eccc8e447e71e5e89e6f"
RDEPENDS:dotnet-host = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_dotnet-hostfxr-9.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dotnet-hostfxr-9.0-9.0.10-1.el10_0.x86_64_v2.rpm;name=dotnet-hostfxr-9.0;unpack=0"
SRC_URI += "${URI_dotnet-hostfxr-9.0}"
SRC_URI[dotnet-hostfxr-9.0.sha256sum] = "312a05527d92b8984fa28783683ce0e6b171f09a5b8baba79d7cfb01f71dad57"
RDEPENDS:dotnet-hostfxr-9.0 = " \
 glibc \
 libgcc \
 libstdc++ \
 dotnet-host \
"

URI_dotnet-runtime-9.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dotnet-runtime-9.0-9.0.10-1.el10_0.x86_64_v2.rpm;name=dotnet-runtime-9.0;unpack=0"
SRC_URI += "${URI_dotnet-runtime-9.0}"
SRC_URI[dotnet-runtime-9.0.sha256sum] = "81cd259137780fd874401b61817aebfe927b1981841fffb1ee5c309f74623eb8"
RDEPENDS:dotnet-runtime-9.0 = " \
 zlib-ng-compat \
 openssl-libs \
 libgcc \
 libbrotli \
 dotnet-hostfxr-9.0 \
 libstdc++ \
 glibc \
 libicu \
"

URI_dotnet-runtime-dbg-9.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dotnet-runtime-dbg-9.0-9.0.10-1.el10_0.x86_64_v2.rpm;name=dotnet-runtime-dbg-9.0;unpack=0"
SRC_URI += "${URI_dotnet-runtime-dbg-9.0}"
SRC_URI[dotnet-runtime-dbg-9.0.sha256sum] = "f0e64424da9eae465d5b80b087e321d3adf6f4670b63f34b5867749c9a242031"
RDEPENDS:dotnet-runtime-dbg-9.0 = " \
 dotnet-runtime-9.0 \
"

URI_dotnet-sdk-9.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dotnet-sdk-9.0-9.0.111-1.el10_0.x86_64_v2.rpm;name=dotnet-sdk-9.0;unpack=0"
SRC_URI += "${URI_dotnet-sdk-9.0}"
SRC_URI[dotnet-sdk-9.0.sha256sum] = "d56d1f63a787f1c6cca83d1ca84db55f41b950758a6bd06c7720be30935d8c3d"
RDEPENDS:dotnet-sdk-9.0 = " \
 libgcc \
 dotnet-targeting-pack-9.0 \
 dotnet-templates-9.0 \
 libstdc++ \
 netstandard-targeting-pack-2.1 \
 aspnetcore-targeting-pack-9.0 \
 dotnet-runtime-9.0 \
 glibc \
 dotnet-apphost-pack-9.0 \
 aspnetcore-runtime-9.0 \
"

URI_dotnet-sdk-aot-9.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dotnet-sdk-aot-9.0-9.0.111-1.el10_0.x86_64_v2.rpm;name=dotnet-sdk-aot-9.0;unpack=0"
SRC_URI += "${URI_dotnet-sdk-aot-9.0}"
SRC_URI[dotnet-sdk-aot-9.0.sha256sum] = "c0d60e9dc7ed870e743402c56038886b25e0cb5b84936dd512a30e1e91b56833"
RDEPENDS:dotnet-sdk-aot-9.0 = " \
 zlib-ng-compat \
 brotli-devel \
 zlib-ng-compat-devel \
 libgcc \
 openssl-libs \
 libbrotli \
 clang \
 openssl-devel \
 libstdc++ \
 bash \
 dotnet-sdk-9.0 \
 glibc \
"

URI_dotnet-sdk-dbg-9.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dotnet-sdk-dbg-9.0-9.0.111-1.el10_0.x86_64_v2.rpm;name=dotnet-sdk-dbg-9.0;unpack=0"
SRC_URI += "${URI_dotnet-sdk-dbg-9.0}"
SRC_URI[dotnet-sdk-dbg-9.0.sha256sum] = "e74cb160278c0347ea02c4bdd36b10ef5fe5b283bbdaa762e5e97c13f3566e0d"
RDEPENDS:dotnet-sdk-dbg-9.0 = " \
 dotnet-sdk-9.0 \
"

URI_dotnet-targeting-pack-9.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dotnet-targeting-pack-9.0-9.0.10-1.el10_0.x86_64_v2.rpm;name=dotnet-targeting-pack-9.0;unpack=0"
SRC_URI += "${URI_dotnet-targeting-pack-9.0}"
SRC_URI[dotnet-targeting-pack-9.0.sha256sum] = "6a79430034c66e99da505457202fb6853d3c6889874b6b703e2560ebd1aae598"
RDEPENDS:dotnet-targeting-pack-9.0 = " \
 dotnet-host \
"

URI_dotnet-templates-9.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dotnet-templates-9.0-9.0.111-1.el10_0.x86_64_v2.rpm;name=dotnet-templates-9.0;unpack=0"
SRC_URI += "${URI_dotnet-templates-9.0}"
SRC_URI[dotnet-templates-9.0.sha256sum] = "51feb8f97509950e0186dd548e2e4263ca666f5a5e8da6f8ea23cecfe5ca60d6"
RDEPENDS:dotnet-templates-9.0 = " \
 dotnet-host \
"

URI_netstandard-targeting-pack-2.1 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/netstandard-targeting-pack-2.1-9.0.111-1.el10_0.x86_64_v2.rpm;name=netstandard-targeting-pack-2.1;unpack=0"
SRC_URI += "${URI_netstandard-targeting-pack-2.1}"
SRC_URI[netstandard-targeting-pack-2.1.sha256sum] = "3d381ff271db36c64c72676a2a95b6d224ca379900466b9579cd4556814bdeb7"
RDEPENDS:netstandard-targeting-pack-2.1 = " \
 dotnet-host \
"

URI_dotnet-sdk-9.0-source-built-artifacts = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/dotnet-sdk-9.0-source-built-artifacts-9.0.111-1.el10_0.x86_64_v2.rpm;name=dotnet-sdk-9.0-source-built-artifacts;unpack=0"
SRC_URI += "${URI_dotnet-sdk-9.0-source-built-artifacts}"
SRC_URI[dotnet-sdk-9.0-source-built-artifacts.sha256sum] = "36b042f22fe6847866cffc226b7456aea2ab2d03607b392c4a0ad60b57b0b09d"
RDEPENDS:dotnet-sdk-9.0-source-built-artifacts = ""
