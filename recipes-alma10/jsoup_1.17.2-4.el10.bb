# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jsoup"
PE = "0"
PV = "1.17.2"
PR = "4.el10"
PACKAGES = "jsoup jsoup-javadoc"
PROVIDES = "rpm/jsoup rpm/jsoup-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/jsoup-1.17.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c2a9aae54bbd183d2b224e39d87ecb9989c733f655d101364f66963f4c78cf2"

URI_jsoup = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jsoup-1.17.2-4.el10.noarch.rpm;name=jsoup;unpack=0"
SRC_URI += "${URI_jsoup}"
SRC_URI[jsoup.sha256sum] = "9c587e444e4d5ebe7b543a8b7d4536d011b6a45c75d1e48bfe97fd290ff1b0d6"
RDEPENDS:jsoup = " \
 javapackages-filesystem \
"

URI_jsoup-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jsoup-javadoc-1.17.2-4.el10.noarch.rpm;name=jsoup-javadoc;unpack=0"
SRC_URI += "${URI_jsoup-javadoc}"
SRC_URI[jsoup-javadoc.sha256sum] = "da7f8a1cd51fe6a1ac5c12b22eee2bda75215bba6bd9e9827993f317a518354a"
RDEPENDS:jsoup-javadoc = " \
 javapackages-filesystem \
"
