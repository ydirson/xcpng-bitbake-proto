# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libbytesize"
PE = "0"
PV = "2.10"
PR = "5.el10"
PACKAGES = "libbytesize python3-bytesize libbytesize-devel libbytesize-tools"
PROVIDES = "rpm/libbytesize rpm/python3-bytesize rpm/libbytesize-devel rpm/libbytesize-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libbytesize-2.10-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d9d022cbe81e6e2e7b155cc1f9471a27b998be521ae881bf9e9e962449c9da9"

URI_libbytesize = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libbytesize-2.10-5.el10.x86_64_v2.rpm;name=libbytesize;unpack=0"
SRC_URI += "${URI_libbytesize}"
SRC_URI[libbytesize.sha256sum] = "f658f3f59f7f821cf62090fbcbe3fc78266b1f4ed4d513f076e58b64e49612b8"
RDEPENDS:libbytesize = " \
 glibc \
 gmp \
 pcre2 \
 mpfr \
"

URI_python3-bytesize = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-bytesize-2.10-5.el10.x86_64_v2.rpm;name=python3-bytesize;unpack=0"
SRC_URI += "${URI_python3-bytesize}"
SRC_URI[python3-bytesize.sha256sum] = "2fb0101955c0bd9f34aaa40783adb985a074020c9d7e419999f4d179ad2087f7"
RDEPENDS:python3-bytesize = " \
 python3 \
 libbytesize \
"

URI_libbytesize-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libbytesize-devel-2.10-5.el10.x86_64_v2.rpm;name=libbytesize-devel;unpack=0"
SRC_URI += "${URI_libbytesize-devel}"
SRC_URI[libbytesize-devel.sha256sum] = "13796ecc4bbd930dbd8635fd277475d902d6f7de0c84b5cef71c96eabac91583"
RDEPENDS:libbytesize-devel = " \
 libbytesize \
 pkgconf-pkg-config \
"

URI_libbytesize-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libbytesize-tools-2.10-5.el10.x86_64_v2.rpm;name=libbytesize-tools;unpack=0"
SRC_URI += "${URI_libbytesize-tools}"
SRC_URI[libbytesize-tools.sha256sum] = "99c455ed77b40b7daeadb843442fbc9c5a1c7e621f01caeffcf7d59924c0957b"
RDEPENDS:libbytesize-tools = " \
 python3 \
 python3-bytesize \
"
