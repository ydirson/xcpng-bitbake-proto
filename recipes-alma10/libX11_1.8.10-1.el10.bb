# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libX11"
PE = "0"
PV = "1.8.10"
PR = "1.el10"
PACKAGES = "libX11 libX11-common libX11-devel libX11-xcb"
PROVIDES = "rpm/libX11 rpm/libX11-common rpm/libX11-devel rpm/libX11-xcb"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libX11-1.8.10-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fdc15fd571ba39d701268873fe5db6a981cb6e7b180cc9cede0b4ae2137603c6"

URI_libX11 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libX11-1.8.10-1.el10.x86_64_v2.rpm;name=libX11;unpack=0"
SRC_URI += "${URI_libX11}"
SRC_URI[libX11.sha256sum] = "cc067f3b853c945c5958b4c07d6e8132be392400341712f81636864e7e27e194"
RDEPENDS:libX11 = " \
 glibc \
 libxcb \
 libX11-common \
"

URI_libX11-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libX11-common-1.8.10-1.el10.noarch.rpm;name=libX11-common;unpack=0"
SRC_URI += "${URI_libX11-common}"
SRC_URI[libX11-common.sha256sum] = "f02b59a9419a3d5907efb7805c915db5c26717c0061ebe1c04754764e868b562"
RDEPENDS:libX11-common = ""

URI_libX11-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libX11-devel-1.8.10-1.el10.x86_64_v2.rpm;name=libX11-devel;unpack=0"
SRC_URI += "${URI_libX11-devel}"
SRC_URI[libX11-devel.sha256sum] = "0034e08a167d410b525a9f4ab8c305603cdaf54780a0601e26cb55aff797ae8b"
RDEPENDS:libX11-devel = " \
 pkgconf-pkg-config \
 libX11 \
 libX11-devel \
 libX11-xcb \
 xorg-x11-proto-devel \
 libxcb-devel \
"

URI_libX11-xcb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libX11-xcb-1.8.10-1.el10.x86_64_v2.rpm;name=libX11-xcb;unpack=0"
SRC_URI += "${URI_libX11-xcb}"
SRC_URI[libX11-xcb.sha256sum] = "c9fb0028b7fa3c982eda82af61b5b1bd0d170bd22b82650ea9b485351e4a5f3a"
RDEPENDS:libX11-xcb = " \
 glibc \
"
