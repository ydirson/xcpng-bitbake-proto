# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cockpit-image-builder"
PE = "0"
PV = "60"
PR = "1.el10"
PACKAGES = "cockpit-image-builder"
PROVIDES = "rpm/cockpit-image-builder"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/cockpit-image-builder-60-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb531847138ae0e1097dade91d756adfb19acad58bab5db9cde4f2751422a037"

URI_cockpit-image-builder = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cockpit-image-builder-60-1.el10.noarch.rpm;name=cockpit-image-builder;unpack=0"
SRC_URI += "${URI_cockpit-image-builder}"
SRC_URI[cockpit-image-builder.sha256sum] = "040deb2c9575912105ec6cc8b30836085a97d3ab0f3f7e9842fa2d8e83522d07"
RDEPENDS:cockpit-image-builder = " \
 cockpit-files \
 cockpit \
 osbuild-composer \
"
