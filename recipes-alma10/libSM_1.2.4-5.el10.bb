# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libSM"
PE = "0"
PV = "1.2.4"
PR = "5.el10"
PACKAGES = "libSM libSM-devel"
PROVIDES = "rpm/libSM rpm/libSM-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libSM-1.2.4-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d5fd5e5262ae7031464bd44c15428492e007534a227afde7b2465169e0c2d5a"

URI_libSM = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libSM-1.2.4-5.el10.x86_64_v2.rpm;name=libSM;unpack=0"
SRC_URI += "${URI_libSM}"
SRC_URI[libSM.sha256sum] = "096a4878913609999b12be4f576943dd1617e91e4bd19b69e58e6a8dc65ba0fb"
RDEPENDS:libSM = " \
 glibc \
 libuuid \
 libICE \
"

URI_libSM-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libSM-devel-1.2.4-5.el10.x86_64_v2.rpm;name=libSM-devel;unpack=0"
SRC_URI += "${URI_libSM-devel}"
SRC_URI[libSM-devel.sha256sum] = "b536f350a0533ef89dd404cdcb53238e335f13ca5dda50a7a491692bed051866"
RDEPENDS:libSM-devel = " \
 libICE-devel \
 pkgconf-pkg-config \
 libSM \
 libuuid-devel \
 xorg-x11-proto-devel \
"
