# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jurand"
PE = "0"
PV = "1.3.2"
PR = "5.el10"
PACKAGES = "jurand"
PROVIDES = "rpm/jurand"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/jurand-1.3.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3139f26165320c89d78825aa81f70b3a3b77612ca4a2f00923f5b702b5750bad"

URI_jurand = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jurand-1.3.2-5.el10.x86_64_v2.rpm;name=jurand;unpack=0"
SRC_URI += "${URI_jurand}"
SRC_URI[jurand.sha256sum] = "2e52c212b8d99cace434955c595d45375e95bc87cb295af083a6b84db112c3bc"
RDEPENDS:jurand = " \
 glibc \
 libgcc \
 libstdc++ \
"
