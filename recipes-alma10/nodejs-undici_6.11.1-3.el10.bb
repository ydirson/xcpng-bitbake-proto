# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "nodejs-undici"
PE = "0"
PV = "6.11.1"
PR = "3.el10"
PACKAGES = "nodejs-undici"
PROVIDES = "rpm/nodejs-undici"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/nodejs-undici-6.11.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23560b1299bdbb81ed4045d48b16f3c9694a16371d711ec630d87aa133f86819"

URI_nodejs-undici = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/nodejs-undici-6.11.1-3.el10.noarch.rpm;name=nodejs-undici;unpack=0"
SRC_URI += "${URI_nodejs-undici}"
SRC_URI[nodejs-undici.sha256sum] = "5faaafa1cc6b531d34bb60d5f7b21058417702bff1d3c6eb0c202dec57059dc7"
RDEPENDS:nodejs-undici = ""
