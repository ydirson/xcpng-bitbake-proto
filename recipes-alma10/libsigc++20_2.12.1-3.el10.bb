# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libsigc++20"
PE = "0"
PV = "2.12.1"
PR = "3.el10"
PACKAGES = "libsigc++20 libsigc++20-devel libsigc++20-doc"
PROVIDES = "rpm/libsigc++20 rpm/libsigc++20-devel rpm/libsigc++20-doc"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/libsigc++20-2.12.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ba6a22edef1521b6b00498a94a098ca60f6af4b8abb007010574ab009e93ab7"

URI_libsigc++20 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libsigc++20-2.12.1-3.el10.x86_64_v2.rpm;name=libsigc++20;unpack=0"
SRC_URI += "${URI_libsigc++20}"
SRC_URI[libsigc++20.sha256sum] = "242c9e82f0ee8ebaeb9b270e2b91a518009f55845162d85cea610c71f3c125e3"
RDEPENDS:libsigc++20 = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_libsigc++20-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libsigc++20-devel-2.12.1-3.el10.x86_64_v2.rpm;name=libsigc++20-devel;unpack=0"
SRC_URI += "${URI_libsigc++20-devel}"
SRC_URI[libsigc++20-devel.sha256sum] = "c8c316b70219df07c999b319be45151161a40f62cf07d1ff4fe4983760660fd9"
RDEPENDS:libsigc++20-devel = " \
 libsigc++20 \
 pkgconf-pkg-config \
"

URI_libsigc++20-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libsigc++20-doc-2.12.1-3.el10.noarch.rpm;name=libsigc++20-doc;unpack=0"
SRC_URI += "${URI_libsigc++20-doc}"
SRC_URI[libsigc++20-doc.sha256sum] = "73bd12467f7a0513ce416342426291a3e81892751ea35d4bf1cb88849ae20943"
RDEPENDS:libsigc++20-doc = " \
 libsigc++20 \
"
