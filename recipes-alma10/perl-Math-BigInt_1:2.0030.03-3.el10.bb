# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Math-BigInt"
PE = "1"
PV = "2.0030.03"
PR = "3.el10"
PACKAGES = "perl-Math-BigInt perl-Math-BigInt-tests"
PROVIDES = "rpm/perl-Math-BigInt rpm/perl-Math-BigInt-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Math-BigInt-2.0030.03-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1bc21adb0e89e5cc63f8215dfb362745ba0cf9c2115309a7a32580ba0f74c816"

URI_perl-Math-BigInt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Math-BigInt-2.0030.03-3.el10.noarch.rpm;name=perl-Math-BigInt;unpack=0"
SRC_URI += "${URI_perl-Math-BigInt}"
SRC_URI[perl-Math-BigInt.sha256sum] = "02876f2380f250e93434934b2e57ddc0b29a744039ab8906c96c25625ac6c076"
RDEPENDS:perl-Math-BigInt = " \
 perl-constant \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Math-BigInt \
 perl-Carp \
 perl-Math-Complex \
 perl-overload \
 perl-Exporter \
"

URI_perl-Math-BigInt-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Math-BigInt-tests-2.0030.03-3.el10.noarch.rpm;name=perl-Math-BigInt-tests;unpack=0"
SRC_URI += "${URI_perl-Math-BigInt-tests}"
SRC_URI[perl-Math-BigInt-tests.sha256sum] = "916f78723b9eaec3beca6cb5168299bda90186fc823d502c70ba83a8026928d9"
RDEPENDS:perl-Math-BigInt-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Math-BigInt \
 perl-Math-Complex \
 perl-overload \
 bash \
 perl-base \
 perl-interpreter \
 perl-Exporter \
 perl-lib \
"
