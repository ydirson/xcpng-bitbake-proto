# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "opencl-filesystem"
PE = "0"
PV = "1.0"
PR = "22.el10"
PACKAGES = "opencl-filesystem"
PROVIDES = "rpm/opencl-filesystem"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/opencl-filesystem-1.0-22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2af43a028b78df27f44f99f9783ff37ca4782a41f56ed4eccf5ecbcfd6830d3"

URI_opencl-filesystem = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/opencl-filesystem-1.0-22.el10.noarch.rpm;name=opencl-filesystem;unpack=0"
SRC_URI += "${URI_opencl-filesystem}"
SRC_URI[opencl-filesystem.sha256sum] = "0aa533eb07ff469344000db9ddff7da77595cb945482b6f823377020c4179814"
RDEPENDS:opencl-filesystem = ""
