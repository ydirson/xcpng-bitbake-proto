# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtlanguageserver"
PE = "0"
PV = "6.8.1"
PR = "2.el10"
PACKAGES = "qt6-qtlanguageserver qt6-qtlanguageserver-devel qt6-qtlanguageserver-tests"
PROVIDES = "rpm/qt6-qtlanguageserver rpm/qt6-qtlanguageserver-devel rpm/qt6-qtlanguageserver-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtlanguageserver-6.8.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3a5842773c90b4c6ad2ff379266e2c50583ca51027d99b47929003b453f56d2"

URI_qt6-qtlanguageserver = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtlanguageserver-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtlanguageserver;unpack=0"
SRC_URI += "${URI_qt6-qtlanguageserver}"
SRC_URI[qt6-qtlanguageserver.sha256sum] = "3c02cdd378270fc7bcaf850bf4670cd3936e7fda42ac46d6fd47c42345a79d04"
RDEPENDS:qt6-qtlanguageserver = " \
 qt6-qtbase \
"

URI_qt6-qtlanguageserver-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtlanguageserver-devel-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtlanguageserver-devel;unpack=0"
SRC_URI += "${URI_qt6-qtlanguageserver-devel}"
SRC_URI[qt6-qtlanguageserver-devel.sha256sum] = "cdf977d0bfb03cb09b162927622759027c7fd2e1d28b6a868b95d1227663c4f5"
RDEPENDS:qt6-qtlanguageserver-devel = " \
 qt6-qtlanguageserver \
 qt6-qtbase-devel \
 cmake-filesystem \
"

URI_qt6-qtlanguageserver-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtlanguageserver-tests-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtlanguageserver-tests;unpack=0"
SRC_URI += "${URI_qt6-qtlanguageserver-tests}"
SRC_URI[qt6-qtlanguageserver-tests.sha256sum] = "ead05a7e882340bd37f1f8ee14de79ce50bbdebbbf3b2d32b00f7f64498cc923"
RDEPENDS:qt6-qtlanguageserver-tests = " \
 qt6-qtlanguageserver \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 glibc \
"
