# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libfontenc"
PE = "0"
PV = "1.1.7"
PR = "5.el10"
PACKAGES = "libfontenc libfontenc-devel"
PROVIDES = "rpm/libfontenc rpm/libfontenc-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libfontenc-1.1.7-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a849fcc0f4e7e4df3fbab2dffcea8366ada4dba26b11a50c620bc4f825ce028"

URI_libfontenc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libfontenc-1.1.7-5.el10.x86_64_v2.rpm;name=libfontenc;unpack=0"
SRC_URI += "${URI_libfontenc}"
SRC_URI[libfontenc.sha256sum] = "e0632c28ecd0a3adbcbd33338980bb488c1e4008d3d28ed76d3ea3602c5b1823"
RDEPENDS:libfontenc = " \
 glibc \
 zlib-ng-compat \
"

URI_libfontenc-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libfontenc-devel-1.1.7-5.el10.x86_64_v2.rpm;name=libfontenc-devel;unpack=0"
SRC_URI += "${URI_libfontenc-devel}"
SRC_URI[libfontenc-devel.sha256sum] = "7721e4309d2e40e4af5e8944ba7f783268d05b40ca5c4aa6b3dbecddcfc38733"
RDEPENDS:libfontenc-devel = " \
 libfontenc \
 pkgconf-pkg-config \
"
