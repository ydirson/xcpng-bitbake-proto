# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-websockets"
PE = "0"
PV = "14.2"
PR = "2.el10_0"
PACKAGES = "python3-websockets"
PROVIDES = "rpm/python3-websockets"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-websockets-14.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d246d3c2cb1b36b4e9354c69b73f63176f113dc2814c4ab1c84abdfaae70cea2"

URI_python3-websockets = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-websockets-14.2-2.el10_0.x86_64_v2.rpm;name=python3-websockets;unpack=0"
SRC_URI += "${URI_python3-websockets}"
SRC_URI[python3-websockets.sha256sum] = "c5ed93a3bc385581d2d741fd63913b04e83515e457c8e3780765c7b64cfc3343"
RDEPENDS:python3-websockets = " \
 glibc \
 python3 \
"
