# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-IPC-SysV"
PE = "0"
PV = "2.09"
PR = "512.el10"
PACKAGES = "perl-IPC-SysV perl-IPC-SysV-tests"
PROVIDES = "rpm/perl-IPC-SysV rpm/perl-IPC-SysV-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-IPC-SysV-2.09-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5c8a808a65b27071b5e4c339c5b8aa3530f8d65887e4279b087776ab04897b3"

URI_perl-IPC-SysV = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-IPC-SysV-2.09-512.el10.x86_64_v2.rpm;name=perl-IPC-SysV;unpack=0"
SRC_URI += "${URI_perl-IPC-SysV}"
SRC_URI[perl-IPC-SysV.sha256sum] = "88b7ad0e888876c45604e633fa8ecc31c0521b3f8c052d2377fe324f54a901fe"
RDEPENDS:perl-IPC-SysV = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-Class-Struct \
 perl-IPC-SysV \
 glibc \
 perl-Exporter \
"

URI_perl-IPC-SysV-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-IPC-SysV-tests-2.09-512.el10.noarch.rpm;name=perl-IPC-SysV-tests;unpack=0"
SRC_URI += "${URI_perl-IPC-SysV-tests}"
SRC_URI[perl-IPC-SysV-tests.sha256sum] = "22720c44dfd9a99aa08570784df07125d7a2b40c8092c91823f99e0d17c515c5"
RDEPENDS:perl-IPC-SysV-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-IPC-SysV \
 bash \
 perl-interpreter \
"
