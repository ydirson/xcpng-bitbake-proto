# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Socket6"
PE = "0"
PV = "0.29"
PR = "25.el10"
PACKAGES = "perl-Socket6 perl-Socket6-tests"
PROVIDES = "rpm/perl-Socket6 rpm/perl-Socket6-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Socket6-0.29-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5843fc07ac88c7e7d33cf0cd15fff60d4b00008c685356c91fcffcff22a3daef"

URI_perl-Socket6 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Socket6-0.29-25.el10.x86_64_v2.rpm;name=perl-Socket6;unpack=0"
SRC_URI += "${URI_perl-Socket6}"
SRC_URI[perl-Socket6.sha256sum] = "4f62959008cfa53198922e29deb13ea4e258af7f89ced35a90bf290728019183"
RDEPENDS:perl-Socket6 = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-DynaLoader \
 glibc \
 perl-Exporter \
 perl-base \
"

URI_perl-Socket6-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Socket6-tests-0.29-25.el10.x86_64_v2.rpm;name=perl-Socket6-tests;unpack=0"
SRC_URI += "${URI_perl-Socket6-tests}"
SRC_URI[perl-Socket6-tests.sha256sum] = "24cb56483cd2b74f114568b615d0267d4789859c808639a43d28be56bb3386ac"
RDEPENDS:perl-Socket6-tests = " \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 perl-Socket \
 perl-Socket6 \
 bash \
 perl-interpreter \
"
