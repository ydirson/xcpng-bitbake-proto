# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-B-COW"
PE = "0"
PV = "0.007"
PR = "9.el10"
PACKAGES = "perl-B-COW perl-B-COW-tests"
PROVIDES = "rpm/perl-B-COW rpm/perl-B-COW-tests"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-B-COW-0.007-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba24eb9ca2175d26546f983dbcebd63cdb64ca58c2fb997453284fec06d64d76"

URI_perl-B-COW = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-B-COW-0.007-9.el10.x86_64_v2.rpm;name=perl-B-COW;unpack=0"
SRC_URI += "${URI_perl-B-COW}"
SRC_URI[perl-B-COW.sha256sum] = "a56b492ce309321335ac1e632c2f9c48319bbd093c79049d408269f37f926a20"
RDEPENDS:perl-B-COW = " \
 glibc \
 perl-Exporter \
 perl-libs \
 perl-base \
"

URI_perl-B-COW-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-B-COW-tests-0.007-9.el10.noarch.rpm;name=perl-B-COW-tests;unpack=0"
SRC_URI += "${URI_perl-B-COW-tests}"
SRC_URI[perl-B-COW-tests.sha256sum] = "a06423171ce79babcb24b6c749823aa98f2689911aee594a21273b9698680783"
RDEPENDS:perl-B-COW-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-ExtUtils-MakeMaker \
 perl-B-COW \
 perl-Devel-Peek \
 perl-Test-Simple \
 perl-PathTools \
 bash \
 perl-interpreter \
"
