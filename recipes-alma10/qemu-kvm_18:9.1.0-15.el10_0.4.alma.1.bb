# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qemu-kvm"
PE = "18"
PV = "9.1.0"
PR = "15.el10_0.4.alma.1"
PACKAGES = "qemu-guest-agent qemu-img qemu-kvm qemu-kvm-audio-pa qemu-kvm-block-blkio qemu-kvm-block-curl qemu-kvm-block-rbd qemu-kvm-common qemu-kvm-core qemu-kvm-device-display-virtio-gpu qemu-kvm-device-display-virtio-gpu-pci qemu-kvm-device-display-virtio-vga qemu-kvm-device-usb-host qemu-kvm-device-usb-redirect qemu-kvm-docs qemu-kvm-tools qemu-kvm-ui-egl-headless qemu-kvm-ui-opengl qemu-kvm-ui-spice qemu-pr-helper qemu-kvm-audio-dbus qemu-kvm-tests qemu-kvm-ui-dbus"
PROVIDES = "rpm/qemu-guest-agent rpm/qemu-img rpm/qemu-kvm rpm/qemu-kvm-audio-pa rpm/qemu-kvm-block-blkio rpm/qemu-kvm-block-curl rpm/qemu-kvm-block-rbd rpm/qemu-kvm-common rpm/qemu-kvm-core rpm/qemu-kvm-device-display-virtio-gpu rpm/qemu-kvm-device-display-virtio-gpu-pci rpm/qemu-kvm-device-display-virtio-vga rpm/qemu-kvm-device-usb-host rpm/qemu-kvm-device-usb-redirect rpm/qemu-kvm-docs rpm/qemu-kvm-tools rpm/qemu-kvm-ui-egl-headless rpm/qemu-kvm-ui-opengl rpm/qemu-kvm-ui-spice rpm/qemu-pr-helper rpm/qemu-kvm-audio-dbus rpm/qemu-kvm-tests rpm/qemu-kvm-ui-dbus"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qemu-kvm-9.1.0-15.el10_0.4.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64ddebf44c56cca65690a1d5d32193485d16aa51ee4a341c0a89f708ebb9de43"

URI_qemu-guest-agent = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qemu-guest-agent-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=qemu-guest-agent;unpack=0"
SRC_URI += "${URI_qemu-guest-agent}"
SRC_URI[qemu-guest-agent.sha256sum] = "daa5211f799bb67f4cef6b99167a5e260a1ee01ee37e4a9c13e677003764da2e"
RDEPENDS:qemu-guest-agent = " \
 systemd \
 systemd-libs \
 numactl-libs \
 libgcc \
 bash \
 glib2 \
 glibc \
 liburing \
"

URI_qemu-img = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qemu-img-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=qemu-img;unpack=0"
SRC_URI += "${URI_qemu-img}"
SRC_URI[qemu-img.sha256sum] = "344e001def38e99693a1e0dcdba2fa04b6c341e712e9bc69aaccfa4facbfc7bb"
RDEPENDS:qemu-img = " \
 zlib-ng-compat \
 libaio \
 gnutls \
 numactl-libs \
 libgcc \
 libzstd \
 glib2 \
 glibc \
 libselinux \
 liburing \
"

URI_qemu-kvm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qemu-kvm-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=qemu-kvm;unpack=0"
SRC_URI += "${URI_qemu-kvm}"
SRC_URI[qemu-kvm.sha256sum] = "dd1a784918ab6f763b718f1aa822d0b047f0e57a01afd30cfcf0afa43242e9e8"
RDEPENDS:qemu-kvm = " \
 qemu-kvm-core \
 qemu-pr-helper \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-display-virtio-vga \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 virtiofsd \
 qemu-kvm-audio-pa \
 qemu-kvm-docs \
 qemu-kvm-block-blkio \
 qemu-kvm-tools \
 qemu-kvm-ui-egl-headless \
 qemu-kvm-block-rbd \
 qemu-kvm-ui-opengl \
 qemu-kvm-ui-spice \
"

URI_qemu-kvm-audio-pa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qemu-kvm-audio-pa-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=qemu-kvm-audio-pa;unpack=0"
SRC_URI += "${URI_qemu-kvm-audio-pa}"
SRC_URI[qemu-kvm-audio-pa.sha256sum] = "321584ac074fb00ccd648a9adfa45fef015bce3d6d0bb22fb395e5fdc9f93bd2"
RDEPENDS:qemu-kvm-audio-pa = " \
 glibc \
 pulseaudio-libs \
 qemu-kvm-common \
"

URI_qemu-kvm-block-blkio = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qemu-kvm-block-blkio-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=qemu-kvm-block-blkio;unpack=0"
SRC_URI += "${URI_qemu-kvm-block-blkio}"
SRC_URI[qemu-kvm-block-blkio.sha256sum] = "52d15f2654e5b98cd8ed50e0fde3d7a21ff223577b4bfde4e0a8add31d60e295"
RDEPENDS:qemu-kvm-block-blkio = " \
 glibc \
 libblkio \
 libgcc \
 qemu-kvm-common \
"

URI_qemu-kvm-block-curl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qemu-kvm-block-curl-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=qemu-kvm-block-curl;unpack=0"
SRC_URI += "${URI_qemu-kvm-block-curl}"
SRC_URI[qemu-kvm-block-curl.sha256sum] = "84ca2c07fe1bc7a32645c203e28b57866090763025d87b87178b9b04a14e6cb9"
RDEPENDS:qemu-kvm-block-curl = " \
 glibc \
 libgcc \
 qemu-kvm-common \
 libcurl \
"

URI_qemu-kvm-block-rbd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qemu-kvm-block-rbd-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=qemu-kvm-block-rbd;unpack=0"
SRC_URI += "${URI_qemu-kvm-block-rbd}"
SRC_URI[qemu-kvm-block-rbd.sha256sum] = "094526ea1f16fe578b04f01551d1c069a40a72935928d76062a0c41400237fd1"
RDEPENDS:qemu-kvm-block-rbd = " \
 librados2 \
 librbd1 \
 libgcc \
 glibc \
 qemu-kvm-common \
"

URI_qemu-kvm-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qemu-kvm-common-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=qemu-kvm-common;unpack=0"
SRC_URI += "${URI_qemu-kvm-common}"
SRC_URI[qemu-kvm-common.sha256sum] = "c3bcb201cfd831fb6fcb662e99480a0d1679a6faa715a1f6fa6bd735e98c71a1"
RDEPENDS:qemu-kvm-common = " \
 glibc-common \
 shadow-utils \
 systemd \
 libgcc \
 libcap-ng \
 bash \
 glib2 \
 glibc \
 ipxe-roms-qemu \
 seabios-bin \
 seavgabios-bin \
"

URI_qemu-kvm-core = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qemu-kvm-core-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=qemu-kvm-core;unpack=0"
SRC_URI += "${URI_qemu-kvm-core}"
SRC_URI[qemu-kvm-core.sha256sum] = "07c58fee5da229dee534fc335c301ec5c914d77088d8457f952ec33f8acfef1c"
RDEPENDS:qemu-kvm-core = " \
 libpng \
 cyrus-sasl-lib \
 libseccomp \
 edk2-ovmf \
 libaio \
 numactl-libs \
 qemu-img \
 capstone \
 libfdt \
 qemu-kvm-common \
 liburing \
 libusb1 \
 zlib-ng-compat \
 gnutls \
 libgcc \
 snappy \
 libzstd \
 libslirp \
 pixman \
 lzo \
 glib2 \
 glibc \
"

URI_qemu-kvm-device-display-virtio-gpu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-display-virtio-gpu-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=qemu-kvm-device-display-virtio-gpu;unpack=0"
SRC_URI += "${URI_qemu-kvm-device-display-virtio-gpu}"
SRC_URI[qemu-kvm-device-display-virtio-gpu.sha256sum] = "a192331388fdafb77395d31b5afe62f2a27cd779b1a7c72150fd84ee8a4adeff"
RDEPENDS:qemu-kvm-device-display-virtio-gpu = " \
 glibc \
 qemu-kvm-common \
 pixman \
"

URI_qemu-kvm-device-display-virtio-gpu-pci = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-display-virtio-gpu-pci-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=qemu-kvm-device-display-virtio-gpu-pci;unpack=0"
SRC_URI += "${URI_qemu-kvm-device-display-virtio-gpu-pci}"
SRC_URI[qemu-kvm-device-display-virtio-gpu-pci.sha256sum] = "44dd4aec022849a07ed94728392861cf83c47c40db10c2e4a2ea8352475d3a70"
RDEPENDS:qemu-kvm-device-display-virtio-gpu-pci = " \
 glibc \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-common \
"

URI_qemu-kvm-device-display-virtio-vga = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-display-virtio-vga-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=qemu-kvm-device-display-virtio-vga;unpack=0"
SRC_URI += "${URI_qemu-kvm-device-display-virtio-vga}"
SRC_URI[qemu-kvm-device-display-virtio-vga.sha256sum] = "f6dee20ed97caeb9ef4902cae9279b1e95632246c772615b3b77cefce0bf5671"
RDEPENDS:qemu-kvm-device-display-virtio-vga = " \
 glibc \
 qemu-kvm-common \
"

URI_qemu-kvm-device-usb-host = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-usb-host-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=qemu-kvm-device-usb-host;unpack=0"
SRC_URI += "${URI_qemu-kvm-device-usb-host}"
SRC_URI[qemu-kvm-device-usb-host.sha256sum] = "a07bfc5a377415daccaf7b1e6ef3c53254c316bbe8bfd760db6e63211c7adb8f"
RDEPENDS:qemu-kvm-device-usb-host = " \
 glibc \
 qemu-kvm-common \
 libusb1 \
"

URI_qemu-kvm-device-usb-redirect = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-usb-redirect-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=qemu-kvm-device-usb-redirect;unpack=0"
SRC_URI += "${URI_qemu-kvm-device-usb-redirect}"
SRC_URI[qemu-kvm-device-usb-redirect.sha256sum] = "d7a67b82594d165c9d2c4aedd238488e4831897c8a18cf80e817809ec570f8d8"
RDEPENDS:qemu-kvm-device-usb-redirect = " \
 glibc \
 usbredir \
 libgcc \
 qemu-kvm-common \
"

URI_qemu-kvm-docs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qemu-kvm-docs-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=qemu-kvm-docs;unpack=0"
SRC_URI += "${URI_qemu-kvm-docs}"
SRC_URI[qemu-kvm-docs.sha256sum] = "418d503a5a372c8f33dadda241b3a06238f21636692e40005c5bf36c56e44c6c"
RDEPENDS:qemu-kvm-docs = ""

URI_qemu-kvm-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qemu-kvm-tools-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=qemu-kvm-tools;unpack=0"
SRC_URI += "${URI_qemu-kvm-tools}"
SRC_URI[qemu-kvm-tools.sha256sum] = "4336e4df18554b0678de7daf3218e2d8caeddeb1eb9845e43b66a9ee05ac3086"
RDEPENDS:qemu-kvm-tools = " \
 python3 \
 libgcc \
 glib2 \
 libcurl \
 glibc \
 libxkbcommon \
"

URI_qemu-kvm-ui-egl-headless = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qemu-kvm-ui-egl-headless-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=qemu-kvm-ui-egl-headless;unpack=0"
SRC_URI += "${URI_qemu-kvm-ui-egl-headless}"
SRC_URI[qemu-kvm-ui-egl-headless.sha256sum] = "cd58c619086f854da59f6952c60f0492f48d2a5b1a4609b73ba7c155e4cfa96d"
RDEPENDS:qemu-kvm-ui-egl-headless = " \
 libepoxy \
 glibc \
 qemu-kvm-ui-opengl \
 qemu-kvm-common \
 pixman \
"

URI_qemu-kvm-ui-opengl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qemu-kvm-ui-opengl-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=qemu-kvm-ui-opengl;unpack=0"
SRC_URI += "${URI_qemu-kvm-ui-opengl}"
SRC_URI[qemu-kvm-ui-opengl.sha256sum] = "a3bdf9cc596fb266110d59ba90ae7f4578ea6934b749bfbd34b438423cb477f9"
RDEPENDS:qemu-kvm-ui-opengl = " \
 mesa-dri-drivers \
 libepoxy \
 libgcc \
 mesa-libEGL \
 mesa-libGL \
 mesa-libgbm \
 glibc \
 qemu-kvm-common \
 pixman \
"

URI_qemu-kvm-ui-spice = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qemu-kvm-ui-spice-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=qemu-kvm-ui-spice;unpack=0"
SRC_URI += "${URI_qemu-kvm-ui-spice}"
SRC_URI[qemu-kvm-ui-spice.sha256sum] = "edcd2f7f9a1658fd0f0a60cdd94b6942cfa0899c38e361f69f2d882c5084234c"
RDEPENDS:qemu-kvm-ui-spice = " \
 libgcc \
 spice-server \
 glibc \
 qemu-kvm-ui-opengl \
 qemu-kvm-common \
 pixman \
"

URI_qemu-pr-helper = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qemu-pr-helper-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=qemu-pr-helper;unpack=0"
SRC_URI += "${URI_qemu-pr-helper}"
SRC_URI[qemu-pr-helper.sha256sum] = "488d464d7a35f82d1659529345b3d2612c4eb0ea43aee1173cff33eb689a33f9"
RDEPENDS:qemu-pr-helper = " \
 gnutls \
 systemd-libs \
 numactl-libs \
 device-mapper-multipath-libs \
 libgcc \
 libcap-ng \
 glib2 \
 glibc \
 liburing \
"

URI_qemu-kvm-audio-dbus = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qemu-kvm-audio-dbus-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=qemu-kvm-audio-dbus;unpack=0"
SRC_URI += "${URI_qemu-kvm-audio-dbus}"
SRC_URI[qemu-kvm-audio-dbus.sha256sum] = "2bf8e6c23f0ab1bede6f0dd823c0223240778af11e535ef65ed929d4d82ca0aa"
RDEPENDS:qemu-kvm-audio-dbus = " \
 libgcc \
 glib2 \
 qemu-kvm-ui-dbus \
 glibc \
 qemu-kvm-common \
"

URI_qemu-kvm-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qemu-kvm-tests-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=qemu-kvm-tests;unpack=0"
SRC_URI += "${URI_qemu-kvm-tests}"
SRC_URI[qemu-kvm-tests.sha256sum] = "4725e74aa5fe6558841b0547feb0d3438f0dbaa7394e6f3cdfcdf98b6296d54c"
RDEPENDS:qemu-kvm-tests = " \
 glibc \
 bash \
 python3 \
 qemu-kvm \
"

URI_qemu-kvm-ui-dbus = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qemu-kvm-ui-dbus-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=qemu-kvm-ui-dbus;unpack=0"
SRC_URI += "${URI_qemu-kvm-ui-dbus}"
SRC_URI[qemu-kvm-ui-dbus.sha256sum] = "9d96848754b8a6e04256b82035b3f504e770bd0d3a11d8317fb3472af6d90423"
RDEPENDS:qemu-kvm-ui-dbus = " \
 libepoxy \
 libgcc \
 glib2 \
 glibc \
 qemu-kvm-common \
 pixman \
"
