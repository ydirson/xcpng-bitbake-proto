# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "scipy"
PE = "0"
PV = "1.11.3"
PR = "17.el10"
PACKAGES = "python3-scipy python3-scipy-tests"
PROVIDES = "rpm/python3-scipy rpm/python3-scipy-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/scipy-1.11.3-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d79151f9fdd950b0d77863520d0da248729a42da51f56ea6c50b738cc10b6930"

URI_python3-scipy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-scipy-1.11.3-17.el10.x86_64_v2.rpm;name=python3-scipy;unpack=0"
SRC_URI += "${URI_python3-scipy}"
SRC_URI[python3-scipy.sha256sum] = "de6fc09bbe3456dc0805e09d4a215e954809d12ca086a5a5bc9b639911160bad"
RDEPENDS:python3-scipy = " \
 python3-numpy-f2py \
 python3 \
 flexiblas-netlib \
 libgcc \
 libgfortran \
 libstdc++ \
 glibc \
 python3-numpy \
"

URI_python3-scipy-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-scipy-tests-1.11.3-17.el10.x86_64_v2.rpm;name=python3-scipy-tests;unpack=0"
SRC_URI += "${URI_python3-scipy-tests}"
SRC_URI[python3-scipy-tests.sha256sum] = "627a3d07057dc9d3afc63310442e9c16d052edd3d4dee6171c9f6a5e9d24912a"
RDEPENDS:python3-scipy-tests = " \
 python3 \
 python3-pytest \
 python3-scipy \
"
