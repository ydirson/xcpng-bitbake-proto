# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Unicode-LineBreak"
PE = "0"
PV = "2019.001"
PR = "24.el10"
PACKAGES = "perl-Unicode-LineBreak perl-Unicode-LineBreak-tests"
PROVIDES = "rpm/perl-Unicode-LineBreak rpm/perl-Unicode-LineBreak-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Unicode-LineBreak-2019.001-24.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b14d618b21525445e0c4696a2643d1a26eef8bdc45ead5ad41e90a13b3c27cb7"

URI_perl-Unicode-LineBreak = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Unicode-LineBreak-2019.001-24.el10.x86_64_v2.rpm;name=perl-Unicode-LineBreak;unpack=0"
SRC_URI += "${URI_perl-Unicode-LineBreak}"
SRC_URI[perl-Unicode-LineBreak.sha256sum] = "d163769391081b3d2857c63541f6800745f62a32449e1e8c4f802444bb53d99b"
RDEPENDS:perl-Unicode-LineBreak = " \
 perl-MIME-Charset \
 sombok \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-Unicode-LineBreak \
 perl-Encode \
 perl-overload \
 glibc \
 perl-Exporter \
"

URI_perl-Unicode-LineBreak-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Unicode-LineBreak-tests-2019.001-24.el10.x86_64_v2.rpm;name=perl-Unicode-LineBreak-tests;unpack=0"
SRC_URI += "${URI_perl-Unicode-LineBreak-tests}"
SRC_URI[perl-Unicode-LineBreak-tests.sha256sum] = "18ed4db961c985f86c02f8b368312194a162f98e8488274c2d017f4f88f89842"
RDEPENDS:perl-Unicode-LineBreak-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Unicode-LineBreak \
 perl-FindBin \
 bash \
 perl-interpreter \
 perl-lib \
"
