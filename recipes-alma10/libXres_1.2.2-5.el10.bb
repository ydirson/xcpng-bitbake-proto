# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libXres"
PE = "0"
PV = "1.2.2"
PR = "5.el10"
PACKAGES = "libXres libXres-devel"
PROVIDES = "rpm/libXres rpm/libXres-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libXres-1.2.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c3a9bed6290a7d7f094413269619f5cb1bef4c4198089916053e9c6ede9a468"

URI_libXres = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXres-1.2.2-5.el10.x86_64_v2.rpm;name=libXres;unpack=0"
SRC_URI += "${URI_libXres}"
SRC_URI[libXres.sha256sum] = "d0c3dd1a2dcfe66ede27dbe89cf7cb48cdb87ee5cd319d6a8f7a1d05b010e13d"
RDEPENDS:libXres = " \
 glibc \
 libX11 \
 libXext \
"

URI_libXres-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libXres-devel-1.2.2-5.el10.x86_64_v2.rpm;name=libXres-devel;unpack=0"
SRC_URI += "${URI_libXres-devel}"
SRC_URI[libXres-devel.sha256sum] = "7c93edab321d153ec13d24b7080f12a2400cdc34518558f3741fb94f87a868cf"
RDEPENDS:libXres-devel = " \
 libXext-devel \
 pkgconf-pkg-config \
 libX11-devel \
 libXres \
 xorg-x11-proto-devel \
"
