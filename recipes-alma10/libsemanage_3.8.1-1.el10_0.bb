# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libsemanage"
PE = "0"
PV = "3.8.1"
PR = "1.el10_0"
PACKAGES = "libsemanage python3-libsemanage libsemanage-devel libsemanage-static"
PROVIDES = "rpm/libsemanage rpm/python3-libsemanage rpm/libsemanage-devel rpm/libsemanage-static"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libsemanage-3.8.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f299103a1bba856f7e2f1a822e93ed21d025823c2f713f09092c714cef506ba"

URI_libsemanage = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libsemanage-3.8.1-1.el10_0.x86_64_v2.rpm;name=libsemanage;unpack=0"
SRC_URI += "${URI_libsemanage}"
SRC_URI[libsemanage.sha256sum] = "8b9fb454011da505938817fc5d54c1a96abaf7e4668774e0ecb88e2fc4f0b879"
RDEPENDS:libsemanage = " \
 bzip2-libs \
 audit-libs \
 glibc \
 libselinux \
 libsepol \
"

URI_python3-libsemanage = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-libsemanage-3.8.1-1.el10_0.x86_64_v2.rpm;name=python3-libsemanage;unpack=0"
SRC_URI += "${URI_python3-libsemanage}"
SRC_URI[python3-libsemanage.sha256sum] = "701e4bc5cb3ca01a991d2ea65b70d17076c7f22e954139ae1c559b38d57499c5"
RDEPENDS:python3-libsemanage = " \
 glibc \
 libsemanage \
 python3 \
 python3-libselinux \
"

URI_libsemanage-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libsemanage-devel-3.8.1-1.el10_0.x86_64_v2.rpm;name=libsemanage-devel;unpack=0"
SRC_URI += "${URI_libsemanage-devel}"
SRC_URI[libsemanage-devel.sha256sum] = "a7821ee5ed4ef6c3dd7359763e0f32f796fd2f09cae785069551415fb0831ef5"
RDEPENDS:libsemanage-devel = " \
 libsemanage \
 libselinux-devel \
 pkgconf-pkg-config \
 libsepol-devel \
"

URI_libsemanage-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libsemanage-static-3.8.1-1.el10_0.x86_64_v2.rpm;name=libsemanage-static;unpack=0"
SRC_URI += "${URI_libsemanage-static}"
SRC_URI[libsemanage-static.sha256sum] = "f15aea483a87e517292b7869a760c32e1a9ca1d59a4fc06408e68ca2c7ffe2d5"
RDEPENDS:libsemanage-static = " \
 libsemanage-devel \
"
