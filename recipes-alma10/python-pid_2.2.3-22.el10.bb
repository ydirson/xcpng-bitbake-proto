# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-pid"
PE = "0"
PV = "2.2.3"
PR = "22.el10"
PACKAGES = "python3-pid"
PROVIDES = "rpm/python3-pid"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-pid-2.2.3-22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f75b17278025804712bb61223fde6676e6163bfbb9dd4b0de58f7d975c34431f"

URI_python3-pid = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-pid-2.2.3-22.el10.noarch.rpm;name=python3-pid;unpack=0"
SRC_URI += "${URI_python3-pid}"
SRC_URI[python3-pid.sha256sum] = "7778778d9bc275e317fc67514ed81e527e86c1af0f18894f981f6ccee80633ca"
RDEPENDS:python3-pid = " \
 python3 \
"
