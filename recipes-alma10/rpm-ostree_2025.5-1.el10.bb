# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rpm-ostree"
PE = "0"
PV = "2025.5"
PR = "1.el10"
PACKAGES = "rpm-ostree rpm-ostree-libs rpm-ostree-devel"
PROVIDES = "rpm/rpm-ostree rpm/rpm-ostree-libs rpm/rpm-ostree-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/rpm-ostree-2025.5-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d00fe192e3df48fd6b4205034c78c712c8b66bb96db7928aa98dfa0a40f734dc"

URI_rpm-ostree = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rpm-ostree-2025.5-1.el10.x86_64_v2.rpm;name=rpm-ostree;unpack=0"
SRC_URI += "${URI_rpm-ostree}"
SRC_URI[rpm-ostree.sha256sum] = "842abe8e336c9ad9ad9b5c16e2a8f0073b462f26c0b44969d90fec0e13f1fd72"
RDEPENDS:rpm-ostree = " \
 ostree-libs \
 systemd-libs \
 bootc \
 librepo \
 libsolv \
 libarchive \
 json-c \
 json-glib \
 libcap \
 skopeo \
 libstdc++ \
 zlib-ng-compat \
 libgcc \
 openssl-libs \
 libzstd \
 sqlite-libs \
 bash \
 rpm-ostree-libs \
 bubblewrap \
 fuse3 \
 libmodulemd \
 polkit-libs \
 glib2 \
 glibc \
 ostree \
 rpm-libs \
"

URI_rpm-ostree-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rpm-ostree-libs-2025.5-1.el10.x86_64_v2.rpm;name=rpm-ostree-libs;unpack=0"
SRC_URI += "${URI_rpm-ostree-libs}"
SRC_URI[rpm-ostree-libs.sha256sum] = "343be06ecfd09b186c4e9c31052ca94817ea0f28404e3ca14c1de01b729cda86"
RDEPENDS:rpm-ostree-libs = " \
 ostree-libs \
 libgcc \
 json-glib \
 popt \
 glib2 \
 glibc \
 rpm-libs \
"

URI_rpm-ostree-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rpm-ostree-devel-2025.5-1.el10.x86_64_v2.rpm;name=rpm-ostree-devel;unpack=0"
SRC_URI += "${URI_rpm-ostree-devel}"
SRC_URI[rpm-ostree-devel.sha256sum] = "c40af1e83148b1afecb74696ebb5a1e9d73a9c24da2baffc4dbdc616978dd49c"
RDEPENDS:rpm-ostree-devel = " \
 ostree-devel \
 pkgconf-pkg-config \
 rpm-ostree-libs \
"
