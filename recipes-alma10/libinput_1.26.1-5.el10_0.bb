# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libinput"
PE = "0"
PV = "1.26.1"
PR = "5.el10_0"
PACKAGES = "libinput libinput-utils libinput-devel libinput-test"
PROVIDES = "rpm/libinput rpm/libinput-utils rpm/libinput-devel rpm/libinput-test"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libinput-1.26.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6bfe1110abbba44725c5c6f3d5f5efd1b7c3fc9e93bead04dbb0e40f84726fb2"

URI_libinput = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libinput-1.26.1-5.el10_0.x86_64_v2.rpm;name=libinput;unpack=0"
SRC_URI += "${URI_libinput}"
SRC_URI[libinput.sha256sum] = "841a3b0e729f5ae1c460c86bdaa6e2fde6d6f82f552390842241e7a7f3a9145d"
RDEPENDS:libinput = " \
 libwacom \
 systemd-libs \
 mtdev \
 libevdev \
 bash \
 glibc \
"

URI_libinput-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libinput-utils-1.26.1-5.el10_0.x86_64_v2.rpm;name=libinput-utils;unpack=0"
SRC_URI += "${URI_libinput-utils}"
SRC_URI[libinput-utils.sha256sum] = "54c1b012b371cfdc0c49d7fc626a0045c6c8de967071346455129e93b72b2510"
RDEPENDS:libinput-utils = " \
 python3 \
 python3-pyudev \
 python3-libevdev \
 systemd-libs \
 libinput \
 libevdev \
 glibc \
"

URI_libinput-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libinput-devel-1.26.1-5.el10_0.x86_64_v2.rpm;name=libinput-devel;unpack=0"
SRC_URI += "${URI_libinput-devel}"
SRC_URI[libinput-devel.sha256sum] = "7256b409823a57d271d0823bb3cd1f1f2c74d0c86c815a4fb40307eb43ff2e3f"
RDEPENDS:libinput-devel = " \
 libinput \
 pkgconf-pkg-config \
"

URI_libinput-test = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libinput-test-1.26.1-5.el10_0.x86_64_v2.rpm;name=libinput-test;unpack=0"
SRC_URI += "${URI_libinput-test}"
SRC_URI[libinput-test.sha256sum] = "d7f734d4ecfca7015ac02fbe52ff2eb9d3ea6af9442eb7948c95fe32cbc009ba"
RDEPENDS:libinput-test = " \
 libwacom \
 systemd-libs \
 check \
 libinput \
 libevdev \
 glibc \
"
