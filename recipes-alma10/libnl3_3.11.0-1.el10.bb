# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libnl3"
PE = "0"
PV = "3.11.0"
PR = "1.el10"
PACKAGES = "libnl3 libnl3-cli libnl3-devel libnl3-doc"
PROVIDES = "rpm/libnl3 rpm/libnl3-cli rpm/libnl3-devel rpm/libnl3-doc"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libnl3-3.11.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e76c24b692eddba4d279b1af99ed696810f14ee7a9e831251f19e9f854579e3"

URI_libnl3 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libnl3-3.11.0-1.el10.x86_64_v2.rpm;name=libnl3;unpack=0"
SRC_URI += "${URI_libnl3}"
SRC_URI[libnl3.sha256sum] = "163d73afcf0cf19e04417ccba6744b3413319faa008d7a50a86cbe5e66f3b511"
RDEPENDS:libnl3 = " \
 glibc \
 libgcc \
"

URI_libnl3-cli = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libnl3-cli-3.11.0-1.el10.x86_64_v2.rpm;name=libnl3-cli;unpack=0"
SRC_URI += "${URI_libnl3-cli}"
SRC_URI[libnl3-cli.sha256sum] = "8527d2b75f608b301672bf450e8546f7f04942fbd71a90fd9474fb8f127590db"
RDEPENDS:libnl3-cli = " \
 glibc \
 libnl3 \
"

URI_libnl3-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libnl3-devel-3.11.0-1.el10.x86_64_v2.rpm;name=libnl3-devel;unpack=0"
SRC_URI += "${URI_libnl3-devel}"
SRC_URI[libnl3-devel.sha256sum] = "1ea3c9a7824bc1a1e3099c2166fa184061aa90de4caf168e8f696227d86cbeaa"
RDEPENDS:libnl3-devel = " \
 kernel-headers \
 pkgconf-pkg-config \
 libnl3 \
 libnl3-cli \
 libnl3-devel \
"

URI_libnl3-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libnl3-doc-3.11.0-1.el10.x86_64_v2.rpm;name=libnl3-doc;unpack=0"
SRC_URI += "${URI_libnl3-doc}"
SRC_URI[libnl3-doc.sha256sum] = "f5f6203d6cde284ee8d8cd28a8cfabfc275d93bd22b3dd7ef72e71f5a0ed490e"
RDEPENDS:libnl3-doc = " \
 libnl3 \
"
