# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-ts"
PE = "0"
PV = "0.20110323.1"
PR = "18.el10"
PACKAGES = "hunspell-ts"
PROVIDES = "rpm/hunspell-ts"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-ts-0.20110323.1-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "923ec0b7930b70de19fcfb1a945277ccec2ddb4e4e9880029204652df9ae8da4"

URI_hunspell-ts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-ts-0.20110323.1-18.el10.noarch.rpm;name=hunspell-ts;unpack=0"
SRC_URI += "${URI_hunspell-ts}"
SRC_URI[hunspell-ts.sha256sum] = "2a34b414d87c1105cc8c755abbd7f03b0e3be5ff91bcfce51d2e61900de89d43"
RDEPENDS:hunspell-ts = " \
 hunspell-filesystem \
"
