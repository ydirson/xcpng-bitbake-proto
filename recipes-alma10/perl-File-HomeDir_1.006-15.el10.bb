# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-File-HomeDir"
PE = "0"
PV = "1.006"
PR = "15.el10"
PACKAGES = "perl-File-HomeDir perl-File-HomeDir-tests"
PROVIDES = "rpm/perl-File-HomeDir rpm/perl-File-HomeDir-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-File-HomeDir-1.006-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7abcfaaf477f93d852da1fd74e32bf9e0488ed084287cd73ef1bd73ab2b1bbca"

URI_perl-File-HomeDir = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-File-HomeDir-1.006-15.el10.noarch.rpm;name=perl-File-HomeDir;unpack=0"
SRC_URI += "${URI_perl-File-HomeDir}"
SRC_URI[perl-File-HomeDir.sha256sum] = "eeeed0c4996e6bc6c9a3d6f43a7eee2612cc1cd2672a6367c489c2de78d22b73"
RDEPENDS:perl-File-HomeDir = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-PathTools \
 perl-File-HomeDir \
 perl-Exporter \
 perl-File-Path \
 perl-base \
 perl-File-Temp \
 perl-File-Which \
"

URI_perl-File-HomeDir-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-File-HomeDir-tests-1.006-15.el10.noarch.rpm;name=perl-File-HomeDir-tests;unpack=0"
SRC_URI += "${URI_perl-File-HomeDir-tests}"
SRC_URI[perl-File-HomeDir-tests.sha256sum] = "b5dffecec6fb0eec5fbd99adf0a49537cdacc9453a791e41835cc4d4b68164b4"
RDEPENDS:perl-File-HomeDir-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 bash \
 perl-PathTools \
 perl-File-HomeDir \
 perl-interpreter \
"
