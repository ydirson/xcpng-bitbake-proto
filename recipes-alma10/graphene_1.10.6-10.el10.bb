# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "graphene"
PE = "0"
PV = "1.10.6"
PR = "10.el10"
PACKAGES = "graphene graphene-devel graphene-tests"
PROVIDES = "rpm/graphene rpm/graphene-devel rpm/graphene-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/graphene-1.10.6-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0406f469ef8d83e6b9c2d53cc694e9039c9f6d0f23b93ae14a071ea93ac9b3b"

URI_graphene = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/graphene-1.10.6-10.el10.x86_64_v2.rpm;name=graphene;unpack=0"
SRC_URI += "${URI_graphene}"
SRC_URI[graphene.sha256sum] = "ead551cacc2bb6e608691f4a81489d1beb1f6423d683859467618ed7be034041"
RDEPENDS:graphene = " \
 glibc \
 glib2 \
"

URI_graphene-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/graphene-devel-1.10.6-10.el10.x86_64_v2.rpm;name=graphene-devel;unpack=0"
SRC_URI += "${URI_graphene-devel}"
SRC_URI[graphene-devel.sha256sum] = "2f1c8656313546ed05604bcd35fccc5666ac4eb35fa531ea241a0adaf2fa9dea"
RDEPENDS:graphene-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 graphene \
 graphene-devel \
"

URI_graphene-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/graphene-tests-1.10.6-10.el10.x86_64_v2.rpm;name=graphene-tests;unpack=0"
SRC_URI += "${URI_graphene-tests}"
SRC_URI[graphene-tests.sha256sum] = "90f84de34e089abc715093e641ec06984666f880bb7954b4900560970fa1dcda"
RDEPENDS:graphene-tests = " \
 glibc \
 graphene \
"
