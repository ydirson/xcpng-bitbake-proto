# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mptcpd"
PE = "0"
PV = "0.12"
PR = "6.el10"
PACKAGES = "mptcpd mptcpd-devel"
PROVIDES = "rpm/mptcpd rpm/mptcpd-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mptcpd-0.12-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c644d4fcb875c6e3393bc1091a9442adbb3e7a51bef40c1bd11f6e283239a4e0"

URI_mptcpd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mptcpd-0.12-6.el10.x86_64_v2.rpm;name=mptcpd;unpack=0"
SRC_URI += "${URI_mptcpd}"
SRC_URI[mptcpd.sha256sum] = "4dcc69b9a974c04810279ff40fba62c98a13aa12b089e88a82b2ae82dfd3950c"
RDEPENDS:mptcpd = " \
 glibc \
 libell \
 systemd \
"

URI_mptcpd-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mptcpd-devel-0.12-6.el10.x86_64_v2.rpm;name=mptcpd-devel;unpack=0"
SRC_URI += "${URI_mptcpd-devel}"
SRC_URI[mptcpd-devel.sha256sum] = "3ab0a215ae6fb2ce11e9cb9760c1c913464b5f7b18286c4ab425f276a5f5660e"
RDEPENDS:mptcpd-devel = " \
 mptcpd \
 pkgconf-pkg-config \
 libell-devel \
"
