# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Term-Size-Perl"
PE = "0"
PV = "0.031"
PR = "22.el10"
PACKAGES = "perl-Term-Size-Perl perl-Term-Size-Perl-tests"
PROVIDES = "rpm/perl-Term-Size-Perl rpm/perl-Term-Size-Perl-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Term-Size-Perl-0.031-22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ebcc37ccdb6d0ac12b552f35598678f18d3269ca65e7ce6a6a31053cfe7a089f"

URI_perl-Term-Size-Perl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Term-Size-Perl-0.031-22.el10.x86_64_v2.rpm;name=perl-Term-Size-Perl;unpack=0"
SRC_URI += "${URI_perl-Term-Size-Perl}"
SRC_URI[perl-Term-Size-Perl.sha256sum] = "e15afa47a8fd512376176045a60fa880e7f1354a8e8ecf87d1164d24d4a49bb8"
RDEPENDS:perl-Term-Size-Perl = " \
 perl-Exporter \
 perl-libs \
 perl-vars \
 perl-Term-Size-Perl \
"

URI_perl-Term-Size-Perl-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Term-Size-Perl-tests-0.031-22.el10.x86_64_v2.rpm;name=perl-Term-Size-Perl-tests;unpack=0"
SRC_URI += "${URI_perl-Term-Size-Perl-tests}"
SRC_URI[perl-Term-Size-Perl-tests.sha256sum] = "d8be5189a4ddc76fe81a8f0a262731c0bf4e03f6a2014ad3c8873b5ac1649b57"
RDEPENDS:perl-Term-Size-Perl-tests = " \
 perl-Test-Harness \
 perl-Test-Simple \
 bash \
 perl-interpreter \
 perl-Term-Size-Perl \
"
