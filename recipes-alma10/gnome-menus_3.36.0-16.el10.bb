# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-menus"
PE = "0"
PV = "3.36.0"
PR = "16.el10"
PACKAGES = "gnome-menus gnome-menus-devel"
PROVIDES = "rpm/gnome-menus rpm/gnome-menus-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-menus-3.36.0-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6113f3f5b47d10f2db091c518b643ccdb741c9c0e7dddaef4c0032e62841c19"

URI_gnome-menus = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-menus-3.36.0-16.el10.x86_64_v2.rpm;name=gnome-menus;unpack=0"
SRC_URI += "${URI_gnome-menus}"
SRC_URI[gnome-menus.sha256sum] = "1970d1209d60dd35e80ee3f550edf8ee8f0f96b32ca83cf344626f4fe7395183"
RDEPENDS:gnome-menus = " \
 glibc \
 glib2 \
"

URI_gnome-menus-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gnome-menus-devel-3.36.0-16.el10.x86_64_v2.rpm;name=gnome-menus-devel;unpack=0"
SRC_URI += "${URI_gnome-menus-devel}"
SRC_URI[gnome-menus-devel.sha256sum] = "9f7fdd45900149b9c78314e50841645e156348280c17805e55df126b195cd480"
RDEPENDS:gnome-menus-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 gnome-menus \
"
