# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-it"
PE = "0"
PV = "5.1.1"
PR = "8.el10"
PACKAGES = "hyphen-it"
PROVIDES = "rpm/hyphen-it"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-it-5.1.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "006ad041fa0b22aae050244541b0177f7919804fe833048b07d2fa21ac1e02dd"

URI_hyphen-it = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-it-5.1.1-8.el10.noarch.rpm;name=hyphen-it;unpack=0"
SRC_URI += "${URI_hyphen-it}"
SRC_URI[hyphen-it.sha256sum] = "afb19ac2561f4f4694966f447435d1c4ff10b8d26b7ef703878b2e881ab27f08"
RDEPENDS:hyphen-it = " \
 hyphen \
"
