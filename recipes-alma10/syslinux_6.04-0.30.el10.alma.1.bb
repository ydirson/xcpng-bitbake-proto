# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "syslinux"
PE = "0"
PV = "6.04"
PR = "0.30.el10.alma.1"
PACKAGES = "syslinux syslinux-extlinux syslinux-extlinux-nonlinux syslinux-nonlinux syslinux-tftpboot syslinux-devel syslinux-efi64 syslinux-perl"
PROVIDES = "rpm/syslinux rpm/syslinux-extlinux rpm/syslinux-extlinux-nonlinux rpm/syslinux-nonlinux rpm/syslinux-tftpboot rpm/syslinux-devel rpm/syslinux-efi64 rpm/syslinux-perl"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/syslinux-6.04-0.30.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7eaf2d3b201f32ba43392c342b267ad07ab9b6565b6888f378327f93615f9af4"

URI_syslinux = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/syslinux-6.04-0.30.el10.alma.1.x86_64_v2.rpm;name=syslinux;unpack=0"
SRC_URI += "${URI_syslinux}"
SRC_URI[syslinux.sha256sum] = "5a3d1763971eb401d440784d67132072d9c229c98cba5a12fe57bafb30e8d3dc"
RDEPENDS:syslinux = " \
 glibc \
 libuuid \
 syslinux-nonlinux \
 mtools \
"

URI_syslinux-extlinux = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/syslinux-extlinux-6.04-0.30.el10.alma.1.x86_64_v2.rpm;name=syslinux-extlinux;unpack=0"
SRC_URI += "${URI_syslinux-extlinux}"
SRC_URI[syslinux-extlinux.sha256sum] = "7ae2558eeb88f35296da729ab1b62b9ac2fb76e8805ee9b4ec21a186cfb3adaa"
RDEPENDS:syslinux-extlinux = " \
 glibc \
 syslinux-extlinux-nonlinux \
 bash \
 syslinux \
"

URI_syslinux-extlinux-nonlinux = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/syslinux-extlinux-nonlinux-6.04-0.30.el10.alma.1.noarch.rpm;name=syslinux-extlinux-nonlinux;unpack=0"
SRC_URI += "${URI_syslinux-extlinux-nonlinux}"
SRC_URI[syslinux-extlinux-nonlinux.sha256sum] = "f8afaedbcf9af81c3299ea04889e98a0b581cb480307d2667b0579c251e20670"
RDEPENDS:syslinux-extlinux-nonlinux = " \
 glibc \
 syslinux \
"

URI_syslinux-nonlinux = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/syslinux-nonlinux-6.04-0.30.el10.alma.1.noarch.rpm;name=syslinux-nonlinux;unpack=0"
SRC_URI += "${URI_syslinux-nonlinux}"
SRC_URI[syslinux-nonlinux.sha256sum] = "e82149bd201bf7d06b2fba3f5ea418b3b297de73142424421349631d8bdeb36a"
RDEPENDS:syslinux-nonlinux = " \
 glibc \
 syslinux \
"

URI_syslinux-tftpboot = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/syslinux-tftpboot-6.04-0.30.el10.alma.1.noarch.rpm;name=syslinux-tftpboot;unpack=0"
SRC_URI += "${URI_syslinux-tftpboot}"
SRC_URI[syslinux-tftpboot.sha256sum] = "b8a86cea5a86f9c0355a93774fa5184677481e09b2f5330bcc81c8130850fde8"
RDEPENDS:syslinux-tftpboot = " \
 glibc \
"

URI_syslinux-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/syslinux-devel-6.04-0.30.el10.alma.1.x86_64_v2.rpm;name=syslinux-devel;unpack=0"
SRC_URI += "${URI_syslinux-devel}"
SRC_URI[syslinux-devel.sha256sum] = "e4c6980f926c3478b8f32305d3f5291fd906c3be22e0d0a8f36f131532197c69"
RDEPENDS:syslinux-devel = " \
 glibc \
"

URI_syslinux-efi64 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/syslinux-efi64-6.04-0.30.el10.alma.1.x86_64_v2.rpm;name=syslinux-efi64;unpack=0"
SRC_URI += "${URI_syslinux-efi64}"
SRC_URI[syslinux-efi64.sha256sum] = "c24769588d3f3819f91b9c05e61d46ebfe10312948322ce2b70875eb5d0ff20b"
RDEPENDS:syslinux-efi64 = " \
 glibc \
"

URI_syslinux-perl = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/syslinux-perl-6.04-0.30.el10.alma.1.x86_64_v2.rpm;name=syslinux-perl;unpack=0"
SRC_URI += "${URI_syslinux-perl}"
SRC_URI[syslinux-perl.sha256sum] = "cd177f35a11caed79d0d6b184318422a411ea99930b516a10a59c72fece7f019"
RDEPENDS:syslinux-perl = " \
 perl-libs \
 perl-IO \
 perl-Socket \
 perl-Digest-SHA \
 perl-Fcntl \
 perl-PathTools \
 perl-Errno \
 perl-interpreter \
 perl-Crypt-PasswdMD5 \
 perl-MIME-Base64 \
"
