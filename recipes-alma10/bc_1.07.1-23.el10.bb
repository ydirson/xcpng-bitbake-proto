# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "bc"
PE = "0"
PV = "1.07.1"
PR = "23.el10"
PACKAGES = "bc"
PROVIDES = "rpm/bc"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/bc-1.07.1-23.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0096ec325c3800dee458fc16db2263424e88e35adb5b0d3588f6ae03e2805243"

URI_bc = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/bc-1.07.1-23.el10.x86_64_v2.rpm;name=bc;unpack=0"
SRC_URI += "${URI_bc}"
SRC_URI[bc.sha256sum] = "87474f9031cc71575ca89194d41dd17b042845485dd1a76eea8f27f7d9228747"
RDEPENDS:bc = " \
 glibc \
 readline \
"
