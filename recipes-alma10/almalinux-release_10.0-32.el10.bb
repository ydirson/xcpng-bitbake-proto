# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "almalinux-release"
PE = "0"
PV = "10.0"
PR = "32.el10"
PACKAGES = "almalinux-gpg-keys almalinux-release almalinux-repos almalinux-sb-certs"
PROVIDES = "rpm/almalinux-gpg-keys rpm/almalinux-release rpm/almalinux-repos rpm/almalinux-sb-certs"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/almalinux-release-10.0-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d392c3d5a83207f66c65055f9f67c6b0358d69e58d1744f89f42c98686e53b1"

URI_almalinux-gpg-keys = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/almalinux-gpg-keys-10.0-32.el10.x86_64_v2.rpm;name=almalinux-gpg-keys;unpack=0"
SRC_URI += "${URI_almalinux-gpg-keys}"
SRC_URI[almalinux-gpg-keys.sha256sum] = "b6564216425e3ffc1e6bcc9c9afb029eabe76f3a1de524ed8b81dc9ec20080de"
RDEPENDS:almalinux-gpg-keys = ""

URI_almalinux-release = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/almalinux-release-10.0-32.el10.x86_64_v2.rpm;name=almalinux-release;unpack=0"
SRC_URI += "${URI_almalinux-release}"
SRC_URI[almalinux-release.sha256sum] = "f569e53d7d90f58a8ce202af34fe6e01b426893b677e0bfeb063ab744399acf4"
RDEPENDS:almalinux-release = " \
 almalinux-repos \
"

URI_almalinux-repos = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/almalinux-repos-10.0-32.el10.x86_64_v2.rpm;name=almalinux-repos;unpack=0"
SRC_URI += "${URI_almalinux-repos}"
SRC_URI[almalinux-repos.sha256sum] = "f3e6b7d69a8d060b8e538f037901040f08839302b3e89e90cc51aaa377802579"
RDEPENDS:almalinux-repos = " \
 almalinux-gpg-keys \
 almalinux-release \
"

URI_almalinux-sb-certs = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/almalinux-sb-certs-10.0-32.el10.x86_64_v2.rpm;name=almalinux-sb-certs;unpack=0"
SRC_URI += "${URI_almalinux-sb-certs}"
SRC_URI[almalinux-sb-certs.sha256sum] = "4030b61906da8e67b3c27cdf4e3ec31ce757436a920d08abdc48d6272d59da33"
RDEPENDS:almalinux-sb-certs = ""
