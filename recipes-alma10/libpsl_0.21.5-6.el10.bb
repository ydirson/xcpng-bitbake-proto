# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libpsl"
PE = "0"
PV = "0.21.5"
PR = "6.el10"
PACKAGES = "libpsl libpsl-devel psl psl-make-dafsa"
PROVIDES = "rpm/libpsl rpm/libpsl-devel rpm/psl rpm/psl-make-dafsa"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libpsl-0.21.5-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5bd5e5d4ef48803aee49fe47dee5b991f14cbc3eb11fce80e150b706f62a5fec"

URI_libpsl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libpsl-0.21.5-6.el10.x86_64_v2.rpm;name=libpsl;unpack=0"
SRC_URI += "${URI_libpsl}"
SRC_URI[libpsl.sha256sum] = "1d1f4ba5ec8632991cd89ff539b7d32b16d5acd2c5162e9c6f9e1e125a59f579"
RDEPENDS:libpsl = " \
 glibc \
 libidn2 \
 publicsuffix-list-dafsa \
 libunistring \
"

URI_libpsl-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libpsl-devel-0.21.5-6.el10.x86_64_v2.rpm;name=libpsl-devel;unpack=0"
SRC_URI += "${URI_libpsl-devel}"
SRC_URI[libpsl-devel.sha256sum] = "2780d66e3446e153db427be5d7201248658b4681bc48c162592382e51a59395c"
RDEPENDS:libpsl-devel = " \
 libpsl \
 publicsuffix-list \
 pkgconf-pkg-config \
"

URI_psl = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/psl-0.21.5-6.el10.x86_64_v2.rpm;name=psl;unpack=0"
SRC_URI += "${URI_psl}"
SRC_URI[psl.sha256sum] = "691b0237ecaaf5a47e5e7a5365755ad46f5c11ec9e46c285a4b964ce445703ff"
RDEPENDS:psl = " \
 glibc \
 libpsl \
"

URI_psl-make-dafsa = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/psl-make-dafsa-0.21.5-6.el10.noarch.rpm;name=psl-make-dafsa;unpack=0"
SRC_URI += "${URI_psl-make-dafsa}"
SRC_URI[psl-make-dafsa.sha256sum] = "9730cbad77122ee7ce922a1bfebf085a1dc9351dd3c74acf7ab1bee904ccfff7"
RDEPENDS:psl-make-dafsa = " \
 python3 \
"
