# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Module-Package"
PE = "0"
PV = "0.30"
PR = "37.el10"
PACKAGES = "perl-Module-Package perl-Module-Package-tests"
PROVIDES = "rpm/perl-Module-Package rpm/perl-Module-Package-tests"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-Module-Package-0.30-37.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6bb413d9e5feed8e35d2c93872cb580482a1973d256a23363a617607637d9ca"

URI_perl-Module-Package = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Module-Package-0.30-37.el10.noarch.rpm;name=perl-Module-Package;unpack=0"
SRC_URI += "${URI_perl-Module-Package}"
SRC_URI[perl-Module-Package.sha256sum] = "42e806df7652e43ec3e599332b214c0a2cd861b1628ed6ed537b525fc76f118a"
RDEPENDS:perl-Module-Package = " \
 perl-Module-Install-ManifestSkip \
 perl-libs \
 perl-vars \
 perl-Module-Install \
 perl-Module-Package \
 perl-Moo \
 perl-overload \
 perl-PathTools \
 perl-File-Find \
 perl-File-Path \
 perl-Data-Dumper \
 perl-Module-Install-AuthorRequires \
 perl-IO-All \
"

URI_perl-Module-Package-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Module-Package-tests-0.30-37.el10.noarch.rpm;name=perl-Module-Package-tests;unpack=0"
SRC_URI += "${URI_perl-Module-Package-tests}"
SRC_URI[perl-Module-Package-tests.sha256sum] = "5853a5a3e292dbaa872b147ce2967a393df3efdc802cb2ede331f4c8669f5d4d"
RDEPENDS:perl-Module-Package-tests = " \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Module-Package \
 bash \
 perl-interpreter \
"
