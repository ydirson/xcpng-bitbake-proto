# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "unicode-emoji"
PE = "0"
PV = "15.1"
PR = "3.el10"
PACKAGES = "unicode-emoji"
PROVIDES = "rpm/unicode-emoji"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/unicode-emoji-15.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b48c2fed86fc62cd759ebffc0f78bca91ba5ee7519cd3a5ec25720fc67b92d17"

URI_unicode-emoji = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/unicode-emoji-15.1-3.el10.noarch.rpm;name=unicode-emoji;unpack=0"
SRC_URI += "${URI_unicode-emoji}"
SRC_URI[unicode-emoji.sha256sum] = "3f07cc29946bb815d1086f830878cea3338f4e815a458910da4fe00f2de23a61"
RDEPENDS:unicode-emoji = ""
