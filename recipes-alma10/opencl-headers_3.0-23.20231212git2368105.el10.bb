# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "opencl-headers"
PE = "0"
PV = "3.0"
PR = "23.20231212git2368105.el10"
PACKAGES = "opencl-headers"
PROVIDES = "rpm/opencl-headers"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/opencl-headers-3.0-23.20231212git2368105.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f88441c347a2a4b20b550356af45afb0b23985fe42fd850ca69cdf9ceb5c80e6"

URI_opencl-headers = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/opencl-headers-3.0-23.20231212git2368105.el10.noarch.rpm;name=opencl-headers;unpack=0"
SRC_URI += "${URI_opencl-headers}"
SRC_URI[opencl-headers.sha256sum] = "c7b162c0f12a81391688939e97cab6ac8acc4a24d350d08b21870e5447d4c644"
RDEPENDS:opencl-headers = " \
 opencl-headers \
 pkgconf-pkg-config \
"
