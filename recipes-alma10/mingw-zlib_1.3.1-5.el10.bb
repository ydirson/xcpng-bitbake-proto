# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mingw-zlib"
PE = "0"
PV = "1.3.1"
PR = "5.el10"
PACKAGES = "mingw32-zlib mingw32-zlib-static mingw64-zlib mingw64-zlib-static ucrt64-zlib ucrt64-zlib-static"
PROVIDES = "rpm/mingw32-zlib rpm/mingw32-zlib-static rpm/mingw64-zlib rpm/mingw64-zlib-static rpm/ucrt64-zlib rpm/ucrt64-zlib-static"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/mingw-zlib-1.3.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "faa7b78e126db6feef818c711dff3b7d4913ab415eb899e5124ff42a1d9e2399"

URI_mingw32-zlib = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw32-zlib-1.3.1-5.el10.noarch.rpm;name=mingw32-zlib;unpack=0"
SRC_URI += "${URI_mingw32-zlib}"
SRC_URI[mingw32-zlib.sha256sum] = "7104f07608b9312e311cb5fdb971dbd55e23252529706d8022fb986360a31e75"
RDEPENDS:mingw32-zlib = " \
 mingw32-crt \
 mingw32-filesystem \
"

URI_mingw32-zlib-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw32-zlib-static-1.3.1-5.el10.noarch.rpm;name=mingw32-zlib-static;unpack=0"
SRC_URI += "${URI_mingw32-zlib-static}"
SRC_URI[mingw32-zlib-static.sha256sum] = "04d3ec64b1f2114921ba3a8b54fbcde9ded021bb8a879aca6d80d7d7e0d0f3cb"
RDEPENDS:mingw32-zlib-static = " \
 mingw32-zlib \
"

URI_mingw64-zlib = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw64-zlib-1.3.1-5.el10.noarch.rpm;name=mingw64-zlib;unpack=0"
SRC_URI += "${URI_mingw64-zlib}"
SRC_URI[mingw64-zlib.sha256sum] = "0f994d5aafb7d321e1adf6e56b5205a162383dbb6b7b30d3eb8c520198a2fdbb"
RDEPENDS:mingw64-zlib = " \
 mingw64-crt \
 mingw64-filesystem \
"

URI_mingw64-zlib-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw64-zlib-static-1.3.1-5.el10.noarch.rpm;name=mingw64-zlib-static;unpack=0"
SRC_URI += "${URI_mingw64-zlib-static}"
SRC_URI[mingw64-zlib-static.sha256sum] = "73f6aae6ad8d1093fdc6cd3fd71e9c5f4b9885b72d149a5997c154724877cf32"
RDEPENDS:mingw64-zlib-static = " \
 mingw64-zlib \
"

URI_ucrt64-zlib = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ucrt64-zlib-1.3.1-5.el10.noarch.rpm;name=ucrt64-zlib;unpack=0"
SRC_URI += "${URI_ucrt64-zlib}"
SRC_URI[ucrt64-zlib.sha256sum] = "919d75718b3325d2a310ea62c7042e5ca671d579e7bbeec7f2a452b6e011ae00"
RDEPENDS:ucrt64-zlib = " \
 ucrt64-crt \
 ucrt64-filesystem \
"

URI_ucrt64-zlib-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ucrt64-zlib-static-1.3.1-5.el10.noarch.rpm;name=ucrt64-zlib-static;unpack=0"
SRC_URI += "${URI_ucrt64-zlib-static}"
SRC_URI[ucrt64-zlib-static.sha256sum] = "655825b1db4fd2325268e0d366f46a81d41f7cc278a1fa0d06976965f3019319"
RDEPENDS:ucrt64-zlib-static = " \
 ucrt64-zlib \
"
