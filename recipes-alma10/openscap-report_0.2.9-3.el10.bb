# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "openscap-report"
PE = "0"
PV = "0.2.9"
PR = "3.el10"
PACKAGES = "openscap-report"
PROVIDES = "rpm/openscap-report"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/openscap-report-0.2.9-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd0d383984007bc695207b82922d5f8678008505ebd0ed5710ac589de1441b43"

URI_openscap-report = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/openscap-report-0.2.9-3.el10.noarch.rpm;name=openscap-report;unpack=0"
SRC_URI += "${URI_openscap-report}"
SRC_URI[openscap-report.sha256sum] = "a178bb19f592b01c8bf04885836d493d268a1196be8ea6bbf4c0cb453f19d367"
RDEPENDS:openscap-report = " \
 python3 \
 python3-jinja2 \
 python3-lxml \
"
