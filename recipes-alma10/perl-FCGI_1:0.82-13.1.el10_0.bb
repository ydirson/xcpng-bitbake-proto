# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-FCGI"
PE = "1"
PV = "0.82"
PR = "13.1.el10_0"
PACKAGES = "perl-FCGI perl-FCGI-tests"
PROVIDES = "rpm/perl-FCGI rpm/perl-FCGI-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-FCGI-0.82-13.1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "763910aaab544157aebb283d82cb5c705a422b612ebe03cbffc87ecbe289b483"

URI_perl-FCGI = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-FCGI-0.82-13.1.el10_0.x86_64_v2.rpm;name=perl-FCGI;unpack=0"
SRC_URI += "${URI_perl-FCGI}"
SRC_URI[perl-FCGI.sha256sum] = "a5aac25e139f067c863b62f6ea84cbcf1c39635d0c7e23235c61e9c10b861719"
RDEPENDS:perl-FCGI = " \
 glibc \
 perl-libs \
 perl-Carp \
"

URI_perl-FCGI-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-FCGI-tests-0.82-13.1.el10_0.noarch.rpm;name=perl-FCGI-tests;unpack=0"
SRC_URI += "${URI_perl-FCGI-tests}"
SRC_URI[perl-FCGI-tests.sha256sum] = "47215d7b44946b9b8dbf11f89662797f7864b795567dadfc5a1816f19cfc3a22"
RDEPENDS:perl-FCGI-tests = " \
 perl-Test \
 perl-Test-Harness \
 perl-FCGI \
 bash \
 perl-interpreter \
"
