# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "nano"
PE = "0"
PV = "8.1"
PR = "3.el10"
PACKAGES = "nano"
PROVIDES = "rpm/nano"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/nano-8.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36930f887460adf2d85853b27d107eb1753804d08d05812389da4ba603f66cbc"

URI_nano = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/nano-8.1-3.el10.x86_64_v2.rpm;name=nano;unpack=0"
SRC_URI += "${URI_nano}"
SRC_URI[nano.sha256sum] = "9d88f7c8c63102e1608303ebda4f824fff0a01cb877bb937840082c1e7763d93"
RDEPENDS:nano = " \
 glibc \
 file-libs \
 ncurses-libs \
"
