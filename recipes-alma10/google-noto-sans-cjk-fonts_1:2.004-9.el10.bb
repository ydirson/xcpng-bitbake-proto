# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "google-noto-sans-cjk-fonts"
PE = "1"
PV = "2.004"
PR = "9.el10"
PACKAGES = "google-noto-sans-cjk-fonts"
PROVIDES = "rpm/google-noto-sans-cjk-fonts"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/google-noto-sans-cjk-fonts-2.004-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a9f40ffa93f1c305234f881dca82fbf012cafa05939f20547011233847727e0"

URI_google-noto-sans-cjk-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-cjk-fonts-2.004-9.el10.noarch.rpm;name=google-noto-sans-cjk-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-cjk-fonts}"
SRC_URI[google-noto-sans-cjk-fonts.sha256sum] = "29b55abd89b1d8c96fd15063f5ddeac6fa8b17d8cf17fa97db7192689af1ce75"
RDEPENDS:google-noto-sans-cjk-fonts = " \
 fonts-filesystem \
"
