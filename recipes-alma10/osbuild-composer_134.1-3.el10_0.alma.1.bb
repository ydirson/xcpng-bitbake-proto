# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "osbuild-composer"
PE = "0"
PV = "134.1"
PR = "3.el10_0.alma.1"
PACKAGES = "osbuild-composer osbuild-composer-core osbuild-composer-worker osbuild-composer-tests"
PROVIDES = "rpm/osbuild-composer rpm/osbuild-composer-core rpm/osbuild-composer-worker rpm/osbuild-composer-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/osbuild-composer-134.1-3.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40ebecf69fd87c16faae4894f5d14273974b07f975b59b3c039001b86b9356f6"

URI_osbuild-composer = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/osbuild-composer-134.1-3.el10_0.alma.1.x86_64_v2.rpm;name=osbuild-composer;unpack=0"
SRC_URI += "${URI_osbuild-composer}"
SRC_URI[osbuild-composer.sha256sum] = "0aee62e9ce3bf33a52236eadb96e76d21c4c1549f62d54c9a6ce19f85144ebd1"
RDEPENDS:osbuild-composer = " \
 osbuild-composer-core \
 systemd \
 bash \
 osbuild-composer-worker \
"

URI_osbuild-composer-core = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/osbuild-composer-core-134.1-3.el10_0.alma.1.x86_64_v2.rpm;name=osbuild-composer-core;unpack=0"
SRC_URI += "${URI_osbuild-composer-core}"
SRC_URI[osbuild-composer-core.sha256sum] = "cc85fdff91de20028eae952a624249987e0cc2abe72255a369b238868470ff14"
RDEPENDS:osbuild-composer-core = " \
 glibc \
 libxcrypt \
 gpgme \
 osbuild-depsolve-dnf \
"

URI_osbuild-composer-worker = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/osbuild-composer-worker-134.1-3.el10_0.alma.1.x86_64_v2.rpm;name=osbuild-composer-worker;unpack=0"
SRC_URI += "${URI_osbuild-composer-worker}"
SRC_URI[osbuild-composer-worker.sha256sum] = "3327d671fe4187de1ced614f272f0fb0b6571aa421f377731ca367faa177aac2"
RDEPENDS:osbuild-composer-worker = " \
 systemd \
 osbuild \
 libxcrypt \
 gpgme \
 qemu-img \
 osbuild-depsolve-dnf \
 krb5-libs \
 osbuild-luks2 \
 libcom_err \
 bash \
 osbuild-lvm2 \
 osbuild-ostree \
 glibc \
"

URI_osbuild-composer-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/osbuild-composer-tests-134.1-3.el10_0.alma.1.x86_64_v2.rpm;name=osbuild-composer-tests;unpack=0"
SRC_URI += "${URI_osbuild-composer-tests}"
SRC_URI[osbuild-composer-tests.sha256sum] = "f6c4809a3ae4e9297babd24a569e80faf6df16578911b3f6daea220eb6c19e84"
RDEPENDS:osbuild-composer-tests = " \
 python3 \
 container-selinux \
 systemd-container \
 dnsmasq \
 createrepo_c \
 krb5-libs \
 krb5-workstation \
 libvirt-client \
 libvirt-daemon \
 libvirt-daemon-config-network \
 httpd \
 unzip \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-config-nwfilter \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-interface \
 qemu-img \
 jq \
 libvirt-daemon-driver-storage-disk \
 qemu-kvm \
 libvirt-daemon-driver-nwfilter \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage \
 dnf-plugins-core \
 expect \
 libcom_err \
 python3-lxml \
 libvirt-daemon-kvm \
 skopeo \
 xorriso \
 qemu-kvm-core \
 virt-install \
 libxcrypt \
 openssl \
 gpgme \
 bash \
 rpmdevtools \
 python3-pip \
 firewalld \
 sssd-krb5 \
 weldr-client \
 osbuild-composer \
 make \
 glibc \
 mod_ssl \
 podman \
"
