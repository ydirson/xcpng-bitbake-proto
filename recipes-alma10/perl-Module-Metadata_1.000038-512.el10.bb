# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Module-Metadata"
PE = "0"
PV = "1.000038"
PR = "512.el10"
PACKAGES = "perl-Module-Metadata perl-Module-Metadata-tests"
PROVIDES = "rpm/perl-Module-Metadata rpm/perl-Module-Metadata-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Module-Metadata-1.000038-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ed6bb95701f2a961fa33ef5f912365eab3a44bc705013cbc03c505f54b8643a"

URI_perl-Module-Metadata = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Module-Metadata-1.000038-512.el10.noarch.rpm;name=perl-Module-Metadata;unpack=0"
SRC_URI += "${URI_perl-Module-Metadata}"
SRC_URI[perl-Module-Metadata.sha256sum] = "a71f44b490196cc1ce6e2064923e7669722cfe8215234d2d44b5e88476bb48bb"
RDEPENDS:perl-Module-Metadata = " \
 perl-libs \
 perl-Carp \
 perl-version \
 perl-Fcntl \
 perl-Encode \
 perl-PathTools \
 perl-File-Find \
"

URI_perl-Module-Metadata-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Module-Metadata-tests-1.000038-512.el10.noarch.rpm;name=perl-Module-Metadata-tests;unpack=0"
SRC_URI += "${URI_perl-Module-Metadata-tests}"
SRC_URI[perl-Module-Metadata-tests.sha256sum] = "9b30bd0ccceaad2a88104065e06e52d5a73b76b463f6a03eef103d980aba453b"
RDEPENDS:perl-Module-Metadata-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Carp \
 perl-Test-Simple \
 perl-IO \
 perl-File-Basename \
 perl-Encode \
 perl-File-Temp \
 perl-Module-Metadata \
 perl-PathTools \
 bash \
 perl-interpreter \
 perl-File-Path \
 perl-lib \
"
