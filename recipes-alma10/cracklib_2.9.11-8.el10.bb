# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cracklib"
PE = "0"
PV = "2.9.11"
PR = "8.el10"
PACKAGES = "cracklib cracklib-dicts cracklib-devel"
PROVIDES = "rpm/cracklib rpm/cracklib-dicts rpm/cracklib-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/cracklib-2.9.11-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b703c19da3e25e7b10de586041606b439895ed33139171afdf7915e4baa5a419"

URI_cracklib = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cracklib-2.9.11-8.el10.x86_64_v2.rpm;name=cracklib;unpack=0"
SRC_URI += "${URI_cracklib}"
SRC_URI[cracklib.sha256sum] = "d77056efc5d0dc97a5cdf9e892aafaa7cc9ae51b8ed28fa54b18c9115c9dbcb3"
RDEPENDS:cracklib = " \
 glibc \
 gzip \
 zlib-ng-compat \
 bash \
"

URI_cracklib-dicts = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cracklib-dicts-2.9.11-8.el10.x86_64_v2.rpm;name=cracklib-dicts;unpack=0"
SRC_URI += "${URI_cracklib-dicts}"
SRC_URI[cracklib-dicts.sha256sum] = "bd222838603c9a9eaa1e314ac3c4393dae0ba82c82fbd339c67fc6f73b50a49d"
RDEPENDS:cracklib-dicts = " \
 cracklib \
"

URI_cracklib-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/cracklib-devel-2.9.11-8.el10.x86_64_v2.rpm;name=cracklib-devel;unpack=0"
SRC_URI += "${URI_cracklib-devel}"
SRC_URI[cracklib-devel.sha256sum] = "c22c99f75fee431f1e4f756e9cb6c0acfa7f3121881cacd46619cdb9f6cff522"
RDEPENDS:cracklib-devel = " \
 cracklib \
"
