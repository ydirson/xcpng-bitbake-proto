# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "plexus-archiver"
PE = "0"
PV = "4.9.1"
PR = "4.el10"
PACKAGES = "plexus-archiver plexus-archiver-javadoc"
PROVIDES = "rpm/plexus-archiver rpm/plexus-archiver-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/plexus-archiver-4.9.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52ca77de57653829c6014528fcaedd88864fac6746dd3ef21f1990a50102e568"

URI_plexus-archiver = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-archiver-4.9.1-4.el10.noarch.rpm;name=plexus-archiver;unpack=0"
SRC_URI += "${URI_plexus-archiver}"
SRC_URI[plexus-archiver.sha256sum] = "5ed9eaff22559e66accc5867e9d92f4138f262f8b85d9b3e08c50cfeb239ef25"
RDEPENDS:plexus-archiver = " \
 atinject \
 xz-java \
 apache-commons-compress \
 apache-commons-io \
 plexus-utils \
 javapackages-filesystem \
 slf4j \
 plexus-io \
"

URI_plexus-archiver-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-archiver-javadoc-4.9.1-4.el10.noarch.rpm;name=plexus-archiver-javadoc;unpack=0"
SRC_URI += "${URI_plexus-archiver-javadoc}"
SRC_URI[plexus-archiver-javadoc.sha256sum] = "b7d1229684bd7508870c237b634ea633e120e1635260d172ad269c15dc1b613f"
RDEPENDS:plexus-archiver-javadoc = " \
 javapackages-filesystem \
"
