# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "plexus-resources"
PE = "0"
PV = "1.3.0"
PR = "4.el10"
PACKAGES = "plexus-resources plexus-resources-javadoc"
PROVIDES = "rpm/plexus-resources rpm/plexus-resources-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/plexus-resources-1.3.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09219eb43105901be0e25830472472bbe23574136f7b50921f47001267ff09d4"

URI_plexus-resources = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-resources-1.3.0-4.el10.noarch.rpm;name=plexus-resources;unpack=0"
SRC_URI += "${URI_plexus-resources}"
SRC_URI[plexus-resources.sha256sum] = "daf65359a0cbea75354e576a96f033d9047151a6fef34551d453862c29ab5654"
RDEPENDS:plexus-resources = " \
 atinject \
 plexus-utils \
 javapackages-filesystem \
 plexus-xml \
 slf4j \
"

URI_plexus-resources-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-resources-javadoc-1.3.0-4.el10.noarch.rpm;name=plexus-resources-javadoc;unpack=0"
SRC_URI += "${URI_plexus-resources-javadoc}"
SRC_URI[plexus-resources-javadoc.sha256sum] = "24796859c68962fa7c18b2181262c68be1fc1dfd9732d1a5c1db9dd193f30359"
RDEPENDS:plexus-resources-javadoc = " \
 javapackages-filesystem \
"
