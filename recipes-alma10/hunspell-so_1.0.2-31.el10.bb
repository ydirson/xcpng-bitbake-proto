# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-so"
PE = "0"
PV = "1.0.2"
PR = "31.el10"
PACKAGES = "hunspell-so"
PROVIDES = "rpm/hunspell-so"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-so-1.0.2-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72fd6421afa31f77a70dd1963d990a41b3fdee21f42513fa0c9c032e7c479f96"

URI_hunspell-so = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-so-1.0.2-31.el10.noarch.rpm;name=hunspell-so;unpack=0"
SRC_URI += "${URI_hunspell-so}"
SRC_URI[hunspell-so.sha256sum] = "7d2b5b0cd3f553a2a98fab7924d1b52c5a440106fc2d9d4147b8c15960b56057"
RDEPENDS:hunspell-so = " \
 hunspell \
"
