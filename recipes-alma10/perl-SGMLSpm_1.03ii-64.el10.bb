# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-SGMLSpm"
PE = "0"
PV = "1.03ii"
PR = "64.el10"
PACKAGES = "perl-SGMLSpm"
PROVIDES = "rpm/perl-SGMLSpm"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-SGMLSpm-1.03ii-64.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09426a259e9f33a23524bd543b18a271b857d21d325966c956e32c27143f83d9"

URI_perl-SGMLSpm = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-SGMLSpm-1.03ii-64.el10.noarch.rpm;name=perl-SGMLSpm;unpack=0"
SRC_URI += "${URI_perl-SGMLSpm}"
SRC_URI[perl-SGMLSpm.sha256sum] = "cc6838ebab144f0660647b536a3e057d77687a00851ecd2c7ee1746361b8d4e3"
RDEPENDS:perl-SGMLSpm = " \
 perl-libs \
 perl-Carp \
 perl-interpreter \
 openjade \
 perl-Exporter \
"
