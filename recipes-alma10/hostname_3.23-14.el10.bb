# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hostname"
PE = "0"
PV = "3.23"
PR = "14.el10"
PACKAGES = "hostname"
PROVIDES = "rpm/hostname"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/hostname-3.23-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05337cbd976a43af1a8140bce7041900833039ec99f77ff609b2c7aced9f8a8b"

URI_hostname = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/hostname-3.23-14.el10.x86_64_v2.rpm;name=hostname;unpack=0"
SRC_URI += "${URI_hostname}"
SRC_URI[hostname.sha256sum] = "3eea00f3e321d7a230c92d5f36a724f854c853c0b7f6f4d350956d4edeb6ef8e"
RDEPENDS:hostname = " \
 glibc \
 bash \
"
