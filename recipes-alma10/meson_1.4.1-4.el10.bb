# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "meson"
PE = "0"
PV = "1.4.1"
PR = "4.el10"
PACKAGES = "meson"
PROVIDES = "rpm/meson"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/meson-1.4.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e150d00a07c4dacda3fb4289b7cd16ba89ec954a7406967ba920870a6e2e5b4"

URI_meson = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/meson-1.4.1-4.el10.noarch.rpm;name=meson;unpack=0"
SRC_URI += "${URI_meson}"
SRC_URI[meson.sha256sum] = "a7b81a7a8a7d54f1060683ac2fb9a7fbf32132a46590fc40bb62de07a432b448"
RDEPENDS:meson = " \
 python3 \
 ninja-build \
 python3-setuptools \
"
