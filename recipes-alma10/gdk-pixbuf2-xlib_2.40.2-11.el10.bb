# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gdk-pixbuf2-xlib"
PE = "0"
PV = "2.40.2"
PR = "11.el10"
PACKAGES = "gdk-pixbuf2-xlib gdk-pixbuf2-xlib-devel"
PROVIDES = "rpm/gdk-pixbuf2-xlib rpm/gdk-pixbuf2-xlib-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/gdk-pixbuf2-xlib-2.40.2-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df5c38eda1a71c7fe65a80f7949b5fb60bdfdaf27f59b8016267b25f3aac5c40"

URI_gdk-pixbuf2-xlib = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gdk-pixbuf2-xlib-2.40.2-11.el10.x86_64_v2.rpm;name=gdk-pixbuf2-xlib;unpack=0"
SRC_URI += "${URI_gdk-pixbuf2-xlib}"
SRC_URI[gdk-pixbuf2-xlib.sha256sum] = "baa48b6bc015031c6ec0a55b7528792cd8649f63ac6c66c0b996b996a5e120cc"
RDEPENDS:gdk-pixbuf2-xlib = " \
 glibc \
 glib2 \
 libX11 \
 gdk-pixbuf2 \
"

URI_gdk-pixbuf2-xlib-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gdk-pixbuf2-xlib-devel-2.40.2-11.el10.x86_64_v2.rpm;name=gdk-pixbuf2-xlib-devel;unpack=0"
SRC_URI += "${URI_gdk-pixbuf2-xlib-devel}"
SRC_URI[gdk-pixbuf2-xlib-devel.sha256sum] = "06a7b65907317f146a5ef697409a841af40db26fa1c861d53ae191202d8e265b"
RDEPENDS:gdk-pixbuf2-xlib-devel = " \
 gdk-pixbuf2-devel \
 libX11-devel \
 pkgconf-pkg-config \
 gdk-pixbuf2-xlib \
"
