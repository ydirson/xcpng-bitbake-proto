# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libotf"
PE = "0"
PV = "0.9.16"
PR = "6.el10"
PACKAGES = "libotf libotf-devel"
PROVIDES = "rpm/libotf rpm/libotf-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libotf-0.9.16-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d73b99ef819877431e2572a9c0100dde4e460e5a69ce2d3652297a2645a01da"

URI_libotf = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libotf-0.9.16-6.el10.x86_64_v2.rpm;name=libotf;unpack=0"
SRC_URI += "${URI_libotf}"
SRC_URI[libotf.sha256sum] = "ba1eee8324033883d0a9643754c8504b42f2d5d0e81cb051e1bbbbf81f4a0aa6"
RDEPENDS:libotf = " \
 freetype \
 libX11 \
 libXt \
 libXaw \
 glibc \
"

URI_libotf-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libotf-devel-0.9.16-6.el10.x86_64_v2.rpm;name=libotf-devel;unpack=0"
SRC_URI += "${URI_libotf-devel}"
SRC_URI[libotf-devel.sha256sum] = "51f1a7c44c6c5cfbefc181825c398ba5436f8dce00c665ee970d5ca15eec58d8"
RDEPENDS:libotf-devel = " \
 freetype-devel \
 libotf \
 pkgconf-pkg-config \
"
