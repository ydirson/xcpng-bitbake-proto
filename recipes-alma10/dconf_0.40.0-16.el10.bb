# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dconf"
PE = "0"
PV = "0.40.0"
PR = "16.el10"
PACKAGES = "dconf dconf-devel"
PROVIDES = "rpm/dconf rpm/dconf-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/dconf-0.40.0-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f76ba4b81c5d3cd5bfb3fd8936e5248bcf168fd54c7cba221dc918ab73294dea"

URI_dconf = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dconf-0.40.0-16.el10.x86_64_v2.rpm;name=dconf;unpack=0"
SRC_URI += "${URI_dconf}"
SRC_URI[dconf.sha256sum] = "5a99f6bd9ab89b9d07bd3e027b29a4287d971b43794798aba8585f94e95f2dc6"
RDEPENDS:dconf = " \
 libgcc \
 bash \
 glib2 \
 dbus \
 glibc \
"

URI_dconf-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/dconf-devel-0.40.0-16.el10.x86_64_v2.rpm;name=dconf-devel;unpack=0"
SRC_URI += "${URI_dconf-devel}"
SRC_URI[dconf-devel.sha256sum] = "a26c8ed098577fa35b764016b31275c132405c56e20473d236117fc789338e0d"
RDEPENDS:dconf-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 dconf \
"
