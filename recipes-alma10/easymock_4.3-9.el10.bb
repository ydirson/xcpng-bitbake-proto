# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "easymock"
PE = "0"
PV = "4.3"
PR = "9.el10"
PACKAGES = "easymock easymock-javadoc"
PROVIDES = "rpm/easymock rpm/easymock-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/easymock-4.3-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a53c189ceb2f4f63c8e2ecada61741fd8a5c8ff8799dcb3b5c064c59999b3fdd"

URI_easymock = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/easymock-4.3-9.el10.noarch.rpm;name=easymock;unpack=0"
SRC_URI += "${URI_easymock}"
SRC_URI[easymock.sha256sum] = "ed2b852213e10b0af11f72dbda492352bcafc710b51ec6feef365ac5ec4566a5"
RDEPENDS:easymock = " \
 objectweb-asm \
 javapackages-filesystem \
 cglib \
 objenesis \
"

URI_easymock-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/easymock-javadoc-4.3-9.el10.noarch.rpm;name=easymock-javadoc;unpack=0"
SRC_URI += "${URI_easymock-javadoc}"
SRC_URI[easymock-javadoc.sha256sum] = "0e4d6e5f0a9ebfa4541c14b8d96efc9df6c4d49b44a49bb221e0011141a4f601"
RDEPENDS:easymock-javadoc = " \
 javapackages-filesystem \
"
