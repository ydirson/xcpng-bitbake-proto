# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xorg-x11-fonts"
PE = "0"
PV = "7.5"
PR = "40.el10"
PACKAGES = "xorg-x11-fonts-100dpi xorg-x11-fonts-75dpi xorg-x11-fonts-ISO8859-1-100dpi xorg-x11-fonts-ISO8859-1-75dpi xorg-x11-fonts-ISO8859-14-100dpi xorg-x11-fonts-ISO8859-14-75dpi xorg-x11-fonts-ISO8859-15-100dpi xorg-x11-fonts-ISO8859-15-75dpi xorg-x11-fonts-ISO8859-2-100dpi xorg-x11-fonts-ISO8859-2-75dpi xorg-x11-fonts-ISO8859-9-100dpi xorg-x11-fonts-ISO8859-9-75dpi xorg-x11-fonts-Type1 xorg-x11-fonts-cyrillic xorg-x11-fonts-ethiopic xorg-x11-fonts-misc"
PROVIDES = "rpm/xorg-x11-fonts-100dpi rpm/xorg-x11-fonts-75dpi rpm/xorg-x11-fonts-ISO8859-1-100dpi rpm/xorg-x11-fonts-ISO8859-1-75dpi rpm/xorg-x11-fonts-ISO8859-14-100dpi rpm/xorg-x11-fonts-ISO8859-14-75dpi rpm/xorg-x11-fonts-ISO8859-15-100dpi rpm/xorg-x11-fonts-ISO8859-15-75dpi rpm/xorg-x11-fonts-ISO8859-2-100dpi rpm/xorg-x11-fonts-ISO8859-2-75dpi rpm/xorg-x11-fonts-ISO8859-9-100dpi rpm/xorg-x11-fonts-ISO8859-9-75dpi rpm/xorg-x11-fonts-Type1 rpm/xorg-x11-fonts-cyrillic rpm/xorg-x11-fonts-ethiopic rpm/xorg-x11-fonts-misc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xorg-x11-fonts-7.5-40.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e11e28a1a3f7fea3ad4243ec7c7a8937d2ee235a3dea1d246e56107024feada3"

URI_xorg-x11-fonts-100dpi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xorg-x11-fonts-100dpi-7.5-40.el10.noarch.rpm;name=xorg-x11-fonts-100dpi;unpack=0"
SRC_URI += "${URI_xorg-x11-fonts-100dpi}"
SRC_URI[xorg-x11-fonts-100dpi.sha256sum] = "ec6c15f170ab8e3c69a3ab7a926757f273d490f430ec8b2c59b86666c9980e37"
RDEPENDS:xorg-x11-fonts-100dpi = " \
 mkfontscale \
 bash \
"

URI_xorg-x11-fonts-75dpi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xorg-x11-fonts-75dpi-7.5-40.el10.noarch.rpm;name=xorg-x11-fonts-75dpi;unpack=0"
SRC_URI += "${URI_xorg-x11-fonts-75dpi}"
SRC_URI[xorg-x11-fonts-75dpi.sha256sum] = "a99b7ca36a2e302326a86835fd9433abcde0316d5b6805b5e71e328d4bcbe807"
RDEPENDS:xorg-x11-fonts-75dpi = " \
 mkfontscale \
 bash \
"

URI_xorg-x11-fonts-ISO8859-1-100dpi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xorg-x11-fonts-ISO8859-1-100dpi-7.5-40.el10.noarch.rpm;name=xorg-x11-fonts-ISO8859-1-100dpi;unpack=0"
SRC_URI += "${URI_xorg-x11-fonts-ISO8859-1-100dpi}"
SRC_URI[xorg-x11-fonts-ISO8859-1-100dpi.sha256sum] = "d35ff5592ffb8252803c49ed8cb3b7412101964bd92edb4c48b03cd5c8bb1491"
RDEPENDS:xorg-x11-fonts-ISO8859-1-100dpi = " \
 mkfontscale \
 bash \
"

URI_xorg-x11-fonts-ISO8859-1-75dpi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xorg-x11-fonts-ISO8859-1-75dpi-7.5-40.el10.noarch.rpm;name=xorg-x11-fonts-ISO8859-1-75dpi;unpack=0"
SRC_URI += "${URI_xorg-x11-fonts-ISO8859-1-75dpi}"
SRC_URI[xorg-x11-fonts-ISO8859-1-75dpi.sha256sum] = "895b7fa5dc46e8469b43533de12009623fd0a4acbebdc238f8c45a5367e42eb3"
RDEPENDS:xorg-x11-fonts-ISO8859-1-75dpi = " \
 mkfontscale \
 bash \
"

URI_xorg-x11-fonts-ISO8859-14-100dpi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xorg-x11-fonts-ISO8859-14-100dpi-7.5-40.el10.noarch.rpm;name=xorg-x11-fonts-ISO8859-14-100dpi;unpack=0"
SRC_URI += "${URI_xorg-x11-fonts-ISO8859-14-100dpi}"
SRC_URI[xorg-x11-fonts-ISO8859-14-100dpi.sha256sum] = "c06fcb9057acf098c85e8b67e073d361240f175a2bef7108370f70534a42f837"
RDEPENDS:xorg-x11-fonts-ISO8859-14-100dpi = " \
 mkfontscale \
 bash \
"

URI_xorg-x11-fonts-ISO8859-14-75dpi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xorg-x11-fonts-ISO8859-14-75dpi-7.5-40.el10.noarch.rpm;name=xorg-x11-fonts-ISO8859-14-75dpi;unpack=0"
SRC_URI += "${URI_xorg-x11-fonts-ISO8859-14-75dpi}"
SRC_URI[xorg-x11-fonts-ISO8859-14-75dpi.sha256sum] = "572db9e1c534a2bfcb834b5973af75af72fe28296f9de08ce3061f04164318c4"
RDEPENDS:xorg-x11-fonts-ISO8859-14-75dpi = " \
 mkfontscale \
 bash \
"

URI_xorg-x11-fonts-ISO8859-15-100dpi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xorg-x11-fonts-ISO8859-15-100dpi-7.5-40.el10.noarch.rpm;name=xorg-x11-fonts-ISO8859-15-100dpi;unpack=0"
SRC_URI += "${URI_xorg-x11-fonts-ISO8859-15-100dpi}"
SRC_URI[xorg-x11-fonts-ISO8859-15-100dpi.sha256sum] = "9571304f7a1be88c160ccef7dfe069406b206bdf7b8fa3fae1b743d4a2ea73e4"
RDEPENDS:xorg-x11-fonts-ISO8859-15-100dpi = " \
 mkfontscale \
 bash \
"

URI_xorg-x11-fonts-ISO8859-15-75dpi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xorg-x11-fonts-ISO8859-15-75dpi-7.5-40.el10.noarch.rpm;name=xorg-x11-fonts-ISO8859-15-75dpi;unpack=0"
SRC_URI += "${URI_xorg-x11-fonts-ISO8859-15-75dpi}"
SRC_URI[xorg-x11-fonts-ISO8859-15-75dpi.sha256sum] = "dcfedf14a3ee49a44279830baf71aa0f047b386324666f81d2064a9be02de059"
RDEPENDS:xorg-x11-fonts-ISO8859-15-75dpi = " \
 mkfontscale \
 bash \
"

URI_xorg-x11-fonts-ISO8859-2-100dpi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xorg-x11-fonts-ISO8859-2-100dpi-7.5-40.el10.noarch.rpm;name=xorg-x11-fonts-ISO8859-2-100dpi;unpack=0"
SRC_URI += "${URI_xorg-x11-fonts-ISO8859-2-100dpi}"
SRC_URI[xorg-x11-fonts-ISO8859-2-100dpi.sha256sum] = "e343ecc0d826ac1d9f8bfdee2949e0ec57218a7532218d5cff7ff46fedb4001d"
RDEPENDS:xorg-x11-fonts-ISO8859-2-100dpi = " \
 mkfontscale \
 bash \
"

URI_xorg-x11-fonts-ISO8859-2-75dpi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xorg-x11-fonts-ISO8859-2-75dpi-7.5-40.el10.noarch.rpm;name=xorg-x11-fonts-ISO8859-2-75dpi;unpack=0"
SRC_URI += "${URI_xorg-x11-fonts-ISO8859-2-75dpi}"
SRC_URI[xorg-x11-fonts-ISO8859-2-75dpi.sha256sum] = "0ef45ca33c5783094078862fda5d6f4bc19de3b02a6515772ebd1db38894874e"
RDEPENDS:xorg-x11-fonts-ISO8859-2-75dpi = " \
 mkfontscale \
 bash \
"

URI_xorg-x11-fonts-ISO8859-9-100dpi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xorg-x11-fonts-ISO8859-9-100dpi-7.5-40.el10.noarch.rpm;name=xorg-x11-fonts-ISO8859-9-100dpi;unpack=0"
SRC_URI += "${URI_xorg-x11-fonts-ISO8859-9-100dpi}"
SRC_URI[xorg-x11-fonts-ISO8859-9-100dpi.sha256sum] = "4568228494c3e67ec9763e511ff83f66dfea25a293e13f48b30a80cf8099874b"
RDEPENDS:xorg-x11-fonts-ISO8859-9-100dpi = " \
 mkfontscale \
 bash \
"

URI_xorg-x11-fonts-ISO8859-9-75dpi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xorg-x11-fonts-ISO8859-9-75dpi-7.5-40.el10.noarch.rpm;name=xorg-x11-fonts-ISO8859-9-75dpi;unpack=0"
SRC_URI += "${URI_xorg-x11-fonts-ISO8859-9-75dpi}"
SRC_URI[xorg-x11-fonts-ISO8859-9-75dpi.sha256sum] = "0437ff940b82f9887972571d650167b07b903610711c95c2c56c087c54e51b3b"
RDEPENDS:xorg-x11-fonts-ISO8859-9-75dpi = " \
 mkfontscale \
 bash \
"

URI_xorg-x11-fonts-Type1 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xorg-x11-fonts-Type1-7.5-40.el10.noarch.rpm;name=xorg-x11-fonts-Type1;unpack=0"
SRC_URI += "${URI_xorg-x11-fonts-Type1}"
SRC_URI[xorg-x11-fonts-Type1.sha256sum] = "82224b3a3cac77b16d3bc29d817d11b2c229d722c676969be24248c4f2785566"
RDEPENDS:xorg-x11-fonts-Type1 = " \
 ttmkfdir \
 mkfontscale \
 bash \
 fontconfig \
"

URI_xorg-x11-fonts-cyrillic = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xorg-x11-fonts-cyrillic-7.5-40.el10.noarch.rpm;name=xorg-x11-fonts-cyrillic;unpack=0"
SRC_URI += "${URI_xorg-x11-fonts-cyrillic}"
SRC_URI[xorg-x11-fonts-cyrillic.sha256sum] = "3aeab36da2087d8f55284290805b925ec99f404ce35cc4ed92b86a80b5bcee39"
RDEPENDS:xorg-x11-fonts-cyrillic = " \
 mkfontscale \
 bash \
"

URI_xorg-x11-fonts-ethiopic = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xorg-x11-fonts-ethiopic-7.5-40.el10.noarch.rpm;name=xorg-x11-fonts-ethiopic;unpack=0"
SRC_URI += "${URI_xorg-x11-fonts-ethiopic}"
SRC_URI[xorg-x11-fonts-ethiopic.sha256sum] = "07baae8768f17cf8cedac70a86b55ddb5e4e44df5a32ff3cba30bea75507ef1b"
RDEPENDS:xorg-x11-fonts-ethiopic = " \
 ttmkfdir \
 mkfontscale \
 bash \
 fontconfig \
"

URI_xorg-x11-fonts-misc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xorg-x11-fonts-misc-7.5-40.el10.noarch.rpm;name=xorg-x11-fonts-misc;unpack=0"
SRC_URI += "${URI_xorg-x11-fonts-misc}"
SRC_URI[xorg-x11-fonts-misc.sha256sum] = "1c330b308ae934f4252f015e951af7a31e42b11785a38ed590d06486f0f3bfa0"
RDEPENDS:xorg-x11-fonts-misc = " \
 mkfontscale \
 bash \
 fontconfig \
"
