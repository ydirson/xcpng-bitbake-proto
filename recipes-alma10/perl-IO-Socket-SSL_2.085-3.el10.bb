# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-IO-Socket-SSL"
PE = "0"
PV = "2.085"
PR = "3.el10"
PACKAGES = "perl-IO-Socket-SSL"
PROVIDES = "rpm/perl-IO-Socket-SSL"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-IO-Socket-SSL-2.085-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db081e7d9137e0a4b640eb55c2882223ee68b0acfc90cc853122de5d5f093c38"

URI_perl-IO-Socket-SSL = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-IO-Socket-SSL-2.085-3.el10.noarch.rpm;name=perl-IO-Socket-SSL;unpack=0"
SRC_URI += "${URI_perl-IO-Socket-SSL}"
SRC_URI[perl-IO-Socket-SSL.sha256sum] = "7f673ad99f77da322add6a1a696d8d359b935db3da78ff503b224907f7d5ec06"
RDEPENDS:perl-IO-Socket-SSL = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-IO \
 perl-URI \
 perl-Socket \
 openssl-libs \
 perl-IO-Socket-IP \
 perl-IO-Socket-SSL \
 perl-Errno \
 perl-Exporter \
 perl-HTTP-Tiny \
 perl-Net-SSLeay \
"
