# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cepces"
PE = "0"
PV = "0.3.9"
PR = "2.el10"
PACKAGES = "cepces cepces-certmonger cepces-selinux python3-cepces"
PROVIDES = "rpm/cepces rpm/cepces-certmonger rpm/cepces-selinux rpm/python3-cepces"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/cepces-0.3.9-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27dcd2cb00fc5a67abd599b1654fd923bfa139366f6ed0525dcaa37a1cb31563"

URI_cepces = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cepces-0.3.9-2.el10.noarch.rpm;name=cepces;unpack=0"
SRC_URI += "${URI_cepces}"
SRC_URI[cepces.sha256sum] = "424c9ea3c6d06a317a49d0e9e5b3dd285c279c18fe204f8e9e9a209a334d61a3"
RDEPENDS:cepces = " \
 cepces-selinux \
 python3-cepces \
"

URI_cepces-certmonger = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cepces-certmonger-0.3.9-2.el10.noarch.rpm;name=cepces-certmonger;unpack=0"
SRC_URI += "${URI_cepces-certmonger}"
SRC_URI[cepces-certmonger.sha256sum] = "9ef49f635224af8ed17eae40d35e9fc555f2da7590398eff114642d1b9bb849e"
RDEPENDS:cepces-certmonger = " \
 python3 \
 certmonger \
 bash \
 cepces \
"

URI_cepces-selinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cepces-selinux-0.3.9-2.el10.noarch.rpm;name=cepces-selinux;unpack=0"
SRC_URI += "${URI_cepces-selinux}"
SRC_URI[cepces-selinux.sha256sum] = "c39544e0c58c698221d52cd1530020f068c7deb672fd777b73cdbea20d6ae13c"
RDEPENDS:cepces-selinux = " \
 bash \
 selinux-policy-targeted \
 cepces \
"

URI_python3-cepces = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-cepces-0.3.9-2.el10.noarch.rpm;name=python3-cepces;unpack=0"
SRC_URI += "${URI_python3-cepces}"
SRC_URI[python3-cepces.sha256sum] = "b932dde9aab756edc815fc05f407f75ac245339f05e0d849d2e2834a10bc271d"
RDEPENDS:python3-cepces = " \
 python3 \
 python3-requests \
 python3-gssapi \
 python3-cryptography \
 python3-setuptools \
 python3-requests-gssapi \
"
