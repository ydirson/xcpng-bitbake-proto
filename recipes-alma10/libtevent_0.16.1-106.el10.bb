# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libtevent"
PE = "0"
PV = "0.16.1"
PR = "106.el10"
PACKAGES = "libtevent python3-tevent libtevent-devel"
PROVIDES = "rpm/libtevent rpm/python3-tevent rpm/libtevent-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libtevent-0.16.1-106.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "466a3abcc3b765120e46c979befa13a81572a608af0287153c84216b46abbf15"

URI_libtevent = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libtevent-0.16.1-106.el10.x86_64_v2.rpm;name=libtevent;unpack=0"
SRC_URI += "${URI_libtevent}"
SRC_URI[libtevent.sha256sum] = "ee7942e7e423a898f9026620d44f1018a0f980d89893b569a4e3262d90a1680d"
RDEPENDS:libtevent = " \
 glibc \
 libtalloc \
"

URI_python3-tevent = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-tevent-0.16.1-106.el10.x86_64_v2.rpm;name=python3-tevent;unpack=0"
SRC_URI += "${URI_python3-tevent}"
SRC_URI[python3-tevent.sha256sum] = "de48733bcdcb9436886ff2109111b781f6f9e7e359a641dfbdc453a0eb6a5b94"
RDEPENDS:python3-tevent = " \
 glibc \
 python3 \
 libtalloc \
 libtevent \
"

URI_libtevent-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libtevent-devel-0.16.1-106.el10.x86_64_v2.rpm;name=libtevent-devel;unpack=0"
SRC_URI += "${URI_libtevent-devel}"
SRC_URI[libtevent-devel.sha256sum] = "4eda2e8dbd1071ad20e1b2024dc92f7ddd9491806cb0ba2ce23b2ad6c0e9cd84"
RDEPENDS:libtevent-devel = " \
 libtevent \
 libtalloc-devel \
 pkgconf-pkg-config \
"
