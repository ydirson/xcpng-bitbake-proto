# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hicolor-icon-theme"
PE = "0"
PV = "0.17"
PR = "20.el10"
PACKAGES = "hicolor-icon-theme"
PROVIDES = "rpm/hicolor-icon-theme"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hicolor-icon-theme-0.17-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19d8bbd683db7b72acce1446d2cc0c2039040dc80c17b75f503ff04ae1863c6c"

URI_hicolor-icon-theme = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hicolor-icon-theme-0.17-20.el10.noarch.rpm;name=hicolor-icon-theme;unpack=0"
SRC_URI += "${URI_hicolor-icon-theme}"
SRC_URI[hicolor-icon-theme.sha256sum] = "950e9f48cde713dc829d476516323e5b9f3ce2404ddd6bb01460e238583f8c98"
RDEPENDS:hicolor-icon-theme = " \
 bash \
"
