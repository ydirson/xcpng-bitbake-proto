# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mdadm"
PE = "0"
PV = "4.3"
PR = "5.el10"
PACKAGES = "mdadm"
PROVIDES = "rpm/mdadm"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/mdadm-4.3-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ece409ada6ca083305fe30ae65f5daf12b89482ca081c45cbb73cf3851915ea2"

URI_mdadm = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/mdadm-4.3-5.el10.x86_64_v2.rpm;name=mdadm;unpack=0"
SRC_URI += "${URI_mdadm}"
SRC_URI[mdadm.sha256sum] = "0c7e8372c94330ac95acae4b52049389fa824e2b4ea172f7ebc0e6f6bfe22d03"
RDEPENDS:mdadm = " \
 systemd \
 systemd-libs \
 bash \
 glibc \
 coreutils \
"
