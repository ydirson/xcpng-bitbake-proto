# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libvoikko"
PE = "0"
PV = "4.3.2"
PR = "8.el10"
PACKAGES = "libvoikko python3-libvoikko libvoikko-devel voikko-tools"
PROVIDES = "rpm/libvoikko rpm/python3-libvoikko rpm/libvoikko-devel rpm/voikko-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libvoikko-4.3.2-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "021190e333ec26a00f87e48a706472f50b664d9bca239f0146f91e3d57f121ca"

URI_libvoikko = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvoikko-4.3.2-8.el10.x86_64_v2.rpm;name=libvoikko;unpack=0"
SRC_URI += "${URI_libvoikko}"
SRC_URI[libvoikko.sha256sum] = "a508cc7a61559c92e60bf669a2833cb8f45f8313f1e80f4567b73f71e07be80e"
RDEPENDS:libvoikko = " \
 glibc \
 voikko-fi \
 libgcc \
 libstdc++ \
"

URI_python3-libvoikko = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-libvoikko-4.3.2-8.el10.noarch.rpm;name=python3-libvoikko;unpack=0"
SRC_URI += "${URI_python3-libvoikko}"
SRC_URI[python3-libvoikko.sha256sum] = "dba701b6ad5c757f664c2edef868772ea939bcb1e55b97a3b06e75c77825277c"
RDEPENDS:python3-libvoikko = " \
 python3 \
 libvoikko \
"

URI_libvoikko-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libvoikko-devel-4.3.2-8.el10.x86_64_v2.rpm;name=libvoikko-devel;unpack=0"
SRC_URI += "${URI_libvoikko-devel}"
SRC_URI[libvoikko-devel.sha256sum] = "3e5e7610ed58eb285ec46c6e3414ad76712feab1b7b84d83d9be3a9acfed97db"
RDEPENDS:libvoikko-devel = " \
 pkgconf-pkg-config \
 libvoikko \
"

URI_voikko-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/voikko-tools-4.3.2-8.el10.x86_64_v2.rpm;name=voikko-tools;unpack=0"
SRC_URI += "${URI_voikko-tools}"
SRC_URI[voikko-tools.sha256sum] = "3b3178f445fae14dbb822e7855972ebe59258bf465e0eb48e173883cc7455601"
RDEPENDS:voikko-tools = " \
 glibc \
 libgcc \
 libstdc++ \
 libvoikko \
"
