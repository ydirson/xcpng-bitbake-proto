# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-IO-Tty"
PE = "0"
PV = "1.20"
PR = "7.el10"
PACKAGES = "perl-IO-Tty perl-IO-Tty-tests"
PROVIDES = "rpm/perl-IO-Tty rpm/perl-IO-Tty-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-IO-Tty-1.20-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62f1834428517b05644bcf6e249b2babcf74623b6e2df183e567a04ab464e416"

URI_perl-IO-Tty = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-IO-Tty-1.20-7.el10.x86_64_v2.rpm;name=perl-IO-Tty;unpack=0"
SRC_URI += "${URI_perl-IO-Tty}"
SRC_URI[perl-IO-Tty.sha256sum] = "084b95874a0c36b2538ac50df1a53a88f3b87b164c9d696f2ed542c291cea6ce"
RDEPENDS:perl-IO-Tty = " \
 perl-IO-Tty \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-IO \
 perl-POSIX \
 perl-DynaLoader \
 glibc \
 perl-Exporter \
"

URI_perl-IO-Tty-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-IO-Tty-tests-1.20-7.el10.x86_64_v2.rpm;name=perl-IO-Tty-tests;unpack=0"
SRC_URI += "${URI_perl-IO-Tty-tests}"
SRC_URI[perl-IO-Tty-tests.sha256sum] = "e029337061e98e3f2769c9d23409c49477db50f75b70d779c3f6c28c12d04fef"
RDEPENDS:perl-IO-Tty-tests = " \
 perl-IO-Tty \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-POSIX \
 bash \
 perl-interpreter \
"
