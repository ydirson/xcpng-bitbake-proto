# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ocaml-labltk"
PE = "0"
PV = "8.06.13"
PR = "14.el10"
PACKAGES = "ocaml-labltk ocaml-labltk-devel ocaml-labltk-doc"
PROVIDES = "rpm/ocaml-labltk rpm/ocaml-labltk-devel rpm/ocaml-labltk-doc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/ocaml-labltk-8.06.13-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a51170a9f13a780bd26870f539982cd6edcb03141c318acdd0f9ea9095d46372"

URI_ocaml-labltk = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-labltk-8.06.13-14.el10.x86_64_v2.rpm;name=ocaml-labltk;unpack=0"
SRC_URI += "${URI_ocaml-labltk}"
SRC_URI[ocaml-labltk.sha256sum] = "84b8f72e7221d4bff5372a3401f4e2b1eeb638c1887292b5e88497a513a5349a"
RDEPENDS:ocaml-labltk = " \
 ocaml-runtime \
 tk \
 tcl \
 bash \
 glibc \
"

URI_ocaml-labltk-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-labltk-devel-8.06.13-14.el10.x86_64_v2.rpm;name=ocaml-labltk-devel;unpack=0"
SRC_URI += "${URI_ocaml-labltk-devel}"
SRC_URI[ocaml-labltk-devel.sha256sum] = "5ddad54cd9347e525cfb54a5ac92032007980e62a8b5a557224f466c585cd0c2"
RDEPENDS:ocaml-labltk-devel = " \
 tcl-devel \
 ocaml \
 ocaml-runtime \
 tk-devel \
 ocaml-labltk \
"

URI_ocaml-labltk-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-labltk-doc-8.06.13-14.el10.noarch.rpm;name=ocaml-labltk-doc;unpack=0"
SRC_URI += "${URI_ocaml-labltk-doc}"
SRC_URI[ocaml-labltk-doc.sha256sum] = "c63181c1c0645d50643a0c1b3335fee30ca074e6052dd04807039aa713f75f1d"
RDEPENDS:ocaml-labltk-doc = ""
