# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-DBD-SQLite"
PE = "0"
PV = "1.74"
PR = "6.el10"
PACKAGES = "perl-DBD-SQLite perl-DBD-SQLite-tests"
PROVIDES = "rpm/perl-DBD-SQLite rpm/perl-DBD-SQLite-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-DBD-SQLite-1.74-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50a306a797e6025d381fe7a7cc9a363fdd4a9f3d3c3b4055bbae1d7829855ae6"

URI_perl-DBD-SQLite = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-DBD-SQLite-1.74-6.el10.x86_64_v2.rpm;name=perl-DBD-SQLite;unpack=0"
SRC_URI += "${URI_perl-DBD-SQLite}"
SRC_URI[perl-DBD-SQLite.sha256sum] = "53d1522dc7009c5032e21d3a3662a221fd82713e72a2fe8aa8d1963b6b8b2f7f"
RDEPENDS:perl-DBD-SQLite = " \
 perl-constant \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-locale \
 sqlite-libs \
 perl-DBI \
 perl-DBD-SQLite \
 glibc \
 perl-Exporter \
 perl-base \
"

URI_perl-DBD-SQLite-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-DBD-SQLite-tests-1.74-6.el10.x86_64_v2.rpm;name=perl-DBD-SQLite-tests;unpack=0"
SRC_URI += "${URI_perl-DBD-SQLite-tests}"
SRC_URI[perl-DBD-SQLite-tests.sha256sum] = "35b9c4ec11f43432a39545169fe1f7e17a8fce6bac76872dfc28b2198195862d"
RDEPENDS:perl-DBD-SQLite-tests = " \
 perl-libs \
 perl-locale \
 perl-FindBin \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Carp \
 perl-DBD-SQLite \
 perl-DBI \
 perl-lib \
 perl-Time-HiRes \
 perl-Digest-MD5 \
 perl-Encode \
 bash \
 perl-Exporter \
 perl-base \
 perl-POSIX \
 perl-PathTools \
 perl-if \
 perl-interpreter \
 perl-File-Temp \
"
