# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "clevis-pin-tpm2"
PE = "0"
PV = "0.5.3"
PR = "8.el10"
PACKAGES = "clevis-pin-tpm2"
PROVIDES = "rpm/clevis-pin-tpm2"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/clevis-pin-tpm2-0.5.3-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8c49854dff9599bd07a3b2d2b195cf430345aab3c2e07caa154c39f9858a748"

URI_clevis-pin-tpm2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/clevis-pin-tpm2-0.5.3-8.el10.x86_64_v2.rpm;name=clevis-pin-tpm2;unpack=0"
SRC_URI += "${URI_clevis-pin-tpm2}"
SRC_URI[clevis-pin-tpm2.sha256sum] = "3d2a1dd324d7ab07eebb63973d4a06508fb104c1b3531fbfcb9c2ae1a8cc6d7b"
RDEPENDS:clevis-pin-tpm2 = " \
 openssl-libs \
 libgcc \
 clevis \
 tpm2-tss \
 glibc \
"
