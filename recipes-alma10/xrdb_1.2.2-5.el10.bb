# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xrdb"
PE = "0"
PV = "1.2.2"
PR = "5.el10"
PACKAGES = "xrdb"
PROVIDES = "rpm/xrdb"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xrdb-1.2.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0defafaf0c50ff28e8533157d317a48b49e33116476e9b6b3491fed6edc54540"

URI_xrdb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xrdb-1.2.2-5.el10.x86_64_v2.rpm;name=xrdb;unpack=0"
SRC_URI += "${URI_xrdb}"
SRC_URI[xrdb.sha256sum] = "2d17dc87b7f4c6a4befbb3986a01b8ee554bf721728dd75ed8c227ccfed1e951"
RDEPENDS:xrdb = " \
 glibc \
 libXmu \
 libX11 \
"
