# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-File-MimeInfo"
PE = "0"
PV = "0.34"
PR = "5.el10"
PACKAGES = "perl-File-MimeInfo perl-File-MimeInfo-tests"
PROVIDES = "rpm/perl-File-MimeInfo rpm/perl-File-MimeInfo-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-File-MimeInfo-0.34-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "822b785a0d486bd253bd3537734a141653c7afa03f2ebb4bf1090065e822acbc"

URI_perl-File-MimeInfo = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-File-MimeInfo-0.34-5.el10.noarch.rpm;name=perl-File-MimeInfo;unpack=0"
SRC_URI += "${URI_perl-File-MimeInfo}"
SRC_URI[perl-File-MimeInfo.sha256sum] = "25b06a5cc6124dafcca9a839b2c36f2f71d7be74448aa3113f504834352d0b8e"
RDEPENDS:perl-File-MimeInfo = " \
 perl-File-MimeInfo \
 perl-libs \
 perl-Carp \
 perl-interpreter \
 perl-Fcntl \
 perl-Encode \
 perl-Encode-Locale \
 perl-PathTools \
 perl-File-BaseDir \
 perl-File-DesktopEntry \
 perl-Exporter \
"

URI_perl-File-MimeInfo-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-File-MimeInfo-tests-0.34-5.el10.noarch.rpm;name=perl-File-MimeInfo-tests;unpack=0"
SRC_URI += "${URI_perl-File-MimeInfo-tests}"
SRC_URI[perl-File-MimeInfo-tests.sha256sum] = "528d48220a9692b9bb9efc20e064f30df0a35778824d690a87af9d071ffa9034"
RDEPENDS:perl-File-MimeInfo-tests = " \
 perl-File-MimeInfo \
 perl-Test-Harness \
 perl-libs \
 desktop-file-utils \
 shared-mime-info \
 perl-Test-Simple \
 perl-PathTools \
 bash \
 perl-interpreter \
"
