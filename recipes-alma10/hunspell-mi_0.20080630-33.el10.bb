# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-mi"
PE = "0"
PV = "0.20080630"
PR = "33.el10"
PACKAGES = "hunspell-mi"
PROVIDES = "rpm/hunspell-mi"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-mi-0.20080630-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01af81bd6bf5ad76bbba50b05b538e02341022ff7391ff5e10671a1a1b532792"

URI_hunspell-mi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-mi-0.20080630-33.el10.noarch.rpm;name=hunspell-mi;unpack=0"
SRC_URI += "${URI_hunspell-mi}"
SRC_URI[hunspell-mi.sha256sum] = "c65bcaf07d5c92f3d294582fd5af86a3652ebbb6991103f4a3e662c982f22dee"
RDEPENDS:hunspell-mi = " \
 hunspell-filesystem \
"
