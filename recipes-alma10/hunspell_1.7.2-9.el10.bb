# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell"
PE = "0"
PV = "1.7.2"
PR = "9.el10"
PACKAGES = "hunspell hunspell-devel hunspell-filesystem"
PROVIDES = "rpm/hunspell rpm/hunspell-devel rpm/hunspell-filesystem"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-1.7.2-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d0a49cc397e3a74af552432ee7067fef20348ff8afe8dfd7fe9c38e1eb01ace"

URI_hunspell = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-1.7.2-9.el10.x86_64_v2.rpm;name=hunspell;unpack=0"
SRC_URI += "${URI_hunspell}"
SRC_URI[hunspell.sha256sum] = "1660183a454466504f31b39077bfb16c092af2c69b0bcf8eb64c9cd3f28f850a"
RDEPENDS:hunspell = " \
 hunspell-filesystem \
 hunspell-en-US \
 libgcc \
 libstdc++ \
 ncurses-libs \
 glibc \
"

URI_hunspell-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-devel-1.7.2-9.el10.x86_64_v2.rpm;name=hunspell-devel;unpack=0"
SRC_URI += "${URI_hunspell-devel}"
SRC_URI[hunspell-devel.sha256sum] = "859d5f277617bcec3a18746787a511ea59385f746666e15255e298251d959d95"
RDEPENDS:hunspell-devel = " \
 perl-locale \
 libgcc \
 pkgconf-pkg-config \
 perl-Getopt-Long \
 hunspell \
 libstdc++ \
 bash \
 glibc \
 perl-interpreter \
"

URI_hunspell-filesystem = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-filesystem-1.7.2-9.el10.x86_64_v2.rpm;name=hunspell-filesystem;unpack=0"
SRC_URI += "${URI_hunspell-filesystem}"
SRC_URI[hunspell-filesystem.sha256sum] = "0c71828d5ae8160fb083ec92aed5143f1e764c6be8432acf2d710b664544fb6d"
RDEPENDS:hunspell-filesystem = ""
