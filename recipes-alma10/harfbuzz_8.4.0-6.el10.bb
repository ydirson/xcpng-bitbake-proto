# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "harfbuzz"
PE = "0"
PV = "8.4.0"
PR = "6.el10"
PACKAGES = "harfbuzz harfbuzz-cairo harfbuzz-devel harfbuzz-icu"
PROVIDES = "rpm/harfbuzz rpm/harfbuzz-cairo rpm/harfbuzz-devel rpm/harfbuzz-icu"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/harfbuzz-8.4.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d8596aad6cf9a09d0f77c13f4909e8deaccf822a98187a366682d1544705da8"

URI_harfbuzz = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/harfbuzz-8.4.0-6.el10.x86_64_v2.rpm;name=harfbuzz;unpack=0"
SRC_URI += "${URI_harfbuzz}"
SRC_URI[harfbuzz.sha256sum] = "587b44404de519c23a390c5b92b949df490d1c0d16864a3ee550a31ae5023041"
RDEPENDS:harfbuzz = " \
 glibc \
 freetype \
 graphite2 \
 glib2 \
"

URI_harfbuzz-cairo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/harfbuzz-cairo-8.4.0-6.el10.x86_64_v2.rpm;name=harfbuzz-cairo;unpack=0"
SRC_URI += "${URI_harfbuzz-cairo}"
SRC_URI[harfbuzz-cairo.sha256sum] = "409f6deae01f43ac842dfe0286a44b1b0fe778579acd2e62efb18cd2d57e4cad"
RDEPENDS:harfbuzz-cairo = " \
 glibc \
 harfbuzz \
 cairo \
"

URI_harfbuzz-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/harfbuzz-devel-8.4.0-6.el10.x86_64_v2.rpm;name=harfbuzz-devel;unpack=0"
SRC_URI += "${URI_harfbuzz-devel}"
SRC_URI[harfbuzz-devel.sha256sum] = "a15b3d5ea977929219e9d693716a7622578534fd6a0993177910c6868cdbd0a7"
RDEPENDS:harfbuzz-devel = " \
 freetype \
 glib2-devel \
 freetype-devel \
 harfbuzz \
 libicu-devel \
 pkgconf-pkg-config \
 graphite2-devel \
 harfbuzz-icu \
 cairo \
 glib2 \
 harfbuzz-cairo \
 glibc \
 cairo-devel \
"

URI_harfbuzz-icu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/harfbuzz-icu-8.4.0-6.el10.x86_64_v2.rpm;name=harfbuzz-icu;unpack=0"
SRC_URI += "${URI_harfbuzz-icu}"
SRC_URI[harfbuzz-icu.sha256sum] = "b0cca69752e15a5fe63ea03598fbfa8a77e0911857405971089a09c30426b353"
RDEPENDS:harfbuzz-icu = " \
 glibc \
 libicu \
 harfbuzz \
"
