# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libnetfilter_queue"
PE = "0"
PV = "1.0.5"
PR = "9.el10"
PACKAGES = "libnetfilter_queue libnetfilter_queue-devel"
PROVIDES = "rpm/libnetfilter_queue rpm/libnetfilter_queue-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libnetfilter_queue-1.0.5-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51d24c324cfdafd53bb06e4c6c93c4842a6b0971463a77268a20a3ce73616b07"

URI_libnetfilter_queue = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libnetfilter_queue-1.0.5-9.el10.x86_64_v2.rpm;name=libnetfilter_queue;unpack=0"
SRC_URI += "${URI_libnetfilter_queue}"
SRC_URI[libnetfilter_queue.sha256sum] = "e7602b114fdc7d3966219947e44db56cfcbfb2c55e37b496b7842300ef2c1247"
RDEPENDS:libnetfilter_queue = " \
 glibc \
 libmnl \
 libnfnetlink \
"

URI_libnetfilter_queue-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libnetfilter_queue-devel-1.0.5-9.el10.x86_64_v2.rpm;name=libnetfilter_queue-devel;unpack=0"
SRC_URI += "${URI_libnetfilter_queue-devel}"
SRC_URI[libnetfilter_queue-devel.sha256sum] = "468554689ae503f8c9d7d003c7450c4ed2e65121b34810452d26c89f5ddccc41"
RDEPENDS:libnetfilter_queue-devel = " \
 libnfnetlink-devel \
 kernel-headers \
 pkgconf-pkg-config \
 libnetfilter_queue \
"
