# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pywbem"
PE = "1"
PV = "0.17.6"
PR = "11.el10"
PACKAGES = "python3-pywbem"
PROVIDES = "rpm/python3-pywbem"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/pywbem-0.17.6-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8125bab5bff06c9541c0f3e3ece15b4aa3fe590c16edfe417e4771ba87cebd81"

URI_python3-pywbem = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-pywbem-0.17.6-11.el10.noarch.rpm;name=python3-pywbem;unpack=0"
SRC_URI += "${URI_python3-pywbem}"
SRC_URI[python3-pywbem.sha256sum] = "cf58627857e9f9e747e0ec3c89d5eefd2e5a59afdc60a8af3d36b7ed9daae2ab"
RDEPENDS:python3-pywbem = " \
 python3 \
 python3-pyyaml \
 python3-six \
 python3-ply \
"
