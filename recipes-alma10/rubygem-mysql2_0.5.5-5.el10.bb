# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rubygem-mysql2"
PE = "0"
PV = "0.5.5"
PR = "5.el10"
PACKAGES = "rubygem-mysql2 rubygem-mysql2-doc"
PROVIDES = "rpm/rubygem-mysql2 rpm/rubygem-mysql2-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/rubygem-mysql2-0.5.5-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d187ac825b7da01b347a869c9903ebd6aa1b797922a4bc2ec4c0e72699673b7a"

URI_rubygem-mysql2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rubygem-mysql2-0.5.5-5.el10.x86_64_v2.rpm;name=rubygem-mysql2;unpack=0"
SRC_URI += "${URI_rubygem-mysql2}"
SRC_URI[rubygem-mysql2.sha256sum] = "b998f80f2b88e54ba15bc4f8e43cb63f86ec099464f52c29fca05d621281c02d"
RDEPENDS:rubygem-mysql2 = " \
 rubygems \
 mariadb-connector-c \
 ruby-libs \
 rubygem-bigdecimal \
 glibc \
"

URI_rubygem-mysql2-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/rubygem-mysql2-doc-0.5.5-5.el10.noarch.rpm;name=rubygem-mysql2-doc;unpack=0"
SRC_URI += "${URI_rubygem-mysql2-doc}"
SRC_URI[rubygem-mysql2-doc.sha256sum] = "03164cecbc99e1d97ec68e56f160a33871b2c6af6bd88ffef9d57a9b9c0ac364"
RDEPENDS:rubygem-mysql2-doc = " \
 rubygem-mysql2 \
"
