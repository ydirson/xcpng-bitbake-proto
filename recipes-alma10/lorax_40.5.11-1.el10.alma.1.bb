# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lorax"
PE = "0"
PV = "40.5.11"
PR = "1.el10.alma.1"
PACKAGES = "lorax lorax-docs lorax-lmc-novirt lorax-lmc-virt lorax-templates-generic"
PROVIDES = "rpm/lorax rpm/lorax-docs rpm/lorax-lmc-novirt rpm/lorax-lmc-virt rpm/lorax-templates-generic"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/lorax-40.5.11-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9988f2f38096dea5e2adad8419cf4f9dfe026edf771549db650f83fc4bc81bfa"

URI_lorax = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lorax-40.5.11-1.el10.alma.1.x86_64_v2.rpm;name=lorax;unpack=0"
SRC_URI += "${URI_lorax}"
SRC_URI[lorax.sha256sum] = "0ddca6999873542a94e0c0408e36ed34c999620a756ed3633317f6e44224a3e4"
RDEPENDS:lorax = " \
 python3 \
 glibc-common \
 isomd5sum \
 kmod \
 lorax-templates-generic \
 kpartx \
 lorax-templates-rhel \
 python3-dnf \
 python3-kickstart \
 device-mapper \
 pbzip2 \
 util-linux \
 python3-librepo \
 python3-libselinux \
 dosfstools \
 dracut \
 python3-mako \
 xorriso \
 xz \
 e2fsprogs \
 xz-lzma-compat \
 parted \
 squashfs-tools \
 erofs-utils \
 grub2-pc \
 findutils \
 grub2-tools \
 pigz \
 gzip \
 gawk \
 python3-pycdio \
 cpio \
 glib2 \
 glibc \
 psmisc \
"

URI_lorax-docs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lorax-docs-40.5.11-1.el10.alma.1.x86_64_v2.rpm;name=lorax-docs;unpack=0"
SRC_URI += "${URI_lorax-docs}"
SRC_URI[lorax-docs.sha256sum] = "06705a9c89fb366d37019e522f55a10fb76740316f26ca080643fcf780c6c8be"
RDEPENDS:lorax-docs = " \
 lorax \
"

URI_lorax-lmc-novirt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lorax-lmc-novirt-40.5.11-1.el10.alma.1.x86_64_v2.rpm;name=lorax-lmc-novirt;unpack=0"
SRC_URI += "${URI_lorax-lmc-novirt}"
SRC_URI[lorax-lmc-novirt.sha256sum] = "052c7c14d0b67bf5a79583dc1f1fc8f7b5210f073fa7dc11edc091f91f308f1f"
RDEPENDS:lorax-lmc-novirt = " \
 python3-psutil \
 lorax \
 tar \
 anaconda-core \
 almalinux-logos \
 anaconda-install-env-deps \
 anaconda-tui \
"

URI_lorax-lmc-virt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lorax-lmc-virt-40.5.11-1.el10.alma.1.x86_64_v2.rpm;name=lorax-lmc-virt;unpack=0"
SRC_URI += "${URI_lorax-lmc-virt}"
SRC_URI[lorax-lmc-virt.sha256sum] = "2259aca4143a585af6bd3acd9afadc233000b3395d4e3091c96bb4733446a344"
RDEPENDS:lorax-lmc-virt = " \
 lorax \
 tar \
 edk2-ovmf \
 qemu-kvm \
"

URI_lorax-templates-generic = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lorax-templates-generic-40.5.11-1.el10.alma.1.x86_64_v2.rpm;name=lorax-templates-generic;unpack=0"
SRC_URI += "${URI_lorax-templates-generic}"
SRC_URI[lorax-templates-generic.sha256sum] = "63657aa0003b7d21c6f500e1ab2a3cda883736f2466e5765c973698934cd3112"
RDEPENDS:lorax-templates-generic = " \
 lorax \
"
