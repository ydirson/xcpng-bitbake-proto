# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libhangul"
PE = "0"
PV = "0.1.0"
PR = "33.el10"
PACKAGES = "libhangul libhangul-devel"
PROVIDES = "rpm/libhangul rpm/libhangul-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libhangul-0.1.0-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7139010f32996aeded566363ddf982b9b4f628e93f24f535db4807ba92656e35"

URI_libhangul = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libhangul-0.1.0-33.el10.x86_64_v2.rpm;name=libhangul;unpack=0"
SRC_URI += "${URI_libhangul}"
SRC_URI[libhangul.sha256sum] = "8a84170f782c2263e31f57b84af6a7856331e4d036c3e4bab7e54c3453f5d883"
RDEPENDS:libhangul = " \
 glibc \
"

URI_libhangul-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libhangul-devel-0.1.0-33.el10.x86_64_v2.rpm;name=libhangul-devel;unpack=0"
SRC_URI += "${URI_libhangul-devel}"
SRC_URI[libhangul-devel.sha256sum] = "08cd57b91f3f614222896d42a95eb254886d7d29526305a0828f5b7d8f2ec14a"
RDEPENDS:libhangul-devel = " \
 libhangul \
 pkgconf-pkg-config \
"
