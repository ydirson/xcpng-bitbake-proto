# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dbus"
PE = "1"
PV = "1.14.10"
PR = "5.el10"
PACKAGES = "dbus dbus-common dbus-libs dbus-tools dbus-daemon dbus-devel dbus-x11 dbus-doc dbus-tests"
PROVIDES = "rpm/dbus rpm/dbus-common rpm/dbus-libs rpm/dbus-tools rpm/dbus-daemon rpm/dbus-devel rpm/dbus-x11 rpm/dbus-doc rpm/dbus-tests"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/dbus-1.14.10-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "007f2c4535cc93bb7fb7ee22741a65477d28c15b9f87e8436013b09b3362d394"

URI_dbus = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/dbus-1.14.10-5.el10.x86_64_v2.rpm;name=dbus;unpack=0"
SRC_URI += "${URI_dbus}"
SRC_URI[dbus.sha256sum] = "2429aeaa8f841561075614cd2c151976d84f6fa41163e03e2b6016c01ad9b651"
RDEPENDS:dbus = " \
 dbus-broker \
"

URI_dbus-common = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/dbus-common-1.14.10-5.el10.noarch.rpm;name=dbus-common;unpack=0"
SRC_URI += "${URI_dbus-common}"
SRC_URI[dbus-common.sha256sum] = "0c163d031c1b356eb5ac309517325f3da23b89b33352538dff3870c9f499eb9d"
RDEPENDS:dbus-common = " \
 bash \
"

URI_dbus-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/dbus-libs-1.14.10-5.el10.x86_64_v2.rpm;name=dbus-libs;unpack=0"
SRC_URI += "${URI_dbus-libs}"
SRC_URI[dbus-libs.sha256sum] = "9c53b501b6b501d47ee846abafca3936a2b422baea4fb539ddd4dc13296f10a2"
RDEPENDS:dbus-libs = " \
 glibc \
 systemd-libs \
"

URI_dbus-tools = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/dbus-tools-1.14.10-5.el10.x86_64_v2.rpm;name=dbus-tools;unpack=0"
SRC_URI += "${URI_dbus-tools}"
SRC_URI[dbus-tools.sha256sum] = "ab658d30e0d7ba73c96476f180efd524dcc4176f7abff28395d52f518c7a1814"
RDEPENDS:dbus-tools = " \
 glibc \
 dbus-libs \
"

URI_dbus-daemon = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dbus-daemon-1.14.10-5.el10.x86_64_v2.rpm;name=dbus-daemon;unpack=0"
SRC_URI += "${URI_dbus-daemon}"
SRC_URI[dbus-daemon.sha256sum] = "1c9e5c9d9801f816897a9d165ae76b3a64778a81858530ebee928067adb741c6"
RDEPENDS:dbus-daemon = " \
 dbus-tools \
 shadow-utils \
 systemd-libs \
 audit-libs \
 libcap-ng \
 bash \
 expat \
 glibc \
 libselinux \
 dbus-libs \
 dbus-common \
"

URI_dbus-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dbus-devel-1.14.10-5.el10.x86_64_v2.rpm;name=dbus-devel;unpack=0"
SRC_URI += "${URI_dbus-devel}"
SRC_URI[dbus-devel.sha256sum] = "8ea3a085a8333db93cd1507f0152b94f6f2c91bf867b3945e1dce2f359d9479e"
RDEPENDS:dbus-devel = " \
 dbus-libs \
 cmake-filesystem \
 pkgconf-pkg-config \
 xml-common \
"

URI_dbus-x11 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dbus-x11-1.14.10-5.el10.x86_64_v2.rpm;name=dbus-x11;unpack=0"
SRC_URI += "${URI_dbus-x11}"
SRC_URI[dbus-x11.sha256sum] = "8ab8128105b05804d9c8cfc3e4edb420f03e5bf90fbd434e5de2b1b0e694a362"
RDEPENDS:dbus-x11 = " \
 libX11 \
 dbus-daemon \
 bash \
 glibc \
 dbus-libs \
"

URI_dbus-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/dbus-doc-1.14.10-5.el10.noarch.rpm;name=dbus-doc;unpack=0"
SRC_URI += "${URI_dbus-doc}"
SRC_URI[dbus-doc.sha256sum] = "d2a3ca9d88f4801283397c92fa9a71789e1bbd70d0644f91ee37833b01cc2ef3"
RDEPENDS:dbus-doc = " \
 dbus-daemon \
"

URI_dbus-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/dbus-tests-1.14.10-5.el10.x86_64_v2.rpm;name=dbus-tests;unpack=0"
SRC_URI += "${URI_dbus-tests}"
SRC_URI[dbus-tests.sha256sum] = "1c9fdb17ecea7548df4b8ca3ef87d113e3ec97493af686b88121f87a70c4ba4c"
RDEPENDS:dbus-tests = " \
 systemd-libs \
 dbus-daemon \
 bash \
 glib2 \
 glibc \
 dbus-libs \
"
