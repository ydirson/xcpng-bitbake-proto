# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ocaml-augeas"
PE = "0"
PV = "0.6"
PR = "37.el10"
PACKAGES = "ocaml-augeas ocaml-augeas-devel"
PROVIDES = "rpm/ocaml-augeas rpm/ocaml-augeas-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/ocaml-augeas-0.6-37.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ffed6a488e03be47369e67cd4f10599706b704334c260abb8baaf956aa74769"

URI_ocaml-augeas = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-augeas-0.6-37.el10.x86_64_v2.rpm;name=ocaml-augeas;unpack=0"
SRC_URI += "${URI_ocaml-augeas}"
SRC_URI[ocaml-augeas.sha256sum] = "8bd8299fff18917421bf495a0efdf8d28102e3427e88cadf9ea988f32368c247"
RDEPENDS:ocaml-augeas = " \
 glibc \
 ocaml-runtime \
 augeas-libs \
"

URI_ocaml-augeas-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-augeas-devel-0.6-37.el10.x86_64_v2.rpm;name=ocaml-augeas-devel;unpack=0"
SRC_URI += "${URI_ocaml-augeas-devel}"
SRC_URI[ocaml-augeas-devel.sha256sum] = "27cb06db74fa7355d89dc8a7f86955cbcc7a6349dabc3e8b1ecd4a5cf8d16fd7"
RDEPENDS:ocaml-augeas-devel = " \
 ocaml-runtime \
 ocaml-augeas \
 ocaml \
"
