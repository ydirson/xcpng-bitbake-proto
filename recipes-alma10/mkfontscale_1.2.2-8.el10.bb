# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mkfontscale"
PE = "0"
PV = "1.2.2"
PR = "8.el10"
PACKAGES = "mkfontscale"
PROVIDES = "rpm/mkfontscale"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mkfontscale-1.2.2-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12598c2144ebc1f61be3e0ae1cb21042d733604d8e29c2245ff294bf2d6b89d0"

URI_mkfontscale = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mkfontscale-1.2.2-8.el10.x86_64_v2.rpm;name=mkfontscale;unpack=0"
SRC_URI += "${URI_mkfontscale}"
SRC_URI[mkfontscale.sha256sum] = "fdbad42826c4df00c5f732f5b4648210009cb67942d102e467c3ca5ede8979dd"
RDEPENDS:mkfontscale = " \
 zlib-ng-compat \
 freetype \
 bash \
 glibc \
 libfontenc \
"
