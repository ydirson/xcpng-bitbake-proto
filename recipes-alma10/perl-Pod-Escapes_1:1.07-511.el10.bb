# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Pod-Escapes"
PE = "1"
PV = "1.07"
PR = "511.el10"
PACKAGES = "perl-Pod-Escapes perl-Pod-Escapes-tests"
PROVIDES = "rpm/perl-Pod-Escapes rpm/perl-Pod-Escapes-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Pod-Escapes-1.07-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a0be8835ebf800d8a1b5f78858a9b1b681d2995a32b71eb2c935d383e1eee4d"

URI_perl-Pod-Escapes = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Pod-Escapes-1.07-511.el10.noarch.rpm;name=perl-Pod-Escapes;unpack=0"
SRC_URI += "${URI_perl-Pod-Escapes}"
SRC_URI[perl-Pod-Escapes.sha256sum] = "a52f78ce58e47008e138a7ab77516abf7376cc800f399d57b22e6e600d4e90be"
RDEPENDS:perl-Pod-Escapes = " \
 perl-Exporter \
 perl-libs \
 perl-vars \
"

URI_perl-Pod-Escapes-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Pod-Escapes-tests-1.07-511.el10.noarch.rpm;name=perl-Pod-Escapes-tests;unpack=0"
SRC_URI += "${URI_perl-Pod-Escapes-tests}"
SRC_URI[perl-Pod-Escapes-tests.sha256sum] = "00d0bb5913ea25ad5404b5ff2fbf93589bbb90c7080ec17ddb2f8f40beaa699f"
RDEPENDS:perl-Pod-Escapes-tests = " \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 bash \
 perl-Pod-Escapes \
 perl-interpreter \
"
