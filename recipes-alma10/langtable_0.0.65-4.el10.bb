# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "langtable"
PE = "0"
PV = "0.0.65"
PR = "4.el10"
PACKAGES = "langtable python3-langtable"
PROVIDES = "rpm/langtable rpm/python3-langtable"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/langtable-0.0.65-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b142a06718470c54e2e9bc90aab4dee7dda46d09525d7ca713ebbd852eb9474"

URI_langtable = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langtable-0.0.65-4.el10.noarch.rpm;name=langtable;unpack=0"
SRC_URI += "${URI_langtable}"
SRC_URI[langtable.sha256sum] = "94ca9b1b70d12e7c68adc187488f77872d49fd702dc528d7f2e982e166074981"
RDEPENDS:langtable = ""

URI_python3-langtable = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-langtable-0.0.65-4.el10.noarch.rpm;name=python3-langtable;unpack=0"
SRC_URI += "${URI_python3-langtable}"
SRC_URI[python3-langtable.sha256sum] = "fe59211cf688c2a99e523a9f6bf2941cb31ef98ee30dfcde764de039462abe63"
RDEPENDS:python3-langtable = " \
 python3 \
 langtable \
"
