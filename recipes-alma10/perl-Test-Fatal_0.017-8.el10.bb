# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Test-Fatal"
PE = "0"
PV = "0.017"
PR = "8.el10"
PACKAGES = "perl-Test-Fatal perl-Test-Fatal-tests"
PROVIDES = "rpm/perl-Test-Fatal rpm/perl-Test-Fatal-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Test-Fatal-0.017-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10fadfc9d2f8297ae398bc76d51476f4e573ed1f94d923efd55d1e2e9794735a"

URI_perl-Test-Fatal = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Test-Fatal-0.017-8.el10.noarch.rpm;name=perl-Test-Fatal;unpack=0"
SRC_URI += "${URI_perl-Test-Fatal}"
SRC_URI[perl-Test-Fatal.sha256sum] = "8e41753989dcfc369b2fce467a73dda0b70f7607bb74d6ee6a88ff373ac2539e"
RDEPENDS:perl-Test-Fatal = " \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-Try-Tiny \
 perl-Exporter \
"

URI_perl-Test-Fatal-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Test-Fatal-tests-0.017-8.el10.noarch.rpm;name=perl-Test-Fatal-tests;unpack=0"
SRC_URI += "${URI_perl-Test-Fatal-tests}"
SRC_URI[perl-Test-Fatal-tests.sha256sum] = "60a6901e22202d811de8b444d80eb592de0ab3dcca907cdd56b24509bc5e1361"
RDEPENDS:perl-Test-Fatal-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-ExtUtils-MakeMaker \
 perl-Test-Simple \
 perl-Try-Tiny \
 perl-overload \
 perl-PathTools \
 bash \
 perl-interpreter \
 perl-Test-Fatal \
"
