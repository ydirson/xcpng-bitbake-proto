# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jflex"
PE = "0"
PV = "1.7.0"
PR = "19.el10"
PACKAGES = "jflex jflex-javadoc"
PROVIDES = "rpm/jflex rpm/jflex-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/jflex-1.7.0-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df6f3f395c8da1750e1498be711631192888254100eb79cb18a502710ac0acd9"

URI_jflex = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jflex-1.7.0-19.el10.noarch.rpm;name=jflex;unpack=0"
SRC_URI += "${URI_jflex}"
SRC_URI[jflex.sha256sum] = "76aeb5e465d2eebf69a059c559aa021cb7d310f6403dacc1ba427a61049e80c6"
RDEPENDS:jflex = " \
 javapackages-filesystem \
 javapackages-tools \
 bash \
 ant-lib \
 java_cup \
"

URI_jflex-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jflex-javadoc-1.7.0-19.el10.noarch.rpm;name=jflex-javadoc;unpack=0"
SRC_URI += "${URI_jflex-javadoc}"
SRC_URI[jflex-javadoc.sha256sum] = "9c7c58272e397bc7bc98cd229b3c2077f50ccdf55a66838a2fe4dff9a3df0eac"
RDEPENDS:jflex-javadoc = " \
 javapackages-filesystem \
"
