# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-ruamel-yaml"
PE = "0"
PV = "0.18.5"
PR = "5.el10"
PACKAGES = "python3-ruamel-yaml"
PROVIDES = "rpm/python3-ruamel-yaml"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-ruamel-yaml-0.18.5-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a904fa8a6aa9f98a25a6561ed8c310bd2f578f12eb9a18bad6b007790cfa996"

URI_python3-ruamel-yaml = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-ruamel-yaml-0.18.5-5.el10.noarch.rpm;name=python3-ruamel-yaml;unpack=0"
SRC_URI += "${URI_python3-ruamel-yaml}"
SRC_URI[python3-ruamel-yaml.sha256sum] = "c1ebf0fc8aab6287149b80e8ef919d8fbb39a0890875e7ca2cc8de18a566f1e0"
RDEPENDS:python3-ruamel-yaml = " \
 python3 \
 python3-ruamel-yaml-clib \
"
