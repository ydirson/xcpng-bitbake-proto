# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "shadow-utils"
PE = "2"
PV = "4.15.0"
PR = "5.el10"
PACKAGES = "shadow-utils shadow-utils-subid shadow-utils-subid-devel"
PROVIDES = "rpm/shadow-utils rpm/shadow-utils-subid rpm/shadow-utils-subid-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/shadow-utils-4.15.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a76ef5f3f05050045fddd01461c82726f3bd703c1783ebc13078e79ba0686f44"

URI_shadow-utils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/shadow-utils-4.15.0-5.el10.x86_64_v2.rpm;name=shadow-utils;unpack=0"
SRC_URI += "${URI_shadow-utils}"
SRC_URI[shadow-utils.sha256sum] = "a5b57b3327110a28e7439d2b26d4130593426616cac8f73d34d5283760ef49d5"
RDEPENDS:shadow-utils = " \
 setup \
 libacl \
 libxcrypt \
 audit-libs \
 libattr \
 pam-libs \
 glibc \
 libselinux \
 libsemanage \
 libeconf \
"

URI_shadow-utils-subid = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/shadow-utils-subid-4.15.0-5.el10.x86_64_v2.rpm;name=shadow-utils-subid;unpack=0"
SRC_URI += "${URI_shadow-utils-subid}"
SRC_URI[shadow-utils-subid.sha256sum] = "587ffafd2829db2573ec5318cde4377f44a2a8a31f65eb3c44fbd786e548ea8f"
RDEPENDS:shadow-utils-subid = " \
 libacl \
 libxcrypt \
 audit-libs \
 libattr \
 pam-libs \
 glibc \
 libselinux \
 libsemanage \
 libeconf \
"

URI_shadow-utils-subid-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/shadow-utils-subid-devel-4.15.0-5.el10.x86_64_v2.rpm;name=shadow-utils-subid-devel;unpack=0"
SRC_URI += "${URI_shadow-utils-subid-devel}"
SRC_URI[shadow-utils-subid-devel.sha256sum] = "f91a0c8977d959c871fa73d787b809273176aefb47ce6a8a9569a2e652405aed"
RDEPENDS:shadow-utils-subid-devel = " \
 shadow-utils-subid \
"
