# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-ar"
PE = "0"
PV = "3.5"
PR = "24.el10"
PACKAGES = "hunspell-ar"
PROVIDES = "rpm/hunspell-ar"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-ar-3.5-24.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d5408dc8c8db60307f1b76e1354945452392ae69005225b6d629ebd1ea21aba"

URI_hunspell-ar = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-ar-3.5-24.el10.noarch.rpm;name=hunspell-ar;unpack=0"
SRC_URI += "${URI_hunspell-ar}"
SRC_URI[hunspell-ar.sha256sum] = "54ddc78b0d7a679c0282946ab8105be57ce69d72fdfeca53714318adb5385a52"
RDEPENDS:hunspell-ar = " \
 hunspell-filesystem \
"
