# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "maven-archiver"
PE = "0"
PV = "3.6.1"
PR = "7.el10"
PACKAGES = "maven-archiver maven-archiver-javadoc"
PROVIDES = "rpm/maven-archiver rpm/maven-archiver-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/maven-archiver-3.6.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f968401fa0a396a775deb8450ab56c2803f5b14d4e46f938743e1b88d29c86b"

URI_maven-archiver = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-archiver-3.6.1-7.el10.noarch.rpm;name=maven-archiver;unpack=0"
SRC_URI += "${URI_maven-archiver}"
SRC_URI[maven-archiver.sha256sum] = "062d317f82028d44e53d647c027d1bdad6d33b8b0aa51122ce1d2c3efb4677be"
RDEPENDS:maven-archiver = " \
 plexus-archiver \
 plexus-interpolation \
 javapackages-filesystem \
"

URI_maven-archiver-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-archiver-javadoc-3.6.1-7.el10.noarch.rpm;name=maven-archiver-javadoc;unpack=0"
SRC_URI += "${URI_maven-archiver-javadoc}"
SRC_URI[maven-archiver-javadoc.sha256sum] = "1cb43f22b5ed68ddb3a7b84cb5c8829c4f1fdfc7c6045ebb82660ae520b56771"
RDEPENDS:maven-archiver-javadoc = " \
 javapackages-filesystem \
"
