# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "glycin-loaders"
PE = "0"
PV = "1.0.1"
PR = "1.el10"
PACKAGES = "glycin-loaders"
PROVIDES = "rpm/glycin-loaders"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/glycin-loaders-1.0.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc40b63bcc98790ecfc56bc77dd1202018029e9dcc32ca5f4ee858f21f9f8e6d"

URI_glycin-loaders = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/glycin-loaders-1.0.1-1.el10.x86_64_v2.rpm;name=glycin-loaders;unpack=0"
SRC_URI += "${URI_glycin-loaders}"
SRC_URI[glycin-loaders.sha256sum] = "4612ff396aa06624f90072d28d69f9da40af159219e227e6922d23ba1c0379bc"
RDEPENDS:glycin-loaders = " \
 libgcc \
 libxml2 \
 pango \
 cairo \
 glib2 \
 glibc \
"
