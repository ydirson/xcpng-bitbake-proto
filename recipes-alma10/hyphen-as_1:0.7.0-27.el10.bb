# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-as"
PE = "1"
PV = "0.7.0"
PR = "27.el10"
PACKAGES = "hyphen-as"
PROVIDES = "rpm/hyphen-as"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-as-0.7.0-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "252b471451f6816318869e738cccc07d7baaefc5536674eb5b80e0d3d38f1ff9"

URI_hyphen-as = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-as-0.7.0-27.el10.noarch.rpm;name=hyphen-as;unpack=0"
SRC_URI += "${URI_hyphen-as}"
SRC_URI[hyphen-as.sha256sum] = "43194887ca5386b62052fd2eb497c92af457ab4a28f389da1f355d12fe1ac3d3"
RDEPENDS:hyphen-as = " \
 hyphen \
"
