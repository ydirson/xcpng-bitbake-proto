# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "kernel"
PE = "0"
PV = "6.12.0"
PR = "55.43.1.el10_0"
PACKAGES = "kernel kernel-abi-stablelists kernel-core kernel-debug kernel-debug-core kernel-debug-modules kernel-debug-modules-core kernel-debug-modules-extra kernel-debug-uki-virt kernel-modules kernel-modules-core kernel-modules-extra kernel-tools kernel-tools-libs kernel-uki-virt kernel-uki-virt-addons kernel-debug-devel kernel-debug-devel-matched kernel-devel kernel-devel-matched kernel-doc kernel-headers perf python3-perf rtla rv kernel-cross-headers kernel-tools-libs-devel libperf kernel-debug-modules-internal kernel-debug-modules-partner kernel-debug-uki-virt-addons kernel-ipaclones-internal kernel-modules-internal kernel-modules-partner kernel-rt-debug-devel-matched kernel-rt-debug-modules-internal kernel-rt-debug-modules-partner kernel-rt-devel-matched kernel-rt-modules-internal kernel-rt-modules-partner kernel-selftests-internal libperf-devel"
PROVIDES = "rpm/kernel rpm/kernel-abi-stablelists rpm/kernel-core rpm/kernel-debug rpm/kernel-debug-core rpm/kernel-debug-modules rpm/kernel-debug-modules-core rpm/kernel-debug-modules-extra rpm/kernel-debug-uki-virt rpm/kernel-modules rpm/kernel-modules-core rpm/kernel-modules-extra rpm/kernel-tools rpm/kernel-tools-libs rpm/kernel-uki-virt rpm/kernel-uki-virt-addons rpm/kernel-debug-devel rpm/kernel-debug-devel-matched rpm/kernel-devel rpm/kernel-devel-matched rpm/kernel-doc rpm/kernel-headers rpm/perf rpm/python3-perf rpm/rtla rpm/rv rpm/kernel-cross-headers rpm/kernel-tools-libs-devel rpm/libperf rpm/kernel-debug-modules-internal rpm/kernel-debug-modules-partner rpm/kernel-debug-uki-virt-addons rpm/kernel-ipaclones-internal rpm/kernel-modules-internal rpm/kernel-modules-partner rpm/kernel-rt-debug-devel-matched rpm/kernel-rt-debug-modules-internal rpm/kernel-rt-debug-modules-partner rpm/kernel-rt-devel-matched rpm/kernel-rt-modules-internal rpm/kernel-rt-modules-partner rpm/kernel-selftests-internal rpm/libperf-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/kernel-6.12.0-55.43.1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28960e05e71f8976591f354048ea885db970ce8bb1d9cedc0e2de20bd32675c3"

URI_kernel = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kernel-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel;unpack=0"
SRC_URI += "${URI_kernel}"
SRC_URI[kernel.sha256sum] = "7ed1eaa79137cd867af1fb9b8208eb48d850802cc0eb2885b17a2bd50363c1df"
RDEPENDS:kernel = " \
 kernel-modules-core \
 kernel-core \
 kernel-modules \
"

URI_kernel-abi-stablelists = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kernel-abi-stablelists-6.12.0-55.43.1.el10_0.noarch.rpm;name=kernel-abi-stablelists;unpack=0"
SRC_URI += "${URI_kernel-abi-stablelists}"
SRC_URI[kernel-abi-stablelists.sha256sum] = "aadc2e9b1e386f1ea6664405610136dd4772241a6002cfe18a718f14592c63cd"
RDEPENDS:kernel-abi-stablelists = ""

URI_kernel-core = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kernel-core-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-core;unpack=0"
SRC_URI += "${URI_kernel-core}"
SRC_URI[kernel-core.sha256sum] = "42073ee7cd348bbbf08be0d51db5cbdd71cf6e8905559959e2a9fdcefc58c19d"
RDEPENDS:kernel-core = " \
 systemd \
 systemd-udev \
 bash \
 linux-firmware \
 dracut \
 coreutils \
 kernel-modules-core \
"

URI_kernel-debug = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kernel-debug-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-debug;unpack=0"
SRC_URI += "${URI_kernel-debug}"
SRC_URI[kernel-debug.sha256sum] = "04c926a435ff8a3f36373d7094ef8d71f4675d9554bdf60869082a68a2edf4f4"
RDEPENDS:kernel-debug = " \
 kernel-debug-modules-core \
 kernel-debug-modules \
 kernel-debug-core \
"

URI_kernel-debug-core = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kernel-debug-core-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-debug-core;unpack=0"
SRC_URI += "${URI_kernel-debug-core}"
SRC_URI[kernel-debug-core.sha256sum] = "b4443608bd3d80dae8450e25e2406a91f96355b46d2f33f8828f5ee1c1902bef"
RDEPENDS:kernel-debug-core = " \
 systemd \
 kernel-debug-modules-core \
 systemd-udev \
 bash \
 linux-firmware \
 dracut \
 coreutils \
"

URI_kernel-debug-modules = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kernel-debug-modules-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-debug-modules;unpack=0"
SRC_URI += "${URI_kernel-debug-modules}"
SRC_URI[kernel-debug-modules.sha256sum] = "b2c38ac327146781d6402a604912f39dfff1d41a97cf43d66c2921ed8f75d522"
RDEPENDS:kernel-debug-modules = " \
 kernel-debug-modules-core \
 bash \
 kernel-debug-core \
"

URI_kernel-debug-modules-core = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kernel-debug-modules-core-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-debug-modules-core;unpack=0"
SRC_URI += "${URI_kernel-debug-modules-core}"
SRC_URI[kernel-debug-modules-core.sha256sum] = "d87394de1e629956bff3ef4978e2e4d031fffe6a2015372e7b20a9ce75df52ab"
RDEPENDS:kernel-debug-modules-core = " \
 bash \
 kernel-debug-core \
"

URI_kernel-debug-modules-extra = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kernel-debug-modules-extra-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-debug-modules-extra;unpack=0"
SRC_URI += "${URI_kernel-debug-modules-extra}"
SRC_URI[kernel-debug-modules-extra.sha256sum] = "421167e24c4bc8192429f95b93283cebfd8269918f687a6771af59b9eda5c486"
RDEPENDS:kernel-debug-modules-extra = " \
 kernel-debug-modules-core \
 kernel-debug-modules \
 bash \
 kernel-debug-core \
"

URI_kernel-debug-uki-virt = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kernel-debug-uki-virt-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-debug-uki-virt;unpack=0"
SRC_URI += "${URI_kernel-debug-uki-virt}"
SRC_URI[kernel-debug-uki-virt.sha256sum] = "fdf322c68c8c644809d44ee15e4678f970b3c26747547109e824d7ad40ba8539"
RDEPENDS:kernel-debug-uki-virt = " \
 systemd \
 kernel-debug-modules-core \
 systemd-udev \
 bash \
 coreutils \
"

URI_kernel-modules = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kernel-modules-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-modules;unpack=0"
SRC_URI += "${URI_kernel-modules}"
SRC_URI[kernel-modules.sha256sum] = "67542082b18eac2c4bbd04e4c3d2eeab1e592af23c117c6c19dd68cc62b4e666"
RDEPENDS:kernel-modules = " \
 kernel-modules-core \
 bash \
 kernel-core \
"

URI_kernel-modules-core = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kernel-modules-core-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-modules-core;unpack=0"
SRC_URI += "${URI_kernel-modules-core}"
SRC_URI[kernel-modules-core.sha256sum] = "3ffbc9703c8a9597c91bd5873eec338a5de72c9b6ff7c2d0dd16571f64ff7be4"
RDEPENDS:kernel-modules-core = " \
 bash \
 kernel-core \
"

URI_kernel-modules-extra = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kernel-modules-extra-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-modules-extra;unpack=0"
SRC_URI += "${URI_kernel-modules-extra}"
SRC_URI[kernel-modules-extra.sha256sum] = "173ac03df52d513ecae7f721e5f2556366ffebb7c6297dc175ce712d748ec052"
RDEPENDS:kernel-modules-extra = " \
 kernel-modules-core \
 bash \
 kernel-core \
 kernel-modules \
"

URI_kernel-tools = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kernel-tools-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-tools;unpack=0"
SRC_URI += "${URI_kernel-tools}"
SRC_URI[kernel-tools.sha256sum] = "b5aa3f973edeb6d7563f27b9fab100099b83d4d614a6c03a2ba2939ed69e7aae"
RDEPENDS:kernel-tools = " \
 python3 \
 python3-pyyaml \
 libnl3 \
 libcap \
 pciutils-libs \
 ncurses-libs \
 glibc \
 kernel-tools-libs \
 python3-jsonschema \
"

URI_kernel-tools-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kernel-tools-libs-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-tools-libs;unpack=0"
SRC_URI += "${URI_kernel-tools-libs}"
SRC_URI[kernel-tools-libs.sha256sum] = "30778591714b1bd95a543763325c20947f72c3d22f6a0ce9ff805582fbfc8629"
RDEPENDS:kernel-tools-libs = " \
 glibc \
 bash \
"

URI_kernel-uki-virt = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kernel-uki-virt-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-uki-virt;unpack=0"
SRC_URI += "${URI_kernel-uki-virt}"
SRC_URI[kernel-uki-virt.sha256sum] = "edc78109721b71642d1a76c1b744cedb5ae6e3d6578f250d1cf19d401a0d795b"
RDEPENDS:kernel-uki-virt = " \
 systemd \
 systemd-udev \
 bash \
 coreutils \
 kernel-modules-core \
"

URI_kernel-uki-virt-addons = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kernel-uki-virt-addons-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-uki-virt-addons;unpack=0"
SRC_URI += "${URI_kernel-uki-virt-addons}"
SRC_URI[kernel-uki-virt-addons.sha256sum] = "d213f614d4b89cc3dcd626a665e5409e807890fc317d7201de04e3294d43cdbb"
RDEPENDS:kernel-uki-virt-addons = " \
 kernel-uki-virt \
 systemd \
"

URI_kernel-debug-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/kernel-debug-devel-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-debug-devel;unpack=0"
SRC_URI += "${URI_kernel-debug-devel}"
SRC_URI[kernel-debug-devel.sha256sum] = "53011502c6c41ce171d7fafb50741d84ab4f4f50fed003e42a5b2c4a5df9d2f2"
RDEPENDS:kernel-debug-devel = " \
 flex \
 make \
 bison \
 openssl-devel \
 bash \
 gcc \
 perl-interpreter \
 findutils \
 elfutils-libelf-devel \
"

URI_kernel-debug-devel-matched = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/kernel-debug-devel-matched-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-debug-devel-matched;unpack=0"
SRC_URI += "${URI_kernel-debug-devel-matched}"
SRC_URI[kernel-debug-devel-matched.sha256sum] = "12a587eb8883367a0e88889e73ce6814ba38ce710729720637f4d73dd99e3878"
RDEPENDS:kernel-debug-devel-matched = " \
 kernel-debug-devel \
 kernel-debug-core \
"

URI_kernel-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/kernel-devel-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-devel;unpack=0"
SRC_URI += "${URI_kernel-devel}"
SRC_URI[kernel-devel.sha256sum] = "96975b5b7f4b941432fde39217733dab0c82f2943990350c461d7ca183096e52"
RDEPENDS:kernel-devel = " \
 flex \
 make \
 bison \
 openssl-devel \
 bash \
 gcc \
 perl-interpreter \
 findutils \
 elfutils-libelf-devel \
"

URI_kernel-devel-matched = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/kernel-devel-matched-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-devel-matched;unpack=0"
SRC_URI += "${URI_kernel-devel-matched}"
SRC_URI[kernel-devel-matched.sha256sum] = "60e3323ddaf0497d627913cf3990941e1428af76a5db013b22c680957ae9f64a"
RDEPENDS:kernel-devel-matched = " \
 kernel-core \
 kernel-devel \
"

URI_kernel-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/kernel-doc-6.12.0-55.43.1.el10_0.noarch.rpm;name=kernel-doc;unpack=0"
SRC_URI += "${URI_kernel-doc}"
SRC_URI[kernel-doc.sha256sum] = "fb59a2bf75905db148bf655a7be80a53cfcd4725fa0b6b5f67ded19b31dd8005"
RDEPENDS:kernel-doc = ""

URI_kernel-headers = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/kernel-headers-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-headers;unpack=0"
SRC_URI += "${URI_kernel-headers}"
SRC_URI[kernel-headers.sha256sum] = "0f7c276f094fb9e5a528c5a580abf5a14cfde1505fc57e0e2dd6bc2a5e15229a"
RDEPENDS:kernel-headers = ""

URI_perf = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perf-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=perf;unpack=0"
SRC_URI += "${URI_perf}"
SRC_URI[perf.sha256sum] = "5d46c8cd5ce855e8847e9e2ed3e2f2aa79eb7295bed820302ae99da81e5fc432"
RDEPENDS:perf = " \
 perl-libs \
 perf \
 numactl-libs \
 libbpf \
 python3-libs \
 libstdc++ \
 libtraceevent \
 xz-libs \
 zlib-ng-compat \
 libbabeltrace \
 slang \
 openssl-libs \
 elfutils-libelf \
 libzstd \
 elfutils-libs \
 bash \
 perl-Exporter \
 bzip2 \
 perl-POSIX \
 glibc \
 perl-interpreter \
 llvm-libs \
 perl-lib \
"

URI_python3-perf = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-perf-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=python3-perf;unpack=0"
SRC_URI += "${URI_python3-perf}"
SRC_URI[python3-perf.sha256sum] = "5a01c0f2691ff7c6856a0202d921aaada4ac5535d50fed939e732662b075718f"
RDEPENDS:python3-perf = " \
 python3 \
 zlib-ng-compat \
 perl-libs \
 numactl-libs \
 libbabeltrace \
 slang \
 openssl-libs \
 libbpf \
 elfutils-libelf \
 python3-libs \
 libzstd \
 elfutils-libs \
 libstdc++ \
 glibc \
 libtraceevent \
 llvm-libs \
 xz-libs \
"

URI_rtla = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rtla-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=rtla;unpack=0"
SRC_URI += "${URI_rtla}"
SRC_URI[rtla.sha256sum] = "1f54c4837f05e5314840c8415a5a01b153644d28bfc59747e27e209d0e043ec9"
RDEPENDS:rtla = " \
 glibc \
 libtraceevent \
 libtracefs \
 kernel-tools-libs \
"

URI_rv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rv-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=rv;unpack=0"
SRC_URI += "${URI_rv}"
SRC_URI[rv.sha256sum] = "b4342b9164493f31cc6750f9f949ee065bdbdce8241d85f1155eaec8fc3687e4"
RDEPENDS:rv = " \
 glibc \
 libtraceevent \
 libtracefs \
"

URI_kernel-cross-headers = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/kernel-cross-headers-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-cross-headers;unpack=0"
SRC_URI += "${URI_kernel-cross-headers}"
SRC_URI[kernel-cross-headers.sha256sum] = "49a1143ce75b0872be86d42ca5e92db0a9ad1a29d2af60ecb5e1f8523af752b4"
RDEPENDS:kernel-cross-headers = ""

URI_kernel-tools-libs-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/kernel-tools-libs-devel-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-tools-libs-devel;unpack=0"
SRC_URI += "${URI_kernel-tools-libs-devel}"
SRC_URI[kernel-tools-libs-devel.sha256sum] = "406d103173edb520939d5f363bcf555dd4dd7d2d6fd3bb1f337121cdc84e6692"
RDEPENDS:kernel-tools-libs-devel = " \
 kernel-tools-libs \
 kernel-tools \
"

URI_libperf = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libperf-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=libperf;unpack=0"
SRC_URI += "${URI_libperf}"
SRC_URI[libperf.sha256sum] = "0b41b2783f6a4b8bde6293215a529320eaf61580ddd322337d25b88c213ff52b"
RDEPENDS:libperf = " \
 glibc \
"

URI_kernel-debug-modules-internal = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/kernel-debug-modules-internal-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-debug-modules-internal;unpack=0"
SRC_URI += "${URI_kernel-debug-modules-internal}"
SRC_URI[kernel-debug-modules-internal.sha256sum] = "92ca8f1440616424d36a198bcad6f14370fa00091390802f1e1132d632687545"
RDEPENDS:kernel-debug-modules-internal = " \
 kernel-debug-modules-core \
 kernel-debug-modules \
 bash \
 kernel-debug-core \
"

URI_kernel-debug-modules-partner = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/kernel-debug-modules-partner-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-debug-modules-partner;unpack=0"
SRC_URI += "${URI_kernel-debug-modules-partner}"
SRC_URI[kernel-debug-modules-partner.sha256sum] = "37139fae1634def26add71a8e5b5706ece0eff776b9e97c36964e6f5162ed039"
RDEPENDS:kernel-debug-modules-partner = " \
 kernel-debug-modules-core \
 kernel-debug-modules \
 bash \
 kernel-debug-core \
"

URI_kernel-debug-uki-virt-addons = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/kernel-debug-uki-virt-addons-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-debug-uki-virt-addons;unpack=0"
SRC_URI += "${URI_kernel-debug-uki-virt-addons}"
SRC_URI[kernel-debug-uki-virt-addons.sha256sum] = "1386687128d34ba3abed33dd7e8016c57234ecf2436dd0b12c0f2ba336e5c44e"
RDEPENDS:kernel-debug-uki-virt-addons = " \
 kernel-debug-uki-virt \
 systemd \
"

URI_kernel-ipaclones-internal = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/kernel-ipaclones-internal-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-ipaclones-internal;unpack=0"
SRC_URI += "${URI_kernel-ipaclones-internal}"
SRC_URI[kernel-ipaclones-internal.sha256sum] = "01dba80338163239d1e95d8c91b975a5375f1f1a29a9021716a47ceebeb0f6df"
RDEPENDS:kernel-ipaclones-internal = ""

URI_kernel-modules-internal = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/kernel-modules-internal-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-modules-internal;unpack=0"
SRC_URI += "${URI_kernel-modules-internal}"
SRC_URI[kernel-modules-internal.sha256sum] = "da9f1767c2b7b2d8f4dbff97c38b036e28d845cf1f51a8714926182da00e9363"
RDEPENDS:kernel-modules-internal = " \
 kernel-modules-core \
 bash \
 kernel-core \
 kernel-modules \
"

URI_kernel-modules-partner = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/kernel-modules-partner-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-modules-partner;unpack=0"
SRC_URI += "${URI_kernel-modules-partner}"
SRC_URI[kernel-modules-partner.sha256sum] = "bf41a617c6f5b1a4d605610b0c379543e30ea2d9083d7d5db4806419d889100c"
RDEPENDS:kernel-modules-partner = " \
 kernel-modules-core \
 bash \
 kernel-core \
 kernel-modules \
"

URI_kernel-rt-debug-devel-matched = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/kernel-rt-debug-devel-matched-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-rt-debug-devel-matched;unpack=0"
SRC_URI += "${URI_kernel-rt-debug-devel-matched}"
SRC_URI[kernel-rt-debug-devel-matched.sha256sum] = "e20d460ba365f6841385dbe9cfc936fdde8fd471547ae98b4a7db7f8e04e461d"
RDEPENDS:kernel-rt-debug-devel-matched = ""

URI_kernel-rt-debug-modules-internal = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/kernel-rt-debug-modules-internal-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-rt-debug-modules-internal;unpack=0"
SRC_URI += "${URI_kernel-rt-debug-modules-internal}"
SRC_URI[kernel-rt-debug-modules-internal.sha256sum] = "69699ed46cd67febf0dad8913b0c171157d74ae8982d11e9ca17c41e2818ac73"
RDEPENDS:kernel-rt-debug-modules-internal = " \
 bash \
"

URI_kernel-rt-debug-modules-partner = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/kernel-rt-debug-modules-partner-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-rt-debug-modules-partner;unpack=0"
SRC_URI += "${URI_kernel-rt-debug-modules-partner}"
SRC_URI[kernel-rt-debug-modules-partner.sha256sum] = "797af8dad7cf7125f6a15c347089f91fa505c6642049c5ca05a647e419c66995"
RDEPENDS:kernel-rt-debug-modules-partner = " \
 bash \
"

URI_kernel-rt-devel-matched = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/kernel-rt-devel-matched-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-rt-devel-matched;unpack=0"
SRC_URI += "${URI_kernel-rt-devel-matched}"
SRC_URI[kernel-rt-devel-matched.sha256sum] = "127d63ebee7140f177edccd7edcdfc3e4716503cc7074adef6fccf374bad7566"
RDEPENDS:kernel-rt-devel-matched = ""

URI_kernel-rt-modules-internal = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/kernel-rt-modules-internal-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-rt-modules-internal;unpack=0"
SRC_URI += "${URI_kernel-rt-modules-internal}"
SRC_URI[kernel-rt-modules-internal.sha256sum] = "8b39d60a20e2bfd1c647e84492f4d49e382ebc461af9a61db83cf05db26d8203"
RDEPENDS:kernel-rt-modules-internal = " \
 bash \
"

URI_kernel-rt-modules-partner = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/kernel-rt-modules-partner-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-rt-modules-partner;unpack=0"
SRC_URI += "${URI_kernel-rt-modules-partner}"
SRC_URI[kernel-rt-modules-partner.sha256sum] = "c569b63e1af74e684e0f4fd341286d1465aa61a5068535fd72d73325936131b8"
RDEPENDS:kernel-rt-modules-partner = " \
 bash \
"

URI_kernel-selftests-internal = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/kernel-selftests-internal-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=kernel-selftests-internal;unpack=0"
SRC_URI += "${URI_kernel-selftests-internal}"
SRC_URI[kernel-selftests-internal.sha256sum] = "86aa7000787dd9582eed02bb8153f1d77c73ad4e8b692a1d0f61c7f3122f9cc2"
RDEPENDS:kernel-selftests-internal = " \
 python3 \
 perl-libs \
 keyutils \
 iproute-tc \
 bpftool \
 numactl-libs \
 perl-IO \
 libcap \
 libstdc++ \
 zlib-ng-compat \
 libgcc \
 openssl-libs \
 libxml2 \
 elfutils-libelf \
 libzstd \
 bash \
 binutils \
 nmap-ncat \
 fuse-libs \
 libmnl \
 glibc \
 perl-interpreter \
 llvm-libs \
"

URI_libperf-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libperf-devel-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=libperf-devel;unpack=0"
SRC_URI += "${URI_libperf-devel}"
SRC_URI[libperf-devel.sha256sum] = "e6352f205f20c583493072854796c4b0f0b73c9d20ac616f14d2b363c10f8ab2"
RDEPENDS:libperf-devel = " \
 pkgconf-pkg-config \
 libperf \
"
