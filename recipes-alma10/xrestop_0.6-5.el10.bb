# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xrestop"
PE = "0"
PV = "0.6"
PR = "5.el10"
PACKAGES = "xrestop"
PROVIDES = "rpm/xrestop"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xrestop-0.6-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b3aca44fe3bc8cb58ad9764b110e7a90193ef18900d6a1fe7f04e9d100fc234"

URI_xrestop = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xrestop-0.6-5.el10.x86_64_v2.rpm;name=xrestop;unpack=0"
SRC_URI += "${URI_xrestop}"
SRC_URI[xrestop.sha256sum] = "6149bb77c532e423155f6d267649b5aa5dac427c2a2e5644a37c66c94238ca1c"
RDEPENDS:xrestop = " \
 glibc \
 libXres \
 ncurses-libs \
 libX11 \
"
