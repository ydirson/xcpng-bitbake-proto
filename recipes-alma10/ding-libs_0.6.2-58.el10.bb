# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ding-libs"
PE = "0"
PV = "0.6.2"
PR = "58.el10"
PACKAGES = "libbasicobjects libcollection libdhash libini_config libpath_utils libref_array libbasicobjects-devel libcollection-devel libdhash-devel libini_config-devel libpath_utils-devel libref_array-devel"
PROVIDES = "rpm/libbasicobjects rpm/libcollection rpm/libdhash rpm/libini_config rpm/libpath_utils rpm/libref_array rpm/libbasicobjects-devel rpm/libcollection-devel rpm/libdhash-devel rpm/libini_config-devel rpm/libpath_utils-devel rpm/libref_array-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/ding-libs-0.6.2-58.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09d0cce9c5ab27726c8bf825dd0e73419fb3e147d3a29777e22e068aed3adb5e"

URI_libbasicobjects = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libbasicobjects-0.1.1-58.el10.x86_64_v2.rpm;name=libbasicobjects;unpack=0"
SRC_URI += "${URI_libbasicobjects}"
SRC_URI[libbasicobjects.sha256sum] = "e65c6957c022be2150e69e07066e42fcfa8fc85d119e14a49766b3152b77fda8"
RDEPENDS:libbasicobjects = " \
 glibc \
"

URI_libcollection = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libcollection-0.7.0-58.el10.x86_64_v2.rpm;name=libcollection;unpack=0"
SRC_URI += "${URI_libcollection}"
SRC_URI[libcollection.sha256sum] = "f8396afd5162a2c9cb1098edb653fe1ffe51ecbf1850c27890a44b0a8dc32787"
RDEPENDS:libcollection = " \
 glibc \
"

URI_libdhash = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libdhash-0.5.0-58.el10.x86_64_v2.rpm;name=libdhash;unpack=0"
SRC_URI += "${URI_libdhash}"
SRC_URI[libdhash.sha256sum] = "156222338aacca0eda8197657f6bf98082a4c96cf6284afedf97a50988b4abd7"
RDEPENDS:libdhash = " \
 glibc \
"

URI_libini_config = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libini_config-1.3.1-58.el10.x86_64_v2.rpm;name=libini_config;unpack=0"
SRC_URI += "${URI_libini_config}"
SRC_URI[libini_config.sha256sum] = "5b2e9c895ed580b768d1929cdc75583a5f36595d1dd96b557151e7a4f3c3d185"
RDEPENDS:libini_config = " \
 libbasicobjects \
 libref_array \
 libcollection \
 glibc \
 libpath_utils \
"

URI_libpath_utils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libpath_utils-0.2.1-58.el10.x86_64_v2.rpm;name=libpath_utils;unpack=0"
SRC_URI += "${URI_libpath_utils}"
SRC_URI[libpath_utils.sha256sum] = "ca482ba9d2289548af431e0f83e33153facfef89b37b00319c54420c6d5319ce"
RDEPENDS:libpath_utils = " \
 glibc \
"

URI_libref_array = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libref_array-0.1.5-58.el10.x86_64_v2.rpm;name=libref_array;unpack=0"
SRC_URI += "${URI_libref_array}"
SRC_URI[libref_array.sha256sum] = "a781f443e4f9e1e18dd76268fb6d2eadf7c1cd64d1f2f16e3d1992a917295fb1"
RDEPENDS:libref_array = " \
 glibc \
"

URI_libbasicobjects-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libbasicobjects-devel-0.1.1-58.el10.x86_64_v2.rpm;name=libbasicobjects-devel;unpack=0"
SRC_URI += "${URI_libbasicobjects-devel}"
SRC_URI[libbasicobjects-devel.sha256sum] = "519892ca9fa21be25ccdc1066a591c21104f032072736fd74f935cd64689f770"
RDEPENDS:libbasicobjects-devel = " \
 libbasicobjects \
 pkgconf-pkg-config \
"

URI_libcollection-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libcollection-devel-0.7.0-58.el10.x86_64_v2.rpm;name=libcollection-devel;unpack=0"
SRC_URI += "${URI_libcollection-devel}"
SRC_URI[libcollection-devel.sha256sum] = "18611f23d770feb57a37290eaf7ec8b4d6bbae8c397cadfd599c095f2976972b"
RDEPENDS:libcollection-devel = " \
 libcollection \
 pkgconf-pkg-config \
"

URI_libdhash-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libdhash-devel-0.5.0-58.el10.x86_64_v2.rpm;name=libdhash-devel;unpack=0"
SRC_URI += "${URI_libdhash-devel}"
SRC_URI[libdhash-devel.sha256sum] = "3febec51594f5600be86472612861fead97a22b854e680acfb7debc89c2991b0"
RDEPENDS:libdhash-devel = " \
 libdhash \
 pkgconf-pkg-config \
"

URI_libini_config-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libini_config-devel-1.3.1-58.el10.x86_64_v2.rpm;name=libini_config-devel;unpack=0"
SRC_URI += "${URI_libini_config-devel}"
SRC_URI[libini_config-devel.sha256sum] = "0f1d7a1a25fad8401ebdc40c412ce54f099293464b1b241372471cba5af730dd"
RDEPENDS:libini_config-devel = " \
 libcollection-devel \
 pkgconf-pkg-config \
 libref_array-devel \
 libini_config \
 libbasicobjects-devel \
"

URI_libpath_utils-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libpath_utils-devel-0.2.1-58.el10.x86_64_v2.rpm;name=libpath_utils-devel;unpack=0"
SRC_URI += "${URI_libpath_utils-devel}"
SRC_URI[libpath_utils-devel.sha256sum] = "cf0c48804d8e7342da81b179b461fc06d5997694db8832431c8ec0f6785ce8ed"
RDEPENDS:libpath_utils-devel = " \
 pkgconf-pkg-config \
 libpath_utils \
"

URI_libref_array-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libref_array-devel-0.1.5-58.el10.x86_64_v2.rpm;name=libref_array-devel;unpack=0"
SRC_URI += "${URI_libref_array-devel}"
SRC_URI[libref_array-devel.sha256sum] = "7c6cff1cc03f23188777a19eb725316936cae93b490d1e0d8562878afa10a948"
RDEPENDS:libref_array-devel = " \
 libref_array \
 pkgconf-pkg-config \
"
