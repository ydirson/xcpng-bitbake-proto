# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cups-browsed"
PE = "1"
PV = "2.0.0"
PR = "8.el10"
PACKAGES = "cups-browsed"
PROVIDES = "rpm/cups-browsed"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/cups-browsed-2.0.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb4ffea8aaaebcc72759b579f59aee69bbadebbd1db3f3509248138e4cd7f4aa"

URI_cups-browsed = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cups-browsed-2.0.0-8.el10.x86_64_v2.rpm;name=cups-browsed;unpack=0"
SRC_URI += "${URI_cups-browsed}"
SRC_URI[cups-browsed.sha256sum] = "1431e8c3dcd5dbc56406100417ad71b31d7b68f07ea38b53b10fc39201e26fa7"
RDEPENDS:cups-browsed = " \
 systemd \
 cups-filesystem \
 cups-libs \
 avahi-glib \
 avahi-libs \
 bash \
 glib2 \
 libcupsfilters \
 glibc \
 libppd \
"
