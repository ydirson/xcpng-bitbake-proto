# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "binutils"
PE = "0"
PV = "2.41"
PR = "53.el10.alma.1"
PACKAGES = "binutils binutils-gold binutils-devel binutils-gprofng cross-binutils-aarch64 cross-binutils-ppc64le cross-binutils-s390x"
PROVIDES = "rpm/binutils rpm/binutils-gold rpm/binutils-devel rpm/binutils-gprofng rpm/cross-binutils-aarch64 rpm/cross-binutils-ppc64le rpm/cross-binutils-s390x"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/binutils-2.41-53.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb23e3a6f67fdf081dde241611e9971dc24e30b3790c08ec492e17a72c8c84d9"

URI_binutils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/binutils-2.41-53.el10.alma.1.x86_64_v2.rpm;name=binutils;unpack=0"
SRC_URI += "${URI_binutils}"
SRC_URI[binutils.sha256sum] = "2bca11c86881689f71dac612a7e4ce69495a59b070c15fdb27a22fd9e95f3a13"
RDEPENDS:binutils = " \
 zlib-ng-compat \
 jansson \
 elfutils-debuginfod-client \
 libgcc \
 libstdc++ \
 bash \
 glibc \
 coreutils \
 binutils-gold \
 alternatives \
"

URI_binutils-gold = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/binutils-gold-2.41-53.el10.alma.1.x86_64_v2.rpm;name=binutils-gold;unpack=0"
SRC_URI += "${URI_binutils-gold}"
SRC_URI[binutils-gold.sha256sum] = "5d35559c2fcff9ef169ba97092bbca4d0b710986fb572958cb2b6df15a6c2aff"
RDEPENDS:binutils-gold = " \
 zlib-ng-compat \
 jansson \
 libgcc \
 libstdc++ \
 bash \
 binutils \
 glibc \
"

URI_binutils-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/binutils-devel-2.41-53.el10.alma.1.x86_64_v2.rpm;name=binutils-devel;unpack=0"
SRC_URI += "${URI_binutils-devel}"
SRC_URI[binutils-devel.sha256sum] = "a9ac6b6d75d5058a9aa89a867aa7a73c8783a4ff41de7a09135fffd536960301"
RDEPENDS:binutils-devel = " \
 coreutils \
 zlib-ng-compat-devel \
 binutils \
"

URI_binutils-gprofng = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/binutils-gprofng-2.41-53.el10.alma.1.x86_64_v2.rpm;name=binutils-gprofng;unpack=0"
SRC_URI += "${URI_binutils-gprofng}"
SRC_URI[binutils-gprofng.sha256sum] = "34b10e02ba26409ce893a36fe2cfed56ecbd89991f623a4bb982fcbed3cdc3c4"
RDEPENDS:binutils-gprofng = " \
 libgcc \
 libstdc++ \
 binutils \
 glibc \
 perl-interpreter \
"

URI_cross-binutils-aarch64 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/cross-binutils-aarch64-2.41-53.el10.alma.1.x86_64_v2.rpm;name=cross-binutils-aarch64;unpack=0"
SRC_URI += "${URI_cross-binutils-aarch64}"
SRC_URI[cross-binutils-aarch64.sha256sum] = "9666c1076b307feb74b41aa1b649451df91932402ed5964331edddc9519a8c87"
RDEPENDS:cross-binutils-aarch64 = " \
 zlib-ng-compat \
 jansson \
 elfutils-debuginfod-client \
 libgcc \
 zlib-ng-compat-devel \
 libstdc++ \
 glibc \
 coreutils \
 perl-interpreter \
"

URI_cross-binutils-ppc64le = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/cross-binutils-ppc64le-2.41-53.el10.alma.1.x86_64_v2.rpm;name=cross-binutils-ppc64le;unpack=0"
SRC_URI += "${URI_cross-binutils-ppc64le}"
SRC_URI[cross-binutils-ppc64le.sha256sum] = "e437a845c9cfb94097c88d2596230b3ffd47287ce6a3a9a6844fc553414a626b"
RDEPENDS:cross-binutils-ppc64le = " \
 zlib-ng-compat \
 jansson \
 elfutils-debuginfod-client \
 zlib-ng-compat-devel \
 glibc \
 coreutils \
"

URI_cross-binutils-s390x = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/cross-binutils-s390x-2.41-53.el10.alma.1.x86_64_v2.rpm;name=cross-binutils-s390x;unpack=0"
SRC_URI += "${URI_cross-binutils-s390x}"
SRC_URI[cross-binutils-s390x.sha256sum] = "14c7dbedad3bb2e8fcfa6f640bb8f66a10127cd9a15a1ca9dc0ea0a54a7f26cb"
RDEPENDS:cross-binutils-s390x = " \
 zlib-ng-compat \
 jansson \
 elfutils-debuginfod-client \
 zlib-ng-compat-devel \
 glibc \
 coreutils \
"
