# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Test-Pod-Coverage"
PE = "0"
PV = "1.10"
PR = "32.el10"
PACKAGES = "perl-Test-Pod-Coverage perl-Test-Pod-Coverage-tests"
PROVIDES = "rpm/perl-Test-Pod-Coverage rpm/perl-Test-Pod-Coverage-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Test-Pod-Coverage-1.10-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9c5509d50e6bf3134b7f52c9d21016d9553b805b9dcfa05f57250749762841e"

URI_perl-Test-Pod-Coverage = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Test-Pod-Coverage-1.10-32.el10.noarch.rpm;name=perl-Test-Pod-Coverage;unpack=0"
SRC_URI += "${URI_perl-Test-Pod-Coverage}"
SRC_URI[perl-Test-Pod-Coverage.sha256sum] = "3159c8cba6cbdf24f79d07db92dae79a59ef1ec3ee94d22dbcd5a7f488874adc"
RDEPENDS:perl-Test-Pod-Coverage = " \
 perl-Pod-Coverage \
 perl-libs \
 perl-Test-Simple \
"

URI_perl-Test-Pod-Coverage-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Test-Pod-Coverage-tests-1.10-32.el10.noarch.rpm;name=perl-Test-Pod-Coverage-tests;unpack=0"
SRC_URI += "${URI_perl-Test-Pod-Coverage-tests}"
SRC_URI[perl-Test-Pod-Coverage-tests.sha256sum] = "e1f7d31b4d857e29347c8b24c311fe792b61635fdefa209b201f590c6b89181f"
RDEPENDS:perl-Test-Pod-Coverage-tests = " \
 perl-Test-Pod-Coverage \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 bash \
 perl-interpreter \
 perl-base \
 perl-lib \
"
