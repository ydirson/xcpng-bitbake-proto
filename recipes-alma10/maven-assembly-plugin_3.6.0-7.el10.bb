# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "maven-assembly-plugin"
PE = "0"
PV = "3.6.0"
PR = "7.el10"
PACKAGES = "maven-assembly-plugin maven-assembly-plugin-javadoc"
PROVIDES = "rpm/maven-assembly-plugin rpm/maven-assembly-plugin-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/maven-assembly-plugin-3.6.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20ceca42f947f66c711c2e489acea038d8ab3a9275343dbdfc249ecd2dcd6f27"

URI_maven-assembly-plugin = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-assembly-plugin-3.6.0-7.el10.noarch.rpm;name=maven-assembly-plugin;unpack=0"
SRC_URI += "${URI_maven-assembly-plugin}"
SRC_URI[maven-assembly-plugin.sha256sum] = "a9ae34081e20a2c3dc7414ff531858ad815cb3a2be6dc37ec054ecb538cfedc7"
RDEPENDS:maven-assembly-plugin = " \
 maven-filtering \
 plexus-interpolation \
 apache-commons-io \
 plexus-utils \
 javapackages-filesystem \
 maven-archiver \
 maven-common-artifact-filters \
 plexus-archiver \
 plexus-io \
"

URI_maven-assembly-plugin-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-assembly-plugin-javadoc-3.6.0-7.el10.noarch.rpm;name=maven-assembly-plugin-javadoc;unpack=0"
SRC_URI += "${URI_maven-assembly-plugin-javadoc}"
SRC_URI[maven-assembly-plugin-javadoc.sha256sum] = "7ab57b45ae2c9779a3ae53fda6eaee033f265cc51af7401f60cfcd808d58b7fb"
RDEPENDS:maven-assembly-plugin-javadoc = " \
 javapackages-filesystem \
"
