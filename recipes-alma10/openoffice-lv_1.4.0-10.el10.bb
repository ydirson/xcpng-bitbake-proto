# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "openoffice-lv"
PE = "0"
PV = "1.4.0"
PR = "10.el10"
PACKAGES = "hunspell-lv hyphen-lv"
PROVIDES = "rpm/hunspell-lv rpm/hyphen-lv"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/openoffice-lv-1.4.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e0ceae2c89e8da5317d80cc765ed85a24a73c37fcbfd12ca0f2c6c49bb37d2a"

URI_hunspell-lv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-lv-1.4.0-10.el10.noarch.rpm;name=hunspell-lv;unpack=0"
SRC_URI += "${URI_hunspell-lv}"
SRC_URI[hunspell-lv.sha256sum] = "3d5abaa6b724f09e6596f10beebe43a9cfbd5c2b3bd063e92b7293e70808ffe4"
RDEPENDS:hunspell-lv = " \
 hunspell \
"

URI_hyphen-lv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-lv-1.4.0-10.el10.noarch.rpm;name=hyphen-lv;unpack=0"
SRC_URI += "${URI_hyphen-lv}"
SRC_URI[hyphen-lv.sha256sum] = "91fb2930350d63268927a1c8d3b371b155f283f22fe17219399d83dee1be6b2e"
RDEPENDS:hyphen-lv = " \
 hyphen \
"
