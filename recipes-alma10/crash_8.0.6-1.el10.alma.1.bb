# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "crash"
PE = "0"
PV = "8.0.6"
PR = "1.el10.alma.1"
PACKAGES = "crash crash-devel"
PROVIDES = "rpm/crash rpm/crash-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/crash-8.0.6-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "774b41b3d29840fa7abb5fd8d8858960791dfda44b6a96762326ab53fec5e2d2"

URI_crash = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/crash-8.0.6-1.el10.alma.1.x86_64_v2.rpm;name=crash;unpack=0"
SRC_URI += "${URI_crash}"
SRC_URI[crash.sha256sum] = "9e1f91e44893c68a7ba9fe0d4f0b95f8d26a468a4a2782b1984d87fa429c5770"
RDEPENDS:crash = " \
 lzo \
 libgcc \
 snappy \
 libzstd \
 libstdc++ \
 ncurses-libs \
 binutils \
 glibc \
"

URI_crash-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/crash-devel-8.0.6-1.el10.alma.1.x86_64_v2.rpm;name=crash-devel;unpack=0"
SRC_URI += "${URI_crash-devel}"
SRC_URI[crash-devel.sha256sum] = "11a7e97a97e13f6f8b685411a04ac48b0b50b31bfad710d6f5d870d5a55536c1"
RDEPENDS:crash-devel = " \
 crash \
 zlib-ng-compat-devel \
"
