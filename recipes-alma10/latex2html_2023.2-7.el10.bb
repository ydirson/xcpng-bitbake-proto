# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "latex2html"
PE = "0"
PV = "2023.2"
PR = "7.el10"
PACKAGES = "latex2html"
PROVIDES = "rpm/latex2html"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/latex2html-2023.2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d89980751e6dcbc42f535a0d42a9ae064e5506d27418e4b005af85f17d6d0ce"

URI_latex2html = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/latex2html-2023.2-7.el10.noarch.rpm;name=latex2html;unpack=0"
SRC_URI += "${URI_latex2html}"
SRC_URI[latex2html.sha256sum] = "bf0edda7da935029cd0ebee8408262399b841bdfb9f06b84f0255e810cd4bfff"
RDEPENDS:latex2html = " \
 texlive-url \
 perl-libs \
 perl-Getopt-Long \
 poppler-utils \
 perl-Sys-Hostname \
 perl-Carp \
 perl-vars \
 tex-preview \
 netpbm-progs \
 perl-Encode \
 bash \
 perl-Exporter \
 texlive-collection-latexrecommended \
 perl-Fcntl \
 perl-POSIX \
 texlive-dvips \
 perl-File-Copy \
 perl-PathTools \
 perl-interpreter \
"
