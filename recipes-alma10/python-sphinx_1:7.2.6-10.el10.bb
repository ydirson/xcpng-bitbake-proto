# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-sphinx"
PE = "1"
PV = "7.2.6"
PR = "10.el10"
PACKAGES = "python-sphinx-doc python3-sphinx python3-sphinx-latex"
PROVIDES = "rpm/python-sphinx-doc rpm/python3-sphinx rpm/python3-sphinx-latex"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/python-sphinx-7.2.6-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "301fd3beff7af8aeb600e56f933593dd2f3ec58550c2bd7d495f1e92aeb50525"

URI_python-sphinx-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python-sphinx-doc-7.2.6-10.el10.noarch.rpm;name=python-sphinx-doc;unpack=0"
SRC_URI += "${URI_python-sphinx-doc}"
SRC_URI[python-sphinx-doc.sha256sum] = "a960f3bc189fdba315ce22e71eb7337a20491c939f3febc6affc4347803928b4"
RDEPENDS:python-sphinx-doc = ""

URI_python3-sphinx = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-sphinx-7.2.6-10.el10.noarch.rpm;name=python3-sphinx;unpack=0"
SRC_URI += "${URI_python3-sphinx}"
SRC_URI[python3-sphinx.sha256sum] = "6726ffaef1c6a87ba03228b546f1215c34de2405b86e1e1ffc24efbbea041d7c"
RDEPENDS:python3-sphinx = " \
 python3 \
 python3-sphinx-theme-alabaster \
 python3-requests \
 python3-babel \
 python3-pygments \
 python3-jinja2 \
 python3-packaging \
 python3-docutils \
 python3-imagesize \
"

URI_python3-sphinx-latex = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-sphinx-latex-7.2.6-10.el10.noarch.rpm;name=python3-sphinx-latex;unpack=0"
SRC_URI += "${URI_python3-sphinx-latex}"
SRC_URI[python3-sphinx-latex.sha256sum] = "e8421eca135281a1096a9e6ac12d41265939f43f328d02e017410320ff1546d1"
RDEPENDS:python3-sphinx-latex = " \
 texlive-wrapfig \
 texlive-needspace \
 texlive-fancyhdr \
 texlive-fancyvrb \
 texlive-parskip \
 texlive-fncychap \
 texlive-framed \
 python3-sphinx \
 texlive-geometry \
 texlive-polyglossia \
 texlive-graphics \
 texlive-gnu-freefont \
 texlive-amscls \
 texlive-amsmath \
 texlive-anyfontsize \
 texlive-hyperref \
 texlive-kvoptions \
 texlive-capt-of \
 texlive-latex \
 texlive-cmap \
 texlive-tabulary \
 texlive-collection-fontsrecommended \
 texlive-collection-latex \
 texlive-luatex85 \
 texlive-ctablestack \
 texlive-titlesec \
 texlive-dvipng \
 texlive-dvisvgm \
 texlive-ucs \
 texlive-upquote \
"
