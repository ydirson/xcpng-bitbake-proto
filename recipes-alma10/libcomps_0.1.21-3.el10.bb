# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libcomps"
PE = "0"
PV = "0.1.21"
PR = "3.el10"
PACKAGES = "libcomps python3-libcomps libcomps-devel libcomps-doc python-libcomps-doc"
PROVIDES = "rpm/libcomps rpm/python3-libcomps rpm/libcomps-devel rpm/libcomps-doc rpm/python-libcomps-doc"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libcomps-0.1.21-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63e2827c4689abca146ca2396b32694ca761aa1011c341b2a010fb93bf9d999a"

URI_libcomps = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libcomps-0.1.21-3.el10.x86_64_v2.rpm;name=libcomps;unpack=0"
SRC_URI += "${URI_libcomps}"
SRC_URI[libcomps.sha256sum] = "1f32a13fcfe5a9acd65cd89bdb852aca9632943fe6cc94e805ab7af20c522a12"
RDEPENDS:libcomps = " \
 glibc \
 libxml2 \
 expat \
"

URI_python3-libcomps = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-libcomps-0.1.21-3.el10.x86_64_v2.rpm;name=python3-libcomps;unpack=0"
SRC_URI += "${URI_python3-libcomps}"
SRC_URI[python3-libcomps.sha256sum] = "b06617fb2d8bc916f96d93a2446f425387a6c6b5d8070ef9a844a4de30d09739"
RDEPENDS:python3-libcomps = " \
 python3 \
 zlib-ng-compat \
 python3-libs \
 libcomps \
 glibc \
"

URI_libcomps-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libcomps-devel-0.1.21-3.el10.x86_64_v2.rpm;name=libcomps-devel;unpack=0"
SRC_URI += "${URI_libcomps-devel}"
SRC_URI[libcomps-devel.sha256sum] = "03cf2553a7ab0f9e8bbed8aa2817518c468d09fc0be78a0515984b6511fb46ab"
RDEPENDS:libcomps-devel = " \
 libxml2-devel \
 expat-devel \
 libcomps \
 pkgconf-pkg-config \
"

URI_libcomps-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libcomps-doc-0.1.21-3.el10.noarch.rpm;name=libcomps-doc;unpack=0"
SRC_URI += "${URI_libcomps-doc}"
SRC_URI[libcomps-doc.sha256sum] = "8e5c32914505697f177c0b6fe596ef97d69d6f44e546443b1976872374adb4dc"
RDEPENDS:libcomps-doc = " \
 libcomps \
"

URI_python-libcomps-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python-libcomps-doc-0.1.21-3.el10.noarch.rpm;name=python-libcomps-doc;unpack=0"
SRC_URI += "${URI_python-libcomps-doc}"
SRC_URI[python-libcomps-doc.sha256sum] = "289f66e4e0c704463521f99e557d5a87897e737d9de006b6e2e666cd3e44c0bb"
RDEPENDS:python-libcomps-doc = " \
 libcomps \
"
