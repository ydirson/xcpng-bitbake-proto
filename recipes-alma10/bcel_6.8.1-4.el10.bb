# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "bcel"
PE = "0"
PV = "6.8.1"
PR = "4.el10"
PACKAGES = "bcel bcel-javadoc"
PROVIDES = "rpm/bcel rpm/bcel-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/bcel-6.8.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50b935d19b00b90642b971286229e6ccb4698b0718e7004c64f3f584d8221df1"

URI_bcel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/bcel-6.8.1-4.el10.noarch.rpm;name=bcel;unpack=0"
SRC_URI += "${URI_bcel}"
SRC_URI[bcel.sha256sum] = "7238f26da659f61bc35a9f0084182dfdf03e906ba31380f286a67c0f8ad0f822"
RDEPENDS:bcel = " \
 javapackages-filesystem \
 apache-commons-lang3 \
"

URI_bcel-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/bcel-javadoc-6.8.1-4.el10.noarch.rpm;name=bcel-javadoc;unpack=0"
SRC_URI += "${URI_bcel-javadoc}"
SRC_URI[bcel-javadoc.sha256sum] = "c641daeb8e2cce8350ba5b2e778f9269127f54531a0633d15c73bbf290085dc9"
RDEPENDS:bcel-javadoc = " \
 javapackages-filesystem \
"
