# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pavucontrol"
PE = "0"
PV = "6.0"
PR = "5.el10"
PACKAGES = "pavucontrol"
PROVIDES = "rpm/pavucontrol"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/pavucontrol-6.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c98703241557cc2995bcc16c74c16a4221e20015abaa41570675195b77f5d2e6"

URI_pavucontrol = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pavucontrol-6.0-5.el10.x86_64_v2.rpm;name=pavucontrol;unpack=0"
SRC_URI += "${URI_pavucontrol}"
SRC_URI[pavucontrol.sha256sum] = "023ec718dddc2f3e7568645275db125231a211bfea1b7066c0e30ceed5cdb4ef"
RDEPENDS:pavucontrol = " \
 gtkmm4.0 \
 pulseaudio-libs \
 libgcc \
 pulseaudio-libs-glib2 \
 json-glib \
 libstdc++ \
 glib2 \
 glibmm2.68 \
 glibc \
 gtk4 \
 libsigc++30 \
"
