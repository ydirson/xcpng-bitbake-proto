# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "adobe-mappings-pdf"
PE = "0"
PV = "20190401"
PR = "9.el10"
PACKAGES = "adobe-mappings-pdf adobe-mappings-pdf-devel"
PROVIDES = "rpm/adobe-mappings-pdf rpm/adobe-mappings-pdf-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/adobe-mappings-pdf-20190401-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6760450525c884de852ce3c52ef1dde23ef7aba56b9dd4af4c4ea9c77cd21cc"

URI_adobe-mappings-pdf = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/adobe-mappings-pdf-20190401-9.el10.noarch.rpm;name=adobe-mappings-pdf;unpack=0"
SRC_URI += "${URI_adobe-mappings-pdf}"
SRC_URI[adobe-mappings-pdf.sha256sum] = "6df62e10e4115584ac7e3bc135f61e3ddf4b82e5cda71c3f8033410584506996"
RDEPENDS:adobe-mappings-pdf = ""

URI_adobe-mappings-pdf-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/adobe-mappings-pdf-devel-20190401-9.el10.noarch.rpm;name=adobe-mappings-pdf-devel;unpack=0"
SRC_URI += "${URI_adobe-mappings-pdf-devel}"
SRC_URI[adobe-mappings-pdf-devel.sha256sum] = "a98bb7ba9e313701e17a860a5453bdca2cb0aa7053c7c0c4cbd7f68af8779373"
RDEPENDS:adobe-mappings-pdf-devel = " \
 adobe-mappings-pdf \
"
