# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pappl-retrofit"
PE = "0"
PV = "1.0b2"
PR = "7.el10"
PACKAGES = "legacy-printer-app pappl-retrofit pappl-retrofit-devel"
PROVIDES = "rpm/legacy-printer-app rpm/pappl-retrofit rpm/pappl-retrofit-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/pappl-retrofit-1.0b2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c9ec0aca8c090544c8a57810708021c3af8851513e3bed126639ac1aa4f0848"

URI_legacy-printer-app = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/legacy-printer-app-1.0b2-7.el10.x86_64_v2.rpm;name=legacy-printer-app;unpack=0"
SRC_URI += "${URI_legacy-printer-app}"
SRC_URI[legacy-printer-app.sha256sum] = "8074c0535a937e8ead6f3d4a3b0f905461f8d6764930632e8537a605fde44029"
RDEPENDS:legacy-printer-app = " \
 systemd \
 cups-filesystem \
 cups-libs \
 authselect-libs \
 bash \
 libcupsfilters \
 glibc \
 pappl-retrofit \
 libppd \
"

URI_pappl-retrofit = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pappl-retrofit-1.0b2-7.el10.x86_64_v2.rpm;name=pappl-retrofit;unpack=0"
SRC_URI += "${URI_pappl-retrofit}"
SRC_URI[pappl-retrofit.sha256sum] = "a6f2095575149cceeb808a71a5e1efc81fdc7ecf965e42fa08dba1a7773f6abc"
RDEPENDS:pappl-retrofit = " \
 cups-libs \
 libcupsfilters \
 glibc \
 pappl \
 libppd \
"

URI_pappl-retrofit-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/pappl-retrofit-devel-1.0b2-7.el10.x86_64_v2.rpm;name=pappl-retrofit-devel;unpack=0"
SRC_URI += "${URI_pappl-retrofit-devel}"
SRC_URI[pappl-retrofit-devel.sha256sum] = "f3362f7a6a60fbc9050b732afe6774684d2817c4395c498005991422f63aec05"
RDEPENDS:pappl-retrofit-devel = " \
 pappl-retrofit \
 pkgconf-pkg-config \
"
