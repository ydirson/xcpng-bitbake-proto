# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Compress-Raw-Zlib"
PE = "0"
PV = "2.212"
PR = "512.el10"
PACKAGES = "perl-Compress-Raw-Zlib perl-Compress-Raw-Zlib-tests"
PROVIDES = "rpm/perl-Compress-Raw-Zlib rpm/perl-Compress-Raw-Zlib-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Compress-Raw-Zlib-2.212-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e74f24e78d10083390c92f8caed400f35b69fd897e68e3121a456f0d130a6dd0"

URI_perl-Compress-Raw-Zlib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Compress-Raw-Zlib-2.212-512.el10.x86_64_v2.rpm;name=perl-Compress-Raw-Zlib;unpack=0"
SRC_URI += "${URI_perl-Compress-Raw-Zlib}"
SRC_URI[perl-Compress-Raw-Zlib.sha256sum] = "e33f80f8d317f75c5c825cbecbf276f27ff56b3567ee42bf20a08d8ca92c0533"
RDEPENDS:perl-Compress-Raw-Zlib = " \
 perl-constant \
 zlib-ng-compat \
 perl-libs \
 perl-Carp \
 glibc \
 perl-Exporter \
"

URI_perl-Compress-Raw-Zlib-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Compress-Raw-Zlib-tests-2.212-512.el10.x86_64_v2.rpm;name=perl-Compress-Raw-Zlib-tests;unpack=0"
SRC_URI += "${URI_perl-Compress-Raw-Zlib-tests}"
SRC_URI[perl-Compress-Raw-Zlib-tests.sha256sum] = "0a156dcf3fc92c60a6543810ec8028e4294bc8b023f7ef713c7a721882e89c4a"
RDEPENDS:perl-Compress-Raw-Zlib-tests = " \
 perl-constant \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-Scalar-List-Utils \
 perl-Compress-Raw-Zlib \
 bash \
 perl-interpreter \
 perl-File-Path \
 perl-lib \
"
