# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mcstrans"
PE = "0"
PV = "3.8"
PR = "1.el10"
PACKAGES = "mcstrans"
PROVIDES = "rpm/mcstrans"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/mcstrans-3.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14c28d3c429bc84947a04496052f1c438711efcb208045724ee58b96276cf250"

URI_mcstrans = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/mcstrans-3.8-1.el10.x86_64_v2.rpm;name=mcstrans;unpack=0"
SRC_URI += "${URI_mcstrans}"
SRC_URI[mcstrans.sha256sum] = "cd6b4b46d07024d13b8a3822602d751dced43cc17e5fc758791ac640be8f12c8"
RDEPENDS:mcstrans = " \
 systemd \
 libcap \
 bash \
 pcre2 \
 glibc \
 libselinux \
"
