# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "wsmancli"
PE = "0"
PV = "2.6.2"
PR = "5.el10"
PACKAGES = "wsmancli"
PROVIDES = "rpm/wsmancli"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/wsmancli-2.6.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "350d56c1ec816bf31bcea9cbb87424733dc8815abe86a43af05d852353520921"

URI_wsmancli = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/wsmancli-2.6.2-5.el10.x86_64_v2.rpm;name=wsmancli;unpack=0"
SRC_URI += "${URI_wsmancli}"
SRC_URI[wsmancli.sha256sum] = "e46083ac63071ac64fc527b6ab22ae1f795dd94f828384d95bc7d1fdb9987f4b"
RDEPENDS:wsmancli = " \
 glibc \
 libwsman1 \
 curl \
"
