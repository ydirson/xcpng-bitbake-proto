# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "authselect"
PE = "0"
PV = "1.5.0"
PR = "8.el10"
PACKAGES = "authselect authselect-libs authselect-devel"
PROVIDES = "rpm/authselect rpm/authselect-libs rpm/authselect-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/authselect-1.5.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48f76e4539314d4616b9d9563769ac73a48668346427ab56338167f1a26e2c76"

URI_authselect = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/authselect-1.5.0-8.el10.x86_64_v2.rpm;name=authselect;unpack=0"
SRC_URI += "${URI_authselect}"
SRC_URI[authselect.sha256sum] = "267319d3b3f834b684386531b0647d78f03eb10d759922a74d7d1d0906faeb4c"
RDEPENDS:authselect = " \
 glibc \
 authselect-libs \
 bash \
 popt \
"

URI_authselect-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/authselect-libs-1.5.0-8.el10.x86_64_v2.rpm;name=authselect-libs;unpack=0"
SRC_URI += "${URI_authselect-libs}"
SRC_URI[authselect-libs.sha256sum] = "a5fd09a48d4f5deff61bd7cdbacfbe7201c97d44cc74c64a629ea9469d3682cb"
RDEPENDS:authselect-libs = " \
 libselinux \
 bash \
 glibc \
 coreutils \
 sed \
"

URI_authselect-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/authselect-devel-1.5.0-8.el10.x86_64_v2.rpm;name=authselect-devel;unpack=0"
SRC_URI += "${URI_authselect-devel}"
SRC_URI[authselect-devel.sha256sum] = "7126bb16efcd6688b3b8972f35d688c688b7d888f98ce6aeda04ce6bba5ada15"
RDEPENDS:authselect-devel = " \
 authselect-libs \
 pkgconf-pkg-config \
"
