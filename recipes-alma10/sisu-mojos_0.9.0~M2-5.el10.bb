# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sisu-mojos"
PE = "0"
PV = "0.9.0~M2"
PR = "5.el10"
PACKAGES = "sisu-mojos sisu-mojos-javadoc"
PROVIDES = "rpm/sisu-mojos rpm/sisu-mojos-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/sisu-mojos-0.9.0~M2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6164567421633b1c90dd2ac3137620d14eb4f94a3510e30f0db71812ce1a41e1"

URI_sisu-mojos = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/sisu-mojos-0.9.0~M2-5.el10.noarch.rpm;name=sisu-mojos;unpack=0"
SRC_URI += "${URI_sisu-mojos}"
SRC_URI[sisu-mojos.sha256sum] = "a2b04ac97a5f4152390234309511cb713beea0e515c49f770b5d9504a4020589"
RDEPENDS:sisu-mojos = " \
 plexus-utils \
 javapackages-filesystem \
 sisu \
 maven-common-artifact-filters \
 plexus-build-api0 \
 slf4j \
"

URI_sisu-mojos-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/sisu-mojos-javadoc-0.9.0~M2-5.el10.noarch.rpm;name=sisu-mojos-javadoc;unpack=0"
SRC_URI += "${URI_sisu-mojos-javadoc}"
SRC_URI[sisu-mojos-javadoc.sha256sum] = "47215c0a718b25a2b19a5d380b820d960deab0fa68f2f1d387539af2cf104565"
RDEPENDS:sisu-mojos-javadoc = " \
 javapackages-filesystem \
"
