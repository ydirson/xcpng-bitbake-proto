# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "anthy-unicode"
PE = "0"
PV = "1.0.0.20240502"
PR = "12.el10"
PACKAGES = "anthy-unicode anthy-unicode-devel emacs-anthy-unicode"
PROVIDES = "rpm/anthy-unicode rpm/anthy-unicode-devel rpm/emacs-anthy-unicode"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/anthy-unicode-1.0.0.20240502-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c43761e03bf3a50a2a547e6a4aec70ca8257ead533dbd18a958c041d46a464e2"

URI_anthy-unicode = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/anthy-unicode-1.0.0.20240502-12.el10.x86_64_v2.rpm;name=anthy-unicode;unpack=0"
SRC_URI += "${URI_anthy-unicode}"
SRC_URI[anthy-unicode.sha256sum] = "af596386f79462869ecc4833fa0f9974c60bd42a907584f83b7b4b1b720b989a"
RDEPENDS:anthy-unicode = " \
 glibc \
"

URI_anthy-unicode-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/anthy-unicode-devel-1.0.0.20240502-12.el10.x86_64_v2.rpm;name=anthy-unicode-devel;unpack=0"
SRC_URI += "${URI_anthy-unicode-devel}"
SRC_URI[anthy-unicode-devel.sha256sum] = "a3072c5a819cb2fece678cd324ccb18ef5ba27f56a259431a230ae3ab00956f2"
RDEPENDS:anthy-unicode-devel = " \
 pkgconf-pkg-config \
 anthy-unicode \
"

URI_emacs-anthy-unicode = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/emacs-anthy-unicode-1.0.0.20240502-12.el10.noarch.rpm;name=emacs-anthy-unicode;unpack=0"
SRC_URI += "${URI_emacs-anthy-unicode}"
SRC_URI[emacs-anthy-unicode.sha256sum] = "7e6b64528d66460a749c68227164dbd954f5b14541019736f96eba79c38982a4"
RDEPENDS:emacs-anthy-unicode = " \
 emacs-filesystem \
 anthy-unicode \
"
