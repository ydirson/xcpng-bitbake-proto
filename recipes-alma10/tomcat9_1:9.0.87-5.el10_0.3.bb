# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tomcat9"
PE = "1"
PV = "9.0.87"
PR = "5.el10_0.3"
PACKAGES = "tomcat9 tomcat9-admin-webapps tomcat9-docs-webapp tomcat9-el-3.0-api tomcat9-jsp-2.3-api tomcat9-lib tomcat9-servlet-4.0-api tomcat9-webapps"
PROVIDES = "rpm/tomcat9 rpm/tomcat9-admin-webapps rpm/tomcat9-docs-webapp rpm/tomcat9-el-3.0-api rpm/tomcat9-jsp-2.3-api rpm/tomcat9-lib rpm/tomcat9-servlet-4.0-api rpm/tomcat9-webapps"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tomcat9-9.0.87-5.el10_0.3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df43a6b1f6cc2714cb0029a50ad0d398e5aa806af1e3692248bb76914cf5f7ac"

URI_tomcat9 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tomcat9-9.0.87-5.el10_0.3.noarch.rpm;name=tomcat9;unpack=0"
SRC_URI += "${URI_tomcat9}"
SRC_URI[tomcat9.sha256sum] = "e680cc721a750fbd0b6b99bbc96fd817d1d52a9aa3f370c4bdeb4c5f7c5e0f27"
RDEPENDS:tomcat9 = " \
 shadow-utils \
 systemd \
 javapackages-tools \
 tomcat9-lib \
 bash \
 java-21-openjdk-headless \
"

URI_tomcat9-admin-webapps = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tomcat9-admin-webapps-9.0.87-5.el10_0.3.noarch.rpm;name=tomcat9-admin-webapps;unpack=0"
SRC_URI += "${URI_tomcat9-admin-webapps}"
SRC_URI[tomcat9-admin-webapps.sha256sum] = "2d7520d20ea7b78a6fa23800e3a0c5baaa1de8a082f02be669b157955db65a0d"
RDEPENDS:tomcat9-admin-webapps = " \
 tomcat9 \
"

URI_tomcat9-docs-webapp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tomcat9-docs-webapp-9.0.87-5.el10_0.3.noarch.rpm;name=tomcat9-docs-webapp;unpack=0"
SRC_URI += "${URI_tomcat9-docs-webapp}"
SRC_URI[tomcat9-docs-webapp.sha256sum] = "52e8a6c6399b38fe760681235b8919d0b1e4e6d9bdf845ccf75c5f2474690d47"
RDEPENDS:tomcat9-docs-webapp = " \
 tomcat9 \
"

URI_tomcat9-el-3.0-api = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tomcat9-el-3.0-api-9.0.87-5.el10_0.3.noarch.rpm;name=tomcat9-el-3.0-api;unpack=0"
SRC_URI += "${URI_tomcat9-el-3.0-api}"
SRC_URI[tomcat9-el-3.0-api.sha256sum] = "405974ad48200fe52a4f69963b64323d79694de9d002789aa9f09d751ba53abd"
RDEPENDS:tomcat9-el-3.0-api = " \
 bash \
 javapackages-filesystem \
"

URI_tomcat9-jsp-2.3-api = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tomcat9-jsp-2.3-api-9.0.87-5.el10_0.3.noarch.rpm;name=tomcat9-jsp-2.3-api;unpack=0"
SRC_URI += "${URI_tomcat9-jsp-2.3-api}"
SRC_URI[tomcat9-jsp-2.3-api.sha256sum] = "98d12f79159a9233bf027574c3e05b6d1a90cc9aaa9d5d85e1cf42a1a3eb8023"
RDEPENDS:tomcat9-jsp-2.3-api = " \
 tomcat-el-3.0-api \
 javapackages-filesystem \
 tomcat-servlet-4.0-api \
 tomcat9-el-3.0-api \
 tomcat9-servlet-4.0-api \
 bash \
"

URI_tomcat9-lib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tomcat9-lib-9.0.87-5.el10_0.3.noarch.rpm;name=tomcat9-lib;unpack=0"
SRC_URI += "${URI_tomcat9-lib}"
SRC_URI[tomcat9-lib.sha256sum] = "595546b10039ab07d6daa5eebff15803444a0d88923275e03c6a0b9508d5a5a9"
RDEPENDS:tomcat9-lib = " \
 tomcat-el-3.0-api \
 javapackages-filesystem \
 tomcat-servlet-4.0-api \
 tomcat-jsp-2.3-api \
 tomcat9-el-3.0-api \
 tomcat9-jsp-2.3-api \
 ecj \
 tomcat9-servlet-4.0-api \
 coreutils \
"

URI_tomcat9-servlet-4.0-api = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tomcat9-servlet-4.0-api-9.0.87-5.el10_0.3.noarch.rpm;name=tomcat9-servlet-4.0-api;unpack=0"
SRC_URI += "${URI_tomcat9-servlet-4.0-api}"
SRC_URI[tomcat9-servlet-4.0-api.sha256sum] = "ba8d3466ff4ad274e3084accb553ee8b02a682e2d7af66333708c2e0e84de420"
RDEPENDS:tomcat9-servlet-4.0-api = " \
 bash \
 javapackages-filesystem \
"

URI_tomcat9-webapps = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tomcat9-webapps-9.0.87-5.el10_0.3.noarch.rpm;name=tomcat9-webapps;unpack=0"
SRC_URI += "${URI_tomcat9-webapps}"
SRC_URI[tomcat9-webapps.sha256sum] = "b98e648515cc9f01ab70110b9341603ebd8309b19ad6cccc3666f1cb98a7c2e1"
RDEPENDS:tomcat9-webapps = " \
 tomcat9 \
"
