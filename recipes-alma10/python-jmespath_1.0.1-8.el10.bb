# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-jmespath"
PE = "0"
PV = "1.0.1"
PR = "8.el10"
PACKAGES = "python3-jmespath"
PROVIDES = "rpm/python3-jmespath"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-jmespath-1.0.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa69d2a256665a4971e9303f37a45264be0fcee57ca94e944521f81514fa3d12"

URI_python3-jmespath = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-jmespath-1.0.1-8.el10.noarch.rpm;name=python3-jmespath;unpack=0"
SRC_URI += "${URI_python3-jmespath}"
SRC_URI[python3-jmespath.sha256sum] = "3f13c97801297ae411bef26603afc0fadc083fbf4dbbd2e94b777b540499f5f2"
RDEPENDS:python3-jmespath = " \
 python3 \
"
