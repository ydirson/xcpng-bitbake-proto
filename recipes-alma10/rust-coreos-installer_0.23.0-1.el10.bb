# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rust-coreos-installer"
PE = "0"
PV = "0.23.0"
PR = "1.el10"
PACKAGES = "coreos-installer coreos-installer-bootinfra coreos-installer-dracut"
PROVIDES = "rpm/coreos-installer rpm/coreos-installer-bootinfra rpm/coreos-installer-dracut"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/rust-coreos-installer-0.23.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a18c3212dabd7a73905e39c0c6275a75a9343af7541afddbb56d888a4cef75a"

URI_coreos-installer = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/coreos-installer-0.23.0-1.el10.x86_64_v2.rpm;name=coreos-installer;unpack=0"
SRC_URI += "${URI_coreos-installer}"
SRC_URI[coreos-installer.sha256sum] = "623f7247ba17001ec2096af62c65e1fca7e2c665dbe4c37790026493fac82107"
RDEPENDS:coreos-installer = " \
 gnupg2 \
 util-linux \
 systemd-udev \
 openssl-libs \
 libgcc \
 kpartx \
 libzstd \
 glibc \
 xz-libs \
"

URI_coreos-installer-bootinfra = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/coreos-installer-bootinfra-0.23.0-1.el10.x86_64_v2.rpm;name=coreos-installer-bootinfra;unpack=0"
SRC_URI += "${URI_coreos-installer-bootinfra}"
SRC_URI[coreos-installer-bootinfra.sha256sum] = "1e391bc75c28d192227e03d96cd48d3b0878772ee31d851051a159c656e52fd6"
RDEPENDS:coreos-installer-bootinfra = " \
 coreos-installer \
 openssl-libs \
 libgcc \
 libzstd \
 bash \
 glibc \
 xz-libs \
"

URI_coreos-installer-dracut = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/coreos-installer-dracut-0.23.0-1.el10.x86_64_v2.rpm;name=coreos-installer-dracut;unpack=0"
SRC_URI += "${URI_coreos-installer-dracut}"
SRC_URI[coreos-installer-dracut.sha256sum] = "ff50855acf532934a623c3555b7ba5db6882a7fa54e7de773255e14667ad7d80"
RDEPENDS:coreos-installer-dracut = " \
 coreos-installer \
 bash \
"
