# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libnxz"
PE = "0"
PV = "0.64"
PR = "8.el10"
PACKAGES = ""
PROVIDES = ""


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libnxz-0.64-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50879950a51e72f30833dcc2a5e7d7ba2df4de6665575c5c5dcd8a71f203266c"
