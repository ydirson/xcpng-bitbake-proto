# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "apache-commons-collections"
PE = "0"
PV = "3.2.2"
PR = "37.el10"
PACKAGES = "apache-commons-collections apache-commons-collections-javadoc apache-commons-collections-testframework"
PROVIDES = "rpm/apache-commons-collections rpm/apache-commons-collections-javadoc rpm/apache-commons-collections-testframework"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/apache-commons-collections-3.2.2-37.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbe8d085b37cfa0a18af2580a619ff2ae75dd17890b96fb1fa23b6f004f7e7a4"

URI_apache-commons-collections = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/apache-commons-collections-3.2.2-37.el10.noarch.rpm;name=apache-commons-collections;unpack=0"
SRC_URI += "${URI_apache-commons-collections}"
SRC_URI[apache-commons-collections.sha256sum] = "4cf4e3af6177a5de23a0d3390a82d4bc11e95dc9b7365aa8b1b87b7a65ef3d07"
RDEPENDS:apache-commons-collections = " \
 javapackages-filesystem \
"

URI_apache-commons-collections-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/apache-commons-collections-javadoc-3.2.2-37.el10.noarch.rpm;name=apache-commons-collections-javadoc;unpack=0"
SRC_URI += "${URI_apache-commons-collections-javadoc}"
SRC_URI[apache-commons-collections-javadoc.sha256sum] = "b267b62a07b154854525c16ed0292fad6eb0cf5f960d1e9b89398a36d9dd4618"
RDEPENDS:apache-commons-collections-javadoc = " \
 javapackages-filesystem \
"

URI_apache-commons-collections-testframework = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/apache-commons-collections-testframework-3.2.2-37.el10.noarch.rpm;name=apache-commons-collections-testframework;unpack=0"
SRC_URI += "${URI_apache-commons-collections-testframework}"
SRC_URI[apache-commons-collections-testframework.sha256sum] = "cdcbe8bd5c811ffb6b1cb9899707497a78f568eefe92cbd6b2170855b2285d94"
RDEPENDS:apache-commons-collections-testframework = " \
 apache-commons-collections \
 javapackages-filesystem \
"
