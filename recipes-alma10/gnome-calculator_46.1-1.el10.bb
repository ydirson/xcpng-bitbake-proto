# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-calculator"
PE = "0"
PV = "46.1"
PR = "1.el10"
PACKAGES = "gnome-calculator gnome-calculator-devel"
PROVIDES = "rpm/gnome-calculator rpm/gnome-calculator-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-calculator-46.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bacfa37f821932d33ae73aa30d7d4bc2d083ffb84bdf6e5514cb89e23a1b64c4"

URI_gnome-calculator = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-calculator-46.1-1.el10.x86_64_v2.rpm;name=gnome-calculator;unpack=0"
SRC_URI += "${URI_gnome-calculator}"
SRC_URI[gnome-calculator.sha256sum] = "369d1f08c776d7bd92c9567ef1c30218e74996d80d01c08c614bdc036b5bdd38"
RDEPENDS:gnome-calculator = " \
 libgee \
 libsoup3 \
 mpfr \
 libxml2 \
 libmpc \
 glib2 \
 glibc \
 gtk4 \
 libadwaita \
 gtksourceview5 \
"

URI_gnome-calculator-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gnome-calculator-devel-46.1-1.el10.x86_64_v2.rpm;name=gnome-calculator-devel;unpack=0"
SRC_URI += "${URI_gnome-calculator-devel}"
SRC_URI[gnome-calculator-devel.sha256sum] = "edcadff5b8eb074eea7441ab02b77c162d9537240200b0f691fbc24e1d929fa3"
RDEPENDS:gnome-calculator-devel = " \
 gnome-calculator \
 glib2-devel \
 libgee-devel \
 pkgconf-pkg-config \
 gnome-calculator-devel \
 gtk4-devel \
"
