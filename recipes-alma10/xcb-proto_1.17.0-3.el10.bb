# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xcb-proto"
PE = "0"
PV = "1.17.0"
PR = "3.el10"
PACKAGES = "xcb-proto"
PROVIDES = "rpm/xcb-proto"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/xcb-proto-1.17.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e97c350d031689f5a031ac025801c2d58205dc392f5e0b91be4c866e4118ae7"

URI_xcb-proto = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xcb-proto-1.17.0-3.el10.noarch.rpm;name=xcb-proto;unpack=0"
SRC_URI += "${URI_xcb-proto}"
SRC_URI[xcb-proto.sha256sum] = "5af6131f5c37d378aaed75fb15cc723b9a7b17a6df0c11490d03eb1cf1595cda"
RDEPENDS:xcb-proto = " \
 python3 \
 pkgconf-pkg-config \
"
