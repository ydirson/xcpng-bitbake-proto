# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-ply"
PE = "0"
PV = "3.11"
PR = "25.el10"
PACKAGES = "python3-ply"
PROVIDES = "rpm/python3-ply"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/python-ply-3.11-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e95c02169137b128c3c5e696809e5041f4e4bf97c2f7cb266d98b0b78e47723"

URI_python3-ply = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-ply-3.11-25.el10.noarch.rpm;name=python3-ply;unpack=0"
SRC_URI += "${URI_python3-ply}"
SRC_URI[python3-ply.sha256sum] = "61025082f63457b66205a4894e078296c117ab4d0878dcc3b8ab0bdc54cda23a"
RDEPENDS:python3-ply = " \
 python3 \
"
