# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "antlr"
PE = "0"
PV = "2.7.7"
PR = "79.el10"
PACKAGES = "antlr-tool antlr-C++ antlr-javadoc antlr-manual"
PROVIDES = "rpm/antlr-tool rpm/antlr-C++ rpm/antlr-javadoc rpm/antlr-manual"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/antlr-2.7.7-79.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8596ac60908b0eeaea06b695de07d84b3a5b264591d7e06dcd8770db4f0b2140"

URI_antlr-tool = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/antlr-tool-2.7.7-79.el10.noarch.rpm;name=antlr-tool;unpack=0"
SRC_URI += "${URI_antlr-tool}"
SRC_URI[antlr-tool.sha256sum] = "cfce639ae1f1484afabcb82d705e09ad048e414e1e91ce95d48fbf8a16b434a0"
RDEPENDS:antlr-tool = " \
 bash \
 javapackages-filesystem \
 javapackages-tools \
"

URI_antlr-C++ = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/antlr-C++-2.7.7-79.el10.x86_64_v2.rpm;name=antlr-C++;unpack=0"
SRC_URI += "${URI_antlr-C++}"
SRC_URI[antlr-C++.sha256sum] = "a179d84302b2c7898b3206fab7540800e74fcd5b55526944affef6d8e6eb6396"
RDEPENDS:antlr-C++ = " \
 bash \
"

URI_antlr-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/antlr-javadoc-2.7.7-79.el10.noarch.rpm;name=antlr-javadoc;unpack=0"
SRC_URI += "${URI_antlr-javadoc}"
SRC_URI[antlr-javadoc.sha256sum] = "5171a64ce6a9b560d841ae82343973e9d9fabed52c8c27d245322ca929a95389"
RDEPENDS:antlr-javadoc = " \
 javapackages-filesystem \
"

URI_antlr-manual = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/antlr-manual-2.7.7-79.el10.noarch.rpm;name=antlr-manual;unpack=0"
SRC_URI += "${URI_antlr-manual}"
SRC_URI[antlr-manual.sha256sum] = "3460d4bb8ac3da3369dbd619b14bfeda7c9073228a9eb5e8eae574ce85c38372"
RDEPENDS:antlr-manual = ""
