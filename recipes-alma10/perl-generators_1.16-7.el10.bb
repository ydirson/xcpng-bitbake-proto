# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-generators"
PE = "0"
PV = "1.16"
PR = "7.el10"
PACKAGES = "perl-generators perl-generators-tests"
PROVIDES = "rpm/perl-generators rpm/perl-generators-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-generators-1.16-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "459b710bbb40108e7f53a6e842dca2126ef1e1364f3dfef875332f2f40f9db14"

URI_perl-generators = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-generators-1.16-7.el10.noarch.rpm;name=perl-generators;unpack=0"
SRC_URI += "${URI_perl-generators}"
SRC_URI[perl-generators.sha256sum] = "7f7a1d8f0f601a748f7f184b31894447ffd03be71735a0648514a015654a0be7"
RDEPENDS:perl-generators = " \
 perl-interpreter \
 perl-macros \
 perl-Fedora-VSP \
 perl-File-Basename \
"

URI_perl-generators-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-generators-tests-1.16-7.el10.noarch.rpm;name=perl-generators-tests;unpack=0"
SRC_URI += "${URI_perl-generators-tests}"
SRC_URI[perl-generators-tests.sha256sum] = "b729946c4816c6e45a86b69aa74cf6b2e765e03c245a157e28690c75d96305aa"
RDEPENDS:perl-generators-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 bash \
 perl-generators \
 perl-interpreter \
 perl-Exporter \
 perl-lib \
"
