# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ocaml-ocamlbuild"
PE = "0"
PV = "0.14.3"
PR = "7.el10"
PACKAGES = "ocaml-ocamlbuild ocaml-ocamlbuild-doc"
PROVIDES = "rpm/ocaml-ocamlbuild rpm/ocaml-ocamlbuild-doc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/ocaml-ocamlbuild-0.14.3-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f406fd00abb66bdeea092e430209ab525cc1f30651fc33dda7626106259906c"

URI_ocaml-ocamlbuild = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-ocamlbuild-0.14.3-7.el10.x86_64_v2.rpm;name=ocaml-ocamlbuild;unpack=0"
SRC_URI += "${URI_ocaml-ocamlbuild}"
SRC_URI[ocaml-ocamlbuild.sha256sum] = "bab9423cb5e9b1b4b91b369fc4d0c80f3cc93d3af33bd0b75998ea272d421183"
RDEPENDS:ocaml-ocamlbuild = " \
 glibc \
 ocaml-runtime \
 ncurses \
 ocaml \
"

URI_ocaml-ocamlbuild-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-ocamlbuild-doc-0.14.3-7.el10.noarch.rpm;name=ocaml-ocamlbuild-doc;unpack=0"
SRC_URI += "${URI_ocaml-ocamlbuild-doc}"
SRC_URI[ocaml-ocamlbuild-doc.sha256sum] = "c20cb4e365f5b63e8ae3272b64eefef20eef4acce1d8133386d6c52eef459292"
RDEPENDS:ocaml-ocamlbuild-doc = ""
