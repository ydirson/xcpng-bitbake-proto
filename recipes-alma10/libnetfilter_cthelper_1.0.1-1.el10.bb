# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libnetfilter_cthelper"
PE = "0"
PV = "1.0.1"
PR = "1.el10"
PACKAGES = "libnetfilter_cthelper libnetfilter_cthelper-devel"
PROVIDES = "rpm/libnetfilter_cthelper rpm/libnetfilter_cthelper-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libnetfilter_cthelper-1.0.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2159ae30ba6da3f3395c061242c9a854d6bae6da6ddee47fe2ed147c31b2dce2"

URI_libnetfilter_cthelper = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libnetfilter_cthelper-1.0.1-1.el10.x86_64_v2.rpm;name=libnetfilter_cthelper;unpack=0"
SRC_URI += "${URI_libnetfilter_cthelper}"
SRC_URI[libnetfilter_cthelper.sha256sum] = "bc74220c16615879fe566fb765679f9e285a6f0cf28bb52dea26223a2bed3e28"
RDEPENDS:libnetfilter_cthelper = " \
 glibc \
 libmnl \
"

URI_libnetfilter_cthelper-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libnetfilter_cthelper-devel-1.0.1-1.el10.x86_64_v2.rpm;name=libnetfilter_cthelper-devel;unpack=0"
SRC_URI += "${URI_libnetfilter_cthelper-devel}"
SRC_URI[libnetfilter_cthelper-devel.sha256sum] = "a70375ca7fddf5910323dd7d99fb3d9c2429dc857e8b78db501714922f209d81"
RDEPENDS:libnetfilter_cthelper-devel = " \
 libnetfilter_cthelper \
 kernel-headers \
 pkgconf-pkg-config \
 libmnl-devel \
"
