# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rit-meera-new-fonts"
PE = "0"
PV = "1.5.2"
PR = "6.el10"
PACKAGES = "rit-meera-new-fonts"
PROVIDES = "rpm/rit-meera-new-fonts"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/rit-meera-new-fonts-1.5.2-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a932e7d356a09db1868164597bcdfd529ec1211d04731c596d89e194eb725106"

URI_rit-meera-new-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rit-meera-new-fonts-1.5.2-6.el10.noarch.rpm;name=rit-meera-new-fonts;unpack=0"
SRC_URI += "${URI_rit-meera-new-fonts}"
SRC_URI[rit-meera-new-fonts.sha256sum] = "2e8db368b2b6712932c40c69687e74683838de54d04dfc08fd728d4674bf0a34"
RDEPENDS:rit-meera-new-fonts = " \
 fonts-filesystem \
"
