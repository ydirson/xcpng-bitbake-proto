# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-cffi"
PE = "0"
PV = "1.16.0"
PR = "7.el10"
PACKAGES = "python3-cffi python-cffi-doc"
PROVIDES = "rpm/python3-cffi rpm/python-cffi-doc"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/python-cffi-1.16.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5917cf38c447dc9dd6432280a96540c37a574fcef4ca9c3077070d365aff85ba"

URI_python3-cffi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-cffi-1.16.0-7.el10.x86_64_v2.rpm;name=python3-cffi;unpack=0"
SRC_URI += "${URI_python3-cffi}"
SRC_URI[python3-cffi.sha256sum] = "51879dadbf8008fbdd0cdee067a7031d6a4f8147d5fc543384b1e4fe482cf51c"
RDEPENDS:python3-cffi = " \
 glibc \
 libffi \
 python3 \
 python3-pycparser \
"

URI_python-cffi-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python-cffi-doc-1.16.0-7.el10.noarch.rpm;name=python-cffi-doc;unpack=0"
SRC_URI += "${URI_python-cffi-doc}"
SRC_URI[python-cffi-doc.sha256sum] = "42299a39a1f5b8af46c19ea496e3709f7fdc7b10635739ec4791250af7e14c4a"
RDEPENDS:python-cffi-doc = ""
