# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-ss"
PE = "0"
PV = "0.20091030"
PR = "32.el10"
PACKAGES = "hunspell-ss"
PROVIDES = "rpm/hunspell-ss"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-ss-0.20091030-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4d4386e3e1e89905c189bc9fe6d14899cd6bfc12ef62a0e5209e3903985752d"

URI_hunspell-ss = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-ss-0.20091030-32.el10.noarch.rpm;name=hunspell-ss;unpack=0"
SRC_URI += "${URI_hunspell-ss}"
SRC_URI[hunspell-ss.sha256sum] = "33be38445a8d0fca975af599318af7e286c0f868d03167d619a2d7d0087cd9f7"
RDEPENDS:hunspell-ss = " \
 hunspell \
"
