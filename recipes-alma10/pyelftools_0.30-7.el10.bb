# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pyelftools"
PE = "0"
PV = "0.30"
PR = "7.el10"
PACKAGES = "python3-pyelftools"
PROVIDES = "rpm/python3-pyelftools"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/pyelftools-0.30-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87dc17216a9fc985d33a5c9e1ec62e995116f585a881b5ace6b77ad916f05bae"

URI_python3-pyelftools = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-pyelftools-0.30-7.el10.noarch.rpm;name=python3-pyelftools;unpack=0"
SRC_URI += "${URI_python3-pyelftools}"
SRC_URI[python3-pyelftools.sha256sum] = "3d55af27509a2a5cdc000c9a997913088cf0a8a6eaf6ef5b54a0af7710e8db4a"
RDEPENDS:python3-pyelftools = " \
 python3 \
"
