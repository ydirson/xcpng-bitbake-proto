# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-eo"
PE = "1"
PV = "0.20100218"
PR = "17.el10"
PACKAGES = "hunspell-eo"
PROVIDES = "rpm/hunspell-eo"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-eo-0.20100218-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2391e1a4743ae5cf9d41b5d5e751fcea7e109d8791191250bfbf2fc08cab7031"

URI_hunspell-eo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-eo-0.20100218-17.el10.noarch.rpm;name=hunspell-eo;unpack=0"
SRC_URI += "${URI_hunspell-eo}"
SRC_URI[hunspell-eo.sha256sum] = "5585dc7064c1b2c8db89f5a0296a772c44034ef3fd5ecd7bee696a120ae7bd8f"
RDEPENDS:hunspell-eo = " \
 hunspell-filesystem \
"
