# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "criu"
PE = "0"
PV = "3.19"
PR = "9.el10"
PACKAGES = "crit criu criu-libs python3-criu criu-devel criu-ns"
PROVIDES = "rpm/crit rpm/criu rpm/criu-libs rpm/python3-criu rpm/criu-devel rpm/criu-ns"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/criu-3.19-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "332df82619270c83fc14f8dcda266cee91c64bfdf45b00e5ff0c887aa08159de"

URI_crit = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/crit-3.19-9.el10.x86_64_v2.rpm;name=crit;unpack=0"
SRC_URI += "${URI_crit}"
SRC_URI[crit.sha256sum] = "a2748dfd8b14d79ac9d93e3c65ebabcdfe0a7d782f879aa871b7effe7d0eed53"
RDEPENDS:crit = " \
 python3 \
 python3-criu \
"

URI_criu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/criu-3.19-9.el10.x86_64_v2.rpm;name=criu;unpack=0"
SRC_URI += "${URI_criu}"
SRC_URI[criu.sha256sum] = "fdc217ff3a50614560a95f3dd5678db8d0ff125499a7d0d74b2f7c3f6763cdc5"
RDEPENDS:criu = " \
 libuuid \
 nftables \
 gnutls \
 libgcc \
 libnl3 \
 bash \
 libnet \
 glibc \
 libselinux \
 protobuf-c \
"

URI_criu-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/criu-libs-3.19-9.el10.x86_64_v2.rpm;name=criu-libs;unpack=0"
SRC_URI += "${URI_criu-libs}"
SRC_URI[criu-libs.sha256sum] = "13cc444d244ad74d9e710ca82801c0ef5849c636e11305a21a1eb8ca453d51bc"
RDEPENDS:criu-libs = " \
 glibc \
 protobuf-c \
 criu \
"

URI_python3-criu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-criu-3.19-9.el10.x86_64_v2.rpm;name=python3-criu;unpack=0"
SRC_URI += "${URI_python3-criu}"
SRC_URI[python3-criu.sha256sum] = "7f457ccb3b162ed37b5d50379e7598846b787507ef21be9b25ec429b70e1d58f"
RDEPENDS:python3-criu = " \
 python3 \
 python3-protobuf \
"

URI_criu-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/criu-devel-3.19-9.el10.x86_64_v2.rpm;name=criu-devel;unpack=0"
SRC_URI += "${URI_criu-devel}"
SRC_URI[criu-devel.sha256sum] = "8917c74360a62dcf2b251840c8f28dbddaab93ba4e1598e2afdb8bc6bfc1c20e"
RDEPENDS:criu-devel = " \
 criu \
 criu-libs \
 protobuf-c-devel \
 pkgconf-pkg-config \
"

URI_criu-ns = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/criu-ns-3.19-9.el10.x86_64_v2.rpm;name=criu-ns;unpack=0"
SRC_URI += "${URI_criu-ns}"
SRC_URI[criu-ns.sha256sum] = "751520a23df18014c7f75b349824b019737fe8159667aa2311ac6df7c0a8f7ac"
RDEPENDS:criu-ns = " \
 python3 \
 criu \
"
