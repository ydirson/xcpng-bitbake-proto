# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xdg-desktop-portal-gtk"
PE = "0"
PV = "1.15.1"
PR = "8.el10"
PACKAGES = "xdg-desktop-portal-gtk"
PROVIDES = "rpm/xdg-desktop-portal-gtk"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xdg-desktop-portal-gtk-1.15.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a0559b76170fec18803fcfc088f388e03aea8446552abfc73098b7c69729af7"

URI_xdg-desktop-portal-gtk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xdg-desktop-portal-gtk-1.15.1-8.el10.x86_64_v2.rpm;name=xdg-desktop-portal-gtk;unpack=0"
SRC_URI += "${URI_xdg-desktop-portal-gtk}"
SRC_URI[xdg-desktop-portal-gtk.sha256sum] = "1c999a031af25a6ef83abfa080a41092dd9b59687abb6851b3eef6b46ed1c818"
RDEPENDS:xdg-desktop-portal-gtk = " \
 xdg-desktop-portal \
 gsettings-desktop-schemas \
 libgcc \
 fontconfig \
 gdk-pixbuf2 \
 bash \
 glib2 \
 gtk3 \
 dbus \
 glibc \
"
