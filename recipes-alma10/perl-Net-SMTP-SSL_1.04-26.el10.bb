# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Net-SMTP-SSL"
PE = "0"
PV = "1.04"
PR = "26.el10"
PACKAGES = "perl-Net-SMTP-SSL perl-Net-SMTP-SSL-tests"
PROVIDES = "rpm/perl-Net-SMTP-SSL rpm/perl-Net-SMTP-SSL-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Net-SMTP-SSL-1.04-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9408e602e82f65cf2bfafc1d1ffe0a2acc7b5dbba2d111c7d6e0f4435406cfd"

URI_perl-Net-SMTP-SSL = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Net-SMTP-SSL-1.04-26.el10.noarch.rpm;name=perl-Net-SMTP-SSL;unpack=0"
SRC_URI += "${URI_perl-Net-SMTP-SSL}"
SRC_URI[perl-Net-SMTP-SSL.sha256sum] = "1a9c493183b6b05b654de681e3d4bb955e8ab5f85bde3e7144cbf1ccd939be41"
RDEPENDS:perl-Net-SMTP-SSL = " \
 perl-libnet \
 perl-libs \
 perl-IO-Socket-SSL \
"

URI_perl-Net-SMTP-SSL-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Net-SMTP-SSL-tests-1.04-26.el10.noarch.rpm;name=perl-Net-SMTP-SSL-tests;unpack=0"
SRC_URI += "${URI_perl-Net-SMTP-SSL-tests}"
SRC_URI[perl-Net-SMTP-SSL-tests.sha256sum] = "7332f9baa817e79051b1119682e0c8bfc06341bbaad1a0032a50cf46830194d2"
RDEPENDS:perl-Net-SMTP-SSL-tests = " \
 perl-Test-Harness \
 perl-Test-Simple \
 bash \
 perl-interpreter \
 perl-Net-SMTP-SSL \
"
