# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "osgi-compendium"
PE = "0"
PV = "7.0.0"
PR = "21.el10"
PACKAGES = "osgi-compendium osgi-compendium-javadoc"
PROVIDES = "rpm/osgi-compendium rpm/osgi-compendium-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/osgi-compendium-7.0.0-21.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96eaeb18df149556604bf8ef8618fa493717b323a5563079cab4dec503d5eb91"

URI_osgi-compendium = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/osgi-compendium-7.0.0-21.el10.noarch.rpm;name=osgi-compendium;unpack=0"
SRC_URI += "${URI_osgi-compendium}"
SRC_URI[osgi-compendium.sha256sum] = "32f31269ef0124954455977518d062d73410f516c310322cc3ea8caf60d6f6d7"
RDEPENDS:osgi-compendium = " \
 javapackages-filesystem \
"

URI_osgi-compendium-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/osgi-compendium-javadoc-7.0.0-21.el10.noarch.rpm;name=osgi-compendium-javadoc;unpack=0"
SRC_URI += "${URI_osgi-compendium-javadoc}"
SRC_URI[osgi-compendium-javadoc.sha256sum] = "291f017c8d3fa93a868ac9227ba7f6834cdd089046acfa4295b72d6bd637a36e"
RDEPENDS:osgi-compendium-javadoc = " \
 javapackages-filesystem \
"
