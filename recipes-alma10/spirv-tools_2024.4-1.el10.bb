# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "spirv-tools"
PE = "0"
PV = "2024.4"
PR = "1.el10"
PACKAGES = "spirv-tools spirv-tools-libs spirv-tools-devel"
PROVIDES = "rpm/spirv-tools rpm/spirv-tools-libs rpm/spirv-tools-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/spirv-tools-2024.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28c3364c7de8a6ae9eec4ffa5b2a88b2b82b3d6920f4332729cf72d6791d82b0"

URI_spirv-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/spirv-tools-2024.4-1.el10.x86_64_v2.rpm;name=spirv-tools;unpack=0"
SRC_URI += "${URI_spirv-tools}"
SRC_URI[spirv-tools.sha256sum] = "4a786f609617b470eb22a15312dab1bda937d74e37eccc74520e65cb9fffa2b4"
RDEPENDS:spirv-tools = " \
 glibc \
 spirv-tools-libs \
 libstdc++ \
 bash \
"

URI_spirv-tools-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/spirv-tools-libs-2024.4-1.el10.x86_64_v2.rpm;name=spirv-tools-libs;unpack=0"
SRC_URI += "${URI_spirv-tools-libs}"
SRC_URI[spirv-tools-libs.sha256sum] = "1aa652233bc6cfebe5e5aa60c3ccfbda91643d91a476d242916ddfa4a45e5cba"
RDEPENDS:spirv-tools-libs = " \
 glibc \
 libstdc++ \
"

URI_spirv-tools-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/spirv-tools-devel-2024.4-1.el10.x86_64_v2.rpm;name=spirv-tools-devel;unpack=0"
SRC_URI += "${URI_spirv-tools-devel}"
SRC_URI[spirv-tools-devel.sha256sum] = "23f07842592fcb0405641bc740275d6035515a67c28f36a082305375c34cc58d"
RDEPENDS:spirv-tools-devel = " \
 spirv-tools-libs \
 cmake-filesystem \
 pkgconf-pkg-config \
"
