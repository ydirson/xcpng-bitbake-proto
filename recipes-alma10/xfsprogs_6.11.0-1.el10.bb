# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xfsprogs"
PE = "0"
PV = "6.11.0"
PR = "1.el10"
PACKAGES = "xfsprogs xfsprogs-devel xfsprogs-xfs_scrub"
PROVIDES = "rpm/xfsprogs rpm/xfsprogs-devel rpm/xfsprogs-xfs_scrub"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/xfsprogs-6.11.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da1f87414035e90b6db25e1a45e988215413684577c4d5276c64af83db81647a"

URI_xfsprogs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/xfsprogs-6.11.0-1.el10.x86_64_v2.rpm;name=xfsprogs;unpack=0"
SRC_URI += "${URI_xfsprogs}"
SRC_URI[xfsprogs.sha256sum] = "71e6d0222e84eaa8950c113f4d2b61177cae9ada8da908e3b4f7f01116016ccc"
RDEPENDS:xfsprogs = " \
 libuuid \
 userspace-rcu \
 libblkid \
 bash \
 inih \
 glibc \
 libedit \
"

URI_xfsprogs-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xfsprogs-devel-6.11.0-1.el10.x86_64_v2.rpm;name=xfsprogs-devel;unpack=0"
SRC_URI += "${URI_xfsprogs-devel}"
SRC_URI[xfsprogs-devel.sha256sum] = "372ef1197442bb42a02e090f53bdfccc4e9e1dc8d42c3e889ae2129afbf4cb23"
RDEPENDS:xfsprogs-devel = " \
 libuuid-devel \
 xfsprogs \
"

URI_xfsprogs-xfs_scrub = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xfsprogs-xfs_scrub-6.11.0-1.el10.x86_64_v2.rpm;name=xfsprogs-xfs_scrub;unpack=0"
SRC_URI += "${URI_xfsprogs-xfs_scrub}"
SRC_URI[xfsprogs-xfs_scrub.sha256sum] = "6462d7f012e47decd8d2bfa76bfaae8ef507cedbfcd9768e06c43ccffbda7f62"
RDEPENDS:xfsprogs-xfs_scrub = " \
 python3 \
 userspace-rcu \
 util-linux \
 bash \
 glibc \
 libicu \
 xfsprogs \
"
