# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "unixODBC"
PE = "0"
PV = "2.3.12"
PR = "6.el10"
PACKAGES = "unixODBC unixODBC-devel"
PROVIDES = "rpm/unixODBC rpm/unixODBC-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/unixODBC-2.3.12-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc704cf42ee1d5ad81836472a3c779da6964a954b405cb94b13b3e647da85756"

URI_unixODBC = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/unixODBC-2.3.12-6.el10.x86_64_v2.rpm;name=unixODBC;unpack=0"
SRC_URI += "${URI_unixODBC}"
SRC_URI[unixODBC.sha256sum] = "abf51730446d7c489df84ce8e4999213b5de66a2a1af48b7093c4a92355e7f44"
RDEPENDS:unixODBC = " \
 glibc \
 readline \
 libtool-ltdl \
"

URI_unixODBC-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/unixODBC-devel-2.3.12-6.el10.x86_64_v2.rpm;name=unixODBC-devel;unpack=0"
SRC_URI += "${URI_unixODBC-devel}"
SRC_URI[unixODBC-devel.sha256sum] = "a11d2be9a1133863e22e342e85fc5fa2c55ab90bc2412ada5be6f911d16d2d56"
RDEPENDS:unixODBC-devel = " \
 unixODBC-devel \
 unixODBC \
 pkgconf-pkg-config \
"
