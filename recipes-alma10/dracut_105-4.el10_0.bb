# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dracut"
PE = "0"
PV = "105"
PR = "4.el10_0"
PACKAGES = "dracut dracut-config-generic dracut-config-rescue dracut-network dracut-squash dracut-tools dracut-caps dracut-live"
PROVIDES = "rpm/dracut rpm/dracut-config-generic rpm/dracut-config-rescue rpm/dracut-network rpm/dracut-squash rpm/dracut-tools rpm/dracut-caps rpm/dracut-live"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/dracut-105-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0ea781467194453227afca99969ae5ca7a309a3e4ddac57c92f14b432ec5c26"

URI_dracut = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/dracut-105-4.el10_0.x86_64_v2.rpm;name=dracut;unpack=0"
SRC_URI += "${URI_dracut}"
SRC_URI[dracut.sha256sum] = "a4157e5e445f04bb46b7609afbf2c824051d7c75cd41332d1f86c9293cc734e3"
RDEPENDS:dracut = " \
 systemd \
 kmod \
 kmod-libs \
 systemd-udev \
 util-linux \
 sed \
 xz \
 openssl-libs \
 libgcc \
 grep \
 bash \
 filesystem \
 findutils \
 glibc \
 libkcapi-hmaccalc \
 gzip \
 procps-ng \
 coreutils \
 cpio \
"

URI_dracut-config-generic = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/dracut-config-generic-105-4.el10_0.x86_64_v2.rpm;name=dracut-config-generic;unpack=0"
SRC_URI += "${URI_dracut-config-generic}"
SRC_URI[dracut-config-generic.sha256sum] = "2c2396d980569ebf1dcb9a30b99d89a1322f079e1f4422c0f972caf12613be14"
RDEPENDS:dracut-config-generic = " \
 dracut \
"

URI_dracut-config-rescue = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/dracut-config-rescue-105-4.el10_0.x86_64_v2.rpm;name=dracut-config-rescue;unpack=0"
SRC_URI += "${URI_dracut-config-rescue}"
SRC_URI[dracut-config-rescue.sha256sum] = "0e5ef4f35c83c8ec2450c665f009344bb8fe9caa9a8ee5f8692d410ec8419fbf"
RDEPENDS:dracut-config-rescue = " \
 bash \
 dracut \
"

URI_dracut-network = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/dracut-network-105-4.el10_0.x86_64_v2.rpm;name=dracut-network;unpack=0"
SRC_URI += "${URI_dracut-network}"
SRC_URI[dracut-network.sha256sum] = "9747c9cca4dbfe52b6640940afe61aa630a17313b8ec56f148c9402a95f37450"
RDEPENDS:dracut-network = " \
 iproute \
 NetworkManager \
 jq \
 iputils \
 bash \
 dracut \
"

URI_dracut-squash = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/dracut-squash-105-4.el10_0.x86_64_v2.rpm;name=dracut-squash;unpack=0"
SRC_URI += "${URI_dracut-squash}"
SRC_URI[dracut-squash.sha256sum] = "0bcec9bc04d8d733003e3607df354a5a6223c7bec5910e503afaa362e75377ef"
RDEPENDS:dracut-squash = " \
 erofs-utils \
 bash \
 dracut \
"

URI_dracut-tools = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/dracut-tools-105-4.el10_0.x86_64_v2.rpm;name=dracut-tools;unpack=0"
SRC_URI += "${URI_dracut-tools}"
SRC_URI[dracut-tools.sha256sum] = "c031fd26822e708ae760bc4e50011f0624d8de822f7ca2c861387bdcd36c2de9"
RDEPENDS:dracut-tools = " \
 bash \
 dracut \
"

URI_dracut-caps = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dracut-caps-105-4.el10_0.x86_64_v2.rpm;name=dracut-caps;unpack=0"
SRC_URI += "${URI_dracut-caps}"
SRC_URI[dracut-caps.sha256sum] = "21b5d001d505bc79e06cfca69a41b45b03179ef9f72073e58864660e1c99b370"
RDEPENDS:dracut-caps = " \
 bash \
 dracut \
 libcap \
"

URI_dracut-live = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dracut-live-105-4.el10_0.x86_64_v2.rpm;name=dracut-live;unpack=0"
SRC_URI += "${URI_dracut-live}"
SRC_URI[dracut-live.sha256sum] = "0629f98dd285ff48d4616ae7e4064608d6dcfeb3d37e31cb8a12a115dbb59667"
RDEPENDS:dracut-live = " \
 device-mapper \
 gzip \
 tar \
 curl \
 parted \
 bash \
 dracut \
 dracut-network \
 coreutils \
"
