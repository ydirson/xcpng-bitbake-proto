# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libksba"
PE = "0"
PV = "1.6.7"
PR = "2.el10"
PACKAGES = "libksba libksba-devel"
PROVIDES = "rpm/libksba rpm/libksba-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libksba-1.6.7-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a38d598597fb50c51ffc8beb35a6f824ad8020000b0c7e2de1f8377bc3404a70"

URI_libksba = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libksba-1.6.7-2.el10.x86_64_v2.rpm;name=libksba;unpack=0"
SRC_URI += "${URI_libksba}"
SRC_URI[libksba.sha256sum] = "fc734db4e771e84015687cf90810aebf2e9c6ba7d157f12cf13b01c5c282550e"
RDEPENDS:libksba = " \
 glibc \
 libgpg-error \
"

URI_libksba-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libksba-devel-1.6.7-2.el10.x86_64_v2.rpm;name=libksba-devel;unpack=0"
SRC_URI += "${URI_libksba-devel}"
SRC_URI[libksba-devel.sha256sum] = "d9cb7add9d645839ddfc0a996dcf489b3ee19453aa1c95079798b1be9630a532"
RDEPENDS:libksba-devel = " \
 libksba \
 libgpg-error-devel \
 bash \
 pkgconf-pkg-config \
"
