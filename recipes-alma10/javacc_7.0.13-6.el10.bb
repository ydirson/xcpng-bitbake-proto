# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "javacc"
PE = "0"
PV = "7.0.13"
PR = "6.el10"
PACKAGES = "javacc javacc-demo javacc-javadoc javacc-manual"
PROVIDES = "rpm/javacc rpm/javacc-demo rpm/javacc-javadoc rpm/javacc-manual"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/javacc-7.0.13-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3e6996c310c0cf2f37979aa548d2c45d424e295d62865a06bda76cd1c403514"

URI_javacc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/javacc-7.0.13-6.el10.noarch.rpm;name=javacc;unpack=0"
SRC_URI += "${URI_javacc}"
SRC_URI[javacc.sha256sum] = "d12c5a1fbe275c4da8068e32a295f545c69c9e41497c1924734efcf1166b332d"
RDEPENDS:javacc = " \
 bash \
 javapackages-filesystem \
 javapackages-tools \
"

URI_javacc-demo = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/javacc-demo-7.0.13-6.el10.noarch.rpm;name=javacc-demo;unpack=0"
SRC_URI += "${URI_javacc-demo}"
SRC_URI[javacc-demo.sha256sum] = "4c55f114520fa8db5a5f860dc3e00d7e8a0614f03417190c9c7967c2612c937f"
RDEPENDS:javacc-demo = " \
 javacc \
"

URI_javacc-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/javacc-javadoc-7.0.13-6.el10.noarch.rpm;name=javacc-javadoc;unpack=0"
SRC_URI += "${URI_javacc-javadoc}"
SRC_URI[javacc-javadoc.sha256sum] = "1de599869b101f2471c69d406368afa3f5586add4cc28cf9aaea1c864d86be65"
RDEPENDS:javacc-javadoc = " \
 javapackages-filesystem \
"

URI_javacc-manual = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/javacc-manual-7.0.13-6.el10.noarch.rpm;name=javacc-manual;unpack=0"
SRC_URI += "${URI_javacc-manual}"
SRC_URI[javacc-manual.sha256sum] = "c2499addef54f8a86d66c88e8d17e2d51712bc35b412c6d0e23d3d9aaa1898cd"
RDEPENDS:javacc-manual = ""
