# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pmix"
PE = "0"
PV = "4.2.8"
PR = "8.el10"
PACKAGES = "pmix pmix-devel pmix-tools"
PROVIDES = "rpm/pmix rpm/pmix-devel rpm/pmix-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/pmix-4.2.8-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "376c273f97cd6d7b573b0536b120da45e3150760e09fe469fe8e13bf3297c36d"

URI_pmix = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pmix-4.2.8-8.el10.x86_64_v2.rpm;name=pmix;unpack=0"
SRC_URI += "${URI_pmix}"
SRC_URI[pmix.sha256sum] = "335bcf9b06536c04f4bb21a771ce0b12028b0a6e55c2df067bc0eaf6715ce968"
RDEPENDS:pmix = " \
 zlib-ng-compat \
 libevent \
 munge-libs \
 hwloc-libs \
 glibc \
"

URI_pmix-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pmix-devel-4.2.8-8.el10.x86_64_v2.rpm;name=pmix-devel;unpack=0"
SRC_URI += "${URI_pmix-devel}"
SRC_URI[pmix-devel.sha256sum] = "bf9ed3ba7a9416e5ca6606075b42c6bb908ff5818f16bd0d97c2796f029d3a44"
RDEPENDS:pmix-devel = " \
 pmix-tools \
 pkgconf-pkg-config \
 pmix \
"

URI_pmix-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pmix-tools-4.2.8-8.el10.x86_64_v2.rpm;name=pmix-tools;unpack=0"
SRC_URI += "${URI_pmix-tools}"
SRC_URI[pmix-tools.sha256sum] = "1bd9bf9cd6dd20c0252108b51baa1dd9f8d185437f96a894898459f7c026248a"
RDEPENDS:pmix-tools = " \
 glibc \
 pmix \
"
