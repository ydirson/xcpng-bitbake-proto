# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "uuid"
PE = "0"
PV = "1.6.2"
PR = "65.el10"
PACKAGES = "uuid uuid-c++ uuid-dce uuid-devel uuid-c++-devel uuid-dce-devel uuid-perl"
PROVIDES = "rpm/uuid rpm/uuid-c++ rpm/uuid-dce rpm/uuid-devel rpm/uuid-c++-devel rpm/uuid-dce-devel rpm/uuid-perl"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/uuid-1.6.2-65.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "24225c54ea4e5df522e0ad322da23895133f81cdaef995058f85263e6dd88def"

URI_uuid = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/uuid-1.6.2-65.el10.x86_64_v2.rpm;name=uuid;unpack=0"
SRC_URI += "${URI_uuid}"
SRC_URI[uuid.sha256sum] = "ed43e78f7f90bec43e4e75f3c1ad057f11d5150df1d4f2dc397a44efed19cb51"
RDEPENDS:uuid = " \
 glibc \
"

URI_uuid-c++ = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/uuid-c++-1.6.2-65.el10.x86_64_v2.rpm;name=uuid-c++;unpack=0"
SRC_URI += "${URI_uuid-c++}"
SRC_URI[uuid-c++.sha256sum] = "16877775c6a98e95a18399eb712d3880bde1fe2a219833c3d72fb18e7eca876c"
RDEPENDS:uuid-c++ = " \
 glibc \
 libgcc \
 libstdc++ \
 uuid \
"

URI_uuid-dce = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/uuid-dce-1.6.2-65.el10.x86_64_v2.rpm;name=uuid-dce;unpack=0"
SRC_URI += "${URI_uuid-dce}"
SRC_URI[uuid-dce.sha256sum] = "0d3583d07f4caaeb0fd951d646d0aa86e72827ae83e70ab88099a5aeafcc5566"
RDEPENDS:uuid-dce = " \
 glibc \
 uuid \
"

URI_uuid-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/uuid-devel-1.6.2-65.el10.x86_64_v2.rpm;name=uuid-devel;unpack=0"
SRC_URI += "${URI_uuid-devel}"
SRC_URI[uuid-devel.sha256sum] = "518b70f99fa4a778fbb204961e9fe058fb04b7b2836e894b90733e1abbc5582c"
RDEPENDS:uuid-devel = " \
 bash \
 pkgconf-pkg-config \
 uuid \
"

URI_uuid-c++-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/uuid-c++-devel-1.6.2-65.el10.x86_64_v2.rpm;name=uuid-c++-devel;unpack=0"
SRC_URI += "${URI_uuid-c++-devel}"
SRC_URI[uuid-c++-devel.sha256sum] = "dea035efd3f72272b43d5e5bce0b7929cf86e5ec429de3be1a9cc1742879de8c"
RDEPENDS:uuid-c++-devel = " \
 uuid-devel \
 uuid-c++ \
"

URI_uuid-dce-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/uuid-dce-devel-1.6.2-65.el10.x86_64_v2.rpm;name=uuid-dce-devel;unpack=0"
SRC_URI += "${URI_uuid-dce-devel}"
SRC_URI[uuid-dce-devel.sha256sum] = "350e824cc0d0f66a619b7a645889dbac517d93ecbbcb5c7e7e0288ef32039b2c"
RDEPENDS:uuid-dce-devel = " \
 uuid-dce \
 uuid-devel \
"

URI_uuid-perl = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/uuid-perl-1.6.2-65.el10.x86_64_v2.rpm;name=uuid-perl;unpack=0"
SRC_URI += "${URI_uuid-perl}"
SRC_URI[uuid-perl.sha256sum] = "60f810068d9260c5e41068df8a56ab1cce08c27d3b1783085b8aac65ee5add66"
RDEPENDS:uuid-perl = " \
 perl-libs \
 perl-Carp \
 uuid \
 perl-Data-UUID \
 perl-Tie \
 glibc \
 perl-Exporter \
"
