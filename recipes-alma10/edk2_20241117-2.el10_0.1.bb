# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "edk2"
PE = "0"
PV = "20241117"
PR = "2.el10_0.1"
PACKAGES = "edk2-aarch64 edk2-ovmf edk2-aarch64 edk2-ovmf edk2-tools edk2-tools-doc"
PROVIDES = "rpm/edk2-aarch64 rpm/edk2-ovmf rpm/edk2-aarch64 rpm/edk2-ovmf rpm/edk2-tools rpm/edk2-tools-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/edk2-20241117-2.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6914f26a934c157b12d86bb9dc7e3fc820443e2f237fac481ecaec660962e771"

URI_edk2-aarch64 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/edk2-aarch64-20241117-2.el10_0.1.noarch.rpm;name=edk2-aarch64;unpack=0"
SRC_URI += "${URI_edk2-aarch64}"
SRC_URI[edk2-aarch64.sha256sum] = "b612439492f1e0e7bf3e8a35490394972ae72d9a16164c2ab7e57c250b95fe96"
RDEPENDS:edk2-aarch64 = ""

URI_edk2-ovmf = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/edk2-ovmf-20241117-2.el10_0.1.noarch.rpm;name=edk2-ovmf;unpack=0"
SRC_URI += "${URI_edk2-ovmf}"
SRC_URI[edk2-ovmf.sha256sum] = "a9b0b5d7f133f221a162049632f2f6c036b89e6b5bae1278f1a9ffa47d64a602"
RDEPENDS:edk2-ovmf = ""

URI_edk2-aarch64 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/edk2-aarch64-20241117-2.el10_0.1.noarch.rpm;name=edk2-aarch64;unpack=0"
SRC_URI += "${URI_edk2-aarch64}"
SRC_URI[edk2-aarch64.sha256sum] = "b612439492f1e0e7bf3e8a35490394972ae72d9a16164c2ab7e57c250b95fe96"
RDEPENDS:edk2-aarch64 = ""

URI_edk2-ovmf = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/edk2-ovmf-20241117-2.el10_0.1.noarch.rpm;name=edk2-ovmf;unpack=0"
SRC_URI += "${URI_edk2-ovmf}"
SRC_URI[edk2-ovmf.sha256sum] = "a9b0b5d7f133f221a162049632f2f6c036b89e6b5bae1278f1a9ffa47d64a602"
RDEPENDS:edk2-ovmf = ""

URI_edk2-tools = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/edk2-tools-20241117-2.el10_0.1.x86_64_v2.rpm;name=edk2-tools;unpack=0"
SRC_URI += "${URI_edk2-tools}"
SRC_URI[edk2-tools.sha256sum] = "d295d6d0e89062e4fb95d19f85cfd613bec69930089aa00656ba58e76cda086a"
RDEPENDS:edk2-tools = " \
 glibc \
 libgcc \
 bash \
 libstdc++ \
"

URI_edk2-tools-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/edk2-tools-doc-20241117-2.el10_0.1.noarch.rpm;name=edk2-tools-doc;unpack=0"
SRC_URI += "${URI_edk2-tools-doc}"
SRC_URI[edk2-tools-doc.sha256sum] = "5958d3f1154e869275a898f69fbf1b7f9dedb2c8e147a5b81a31d8d6d39494b7"
RDEPENDS:edk2-tools-doc = ""
