# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "apache-commons-codec"
PE = "0"
PV = "1.17.1"
PR = "1.el10"
PACKAGES = "apache-commons-codec apache-commons-codec-javadoc"
PROVIDES = "rpm/apache-commons-codec rpm/apache-commons-codec-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/apache-commons-codec-1.17.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "390d350d1771cba0c55931f1cbd4e2aa866a0b38b16caf58a51c81852231b214"

URI_apache-commons-codec = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/apache-commons-codec-1.17.1-1.el10.noarch.rpm;name=apache-commons-codec;unpack=0"
SRC_URI += "${URI_apache-commons-codec}"
SRC_URI[apache-commons-codec.sha256sum] = "0035212dcd86c29c3c2b03bb563f9d90529b0d21db3fcbb6376e8a23a35d1570"
RDEPENDS:apache-commons-codec = " \
 javapackages-filesystem \
"

URI_apache-commons-codec-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/apache-commons-codec-javadoc-1.17.1-1.el10.noarch.rpm;name=apache-commons-codec-javadoc;unpack=0"
SRC_URI += "${URI_apache-commons-codec-javadoc}"
SRC_URI[apache-commons-codec-javadoc.sha256sum] = "197b4c06f63ff89e65332d110d1b69203836c92b4b4daffd2bf64c376ddebc7d"
RDEPENDS:apache-commons-codec-javadoc = " \
 javapackages-filesystem \
"
