# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "Xaw3d"
PE = "0"
PV = "1.6.5"
PR = "5.el10"
PACKAGES = "Xaw3d Xaw3d-devel"
PROVIDES = "rpm/Xaw3d rpm/Xaw3d-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/Xaw3d-1.6.5-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6acd0e75cab37fe3812c488eb5258a0af219bf2f233790e4e6ca5b4c2b7df70a"

URI_Xaw3d = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/Xaw3d-1.6.5-5.el10.x86_64_v2.rpm;name=Xaw3d;unpack=0"
SRC_URI += "${URI_Xaw3d}"
SRC_URI[Xaw3d.sha256sum] = "51ba47b56366466e7b1fa912bd7f461a4243b323b79dc9ee2f7f408837f14c7d"
RDEPENDS:Xaw3d = " \
 libXmu \
 libXpm \
 libX11 \
 libXt \
 glibc \
 libXext \
"

URI_Xaw3d-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/Xaw3d-devel-1.6.5-5.el10.x86_64_v2.rpm;name=Xaw3d-devel;unpack=0"
SRC_URI += "${URI_Xaw3d-devel}"
SRC_URI[Xaw3d-devel.sha256sum] = "fbbc6cd377eba8d2a16cf5826fb4e9d626ad4a6b943aeafdbd2275572c6943ae"
RDEPENDS:Xaw3d-devel = " \
 libXext-devel \
 Xaw3d \
 libXmu-devel \
 pkgconf-pkg-config \
 libXpm-devel \
 libSM-devel \
 libX11-devel \
 xorg-x11-proto-devel \
 libXt-devel \
"
