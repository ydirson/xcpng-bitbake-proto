# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-DBD-MariaDB"
PE = "0"
PV = "1.23"
PR = "10.el10"
PACKAGES = "perl-DBD-MariaDB perl-DBD-MariaDB-tests"
PROVIDES = "rpm/perl-DBD-MariaDB rpm/perl-DBD-MariaDB-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-DBD-MariaDB-1.23-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ecc052b0aa658374a8fe2fd6a656d4524e285a11558add62eda68d04643ab87"

URI_perl-DBD-MariaDB = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-DBD-MariaDB-1.23-10.el10.x86_64_v2.rpm;name=perl-DBD-MariaDB;unpack=0"
SRC_URI += "${URI_perl-DBD-MariaDB}"
SRC_URI[perl-DBD-MariaDB.sha256sum] = "07c24b7ee07c113ef653ee3d70bf8856b27847fd59059d4fbc78cda086081528"
RDEPENDS:perl-DBD-MariaDB = " \
 perl-libs \
 perl-DynaLoader \
 perl-DBI \
 mariadb-connector-c \
 glibc \
"

URI_perl-DBD-MariaDB-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-DBD-MariaDB-tests-1.23-10.el10.x86_64_v2.rpm;name=perl-DBD-MariaDB-tests;unpack=0"
SRC_URI += "${URI_perl-DBD-MariaDB-tests}"
SRC_URI[perl-DBD-MariaDB-tests.sha256sum] = "9e11d4633adcf02f31dcef710d6ff0f680a5ebf1bafb9b0e63b67bf9c59a6767"
RDEPENDS:perl-DBD-MariaDB-tests = " \
 perl-libs \
 perl-FindBin \
 perl-B \
 perl-Test-Deep \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-CPAN-Meta-YAML \
 perl-vars \
 mariadb \
 mariadb-server \
 perl-DBD-MariaDB \
 perl-DBI \
 perl-lib \
 perl-Data-Dumper \
 perl-Time-HiRes \
 perl-Encode \
 bash \
 perl-bignum \
 hostname \
 perl-interpreter \
 perl-File-Path \
 perl-File-Temp \
"
