# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "zziplib"
PE = "0"
PV = "0.13.78"
PR = "1.el10"
PACKAGES = "zziplib zziplib-utils zziplib-devel"
PROVIDES = "rpm/zziplib rpm/zziplib-utils rpm/zziplib-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/zziplib-0.13.78-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed34d08de507064e3be5ff36c045548c41343d215c2f788b93ba93d060233976"

URI_zziplib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/zziplib-0.13.78-1.el10.x86_64_v2.rpm;name=zziplib;unpack=0"
SRC_URI += "${URI_zziplib}"
SRC_URI[zziplib.sha256sum] = "8086bfbb40f70a4890b3e885081c637124ed82b886d41fcb8badfd0c26f6b2bb"
RDEPENDS:zziplib = " \
 glibc \
 zlib-ng-compat \
"

URI_zziplib-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/zziplib-utils-0.13.78-1.el10.x86_64_v2.rpm;name=zziplib-utils;unpack=0"
SRC_URI += "${URI_zziplib-utils}"
SRC_URI[zziplib-utils.sha256sum] = "07a9707865900de9a2e877476b9c8eb4509a5c2de9fc3ff6410ddc8fa202d9c2"
RDEPENDS:zziplib-utils = " \
 glibc \
 zlib-ng-compat \
 zziplib \
"

URI_zziplib-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/zziplib-devel-0.13.78-1.el10.x86_64_v2.rpm;name=zziplib-devel;unpack=0"
SRC_URI += "${URI_zziplib-devel}"
SRC_URI[zziplib-devel.sha256sum] = "6bf99b807ab2c05a1914800d06738fdb178369a01792c8cb85bbdef585af8c51"
RDEPENDS:zziplib-devel = " \
 sdl12-compat-devel \
 zlib-ng-compat-devel \
 zziplib-devel \
 zziplib \
 pkgconf-pkg-config \
"
