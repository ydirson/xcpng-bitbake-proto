# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "CUnit"
PE = "0"
PV = "2.1.3"
PR = "34.el10"
PACKAGES = "CUnit CUnit-devel"
PROVIDES = "rpm/CUnit rpm/CUnit-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/CUnit-2.1.3-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b46bd70f5dbfac638280f9fbc83a418225d1477dab4fa9dc1305d703df9422a"

URI_CUnit = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/CUnit-2.1.3-34.el10.x86_64_v2.rpm;name=CUnit;unpack=0"
SRC_URI += "${URI_CUnit}"
SRC_URI[CUnit.sha256sum] = "7a2fa3f54979bc649887403ccf4aa853468f1d1a95e46bb20aaf7a73de610ad6"
RDEPENDS:CUnit = " \
 glibc \
"

URI_CUnit-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/CUnit-devel-2.1.3-34.el10.x86_64_v2.rpm;name=CUnit-devel;unpack=0"
SRC_URI += "${URI_CUnit-devel}"
SRC_URI[CUnit-devel.sha256sum] = "4d58d752b933dab2a9247b7ff8c66557628e5eefa82c61f56d3914bc2b4cc7c1"
RDEPENDS:CUnit-devel = " \
 CUnit \
 pkgconf-pkg-config \
"
