# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dosfstools"
PE = "0"
PV = "4.2"
PR = "12.el10"
PACKAGES = "dosfstools"
PROVIDES = "rpm/dosfstools"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/dosfstools-4.2-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "94fce5a3eea9d7302198f7e81d9c332e532f4ce51a7d82877ec09a682f63bd10"

URI_dosfstools = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/dosfstools-4.2-12.el10.x86_64_v2.rpm;name=dosfstools;unpack=0"
SRC_URI += "${URI_dosfstools}"
SRC_URI[dosfstools.sha256sum] = "17a84d8377810b755abd57014d27e31430d0ac95737d97bbd99f70deb3969a38"
RDEPENDS:dosfstools = " \
 glibc \
"
