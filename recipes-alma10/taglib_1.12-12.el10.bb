# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "taglib"
PE = "0"
PV = "1.12"
PR = "12.el10"
PACKAGES = "taglib taglib-devel"
PROVIDES = "rpm/taglib rpm/taglib-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/taglib-1.12-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a023a90c7a5e727886c679d0b8ae5f2fcae2741395dc6bd146bc288ecb359883"

URI_taglib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/taglib-1.12-12.el10.x86_64_v2.rpm;name=taglib;unpack=0"
SRC_URI += "${URI_taglib}"
SRC_URI[taglib.sha256sum] = "bcab2799ef43e6f80993e85edfd7233689ee112cb0f0e81b7b42625d858272a6"
RDEPENDS:taglib = " \
 glibc \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
"

URI_taglib-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/taglib-devel-1.12-12.el10.x86_64_v2.rpm;name=taglib-devel;unpack=0"
SRC_URI += "${URI_taglib-devel}"
SRC_URI[taglib-devel.sha256sum] = "cb31f5088cc2fb06d8b492dfd9b86badb20e5173e7c69d4b8cad45aef3f5535e"
RDEPENDS:taglib-devel = " \
 taglib \
 taglib-devel \
 bash \
 pkgconf-pkg-config \
"
