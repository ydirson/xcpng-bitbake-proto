# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "iw"
PE = "0"
PV = "6.9"
PR = "2.el10"
PACKAGES = "iw"
PROVIDES = "rpm/iw"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/iw-6.9-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ef6ae62cd1c889a6b18fef37ceff163375870351ead3888994d00a271fe2856"

URI_iw = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/iw-6.9-2.el10.x86_64_v2.rpm;name=iw;unpack=0"
SRC_URI += "${URI_iw}"
SRC_URI[iw.sha256sum] = "9fe2ed36366895459a96cffe288a12aa0171385a78b3354b80087cc3f0117cf4"
RDEPENDS:iw = " \
 glibc \
 libnl3 \
"
