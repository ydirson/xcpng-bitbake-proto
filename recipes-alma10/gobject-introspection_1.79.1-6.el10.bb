# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gobject-introspection"
PE = "0"
PV = "1.79.1"
PR = "6.el10"
PACKAGES = "gobject-introspection gobject-introspection-devel"
PROVIDES = "rpm/gobject-introspection rpm/gobject-introspection-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/gobject-introspection-1.79.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86095defdc250338243dfa13d693268108de28e10f33e5f7bba2aafacbadc408"

URI_gobject-introspection = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/gobject-introspection-1.79.1-6.el10.x86_64_v2.rpm;name=gobject-introspection;unpack=0"
SRC_URI += "${URI_gobject-introspection}"
SRC_URI[gobject-introspection.sha256sum] = "f6a8164fbf3966e3762293b1f69b95c4ca7691ca2bdc31f48ef9bdb706530e75"
RDEPENDS:gobject-introspection = " \
 glibc \
 libffi \
 glib2 \
"

URI_gobject-introspection-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gobject-introspection-devel-1.79.1-6.el10.x86_64_v2.rpm;name=gobject-introspection-devel;unpack=0"
SRC_URI += "${URI_gobject-introspection-devel}"
SRC_URI[gobject-introspection-devel.sha256sum] = "6463ecc65569c1d426fa557632753fe27e9cbfb4a870808da8e282cc830a14c8"
RDEPENDS:gobject-introspection-devel = " \
 python3 \
 libtool \
 glib2-devel \
 gobject-introspection \
 libffi \
 pkgconf-pkg-config \
 python3-setuptools \
 python3-markdown \
 glib2 \
 python3-mako \
 gobject-introspection-devel \
 glibc \
"
