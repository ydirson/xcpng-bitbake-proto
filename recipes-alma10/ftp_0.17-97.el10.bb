# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ftp"
PE = "0"
PV = "0.17"
PR = "97.el10"
PACKAGES = "ftp"
PROVIDES = "rpm/ftp"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ftp-0.17-97.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3cf0349eda19907bf817d528f50acefe66fa6d9fbb29ecb8f792b51e693fba3f"

URI_ftp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ftp-0.17-97.el10.x86_64_v2.rpm;name=ftp;unpack=0"
SRC_URI += "${URI_ftp}"
SRC_URI[ftp.sha256sum] = "63cf13f13a286a0b52d9ebd5e736574d99ab3c08bce0da22d02b8732b582f32e"
RDEPENDS:ftp = " \
 glibc \
 readline \
"
