# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Test-Deep"
PE = "0"
PV = "1.204"
PR = "9.el10"
PACKAGES = "perl-Test-Deep perl-Test-Deep-tests"
PROVIDES = "rpm/perl-Test-Deep rpm/perl-Test-Deep-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Test-Deep-1.204-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42668e3225860c3298ef3e5a9be0ffbc9093fb2a49628dffd130c5abdec738c6"

URI_perl-Test-Deep = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Test-Deep-1.204-9.el10.noarch.rpm;name=perl-Test-Deep;unpack=0"
SRC_URI += "${URI_perl-Test-Deep}"
SRC_URI[perl-Test-Deep.sha256sum] = "9e8dc2602ce28df1acb92a0e540b4d6874393fd7e4bee1518b6c961071620e3f"
RDEPENDS:perl-Test-Deep = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-Test-Simple \
 perl-Test-Deep \
 perl-overload \
 perl-Exporter \
 perl-base \
"

URI_perl-Test-Deep-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Test-Deep-tests-1.204-9.el10.noarch.rpm;name=perl-Test-Deep-tests;unpack=0"
SRC_URI += "${URI_perl-Test-Deep-tests}"
SRC_URI[perl-Test-Deep-tests.sha256sum] = "da75f7dba9fce14505b20ae2d044127727428e6f331626748d02a63353fa8d35"
RDEPENDS:perl-Test-Deep-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Scalar-List-Utils \
 perl-Test-Deep \
 perl-Test-Simple \
 perl-overload \
 bash \
 perl-if \
 perl-interpreter \
 perl-base \
 perl-lib \
"
