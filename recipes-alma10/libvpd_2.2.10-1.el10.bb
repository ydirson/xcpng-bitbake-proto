# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libvpd"
PE = "0"
PV = "2.2.10"
PR = "1.el10"
PACKAGES = ""
PROVIDES = ""


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libvpd-2.2.10-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9f559d3ce58111cec092a466953d260051d7b79df35a2d352300dc701d5514e"
