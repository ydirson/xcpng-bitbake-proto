# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ppp"
PE = "0"
PV = "2.5.0"
PR = "13.el10"
PACKAGES = "ppp ppp-devel"
PROVIDES = "rpm/ppp rpm/ppp-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/ppp-2.5.0-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe7ae15a5ba09058da10acf5603e45ea3c639626e35887d47741c322ff580359"

URI_ppp = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/ppp-2.5.0-13.el10.x86_64_v2.rpm;name=ppp;unpack=0"
SRC_URI += "${URI_ppp}"
SRC_URI[ppp.sha256sum] = "9b2216740345182d4aca32ba12d02811d0a8cba787fbd1012d2e2c965ff69413"
RDEPENDS:ppp = " \
 glibc-common \
 libpcap \
 shadow-utils \
 systemd \
 systemd-libs \
 libxcrypt \
 openssl-libs \
 authselect-libs \
 pam-libs \
 bash \
 glib2 \
 glibc \
"

URI_ppp-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ppp-devel-2.5.0-13.el10.x86_64_v2.rpm;name=ppp-devel;unpack=0"
SRC_URI += "${URI_ppp-devel}"
SRC_URI[ppp-devel.sha256sum] = "1b2241cc01c777868a0dc2e46238f583b7be1cd924ee2d25262bb15d928c8f9e"
RDEPENDS:ppp-devel = " \
 pkgconf-pkg-config \
 ppp \
"
