# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gstreamer1-plugins-ugly-free"
PE = "0"
PV = "1.24.11"
PR = "1.el10"
PACKAGES = "gstreamer1-plugins-ugly-free"
PROVIDES = "rpm/gstreamer1-plugins-ugly-free"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/gstreamer1-plugins-ugly-free-1.24.11-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fecd5e4628314f6aad8396c24c11c265b3718e85b41c28cb8be15c1dee3f9af5"

URI_gstreamer1-plugins-ugly-free = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-ugly-free-1.24.11-1.el10.x86_64_v2.rpm;name=gstreamer1-plugins-ugly-free;unpack=0"
SRC_URI += "${URI_gstreamer1-plugins-ugly-free}"
SRC_URI[gstreamer1-plugins-ugly-free.sha256sum] = "e93faedcb8c314b3c1292fef63846ef1c52e11c8cb6167cab204e3febe9b558a"
RDEPENDS:gstreamer1-plugins-ugly-free = " \
 libdvdread \
 gstreamer1 \
 gstreamer1-plugins-base \
 libmpeg2 \
 libcdio \
 glib2 \
 glibc \
 liba52 \
 orc \
"
