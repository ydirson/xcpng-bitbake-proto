# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-inc-latest"
PE = "2"
PV = "0.500"
PR = "30.el10"
PACKAGES = "perl-inc-latest perl-inc-latest-tests"
PROVIDES = "rpm/perl-inc-latest rpm/perl-inc-latest-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-inc-latest-0.500-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b7b46a56c6a353a8338a93c69c764124328f5b6d2d5099a04884b76e44f604c"

URI_perl-inc-latest = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-inc-latest-0.500-30.el10.noarch.rpm;name=perl-inc-latest;unpack=0"
SRC_URI += "${URI_perl-inc-latest}"
SRC_URI[perl-inc-latest.sha256sum] = "82d28276df1122d6ea851410a69a8d2b3a197ff21f611421e075d5182be7e42b"
RDEPENDS:perl-inc-latest = " \
 perl-ExtUtils-Install \
 perl-libs \
 perl-Carp \
 perl-IO \
 perl-File-Basename \
 perl-File-Copy \
 perl-PathTools \
 perl-File-Path \
"

URI_perl-inc-latest-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-inc-latest-tests-0.500-30.el10.noarch.rpm;name=perl-inc-latest-tests;unpack=0"
SRC_URI += "${URI_perl-inc-latest-tests}"
SRC_URI[perl-inc-latest-tests.sha256sum] = "4375b29df0235d8a4447458a65195a9a24223ed51d28d86065b24ea84c3100a8"
RDEPENDS:perl-inc-latest-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-ExtUtils-MakeMaker \
 bash \
 perl-PathTools \
 perl-inc-latest \
 perl-interpreter \
"
