# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-fs"
PE = "0"
PV = "2.4.16"
PR = "8.el10"
PACKAGES = "python3-fs"
PROVIDES = "rpm/python3-fs"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/python-fs-2.4.16-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2f4e26c1b953ae3f01be7ebc0a5cf290ef6b6d903a25f5e2e354351adba6123"

URI_python3-fs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-fs-2.4.16-8.el10.noarch.rpm;name=python3-fs;unpack=0"
SRC_URI += "${URI_python3-fs}"
SRC_URI[python3-fs.sha256sum] = "b53df97a29dd463bfe665e2ad29973c27d71a020cc64a3f26f43fc17239d1d2d"
RDEPENDS:python3-fs = " \
 python3-setuptools \
 python3-appdirs \
 python3-six \
 python3 \
"
