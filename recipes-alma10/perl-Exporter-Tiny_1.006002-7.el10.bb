# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Exporter-Tiny"
PE = "0"
PV = "1.006002"
PR = "7.el10"
PACKAGES = "perl-Exporter-Tiny perl-Exporter-Tiny-tests"
PROVIDES = "rpm/perl-Exporter-Tiny rpm/perl-Exporter-Tiny-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Exporter-Tiny-1.006002-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a2284e4a1a9ae5fcfd244ae2907fdb199d29448c69eea01f9d929d3f15e3e6a"

URI_perl-Exporter-Tiny = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Exporter-Tiny-1.006002-7.el10.noarch.rpm;name=perl-Exporter-Tiny;unpack=0"
SRC_URI += "${URI_perl-Exporter-Tiny}"
SRC_URI[perl-Exporter-Tiny.sha256sum] = "33475d272936f28913a9cd2301c347ad0cb0bc68f330fad356b6c849dc510ad7"
RDEPENDS:perl-Exporter-Tiny = " \
 perl-Exporter-Tiny \
 perl-libs \
 perl-Carp \
"

URI_perl-Exporter-Tiny-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Exporter-Tiny-tests-1.006002-7.el10.noarch.rpm;name=perl-Exporter-Tiny-tests;unpack=0"
SRC_URI += "${URI_perl-Exporter-Tiny-tests}"
SRC_URI[perl-Exporter-Tiny-tests.sha256sum] = "c892781406cdecaf76c88e8def09e3dbd456612d52718cab02e71083b39466c3"
RDEPENDS:perl-Exporter-Tiny-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Test-Warnings \
 perl-Test-Fatal \
 bash \
 perl-interpreter \
 perl-Exporter-Tiny \
 perl-Data-Dumper \
 perl-base \
 perl-lib \
"
