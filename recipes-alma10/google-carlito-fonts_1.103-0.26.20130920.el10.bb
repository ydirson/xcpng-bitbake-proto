# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "google-carlito-fonts"
PE = "0"
PV = "1.103"
PR = "0.26.20130920.el10"
PACKAGES = "google-carlito-fonts"
PROVIDES = "rpm/google-carlito-fonts"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/google-carlito-fonts-1.103-0.26.20130920.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e02e705dbd352a9a5ead5f2e156fcd6d81ebc48885b899a50b467724da81e89a"

URI_google-carlito-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-carlito-fonts-1.103-0.26.20130920.el10.noarch.rpm;name=google-carlito-fonts;unpack=0"
SRC_URI += "${URI_google-carlito-fonts}"
SRC_URI[google-carlito-fonts.sha256sum] = "fa7e375471bbca0ab93b0a10ad0aa8ffc679085e12ba524256fc9adfd9430cd6"
RDEPENDS:google-carlito-fonts = " \
 fonts-filesystem \
"
