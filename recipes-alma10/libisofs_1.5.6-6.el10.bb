# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libisofs"
PE = "0"
PV = "1.5.6"
PR = "6.el10"
PACKAGES = "libisofs libisofs-doc libisofs-devel"
PROVIDES = "rpm/libisofs rpm/libisofs-doc rpm/libisofs-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libisofs-1.5.6-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b252b937d9a740f785ad603855a75e2570df55c1bf2c55815b34698c8b06f670"

URI_libisofs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libisofs-1.5.6-6.el10.x86_64_v2.rpm;name=libisofs;unpack=0"
SRC_URI += "${URI_libisofs}"
SRC_URI[libisofs.sha256sum] = "e5dfbbab0d28911ec85d2c7cc976db8285a219213a9cc76e7ba9420748acc37d"
RDEPENDS:libisofs = " \
 glibc \
 libacl \
 zlib-ng-compat \
"

URI_libisofs-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libisofs-doc-1.5.6-6.el10.noarch.rpm;name=libisofs-doc;unpack=0"
SRC_URI += "${URI_libisofs-doc}"
SRC_URI[libisofs-doc.sha256sum] = "e2c4082c959ce6cd709876bd9c1e65f4cae5fbeab296628a94c9579b55942cb0"
RDEPENDS:libisofs-doc = ""

URI_libisofs-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libisofs-devel-1.5.6-6.el10.x86_64_v2.rpm;name=libisofs-devel;unpack=0"
SRC_URI += "${URI_libisofs-devel}"
SRC_URI[libisofs-devel.sha256sum] = "8a0f04e1b2fb0dd3278e25b303312ff4cb343390b3bd6618aa772fbda320941f"
RDEPENDS:libisofs-devel = " \
 pkgconf-pkg-config \
 libisofs \
"
