# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-id"
PE = "0"
PV = "0.20040812"
PR = "33.el10"
PACKAGES = "hunspell-id"
PROVIDES = "rpm/hunspell-id"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-id-0.20040812-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1efa2bb1dc9330875e4a80297b6cd3edb2604af9e80545c39f6ad2bb2e886eb3"

URI_hunspell-id = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-id-0.20040812-33.el10.noarch.rpm;name=hunspell-id;unpack=0"
SRC_URI += "${URI_hunspell-id}"
SRC_URI[hunspell-id.sha256sum] = "90b6ee7bdbd0158e35ac245f44437185142bb599857d75babd2e9f4285862fd1"
RDEPENDS:hunspell-id = " \
 hunspell-filesystem \
"
