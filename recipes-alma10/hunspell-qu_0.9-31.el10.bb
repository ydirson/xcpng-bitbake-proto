# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-qu"
PE = "0"
PV = "0.9"
PR = "31.el10"
PACKAGES = "hunspell-qu"
PROVIDES = "rpm/hunspell-qu"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-qu-0.9-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc4806f405c474365e825be998f931ac8b412d206ce961800d655e55e7455530"

URI_hunspell-qu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-qu-0.9-31.el10.noarch.rpm;name=hunspell-qu;unpack=0"
SRC_URI += "${URI_hunspell-qu}"
SRC_URI[hunspell-qu.sha256sum] = "7a61d91eee6adf5302100c534b798ff17e3429f348c89293a079f63168c4129d"
RDEPENDS:hunspell-qu = " \
 hunspell \
"
