# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ttmkfdir"
PE = "0"
PV = "3.0.9"
PR = "72.el10"
PACKAGES = "ttmkfdir"
PROVIDES = "rpm/ttmkfdir"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ttmkfdir-3.0.9-72.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e47b43af966868ce2f867da13cc229a8639d2b00d54eaa3294aba5829e84bc50"

URI_ttmkfdir = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ttmkfdir-3.0.9-72.el10.x86_64_v2.rpm;name=ttmkfdir;unpack=0"
SRC_URI += "${URI_ttmkfdir}"
SRC_URI[ttmkfdir.sha256sum] = "7b4e7dfcf63ca1443cc369b4d9e36ec6b737f5e08c639c2754d4290a138834f2"
RDEPENDS:ttmkfdir = " \
 zlib-ng-compat \
 freetype \
 libgcc \
 libstdc++ \
 glibc \
"
