# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "units"
PE = "0"
PV = "2.22"
PR = "10.el10"
PACKAGES = "units"
PROVIDES = "rpm/units"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/units-2.22-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b136ed4a64545d39a7a38a2f72bbac3b2dbeaf9b2f7190f990d9039908f8df0"

URI_units = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/units-2.22-10.el10.x86_64_v2.rpm;name=units;unpack=0"
SRC_URI += "${URI_units}"
SRC_URI[units.sha256sum] = "31039aaca88a5da11d0f2d477aca914b7f5b815e1d068f62f9371e74b9adfd24"
RDEPENDS:units = " \
 glibc \
 readline \
 python3 \
"
