# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libpciaccess"
PE = "0"
PV = "0.16"
PR = "16.el10"
PACKAGES = "libpciaccess libpciaccess-devel"
PROVIDES = "rpm/libpciaccess rpm/libpciaccess-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libpciaccess-0.16-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6160fb644ddc49f6e1abef557f6f735fa02b6823190ab737816c679f921925b1"

URI_libpciaccess = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libpciaccess-0.16-16.el10.x86_64_v2.rpm;name=libpciaccess;unpack=0"
SRC_URI += "${URI_libpciaccess}"
SRC_URI[libpciaccess.sha256sum] = "33abfd879be1c2b6db9af8d90d37dc14e750d45097579fd301e72a41198a8f25"
RDEPENDS:libpciaccess = " \
 glibc \
 hwdata \
"

URI_libpciaccess-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libpciaccess-devel-0.16-16.el10.x86_64_v2.rpm;name=libpciaccess-devel;unpack=0"
SRC_URI += "${URI_libpciaccess-devel}"
SRC_URI[libpciaccess-devel.sha256sum] = "0e42db493cb108e7f9778cc916c7ed797b18cabbba03523f98568dfca4bb16bd"
RDEPENDS:libpciaccess-devel = " \
 libpciaccess \
 pkgconf-pkg-config \
"
