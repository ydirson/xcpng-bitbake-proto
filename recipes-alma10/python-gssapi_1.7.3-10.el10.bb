# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-gssapi"
PE = "0"
PV = "1.7.3"
PR = "10.el10"
PACKAGES = "python3-gssapi"
PROVIDES = "rpm/python3-gssapi"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-gssapi-1.7.3-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f9460912d3c863f89c8949652b0ce69f7f9e8c00f46ef40aab57d2dd62e3225"

URI_python3-gssapi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-gssapi-1.7.3-10.el10.x86_64_v2.rpm;name=python3-gssapi;unpack=0"
SRC_URI += "${URI_python3-gssapi}"
SRC_URI[python3-gssapi.sha256sum] = "2b2e767d631122200883005a379c042773a98cfa66e4626bb6f16a5f4ecfff74"
RDEPENDS:python3-gssapi = " \
 glibc \
 krb5-libs \
 python3-decorator \
 python3 \
"
