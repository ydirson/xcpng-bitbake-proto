# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "docbook5-style-xsl"
PE = "0"
PV = "1.79.2"
PR = "23.el10"
PACKAGES = "docbook5-style-xsl"
PROVIDES = "rpm/docbook5-style-xsl"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/docbook5-style-xsl-1.79.2-23.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b741db87958f20a6e77313c68533ff9da4a48ab0e898f9ab9794d11854fbecf0"

URI_docbook5-style-xsl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/docbook5-style-xsl-1.79.2-23.el10.noarch.rpm;name=docbook5-style-xsl;unpack=0"
SRC_URI += "${URI_docbook5-style-xsl}"
SRC_URI[docbook5-style-xsl.sha256sum] = "5ded3f392e3ac66f1252a8c1690c6d4bb98d7b1b53774441d46237b83c07abc7"
RDEPENDS:docbook5-style-xsl = " \
 ruby \
 libxml2 \
 bash \
 xml-common \
 perl-interpreter \
"
