# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mingw-qemu-ga-win"
PE = "0"
PV = "109.1.0"
PR = "7.el10"
PACKAGES = "mingw-qemu-ga-win"
PROVIDES = "rpm/mingw-qemu-ga-win"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mingw-qemu-ga-win-109.1.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c66439ce10aa0da5f2beea744a5cecd41de238564d2b8d67594be5359060a7d4"

URI_mingw-qemu-ga-win = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mingw-qemu-ga-win-109.1.0-7.el10.noarch.rpm;name=mingw-qemu-ga-win;unpack=0"
SRC_URI += "${URI_mingw-qemu-ga-win}"
SRC_URI[mingw-qemu-ga-win.sha256sum] = "a1ffcba136027cd3ca4189fa0c7f63c97257c358ae9cbc25c1a69829d4f47aa1"
RDEPENDS:mingw-qemu-ga-win = " \
 systemd \
"
