# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pf-bb-config"
PE = "0"
PV = "22.11"
PR = "4.el10"
PACKAGES = "pf-bb-config"
PROVIDES = "rpm/pf-bb-config"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/pf-bb-config-22.11-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd0e1fc1b43e780b7ac4a25dec589319041f09c4f2adca22a1da3ba62ddf303e"

URI_pf-bb-config = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pf-bb-config-22.11-4.el10.x86_64_v2.rpm;name=pf-bb-config;unpack=0"
SRC_URI += "${URI_pf-bb-config}"
SRC_URI[pf-bb-config.sha256sum] = "7826f6f47af6fdb48688e05aa532bd2782fed7a93a2022b42145bae209bffc56"
RDEPENDS:pf-bb-config = " \
 glibc \
"
