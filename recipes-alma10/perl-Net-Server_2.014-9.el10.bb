# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Net-Server"
PE = "0"
PV = "2.014"
PR = "9.el10"
PACKAGES = "perl-Net-Server perl-Net-Server-tests"
PROVIDES = "rpm/perl-Net-Server rpm/perl-Net-Server-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Net-Server-2.014-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d276c2b25b64a5c30bba59b66494f9ac58c02843387e360dbc768af6aceb90b"

URI_perl-Net-Server = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Net-Server-2.014-9.el10.noarch.rpm;name=perl-Net-Server;unpack=0"
SRC_URI += "${URI_perl-Net-Server}"
SRC_URI[perl-Net-Server.sha256sum] = "9e733600aac73f65c629f6f82042195a7ee78cd0b62686ba7af3bb32f478920b"
RDEPENDS:perl-Net-Server = " \
 perl-Net-Server \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-interpreter \
 perl-IO \
 perl-Socket \
 perl-IO-Multiplex \
 perl-Fcntl \
 perl-IO-Socket-IP \
 perl-POSIX \
 perl-Sys-Syslog \
 perl-Errno \
 perl-Exporter \
 perl-base \
 perl-File-Temp \
 perl-Time-HiRes \
"

URI_perl-Net-Server-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Net-Server-tests-2.014-9.el10.noarch.rpm;name=perl-Net-Server-tests;unpack=0"
SRC_URI += "${URI_perl-Net-Server-tests}"
SRC_URI[perl-Net-Server-tests.sha256sum] = "d661a3bacf3ae94c086d89fc4ddf23e84f6d6dcfaa9c913b2712160956eae3cc"
RDEPENDS:perl-Net-Server-tests = " \
 perl-Net-Server \
 perl-constant \
 perl-Test-Harness \
 perl-libs \
 perl-IO \
 perl-FindBin \
 perl-File-Temp \
 bash \
 perl-PathTools \
 perl-English \
 perl-interpreter \
 perl-Exporter \
 perl-lib \
"
