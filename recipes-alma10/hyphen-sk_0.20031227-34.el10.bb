# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-sk"
PE = "0"
PV = "0.20031227"
PR = "34.el10"
PACKAGES = "hyphen-sk"
PROVIDES = "rpm/hyphen-sk"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-sk-0.20031227-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff33ec936eab1a9afbfcfb213a260bc054b86812bd918bb7d3c724fd176cc337"

URI_hyphen-sk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-sk-0.20031227-34.el10.noarch.rpm;name=hyphen-sk;unpack=0"
SRC_URI += "${URI_hyphen-sk}"
SRC_URI[hyphen-sk.sha256sum] = "36f3c54eb67951ec0c0e21a2fa5f6bf0ad8cbfdd2f54bad47612a1eec7da7ede"
RDEPENDS:hyphen-sk = " \
 hyphen \
"
