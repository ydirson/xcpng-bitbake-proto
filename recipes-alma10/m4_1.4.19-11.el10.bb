# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "m4"
PE = "0"
PV = "1.4.19"
PR = "11.el10"
PACKAGES = "m4"
PROVIDES = "rpm/m4"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/m4-1.4.19-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8eb6a62d7e5becc14b5527d8f4b7fd0a358728aa15e71b59cd263aadf58898c"

URI_m4 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/m4-1.4.19-11.el10.x86_64_v2.rpm;name=m4;unpack=0"
SRC_URI += "${URI_m4}"
SRC_URI[m4.sha256sum] = "8c4bcf8ab38a20ca2bc853d067b2eeffb75ca5335546b573c84c80706d8d410d"
RDEPENDS:m4 = " \
 glibc \
"
