# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "aardvark-dns"
PE = "2"
PV = "1.14.0"
PR = "1.el10"
PACKAGES = "aardvark-dns"
PROVIDES = "rpm/aardvark-dns"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/aardvark-dns-1.14.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47926f1aeb906d1b9c6869e1c84cdf1488b90fc9c492e017e8f34da29a8c2f13"

URI_aardvark-dns = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/aardvark-dns-1.14.0-1.el10.x86_64_v2.rpm;name=aardvark-dns;unpack=0"
SRC_URI += "${URI_aardvark-dns}"
SRC_URI[aardvark-dns.sha256sum] = "49aa5be4bc3ceb52eba96683f155fe4e7bd44b58482c379a4fbffffa5c8ab02b"
RDEPENDS:aardvark-dns = " \
 glibc \
 libgcc \
"
