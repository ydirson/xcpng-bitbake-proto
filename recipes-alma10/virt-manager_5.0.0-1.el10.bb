# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "virt-manager"
PE = "0"
PV = "5.0.0"
PR = "1.el10"
PACKAGES = "virt-install virt-manager-common virt-manager"
PROVIDES = "rpm/virt-install rpm/virt-manager-common rpm/virt-manager"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/virt-manager-5.0.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33d77a1156045fef6f296c17afb4e309b9a7668e3aef7e8fdaa261e8b5353d82"

URI_virt-install = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/virt-install-5.0.0-1.el10.noarch.rpm;name=virt-install;unpack=0"
SRC_URI += "${URI_virt-install}"
SRC_URI[virt-install.sha256sum] = "200864675d278f3cddc11ebd80bd42d0bbea423b25306f13165331afea5b5079"
RDEPENDS:virt-install = " \
 python3 \
 virt-manager-common \
 libvirt-client \
"

URI_virt-manager-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/virt-manager-common-5.0.0-1.el10.noarch.rpm;name=virt-manager-common;unpack=0"
SRC_URI += "${URI_virt-manager-common}"
SRC_URI[virt-manager-common.sha256sum] = "4e725f2b10a8636c9c897d6dda847b24fde39f06bc8fa179658244f23e696e00"
RDEPENDS:virt-manager-common = " \
 python3-requests \
 libosinfo \
 python3-libvirt \
 python3-libxml2 \
 python3-gobject-base \
 xorriso \
 python3-argcomplete \
"

URI_virt-manager = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/virt-manager-5.0.0-1.el10.noarch.rpm;name=virt-manager;unpack=0"
SRC_URI += "${URI_virt-manager}"
SRC_URI[virt-manager.sha256sum] = "2fdd870278528196682c62c9023828180b1171d79ec6e6aad4c88a016312f615"
RDEPENDS:virt-manager = " \
 python3 \
 python3-gobject \
 virt-manager-common \
 gtk-vnc2 \
 dconf \
 vte291 \
 gtk3 \
 libvirt-glib \
"
