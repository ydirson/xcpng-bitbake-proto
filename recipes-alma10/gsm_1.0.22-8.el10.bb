# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gsm"
PE = "0"
PV = "1.0.22"
PR = "8.el10"
PACKAGES = "gsm gsm-devel gsm-tools"
PROVIDES = "rpm/gsm rpm/gsm-devel rpm/gsm-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gsm-1.0.22-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46d0c452c95a7c5733f252d53a52406e6ab0046f8b10af670f845167e5108ac8"

URI_gsm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gsm-1.0.22-8.el10.x86_64_v2.rpm;name=gsm;unpack=0"
SRC_URI += "${URI_gsm}"
SRC_URI[gsm.sha256sum] = "fc9bc225eb9c0925cbde78a7f588e94d9d4e051bbf733b18b1e86dbcddd97a7e"
RDEPENDS:gsm = " \
 glibc \
"

URI_gsm-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gsm-devel-1.0.22-8.el10.x86_64_v2.rpm;name=gsm-devel;unpack=0"
SRC_URI += "${URI_gsm-devel}"
SRC_URI[gsm-devel.sha256sum] = "7dc1db621da6a61a3d9b0e0bbe21a7920b000324ab8b4ea7b793695b81a49874"
RDEPENDS:gsm-devel = " \
 gsm \
"

URI_gsm-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gsm-tools-1.0.22-8.el10.x86_64_v2.rpm;name=gsm-tools;unpack=0"
SRC_URI += "${URI_gsm-tools}"
SRC_URI[gsm-tools.sha256sum] = "8e12b12c4b6ce537d3b5e9e6c56f5307557bb6e17af08c35e008bb1b008fdf37"
RDEPENDS:gsm-tools = " \
 glibc \
 gsm \
"
