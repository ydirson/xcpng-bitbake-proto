# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "soundtouch"
PE = "0"
PV = "2.3.1"
PR = "8.el10"
PACKAGES = "soundtouch soundtouch-devel"
PROVIDES = "rpm/soundtouch rpm/soundtouch-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/soundtouch-2.3.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "204ccbeeda9421e227c92ca764a5e0d9ff93a662bffca450c6f286946031adf2"

URI_soundtouch = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/soundtouch-2.3.1-8.el10.x86_64_v2.rpm;name=soundtouch;unpack=0"
SRC_URI += "${URI_soundtouch}"
SRC_URI[soundtouch.sha256sum] = "2225d0f262ac05065b36b06879bfddaaef8da620f7cb91c32ff54d3c246a33d0"
RDEPENDS:soundtouch = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_soundtouch-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/soundtouch-devel-2.3.1-8.el10.x86_64_v2.rpm;name=soundtouch-devel;unpack=0"
SRC_URI += "${URI_soundtouch-devel}"
SRC_URI[soundtouch-devel.sha256sum] = "5a85a0d06a49db14101e998d298a8edb7230e104791fde70c517728bc6469067"
RDEPENDS:soundtouch-devel = " \
 soundtouch \
 cmake-filesystem \
 pkgconf-pkg-config \
"
