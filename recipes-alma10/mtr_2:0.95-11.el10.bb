# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mtr"
PE = "2"
PV = "0.95"
PR = "11.el10"
PACKAGES = "mtr mtr-gtk"
PROVIDES = "rpm/mtr rpm/mtr-gtk"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/mtr-0.95-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30403ccd794011db51cbb7f750a0e87feb877c959c6524e30080e0a8b730937f"

URI_mtr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/mtr-0.95-11.el10.x86_64_v2.rpm;name=mtr;unpack=0"
SRC_URI += "${URI_mtr}"
SRC_URI[mtr.sha256sum] = "b91779273e5d4f3701b16e87b04639697914b2cf75a589bc232ff3ffd816a6f8"
RDEPENDS:mtr = " \
 glibc \
 ncurses-libs \
 jansson \
"

URI_mtr-gtk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mtr-gtk-0.95-11.el10.x86_64_v2.rpm;name=mtr-gtk;unpack=0"
SRC_URI += "${URI_mtr-gtk}"
SRC_URI[mtr-gtk.sha256sum] = "14311f62d6c3d138d1f488c41bacce59c67630b9538bf2f96283c97429f6e065"
RDEPENDS:mtr-gtk = " \
 jansson \
 gdk-pixbuf2 \
 mtr \
 ncurses-libs \
 glib2 \
 gtk3 \
 glibc \
"
