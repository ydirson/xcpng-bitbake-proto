# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "glibc"
PE = "0"
PV = "2.39"
PR = "46.el10_0.4.alma.1"
PACKAGES = "glibc glibc-all-langpacks glibc-common glibc-gconv-extra glibc-langpack-aa glibc-langpack-af glibc-langpack-agr glibc-langpack-ak glibc-langpack-am glibc-langpack-an glibc-langpack-anp glibc-langpack-ar glibc-langpack-as glibc-langpack-ast glibc-langpack-ayc glibc-langpack-az glibc-langpack-be glibc-langpack-bem glibc-langpack-ber glibc-langpack-bg glibc-langpack-bhb glibc-langpack-bho glibc-langpack-bi glibc-langpack-bn glibc-langpack-bo glibc-langpack-br glibc-langpack-brx glibc-langpack-bs glibc-langpack-byn glibc-langpack-ca glibc-langpack-ce glibc-langpack-chr glibc-langpack-ckb glibc-langpack-cmn glibc-langpack-crh glibc-langpack-cs glibc-langpack-csb glibc-langpack-cv glibc-langpack-cy glibc-langpack-da glibc-langpack-de glibc-langpack-doi glibc-langpack-dsb glibc-langpack-dv glibc-langpack-dz glibc-langpack-el glibc-langpack-en glibc-langpack-eo glibc-langpack-es glibc-langpack-et glibc-langpack-eu glibc-langpack-fa glibc-langpack-ff glibc-langpack-fi glibc-langpack-fil glibc-langpack-fo glibc-langpack-fr glibc-langpack-fur glibc-langpack-fy glibc-langpack-ga glibc-langpack-gbm glibc-langpack-gd glibc-langpack-gez glibc-langpack-gl glibc-langpack-gu glibc-langpack-gv glibc-langpack-ha glibc-langpack-hak glibc-langpack-he glibc-langpack-hi glibc-langpack-hif glibc-langpack-hne glibc-langpack-hr glibc-langpack-hsb glibc-langpack-ht glibc-langpack-hu glibc-langpack-hy glibc-langpack-ia glibc-langpack-id glibc-langpack-ig glibc-langpack-ik glibc-langpack-is glibc-langpack-it glibc-langpack-iu glibc-langpack-ja glibc-langpack-ka glibc-langpack-kab glibc-langpack-kk glibc-langpack-kl glibc-langpack-km glibc-langpack-kn glibc-langpack-ko glibc-langpack-kok glibc-langpack-ks glibc-langpack-ku glibc-langpack-kv glibc-langpack-kw glibc-langpack-ky glibc-langpack-lb glibc-langpack-lg glibc-langpack-li glibc-langpack-lij glibc-langpack-ln glibc-langpack-lo glibc-langpack-lt glibc-langpack-lv glibc-langpack-lzh glibc-langpack-mag glibc-langpack-mai glibc-langpack-mfe glibc-langpack-mg glibc-langpack-mhr glibc-langpack-mi glibc-langpack-miq glibc-langpack-mjw glibc-langpack-mk glibc-langpack-ml glibc-langpack-mn glibc-langpack-mni glibc-langpack-mnw glibc-langpack-mr glibc-langpack-ms glibc-langpack-mt glibc-langpack-my glibc-langpack-nan glibc-langpack-nb glibc-langpack-nds glibc-langpack-ne glibc-langpack-nhn glibc-langpack-niu glibc-langpack-nl glibc-langpack-nn glibc-langpack-nr glibc-langpack-nso glibc-langpack-oc glibc-langpack-om glibc-langpack-or glibc-langpack-os glibc-langpack-pa glibc-langpack-pap glibc-langpack-pl glibc-langpack-ps glibc-langpack-pt glibc-langpack-quz glibc-langpack-raj glibc-langpack-rif glibc-langpack-ro glibc-langpack-ru glibc-langpack-rw glibc-langpack-sa glibc-langpack-sah glibc-langpack-sat glibc-langpack-sc glibc-langpack-sd glibc-langpack-se glibc-langpack-sgs glibc-langpack-shn glibc-langpack-shs glibc-langpack-si glibc-langpack-sid glibc-langpack-sk glibc-langpack-sl glibc-langpack-sm glibc-langpack-so glibc-langpack-sq glibc-langpack-sr glibc-langpack-ss glibc-langpack-ssy glibc-langpack-st glibc-langpack-su glibc-langpack-sv glibc-langpack-sw glibc-langpack-syr glibc-langpack-szl glibc-langpack-ta glibc-langpack-tcy glibc-langpack-te glibc-langpack-tg glibc-langpack-th glibc-langpack-the glibc-langpack-ti glibc-langpack-tig glibc-langpack-tk glibc-langpack-tl glibc-langpack-tn glibc-langpack-to glibc-langpack-tok glibc-langpack-tpi glibc-langpack-tr glibc-langpack-ts glibc-langpack-tt glibc-langpack-ug glibc-langpack-uk glibc-langpack-unm glibc-langpack-ur glibc-langpack-uz glibc-langpack-ve glibc-langpack-vi glibc-langpack-wa glibc-langpack-wae glibc-langpack-wal glibc-langpack-wo glibc-langpack-xh glibc-langpack-yi glibc-langpack-yo glibc-langpack-yue glibc-langpack-yuw glibc-langpack-zgh glibc-langpack-zh glibc-langpack-zu glibc-minimal-langpack libnsl glibc-devel glibc-doc glibc-locale-source glibc-utils glibc-benchtests glibc-nss-devel glibc-static nss_db nss_hesiod compat-libpthread-nonshared glibc32 sysroot-aarch64-el10-glibc sysroot-ppc64le-el10-glibc sysroot-s390x-el10-glibc sysroot-x86_64-el10-glibc"
PROVIDES = "rpm/glibc rpm/glibc-all-langpacks rpm/glibc-common rpm/glibc-gconv-extra rpm/glibc-langpack-aa rpm/glibc-langpack-af rpm/glibc-langpack-agr rpm/glibc-langpack-ak rpm/glibc-langpack-am rpm/glibc-langpack-an rpm/glibc-langpack-anp rpm/glibc-langpack-ar rpm/glibc-langpack-as rpm/glibc-langpack-ast rpm/glibc-langpack-ayc rpm/glibc-langpack-az rpm/glibc-langpack-be rpm/glibc-langpack-bem rpm/glibc-langpack-ber rpm/glibc-langpack-bg rpm/glibc-langpack-bhb rpm/glibc-langpack-bho rpm/glibc-langpack-bi rpm/glibc-langpack-bn rpm/glibc-langpack-bo rpm/glibc-langpack-br rpm/glibc-langpack-brx rpm/glibc-langpack-bs rpm/glibc-langpack-byn rpm/glibc-langpack-ca rpm/glibc-langpack-ce rpm/glibc-langpack-chr rpm/glibc-langpack-ckb rpm/glibc-langpack-cmn rpm/glibc-langpack-crh rpm/glibc-langpack-cs rpm/glibc-langpack-csb rpm/glibc-langpack-cv rpm/glibc-langpack-cy rpm/glibc-langpack-da rpm/glibc-langpack-de rpm/glibc-langpack-doi rpm/glibc-langpack-dsb rpm/glibc-langpack-dv rpm/glibc-langpack-dz rpm/glibc-langpack-el rpm/glibc-langpack-en rpm/glibc-langpack-eo rpm/glibc-langpack-es rpm/glibc-langpack-et rpm/glibc-langpack-eu rpm/glibc-langpack-fa rpm/glibc-langpack-ff rpm/glibc-langpack-fi rpm/glibc-langpack-fil rpm/glibc-langpack-fo rpm/glibc-langpack-fr rpm/glibc-langpack-fur rpm/glibc-langpack-fy rpm/glibc-langpack-ga rpm/glibc-langpack-gbm rpm/glibc-langpack-gd rpm/glibc-langpack-gez rpm/glibc-langpack-gl rpm/glibc-langpack-gu rpm/glibc-langpack-gv rpm/glibc-langpack-ha rpm/glibc-langpack-hak rpm/glibc-langpack-he rpm/glibc-langpack-hi rpm/glibc-langpack-hif rpm/glibc-langpack-hne rpm/glibc-langpack-hr rpm/glibc-langpack-hsb rpm/glibc-langpack-ht rpm/glibc-langpack-hu rpm/glibc-langpack-hy rpm/glibc-langpack-ia rpm/glibc-langpack-id rpm/glibc-langpack-ig rpm/glibc-langpack-ik rpm/glibc-langpack-is rpm/glibc-langpack-it rpm/glibc-langpack-iu rpm/glibc-langpack-ja rpm/glibc-langpack-ka rpm/glibc-langpack-kab rpm/glibc-langpack-kk rpm/glibc-langpack-kl rpm/glibc-langpack-km rpm/glibc-langpack-kn rpm/glibc-langpack-ko rpm/glibc-langpack-kok rpm/glibc-langpack-ks rpm/glibc-langpack-ku rpm/glibc-langpack-kv rpm/glibc-langpack-kw rpm/glibc-langpack-ky rpm/glibc-langpack-lb rpm/glibc-langpack-lg rpm/glibc-langpack-li rpm/glibc-langpack-lij rpm/glibc-langpack-ln rpm/glibc-langpack-lo rpm/glibc-langpack-lt rpm/glibc-langpack-lv rpm/glibc-langpack-lzh rpm/glibc-langpack-mag rpm/glibc-langpack-mai rpm/glibc-langpack-mfe rpm/glibc-langpack-mg rpm/glibc-langpack-mhr rpm/glibc-langpack-mi rpm/glibc-langpack-miq rpm/glibc-langpack-mjw rpm/glibc-langpack-mk rpm/glibc-langpack-ml rpm/glibc-langpack-mn rpm/glibc-langpack-mni rpm/glibc-langpack-mnw rpm/glibc-langpack-mr rpm/glibc-langpack-ms rpm/glibc-langpack-mt rpm/glibc-langpack-my rpm/glibc-langpack-nan rpm/glibc-langpack-nb rpm/glibc-langpack-nds rpm/glibc-langpack-ne rpm/glibc-langpack-nhn rpm/glibc-langpack-niu rpm/glibc-langpack-nl rpm/glibc-langpack-nn rpm/glibc-langpack-nr rpm/glibc-langpack-nso rpm/glibc-langpack-oc rpm/glibc-langpack-om rpm/glibc-langpack-or rpm/glibc-langpack-os rpm/glibc-langpack-pa rpm/glibc-langpack-pap rpm/glibc-langpack-pl rpm/glibc-langpack-ps rpm/glibc-langpack-pt rpm/glibc-langpack-quz rpm/glibc-langpack-raj rpm/glibc-langpack-rif rpm/glibc-langpack-ro rpm/glibc-langpack-ru rpm/glibc-langpack-rw rpm/glibc-langpack-sa rpm/glibc-langpack-sah rpm/glibc-langpack-sat rpm/glibc-langpack-sc rpm/glibc-langpack-sd rpm/glibc-langpack-se rpm/glibc-langpack-sgs rpm/glibc-langpack-shn rpm/glibc-langpack-shs rpm/glibc-langpack-si rpm/glibc-langpack-sid rpm/glibc-langpack-sk rpm/glibc-langpack-sl rpm/glibc-langpack-sm rpm/glibc-langpack-so rpm/glibc-langpack-sq rpm/glibc-langpack-sr rpm/glibc-langpack-ss rpm/glibc-langpack-ssy rpm/glibc-langpack-st rpm/glibc-langpack-su rpm/glibc-langpack-sv rpm/glibc-langpack-sw rpm/glibc-langpack-syr rpm/glibc-langpack-szl rpm/glibc-langpack-ta rpm/glibc-langpack-tcy rpm/glibc-langpack-te rpm/glibc-langpack-tg rpm/glibc-langpack-th rpm/glibc-langpack-the rpm/glibc-langpack-ti rpm/glibc-langpack-tig rpm/glibc-langpack-tk rpm/glibc-langpack-tl rpm/glibc-langpack-tn rpm/glibc-langpack-to rpm/glibc-langpack-tok rpm/glibc-langpack-tpi rpm/glibc-langpack-tr rpm/glibc-langpack-ts rpm/glibc-langpack-tt rpm/glibc-langpack-ug rpm/glibc-langpack-uk rpm/glibc-langpack-unm rpm/glibc-langpack-ur rpm/glibc-langpack-uz rpm/glibc-langpack-ve rpm/glibc-langpack-vi rpm/glibc-langpack-wa rpm/glibc-langpack-wae rpm/glibc-langpack-wal rpm/glibc-langpack-wo rpm/glibc-langpack-xh rpm/glibc-langpack-yi rpm/glibc-langpack-yo rpm/glibc-langpack-yue rpm/glibc-langpack-yuw rpm/glibc-langpack-zgh rpm/glibc-langpack-zh rpm/glibc-langpack-zu rpm/glibc-minimal-langpack rpm/libnsl rpm/glibc-devel rpm/glibc-doc rpm/glibc-locale-source rpm/glibc-utils rpm/glibc-benchtests rpm/glibc-nss-devel rpm/glibc-static rpm/nss_db rpm/nss_hesiod rpm/compat-libpthread-nonshared rpm/glibc32 rpm/sysroot-aarch64-el10-glibc rpm/sysroot-ppc64le-el10-glibc rpm/sysroot-s390x-el10-glibc rpm/sysroot-x86_64-el10-glibc"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/glibc-2.39-46.el10_0.4.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54c199d7db6a48bf11adc17baf6346e2f2ca9a90f1bc168d4a3a2266e8f1c1a8"

URI_glibc = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc;unpack=0"
SRC_URI += "${URI_glibc}"
SRC_URI[glibc.sha256sum] = "2fb9267bf5864c9da0e3e7c5d0b361fe3534e0bc90fb172ca85090966cac96f6"
RDEPENDS:glibc = " \
 glibc-common \
 glibc-minimal-langpack \
 glibc-gconv-extra \
 libgcc \
 basesystem \
"

URI_glibc-all-langpacks = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-all-langpacks-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-all-langpacks;unpack=0"
SRC_URI += "${URI_glibc-all-langpacks}"
SRC_URI[glibc-all-langpacks.sha256sum] = "7e3da6bf4b7361a0274867b30e34cddd114b5c30b42f2657f95715f7f6b3f794"
RDEPENDS:glibc-all-langpacks = " \
 glibc-common \
 glibc \
"

URI_glibc-common = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-common-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-common;unpack=0"
SRC_URI += "${URI_glibc-common}"
SRC_URI[glibc-common.sha256sum] = "938b9f59bedc4bc4f18f7755ad8187991682706f83516656d0dabd2b0168fbc0"
RDEPENDS:glibc-common = " \
 glibc \
 bash \
"

URI_glibc-gconv-extra = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-gconv-extra-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-gconv-extra;unpack=0"
SRC_URI += "${URI_glibc-gconv-extra}"
SRC_URI[glibc-gconv-extra.sha256sum] = "d903c85e015cb0c95ee23a8e2453a8d04077fb15cd7b43be9ac2034ad15ef8e9"
RDEPENDS:glibc-gconv-extra = " \
 glibc \
 glibc-common \
"

URI_glibc-langpack-aa = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-aa-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-aa;unpack=0"
SRC_URI += "${URI_glibc-langpack-aa}"
SRC_URI[glibc-langpack-aa.sha256sum] = "b90ffe3c4518663ab5a93b195dbbf9c29168647d02d3db4c93ffd288cb09119b"
RDEPENDS:glibc-langpack-aa = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-af = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-af-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-af;unpack=0"
SRC_URI += "${URI_glibc-langpack-af}"
SRC_URI[glibc-langpack-af.sha256sum] = "6c05b973e24c148e7dc1926b04bbca5ba87f14856ba403e876707e52ffc7fee1"
RDEPENDS:glibc-langpack-af = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-agr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-agr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-agr;unpack=0"
SRC_URI += "${URI_glibc-langpack-agr}"
SRC_URI[glibc-langpack-agr.sha256sum] = "169c8071fe28591df3a115ff0873af398451a1ab24867fdab0d83cb9d78202e4"
RDEPENDS:glibc-langpack-agr = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ak = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ak-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ak;unpack=0"
SRC_URI += "${URI_glibc-langpack-ak}"
SRC_URI[glibc-langpack-ak.sha256sum] = "8e09cda8ecd7205e529e4e629febfb20abde41a49a373aade1f98554c4fe61d1"
RDEPENDS:glibc-langpack-ak = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-am = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-am-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-am;unpack=0"
SRC_URI += "${URI_glibc-langpack-am}"
SRC_URI[glibc-langpack-am.sha256sum] = "ae11ef8aa2ac9d2c753a49723b90f2a08ee5af112d9cd4c6427aa80c4e1bf9d2"
RDEPENDS:glibc-langpack-am = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-an = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-an-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-an;unpack=0"
SRC_URI += "${URI_glibc-langpack-an}"
SRC_URI[glibc-langpack-an.sha256sum] = "550a4a09b6a93cbe2a378ac59200d27eb14eea3f7684ad02476d4d159449f77e"
RDEPENDS:glibc-langpack-an = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-anp = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-anp-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-anp;unpack=0"
SRC_URI += "${URI_glibc-langpack-anp}"
SRC_URI[glibc-langpack-anp.sha256sum] = "242e3888abd8ec8ca0f2572fa58383e3f8a75891a6f76bb3c1e9795ad560e0a4"
RDEPENDS:glibc-langpack-anp = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ar = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ar-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ar;unpack=0"
SRC_URI += "${URI_glibc-langpack-ar}"
SRC_URI[glibc-langpack-ar.sha256sum] = "d7f1aa7d31cc41aee815958738ceb9f514446020335be4f9c3244488cb19c9af"
RDEPENDS:glibc-langpack-ar = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-as = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-as-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-as;unpack=0"
SRC_URI += "${URI_glibc-langpack-as}"
SRC_URI[glibc-langpack-as.sha256sum] = "7e1dc629cf09ee55750ff474514642b8710e4106f4ab2fc0b63fca8d06ed86a4"
RDEPENDS:glibc-langpack-as = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ast = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ast-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ast;unpack=0"
SRC_URI += "${URI_glibc-langpack-ast}"
SRC_URI[glibc-langpack-ast.sha256sum] = "0e7aff31d5a3a5b016b1d6ced3f034b89d8ce7f62c376eecb76a55ce2ea183e2"
RDEPENDS:glibc-langpack-ast = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ayc = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ayc-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ayc;unpack=0"
SRC_URI += "${URI_glibc-langpack-ayc}"
SRC_URI[glibc-langpack-ayc.sha256sum] = "aa967fafded7a6ec6b8c97cb882ed5f4282abd9922f9c106a0dc1187c188593a"
RDEPENDS:glibc-langpack-ayc = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-az = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-az-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-az;unpack=0"
SRC_URI += "${URI_glibc-langpack-az}"
SRC_URI[glibc-langpack-az.sha256sum] = "8048d1b6c87a7609905a7dde8a078a0eb65bea0c9303d2cc0effbff9f2e65ac4"
RDEPENDS:glibc-langpack-az = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-be = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-be-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-be;unpack=0"
SRC_URI += "${URI_glibc-langpack-be}"
SRC_URI[glibc-langpack-be.sha256sum] = "c9eb054d9efacef928a06d350f77698ef2833477cc57d7737ee64a91c15ff8d1"
RDEPENDS:glibc-langpack-be = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-bem = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bem-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-bem;unpack=0"
SRC_URI += "${URI_glibc-langpack-bem}"
SRC_URI[glibc-langpack-bem.sha256sum] = "cdd74260b1e42d87cd9a24175031b4220e5b29099a88c736dbd631d396083382"
RDEPENDS:glibc-langpack-bem = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ber = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ber-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ber;unpack=0"
SRC_URI += "${URI_glibc-langpack-ber}"
SRC_URI[glibc-langpack-ber.sha256sum] = "9fcafe0b06a38a0b12585d69a5c18fa7202e740405a78e8ad3a0d12c651b8d50"
RDEPENDS:glibc-langpack-ber = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-bg = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bg-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-bg;unpack=0"
SRC_URI += "${URI_glibc-langpack-bg}"
SRC_URI[glibc-langpack-bg.sha256sum] = "43749160305b5bba0672f2ecd312574e2d5e090fd156e0cfad61025219fcbcf6"
RDEPENDS:glibc-langpack-bg = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-bhb = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bhb-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-bhb;unpack=0"
SRC_URI += "${URI_glibc-langpack-bhb}"
SRC_URI[glibc-langpack-bhb.sha256sum] = "dc86213cd874abc892cc01d4073f3c5fb645755555c0440f81a427a34f1324db"
RDEPENDS:glibc-langpack-bhb = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-bho = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bho-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-bho;unpack=0"
SRC_URI += "${URI_glibc-langpack-bho}"
SRC_URI[glibc-langpack-bho.sha256sum] = "a60e2c09313f83e6cfa558b89871b8eb9e9634625a6d8ae81cf1f68eb9882204"
RDEPENDS:glibc-langpack-bho = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-bi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-bi;unpack=0"
SRC_URI += "${URI_glibc-langpack-bi}"
SRC_URI[glibc-langpack-bi.sha256sum] = "2cb306d2ce27980335ead6142c33d7b90c71473a6c91ecf7a5e546b33b54fdaf"
RDEPENDS:glibc-langpack-bi = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-bn = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-bn;unpack=0"
SRC_URI += "${URI_glibc-langpack-bn}"
SRC_URI[glibc-langpack-bn.sha256sum] = "0a97a198403e047d89e7b04850be8439e3c78231da5557e5fd5ba533c58564a6"
RDEPENDS:glibc-langpack-bn = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-bo = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bo-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-bo;unpack=0"
SRC_URI += "${URI_glibc-langpack-bo}"
SRC_URI[glibc-langpack-bo.sha256sum] = "ffca41f724e643debc05a2f552354bdee322c8c206373a400aeb9f9c6d43ffe0"
RDEPENDS:glibc-langpack-bo = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-br = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-br-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-br;unpack=0"
SRC_URI += "${URI_glibc-langpack-br}"
SRC_URI[glibc-langpack-br.sha256sum] = "8ae4c5fed411d4c0384481d5a5a8e480b4caedf86615abd428bc97b54ebbb243"
RDEPENDS:glibc-langpack-br = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-brx = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-brx-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-brx;unpack=0"
SRC_URI += "${URI_glibc-langpack-brx}"
SRC_URI[glibc-langpack-brx.sha256sum] = "1d130438ac6750bd7cae51f2d7ddf5d1478d312c521e56d1074256c066d71305"
RDEPENDS:glibc-langpack-brx = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-bs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bs-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-bs;unpack=0"
SRC_URI += "${URI_glibc-langpack-bs}"
SRC_URI[glibc-langpack-bs.sha256sum] = "371a64d4395857ca079b0a6b7774f27ef9642d9520e028cc68983a4e8867d406"
RDEPENDS:glibc-langpack-bs = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-byn = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-byn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-byn;unpack=0"
SRC_URI += "${URI_glibc-langpack-byn}"
SRC_URI[glibc-langpack-byn.sha256sum] = "3bfb4a878221d46d7429dc0da05d6b6a78f6ed45d82673edfda7072fc028d2b0"
RDEPENDS:glibc-langpack-byn = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ca = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ca-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ca;unpack=0"
SRC_URI += "${URI_glibc-langpack-ca}"
SRC_URI[glibc-langpack-ca.sha256sum] = "b4b010eee1e8cd618e04272b880071c97609a792010123dd01c80cf9d0545c83"
RDEPENDS:glibc-langpack-ca = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ce = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ce-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ce;unpack=0"
SRC_URI += "${URI_glibc-langpack-ce}"
SRC_URI[glibc-langpack-ce.sha256sum] = "cd5e7a09566c1a38b35817cdb06657aeb5399567c3e8199bc92a3fd0f943d71a"
RDEPENDS:glibc-langpack-ce = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-chr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-chr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-chr;unpack=0"
SRC_URI += "${URI_glibc-langpack-chr}"
SRC_URI[glibc-langpack-chr.sha256sum] = "0ac4460a97d08bad2ca29fb6d4251ba9f7ed88b07e9f7d472d6586727326b69d"
RDEPENDS:glibc-langpack-chr = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ckb = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ckb-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ckb;unpack=0"
SRC_URI += "${URI_glibc-langpack-ckb}"
SRC_URI[glibc-langpack-ckb.sha256sum] = "85922e563bf0a1fd7cf626e22f7a644af8ced568002b14e212b5e13bb5e728a3"
RDEPENDS:glibc-langpack-ckb = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-cmn = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cmn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-cmn;unpack=0"
SRC_URI += "${URI_glibc-langpack-cmn}"
SRC_URI[glibc-langpack-cmn.sha256sum] = "88f5d16eb0764df25b2524ec21514fed0764446afaae867e86d16ce48d9174dd"
RDEPENDS:glibc-langpack-cmn = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-crh = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-crh-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-crh;unpack=0"
SRC_URI += "${URI_glibc-langpack-crh}"
SRC_URI[glibc-langpack-crh.sha256sum] = "a0b36057019d8f9bc91dd7dd9e6d8726c7cd97b0e0119799b066ca0f44bbcc0c"
RDEPENDS:glibc-langpack-crh = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-cs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cs-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-cs;unpack=0"
SRC_URI += "${URI_glibc-langpack-cs}"
SRC_URI[glibc-langpack-cs.sha256sum] = "a17cf9f283d9901afb5da8c9a21757b59e205341c7192ca31ff5815ae4cc1d7e"
RDEPENDS:glibc-langpack-cs = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-csb = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-csb-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-csb;unpack=0"
SRC_URI += "${URI_glibc-langpack-csb}"
SRC_URI[glibc-langpack-csb.sha256sum] = "685dcb113ecf32ab7fd43aefa4b34e28c1a1cdfa9324a5d34a34d9049aecd0cb"
RDEPENDS:glibc-langpack-csb = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-cv = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cv-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-cv;unpack=0"
SRC_URI += "${URI_glibc-langpack-cv}"
SRC_URI[glibc-langpack-cv.sha256sum] = "6c8a1c0ae3443d23011f1fad4e1859fb5d75c338cc392b3a30c8d51c956b5a10"
RDEPENDS:glibc-langpack-cv = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-cy = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cy-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-cy;unpack=0"
SRC_URI += "${URI_glibc-langpack-cy}"
SRC_URI[glibc-langpack-cy.sha256sum] = "e3db96886760e087633abda64a16972c2a23c56fc2d0f7520433bf4b353fd92a"
RDEPENDS:glibc-langpack-cy = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-da = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-da-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-da;unpack=0"
SRC_URI += "${URI_glibc-langpack-da}"
SRC_URI[glibc-langpack-da.sha256sum] = "7fc6e0349797353d9864ed3c19ea16c75c8441c3aba678aeb0a777a4a131fdfb"
RDEPENDS:glibc-langpack-da = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-de = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-de-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-de;unpack=0"
SRC_URI += "${URI_glibc-langpack-de}"
SRC_URI[glibc-langpack-de.sha256sum] = "a8f8ec4cb9b068d46a82ea6fa03f136429ba88b0f8abbaff8b5c6f62a1cc7096"
RDEPENDS:glibc-langpack-de = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-doi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-doi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-doi;unpack=0"
SRC_URI += "${URI_glibc-langpack-doi}"
SRC_URI[glibc-langpack-doi.sha256sum] = "8896a06fdaa6006c8780b34c37a188896d28b223c1fa0e7e159f5fd2dad64960"
RDEPENDS:glibc-langpack-doi = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-dsb = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-dsb-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-dsb;unpack=0"
SRC_URI += "${URI_glibc-langpack-dsb}"
SRC_URI[glibc-langpack-dsb.sha256sum] = "e93ba162cba771a01185e2643f28c77b30e3f99cf96a1aa3c32c7c4f94a1cc0a"
RDEPENDS:glibc-langpack-dsb = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-dv = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-dv-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-dv;unpack=0"
SRC_URI += "${URI_glibc-langpack-dv}"
SRC_URI[glibc-langpack-dv.sha256sum] = "268260ab846639cd250ba5c7982cc93b885fe3dc74b79a26ec38d87d00f4cffe"
RDEPENDS:glibc-langpack-dv = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-dz = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-dz-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-dz;unpack=0"
SRC_URI += "${URI_glibc-langpack-dz}"
SRC_URI[glibc-langpack-dz.sha256sum] = "03c62bd8ad18f0b8d673dfc753b85f63772c1d9f50e893041413709f7c51da8b"
RDEPENDS:glibc-langpack-dz = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-el = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-el-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-el;unpack=0"
SRC_URI += "${URI_glibc-langpack-el}"
SRC_URI[glibc-langpack-el.sha256sum] = "c79dc9fe8c2ee97611d0f4b3a6db0777f9c1ed57a569808f4cd326ab11911c3a"
RDEPENDS:glibc-langpack-el = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-en = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-en-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-en;unpack=0"
SRC_URI += "${URI_glibc-langpack-en}"
SRC_URI[glibc-langpack-en.sha256sum] = "f41bf15e11e68133f2cc76ffe62da1d81c1e2fd433198605edc91893aff354d2"
RDEPENDS:glibc-langpack-en = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-eo = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-eo-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-eo;unpack=0"
SRC_URI += "${URI_glibc-langpack-eo}"
SRC_URI[glibc-langpack-eo.sha256sum] = "298eace09ffa348fa69daba8d4fc284cab2db909e58bb9c3c9896dfae0d76c94"
RDEPENDS:glibc-langpack-eo = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-es = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-es-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-es;unpack=0"
SRC_URI += "${URI_glibc-langpack-es}"
SRC_URI[glibc-langpack-es.sha256sum] = "4df3358be6d9c3a2bf69f6ece110a88306fc7bffc5c6087f5576c78733ef2c67"
RDEPENDS:glibc-langpack-es = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-et = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-et-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-et;unpack=0"
SRC_URI += "${URI_glibc-langpack-et}"
SRC_URI[glibc-langpack-et.sha256sum] = "963d0445716d55f2868c6be87a5f597bece947d3061e99aaf221573f3616f539"
RDEPENDS:glibc-langpack-et = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-eu = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-eu-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-eu;unpack=0"
SRC_URI += "${URI_glibc-langpack-eu}"
SRC_URI[glibc-langpack-eu.sha256sum] = "fb72e9c404cfb9de1c97ad7f8c560c587ebe52770a7a261c53741fc06f162d8f"
RDEPENDS:glibc-langpack-eu = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-fa = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fa-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-fa;unpack=0"
SRC_URI += "${URI_glibc-langpack-fa}"
SRC_URI[glibc-langpack-fa.sha256sum] = "bee3f0b07fa1176030cc28b334663ea7c4a835faf93f436e36c75759429afbf2"
RDEPENDS:glibc-langpack-fa = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ff = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ff-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ff;unpack=0"
SRC_URI += "${URI_glibc-langpack-ff}"
SRC_URI[glibc-langpack-ff.sha256sum] = "0172df1747e6ac9e1b2da81ce01af390e212ecec77d61390f406b6909ea95e50"
RDEPENDS:glibc-langpack-ff = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-fi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-fi;unpack=0"
SRC_URI += "${URI_glibc-langpack-fi}"
SRC_URI[glibc-langpack-fi.sha256sum] = "01ce54ce644a12fc77d9f19709d87c0b0ad60f06c644b42f624ff1d503271ade"
RDEPENDS:glibc-langpack-fi = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-fil = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fil-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-fil;unpack=0"
SRC_URI += "${URI_glibc-langpack-fil}"
SRC_URI[glibc-langpack-fil.sha256sum] = "a9b9828183dfb9c89d2344f3c32449bdb1e5eabe3dd28da42c38d52577127c21"
RDEPENDS:glibc-langpack-fil = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-fo = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fo-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-fo;unpack=0"
SRC_URI += "${URI_glibc-langpack-fo}"
SRC_URI[glibc-langpack-fo.sha256sum] = "fa228f65cf05e566a3deb3c403b7953aaacf4698fb55089a733ded353457c3e4"
RDEPENDS:glibc-langpack-fo = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-fr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-fr;unpack=0"
SRC_URI += "${URI_glibc-langpack-fr}"
SRC_URI[glibc-langpack-fr.sha256sum] = "029ca5ee6053595a40a85b01a3c16fe0041712d5c1d04372c868dba650b2d4cb"
RDEPENDS:glibc-langpack-fr = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-fur = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fur-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-fur;unpack=0"
SRC_URI += "${URI_glibc-langpack-fur}"
SRC_URI[glibc-langpack-fur.sha256sum] = "286056932188db44d04632d13ada4a156f16e88ec1ff30044445f44735c79c6b"
RDEPENDS:glibc-langpack-fur = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-fy = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fy-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-fy;unpack=0"
SRC_URI += "${URI_glibc-langpack-fy}"
SRC_URI[glibc-langpack-fy.sha256sum] = "91de192661c436f8af71dbfcca7b339f83d06cc5d54d85202dffe657053ac7c2"
RDEPENDS:glibc-langpack-fy = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ga = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ga-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ga;unpack=0"
SRC_URI += "${URI_glibc-langpack-ga}"
SRC_URI[glibc-langpack-ga.sha256sum] = "b4e1923de05d6853b9020c6db0e831108a4007b5420fce4a62622362281ec911"
RDEPENDS:glibc-langpack-ga = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-gbm = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gbm-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-gbm;unpack=0"
SRC_URI += "${URI_glibc-langpack-gbm}"
SRC_URI[glibc-langpack-gbm.sha256sum] = "026c1a60ba113548d16db3c0480960b068d8b6f1c7eb6cf857be341984d705fb"
RDEPENDS:glibc-langpack-gbm = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-gd = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gd-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-gd;unpack=0"
SRC_URI += "${URI_glibc-langpack-gd}"
SRC_URI[glibc-langpack-gd.sha256sum] = "4ce1e4781cb968f6805fe74c2b567d1f99bb36447d4508dbb3a2acf5f5bdab0c"
RDEPENDS:glibc-langpack-gd = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-gez = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gez-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-gez;unpack=0"
SRC_URI += "${URI_glibc-langpack-gez}"
SRC_URI[glibc-langpack-gez.sha256sum] = "5eeeb33a74b52b1e3486a8ea42fc0a6d9777b9f83fe8d0ba63033232138e38cf"
RDEPENDS:glibc-langpack-gez = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-gl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-gl;unpack=0"
SRC_URI += "${URI_glibc-langpack-gl}"
SRC_URI[glibc-langpack-gl.sha256sum] = "fa4a957d6ab3b543af82b97ce7378f62d9b24c07e99918ef1e7eb23562ddf75a"
RDEPENDS:glibc-langpack-gl = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-gu = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gu-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-gu;unpack=0"
SRC_URI += "${URI_glibc-langpack-gu}"
SRC_URI[glibc-langpack-gu.sha256sum] = "b4206cb470bcaf00807452b6a2e59e41eb5883563f7ed30a9a4a99b09157d886"
RDEPENDS:glibc-langpack-gu = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-gv = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gv-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-gv;unpack=0"
SRC_URI += "${URI_glibc-langpack-gv}"
SRC_URI[glibc-langpack-gv.sha256sum] = "c70ba498268f6b3c88325ababeb897d876cb61a701f7d579fc794c65726f1dee"
RDEPENDS:glibc-langpack-gv = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ha = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ha-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ha;unpack=0"
SRC_URI += "${URI_glibc-langpack-ha}"
SRC_URI[glibc-langpack-ha.sha256sum] = "ccd41beeffb6b8cb630149d2e41cb604b7067a592f6fd73105251249ebbce5ac"
RDEPENDS:glibc-langpack-ha = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-hak = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hak-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-hak;unpack=0"
SRC_URI += "${URI_glibc-langpack-hak}"
SRC_URI[glibc-langpack-hak.sha256sum] = "486ecdf2e89a9fd96f946cf35a7a2fbb51319261c3373c4abf174f1f7b8ab34e"
RDEPENDS:glibc-langpack-hak = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-he = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-he-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-he;unpack=0"
SRC_URI += "${URI_glibc-langpack-he}"
SRC_URI[glibc-langpack-he.sha256sum] = "7a7902c00d0c8f9d4d594aade1c4f32d3a1b8bc427bc6196150e8ac68abc56b2"
RDEPENDS:glibc-langpack-he = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-hi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-hi;unpack=0"
SRC_URI += "${URI_glibc-langpack-hi}"
SRC_URI[glibc-langpack-hi.sha256sum] = "2adf32e29b9e1add30e3ad58c063316062233b141f2df8f9a6c050c1624a2564"
RDEPENDS:glibc-langpack-hi = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-hif = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hif-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-hif;unpack=0"
SRC_URI += "${URI_glibc-langpack-hif}"
SRC_URI[glibc-langpack-hif.sha256sum] = "a0de4cfd628740d4013a07c6b4239872a6065b2f1ab368db3b4ba4593267a55d"
RDEPENDS:glibc-langpack-hif = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-hne = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hne-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-hne;unpack=0"
SRC_URI += "${URI_glibc-langpack-hne}"
SRC_URI[glibc-langpack-hne.sha256sum] = "c908bb75a90ecc57afb981b53650021b9f09fe3bc9842f2690246ae025a53445"
RDEPENDS:glibc-langpack-hne = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-hr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-hr;unpack=0"
SRC_URI += "${URI_glibc-langpack-hr}"
SRC_URI[glibc-langpack-hr.sha256sum] = "1f5d3121757b92a779c5de418fcd2db72f5144b54ad72b75c4755a580de49c1f"
RDEPENDS:glibc-langpack-hr = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-hsb = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hsb-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-hsb;unpack=0"
SRC_URI += "${URI_glibc-langpack-hsb}"
SRC_URI[glibc-langpack-hsb.sha256sum] = "55e55e20b457d2d54c8e58ead2e76a10cdc70314c0781eef9fbdcfb83da84f60"
RDEPENDS:glibc-langpack-hsb = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ht = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ht-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ht;unpack=0"
SRC_URI += "${URI_glibc-langpack-ht}"
SRC_URI[glibc-langpack-ht.sha256sum] = "05855cbb502a63c8ee760892034f360943da7e40785e03f215f9c84a81ff09a8"
RDEPENDS:glibc-langpack-ht = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-hu = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hu-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-hu;unpack=0"
SRC_URI += "${URI_glibc-langpack-hu}"
SRC_URI[glibc-langpack-hu.sha256sum] = "9d44db988beab1096d751dffe965494d381cd758ec11dc31d23e05b48aa6ba0d"
RDEPENDS:glibc-langpack-hu = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-hy = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hy-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-hy;unpack=0"
SRC_URI += "${URI_glibc-langpack-hy}"
SRC_URI[glibc-langpack-hy.sha256sum] = "3655e1090264e99ba4a2efff91037e31f91d3feb65d0e9cb0c18208a943af926"
RDEPENDS:glibc-langpack-hy = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ia = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ia-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ia;unpack=0"
SRC_URI += "${URI_glibc-langpack-ia}"
SRC_URI[glibc-langpack-ia.sha256sum] = "046213cff2337171958375d6e41ad1954e43e90c59465322110913de64a8b1ea"
RDEPENDS:glibc-langpack-ia = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-id = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-id-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-id;unpack=0"
SRC_URI += "${URI_glibc-langpack-id}"
SRC_URI[glibc-langpack-id.sha256sum] = "f709658f63f60c151f560a193d7362917a0eff9afc73255748661b6eda42a329"
RDEPENDS:glibc-langpack-id = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ig = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ig-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ig;unpack=0"
SRC_URI += "${URI_glibc-langpack-ig}"
SRC_URI[glibc-langpack-ig.sha256sum] = "e78f9edc7af725fe2d99412a7a8964ca2703a0bd00baec177160a786fa56da94"
RDEPENDS:glibc-langpack-ig = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ik = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ik-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ik;unpack=0"
SRC_URI += "${URI_glibc-langpack-ik}"
SRC_URI[glibc-langpack-ik.sha256sum] = "ffd7c98f8969ea141256f8a4be4b65c767e67d12b18e69347060efbcb16b2b04"
RDEPENDS:glibc-langpack-ik = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-is = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-is-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-is;unpack=0"
SRC_URI += "${URI_glibc-langpack-is}"
SRC_URI[glibc-langpack-is.sha256sum] = "aeabc0a806ced30786a1e9bfc4038d2485e3d33591bbcbf7d05c381bc5f4f60a"
RDEPENDS:glibc-langpack-is = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-it = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-it-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-it;unpack=0"
SRC_URI += "${URI_glibc-langpack-it}"
SRC_URI[glibc-langpack-it.sha256sum] = "991eb687bf62d4c4b95ca93d74101b23a4500d88a07b609007767fd8e1a732fa"
RDEPENDS:glibc-langpack-it = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-iu = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-iu-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-iu;unpack=0"
SRC_URI += "${URI_glibc-langpack-iu}"
SRC_URI[glibc-langpack-iu.sha256sum] = "124cafe5db099e56e56f5ca380f34c1900c4ae74bb0c4e387c5cb7af36a1897b"
RDEPENDS:glibc-langpack-iu = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ja = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ja-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ja;unpack=0"
SRC_URI += "${URI_glibc-langpack-ja}"
SRC_URI[glibc-langpack-ja.sha256sum] = "4dc63485ae4bec5856ee33544cd0d527e725c9ce4d15015fad93e3cf26e9c312"
RDEPENDS:glibc-langpack-ja = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ka = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ka-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ka;unpack=0"
SRC_URI += "${URI_glibc-langpack-ka}"
SRC_URI[glibc-langpack-ka.sha256sum] = "503439b9cb9faa9768d6ece77e8268e0d1c70be7aa1e46eb45392e03d4e55f55"
RDEPENDS:glibc-langpack-ka = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-kab = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kab-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-kab;unpack=0"
SRC_URI += "${URI_glibc-langpack-kab}"
SRC_URI[glibc-langpack-kab.sha256sum] = "f2b7f996d6c54ee737b371b997b16fec27952f6d920ca82cd12d7104476271a7"
RDEPENDS:glibc-langpack-kab = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-kk = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kk-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-kk;unpack=0"
SRC_URI += "${URI_glibc-langpack-kk}"
SRC_URI[glibc-langpack-kk.sha256sum] = "89ef9d1952b72977ed20295e28b43699a86930623f03acc614f91d46e7e5282f"
RDEPENDS:glibc-langpack-kk = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-kl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-kl;unpack=0"
SRC_URI += "${URI_glibc-langpack-kl}"
SRC_URI[glibc-langpack-kl.sha256sum] = "c5e0f3d98e3218abd7776919f1acfd80058c4fd634e567908494ba48bf713a06"
RDEPENDS:glibc-langpack-kl = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-km = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-km-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-km;unpack=0"
SRC_URI += "${URI_glibc-langpack-km}"
SRC_URI[glibc-langpack-km.sha256sum] = "5e87021d2df87e7687ba2998268123b4562ed5669883cb8c1ddc1febe0daa812"
RDEPENDS:glibc-langpack-km = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-kn = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-kn;unpack=0"
SRC_URI += "${URI_glibc-langpack-kn}"
SRC_URI[glibc-langpack-kn.sha256sum] = "8e3b696b18ebe0e6fbdfa4dee267f8bdf8634d72252ecf0cbaa0cd993e464306"
RDEPENDS:glibc-langpack-kn = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ko = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ko-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ko;unpack=0"
SRC_URI += "${URI_glibc-langpack-ko}"
SRC_URI[glibc-langpack-ko.sha256sum] = "2f6eee26d074c8f8b282e60490d4d71cb3653be7ff9874918c55c9854894bce7"
RDEPENDS:glibc-langpack-ko = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-kok = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kok-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-kok;unpack=0"
SRC_URI += "${URI_glibc-langpack-kok}"
SRC_URI[glibc-langpack-kok.sha256sum] = "3d5590a8b9794c873f249f308649b284e835f6887c3085aec99fdd5fb9e419f3"
RDEPENDS:glibc-langpack-kok = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ks = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ks-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ks;unpack=0"
SRC_URI += "${URI_glibc-langpack-ks}"
SRC_URI[glibc-langpack-ks.sha256sum] = "68f7c259175811966c56d123d8bd31b545b114a1c9aa0b69df355e8a19400848"
RDEPENDS:glibc-langpack-ks = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ku = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ku-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ku;unpack=0"
SRC_URI += "${URI_glibc-langpack-ku}"
SRC_URI[glibc-langpack-ku.sha256sum] = "51f72ac255291a878b18374f8e0eb4334f9985f8a662ff0cfbd97a35483a68b4"
RDEPENDS:glibc-langpack-ku = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-kv = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kv-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-kv;unpack=0"
SRC_URI += "${URI_glibc-langpack-kv}"
SRC_URI[glibc-langpack-kv.sha256sum] = "cdb701400cd65a34dadf2fded7db26095cbf319be713e9877853fc9777df5fdd"
RDEPENDS:glibc-langpack-kv = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-kw = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kw-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-kw;unpack=0"
SRC_URI += "${URI_glibc-langpack-kw}"
SRC_URI[glibc-langpack-kw.sha256sum] = "37aaacf7e69dc48724fb9abbcbf2dc694e835dedfb2bea5027403a3ff9c2c172"
RDEPENDS:glibc-langpack-kw = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ky = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ky-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ky;unpack=0"
SRC_URI += "${URI_glibc-langpack-ky}"
SRC_URI[glibc-langpack-ky.sha256sum] = "e51858d8a573163f8e03f07b88e11f8c15ae88de684fbf62c724a0fbf05c16fc"
RDEPENDS:glibc-langpack-ky = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-lb = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lb-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-lb;unpack=0"
SRC_URI += "${URI_glibc-langpack-lb}"
SRC_URI[glibc-langpack-lb.sha256sum] = "08c770f7d129120e4dbfa7e3fd725c7a5023895f67c3fadba7741fff85acca34"
RDEPENDS:glibc-langpack-lb = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-lg = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lg-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-lg;unpack=0"
SRC_URI += "${URI_glibc-langpack-lg}"
SRC_URI[glibc-langpack-lg.sha256sum] = "c1554ee3e63101a8b2b23ee47000b8600db81414b7e38db11ff0ac3e7a5ee6a6"
RDEPENDS:glibc-langpack-lg = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-li = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-li-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-li;unpack=0"
SRC_URI += "${URI_glibc-langpack-li}"
SRC_URI[glibc-langpack-li.sha256sum] = "120e849660572d5f589bf0739b80ea1f5ab9ab0ae029e2c2a5ba868527a9ca7f"
RDEPENDS:glibc-langpack-li = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-lij = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lij-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-lij;unpack=0"
SRC_URI += "${URI_glibc-langpack-lij}"
SRC_URI[glibc-langpack-lij.sha256sum] = "17e60dfc31c9833bd1b50369c748096185a1f725897ad6ae6531a73cf7a9ebe2"
RDEPENDS:glibc-langpack-lij = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ln = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ln-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ln;unpack=0"
SRC_URI += "${URI_glibc-langpack-ln}"
SRC_URI[glibc-langpack-ln.sha256sum] = "cb3beb858fbbbf98ff900baaf629fbbc32246594c0ce6009d381ce0879bc4eaf"
RDEPENDS:glibc-langpack-ln = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-lo = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lo-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-lo;unpack=0"
SRC_URI += "${URI_glibc-langpack-lo}"
SRC_URI[glibc-langpack-lo.sha256sum] = "22163bd4b5cdd4fc8cc6ae53c5a534aeff55f9ebbfbc92994db8075b67e5d0bf"
RDEPENDS:glibc-langpack-lo = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-lt = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lt-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-lt;unpack=0"
SRC_URI += "${URI_glibc-langpack-lt}"
SRC_URI[glibc-langpack-lt.sha256sum] = "4ec8ed6d62e933f64f4e0587f3d9a26835fb664d15418db7602e29c565a57157"
RDEPENDS:glibc-langpack-lt = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-lv = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lv-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-lv;unpack=0"
SRC_URI += "${URI_glibc-langpack-lv}"
SRC_URI[glibc-langpack-lv.sha256sum] = "be013d4d296a085a6d1efd6aefd9b3b3d578faba34ffe4dac57657ed8c99b744"
RDEPENDS:glibc-langpack-lv = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-lzh = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lzh-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-lzh;unpack=0"
SRC_URI += "${URI_glibc-langpack-lzh}"
SRC_URI[glibc-langpack-lzh.sha256sum] = "123fbdfa8c4e41743cabd2c1faf2c07f8a173959d68a4520e0879e261f378b19"
RDEPENDS:glibc-langpack-lzh = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-mag = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mag-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-mag;unpack=0"
SRC_URI += "${URI_glibc-langpack-mag}"
SRC_URI[glibc-langpack-mag.sha256sum] = "d9464ce8cf3100380088a0704944c38b1318d0f3be39d5b89e853e8ee31a2dc8"
RDEPENDS:glibc-langpack-mag = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-mai = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mai-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-mai;unpack=0"
SRC_URI += "${URI_glibc-langpack-mai}"
SRC_URI[glibc-langpack-mai.sha256sum] = "0d6e7364c2332c6f0d351f46a506e69865927b8225c525ddad511d40d245a155"
RDEPENDS:glibc-langpack-mai = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-mfe = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mfe-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-mfe;unpack=0"
SRC_URI += "${URI_glibc-langpack-mfe}"
SRC_URI[glibc-langpack-mfe.sha256sum] = "fe82d7cf8ec2969b2c5b7e3ba4d0315e111492f7909b9d36a38df2a48f76ea86"
RDEPENDS:glibc-langpack-mfe = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-mg = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mg-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-mg;unpack=0"
SRC_URI += "${URI_glibc-langpack-mg}"
SRC_URI[glibc-langpack-mg.sha256sum] = "9c7fc21957e63e1fc223dca1aa8332a15b9bb4e8b8901d7c55a81d3cffec653e"
RDEPENDS:glibc-langpack-mg = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-mhr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mhr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-mhr;unpack=0"
SRC_URI += "${URI_glibc-langpack-mhr}"
SRC_URI[glibc-langpack-mhr.sha256sum] = "b373a94bba5bd986b260ae47ffc08e34722472c21c47612ba6f9cd6d03086591"
RDEPENDS:glibc-langpack-mhr = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-mi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-mi;unpack=0"
SRC_URI += "${URI_glibc-langpack-mi}"
SRC_URI[glibc-langpack-mi.sha256sum] = "61501102bf02097166690ea0d4ef4dcef9196a1fa480851f94d2fd6397d3ce69"
RDEPENDS:glibc-langpack-mi = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-miq = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-miq-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-miq;unpack=0"
SRC_URI += "${URI_glibc-langpack-miq}"
SRC_URI[glibc-langpack-miq.sha256sum] = "e18604725f003211b79ee2e11f5bd4df617e651a0241397e92f0eff593058b75"
RDEPENDS:glibc-langpack-miq = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-mjw = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mjw-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-mjw;unpack=0"
SRC_URI += "${URI_glibc-langpack-mjw}"
SRC_URI[glibc-langpack-mjw.sha256sum] = "2e51bf3c3434273143f2e46c84c4faf08fc698a4469e3faa0645ea39cf0b087c"
RDEPENDS:glibc-langpack-mjw = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-mk = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mk-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-mk;unpack=0"
SRC_URI += "${URI_glibc-langpack-mk}"
SRC_URI[glibc-langpack-mk.sha256sum] = "197dfc4b644e6c8becf26f0151f80a703248656b509675d3ad62c2b16e36f0ad"
RDEPENDS:glibc-langpack-mk = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ml = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ml-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ml;unpack=0"
SRC_URI += "${URI_glibc-langpack-ml}"
SRC_URI[glibc-langpack-ml.sha256sum] = "ecf0ba8092b248d33f09e1c1414f3daf76f37e5e89163bde51a054c4930b4489"
RDEPENDS:glibc-langpack-ml = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-mn = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-mn;unpack=0"
SRC_URI += "${URI_glibc-langpack-mn}"
SRC_URI[glibc-langpack-mn.sha256sum] = "7c394811ec50e738f23ed038de96e89aefa2bb17c6972e688798026057b38df1"
RDEPENDS:glibc-langpack-mn = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-mni = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mni-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-mni;unpack=0"
SRC_URI += "${URI_glibc-langpack-mni}"
SRC_URI[glibc-langpack-mni.sha256sum] = "a2dd3e83ccd0704d3b3bd00a4747a0b642604022b195dff2d84d37832074704c"
RDEPENDS:glibc-langpack-mni = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-mnw = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mnw-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-mnw;unpack=0"
SRC_URI += "${URI_glibc-langpack-mnw}"
SRC_URI[glibc-langpack-mnw.sha256sum] = "1f597a358687bb2e30b0b53854423efb767079eb8a921c5e6b19a849f1767dd2"
RDEPENDS:glibc-langpack-mnw = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-mr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-mr;unpack=0"
SRC_URI += "${URI_glibc-langpack-mr}"
SRC_URI[glibc-langpack-mr.sha256sum] = "c5de8f1966db1d247631a2e1d5617f91569b2d18e37c70573b0246176ad5d39f"
RDEPENDS:glibc-langpack-mr = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ms = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ms-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ms;unpack=0"
SRC_URI += "${URI_glibc-langpack-ms}"
SRC_URI[glibc-langpack-ms.sha256sum] = "26006fa35dbb731251ab4f6f1cf2ffd19c16974580865635e34125843537d802"
RDEPENDS:glibc-langpack-ms = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-mt = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mt-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-mt;unpack=0"
SRC_URI += "${URI_glibc-langpack-mt}"
SRC_URI[glibc-langpack-mt.sha256sum] = "6201b1e23525e9fcae8e116071e9464b45c61efdb18506d8c7e3aada4347ea17"
RDEPENDS:glibc-langpack-mt = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-my = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-my-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-my;unpack=0"
SRC_URI += "${URI_glibc-langpack-my}"
SRC_URI[glibc-langpack-my.sha256sum] = "29f63941a167eaf1e9d0f41c38ca2ae7b9109d7d0281f72703b2fb2a91efeb41"
RDEPENDS:glibc-langpack-my = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-nan = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nan-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-nan;unpack=0"
SRC_URI += "${URI_glibc-langpack-nan}"
SRC_URI[glibc-langpack-nan.sha256sum] = "39bd6933f499cc6cce646cce8c9e427c0366a9ab717c992d1e89e0f5f85c1d4d"
RDEPENDS:glibc-langpack-nan = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-nb = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nb-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-nb;unpack=0"
SRC_URI += "${URI_glibc-langpack-nb}"
SRC_URI[glibc-langpack-nb.sha256sum] = "e2056134a20df4410f807821e776b8f6beefd348940deb695d3379e8ec568de0"
RDEPENDS:glibc-langpack-nb = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-nds = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nds-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-nds;unpack=0"
SRC_URI += "${URI_glibc-langpack-nds}"
SRC_URI[glibc-langpack-nds.sha256sum] = "6b3737b1162c08a76a518aa6824d28fdd278d77d284c0b3e937b9c7d5edbe221"
RDEPENDS:glibc-langpack-nds = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ne = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ne-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ne;unpack=0"
SRC_URI += "${URI_glibc-langpack-ne}"
SRC_URI[glibc-langpack-ne.sha256sum] = "4c2a067f3ed85d5b7f40b4c0b0db04910e363af25096eaca7bea2553597a46ef"
RDEPENDS:glibc-langpack-ne = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-nhn = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nhn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-nhn;unpack=0"
SRC_URI += "${URI_glibc-langpack-nhn}"
SRC_URI[glibc-langpack-nhn.sha256sum] = "33a95bffd37243d1cf90feb5cee2bf6677890faa377555abd5120048f34a54a0"
RDEPENDS:glibc-langpack-nhn = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-niu = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-niu-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-niu;unpack=0"
SRC_URI += "${URI_glibc-langpack-niu}"
SRC_URI[glibc-langpack-niu.sha256sum] = "6898c48b2ae8dadd9b1c494bf3f10fb64c1cea23aae0a857951ca714e18e7452"
RDEPENDS:glibc-langpack-niu = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-nl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-nl;unpack=0"
SRC_URI += "${URI_glibc-langpack-nl}"
SRC_URI[glibc-langpack-nl.sha256sum] = "7630333de24063cfd87cc6114e85646966bd0410e59c8f70cf32e6977f6d1541"
RDEPENDS:glibc-langpack-nl = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-nn = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-nn;unpack=0"
SRC_URI += "${URI_glibc-langpack-nn}"
SRC_URI[glibc-langpack-nn.sha256sum] = "bbe629476ea2bcd83cc5dd95c3ced611ebd0a929d507903e6507480b0d9c4605"
RDEPENDS:glibc-langpack-nn = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-nr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-nr;unpack=0"
SRC_URI += "${URI_glibc-langpack-nr}"
SRC_URI[glibc-langpack-nr.sha256sum] = "1cc417a9afb1744baa3d0096b1c2269e1bebc6ff2874f84e0c72d193574e3a49"
RDEPENDS:glibc-langpack-nr = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-nso = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nso-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-nso;unpack=0"
SRC_URI += "${URI_glibc-langpack-nso}"
SRC_URI[glibc-langpack-nso.sha256sum] = "1d6f85d00553940a8015d5e61d64f2e09b4c38d316d8f28250c0d236ce3494b6"
RDEPENDS:glibc-langpack-nso = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-oc = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-oc-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-oc;unpack=0"
SRC_URI += "${URI_glibc-langpack-oc}"
SRC_URI[glibc-langpack-oc.sha256sum] = "45a9d789c780a2d067dd5c888c57ddd37cf1c54ad61f02895ed5671897f712c4"
RDEPENDS:glibc-langpack-oc = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-om = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-om-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-om;unpack=0"
SRC_URI += "${URI_glibc-langpack-om}"
SRC_URI[glibc-langpack-om.sha256sum] = "18f9ce9960943a92d001fd170f13189155b86b5d1f55564773240cb7d0271a5c"
RDEPENDS:glibc-langpack-om = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-or = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-or-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-or;unpack=0"
SRC_URI += "${URI_glibc-langpack-or}"
SRC_URI[glibc-langpack-or.sha256sum] = "fa7a82c832caef7e0969696d6f608100229945778dfc18ab1d3b7fbd3c13ea59"
RDEPENDS:glibc-langpack-or = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-os = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-os-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-os;unpack=0"
SRC_URI += "${URI_glibc-langpack-os}"
SRC_URI[glibc-langpack-os.sha256sum] = "df51300c6a10ff855adebe844cc2eaf68e30a57c60bfdd495638bea53a696600"
RDEPENDS:glibc-langpack-os = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-pa = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pa-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-pa;unpack=0"
SRC_URI += "${URI_glibc-langpack-pa}"
SRC_URI[glibc-langpack-pa.sha256sum] = "209323f9303f46ba12d36785b7b7202494529aa41670d6e868ceac5dd44ed805"
RDEPENDS:glibc-langpack-pa = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-pap = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pap-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-pap;unpack=0"
SRC_URI += "${URI_glibc-langpack-pap}"
SRC_URI[glibc-langpack-pap.sha256sum] = "caeb23e7ee15c23dce183a44c407f77cd46482bf977594fab3de254f3ca522c8"
RDEPENDS:glibc-langpack-pap = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-pl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-pl;unpack=0"
SRC_URI += "${URI_glibc-langpack-pl}"
SRC_URI[glibc-langpack-pl.sha256sum] = "1b8cb2dea821864ae73d579705327b612f1c51148c41f957a594430521e41a17"
RDEPENDS:glibc-langpack-pl = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ps = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ps-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ps;unpack=0"
SRC_URI += "${URI_glibc-langpack-ps}"
SRC_URI[glibc-langpack-ps.sha256sum] = "ddf1c1554e2d2c5ecfba0236db791c95ac46ab18bef5a69b2fe4601c77836a79"
RDEPENDS:glibc-langpack-ps = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-pt = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pt-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-pt;unpack=0"
SRC_URI += "${URI_glibc-langpack-pt}"
SRC_URI[glibc-langpack-pt.sha256sum] = "5c4e32066a76bf123830bf8ea77e30835d600dfd305ed14c29ccaa993476cf20"
RDEPENDS:glibc-langpack-pt = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-quz = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-quz-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-quz;unpack=0"
SRC_URI += "${URI_glibc-langpack-quz}"
SRC_URI[glibc-langpack-quz.sha256sum] = "0d1aaed20f444a9cba2e491efc3b50e507784fad24f473b1327a2be0bce21141"
RDEPENDS:glibc-langpack-quz = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-raj = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-raj-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-raj;unpack=0"
SRC_URI += "${URI_glibc-langpack-raj}"
SRC_URI[glibc-langpack-raj.sha256sum] = "80d19a83cf0380a5d0d9f74e5d2956309ffe743e1b13600521bc645989ecdf15"
RDEPENDS:glibc-langpack-raj = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-rif = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-rif-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-rif;unpack=0"
SRC_URI += "${URI_glibc-langpack-rif}"
SRC_URI[glibc-langpack-rif.sha256sum] = "db4442c17b8fdcb92e5b237d886d915262e30e729719d170abce37aef4d038f3"
RDEPENDS:glibc-langpack-rif = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ro = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ro-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ro;unpack=0"
SRC_URI += "${URI_glibc-langpack-ro}"
SRC_URI[glibc-langpack-ro.sha256sum] = "589e100395fcf9987b35b691ce74c4eddf40ee8f3fba416590a9378b95e722d2"
RDEPENDS:glibc-langpack-ro = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ru = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ru-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ru;unpack=0"
SRC_URI += "${URI_glibc-langpack-ru}"
SRC_URI[glibc-langpack-ru.sha256sum] = "63cad8eddfb3c79af3360906083387daf811469f3763924972faf2c1d91814f1"
RDEPENDS:glibc-langpack-ru = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-rw = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-rw-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-rw;unpack=0"
SRC_URI += "${URI_glibc-langpack-rw}"
SRC_URI[glibc-langpack-rw.sha256sum] = "87bdd23fc5ecbc689b621b9485fb338bd87e8d79f2b57819f6bb15b8b8314788"
RDEPENDS:glibc-langpack-rw = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-sa = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sa-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-sa;unpack=0"
SRC_URI += "${URI_glibc-langpack-sa}"
SRC_URI[glibc-langpack-sa.sha256sum] = "05ee16d0722bbcec776ad03e5ba2d36a48c1ee7069133a7411307e58258fa46e"
RDEPENDS:glibc-langpack-sa = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-sah = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sah-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-sah;unpack=0"
SRC_URI += "${URI_glibc-langpack-sah}"
SRC_URI[glibc-langpack-sah.sha256sum] = "bae06924ffb309eb0f0b30ee9367be685c9329c1b0491080518c6fdb7eda7285"
RDEPENDS:glibc-langpack-sah = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-sat = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sat-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-sat;unpack=0"
SRC_URI += "${URI_glibc-langpack-sat}"
SRC_URI[glibc-langpack-sat.sha256sum] = "a06caf609deb8f1434c8ff4e484f2e409bb1bd24669154070131fd3f29885994"
RDEPENDS:glibc-langpack-sat = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-sc = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sc-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-sc;unpack=0"
SRC_URI += "${URI_glibc-langpack-sc}"
SRC_URI[glibc-langpack-sc.sha256sum] = "6c559a9224fbea2df6dea71512bf90bb27ae32b997be1b5106a70d62aab8f1e2"
RDEPENDS:glibc-langpack-sc = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-sd = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sd-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-sd;unpack=0"
SRC_URI += "${URI_glibc-langpack-sd}"
SRC_URI[glibc-langpack-sd.sha256sum] = "b4b9d3a41561caea3aef6cfae551da20bc73c18f535ca9fadd8b13ba0f53ebc4"
RDEPENDS:glibc-langpack-sd = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-se = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-se-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-se;unpack=0"
SRC_URI += "${URI_glibc-langpack-se}"
SRC_URI[glibc-langpack-se.sha256sum] = "d9a30284bfbabdcf1226fa9eef475db052ed5ad49f6e3ed6fbd60ca9c152e0d6"
RDEPENDS:glibc-langpack-se = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-sgs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sgs-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-sgs;unpack=0"
SRC_URI += "${URI_glibc-langpack-sgs}"
SRC_URI[glibc-langpack-sgs.sha256sum] = "dee205394149429f6a6e22fe72549d2c1aa1e8db5ab21dff7d42b9151e97dfff"
RDEPENDS:glibc-langpack-sgs = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-shn = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-shn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-shn;unpack=0"
SRC_URI += "${URI_glibc-langpack-shn}"
SRC_URI[glibc-langpack-shn.sha256sum] = "2eb4c6394aa2b3de2f0a64ac2b25e4e5d78634f646405f7aacfd4db77995dc5e"
RDEPENDS:glibc-langpack-shn = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-shs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-shs-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-shs;unpack=0"
SRC_URI += "${URI_glibc-langpack-shs}"
SRC_URI[glibc-langpack-shs.sha256sum] = "e37b89f77141954dc329d27f1b79b00d4f5b7871e221625ee5359d2b07e7e4c4"
RDEPENDS:glibc-langpack-shs = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-si = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-si-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-si;unpack=0"
SRC_URI += "${URI_glibc-langpack-si}"
SRC_URI[glibc-langpack-si.sha256sum] = "7167c96f55fd5976eda55ec6cec9c8b89073b1fa06549d4ab5cf0b99df9b2cd0"
RDEPENDS:glibc-langpack-si = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-sid = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sid-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-sid;unpack=0"
SRC_URI += "${URI_glibc-langpack-sid}"
SRC_URI[glibc-langpack-sid.sha256sum] = "a1ed5eaff69bc12f9dafe9d0d068c3d5cac0d0f9d7c8c1447c16ee0d848e5024"
RDEPENDS:glibc-langpack-sid = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-sk = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sk-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-sk;unpack=0"
SRC_URI += "${URI_glibc-langpack-sk}"
SRC_URI[glibc-langpack-sk.sha256sum] = "8db4c241eec6e2ac4476d50591dc9e5cb60e15ebd971996419ff785a89aa627d"
RDEPENDS:glibc-langpack-sk = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-sl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-sl;unpack=0"
SRC_URI += "${URI_glibc-langpack-sl}"
SRC_URI[glibc-langpack-sl.sha256sum] = "fa4a009fd840f5a28827a49925d6acf9fa1b0d35532f40580dc6f10ab8828ab9"
RDEPENDS:glibc-langpack-sl = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-sm = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sm-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-sm;unpack=0"
SRC_URI += "${URI_glibc-langpack-sm}"
SRC_URI[glibc-langpack-sm.sha256sum] = "cc5b6fe5b0c36419b2efffebf478d690ce8bf2ace874b1227da0a7eee129ae32"
RDEPENDS:glibc-langpack-sm = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-so = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-so-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-so;unpack=0"
SRC_URI += "${URI_glibc-langpack-so}"
SRC_URI[glibc-langpack-so.sha256sum] = "5bb05fb3fe1afd0e44ff1f66528cc222b64a13e42ad3abb3a029ea3ac9fe72a1"
RDEPENDS:glibc-langpack-so = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-sq = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sq-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-sq;unpack=0"
SRC_URI += "${URI_glibc-langpack-sq}"
SRC_URI[glibc-langpack-sq.sha256sum] = "ebb041e7f5122995a0561cd6404049fa5f6931031587603904c97864107a51da"
RDEPENDS:glibc-langpack-sq = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-sr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-sr;unpack=0"
SRC_URI += "${URI_glibc-langpack-sr}"
SRC_URI[glibc-langpack-sr.sha256sum] = "707f5cf97cab8952dbe3e820049a1b5258e25497861872785ebce298aa7fca56"
RDEPENDS:glibc-langpack-sr = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ss = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ss-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ss;unpack=0"
SRC_URI += "${URI_glibc-langpack-ss}"
SRC_URI[glibc-langpack-ss.sha256sum] = "b335e22f0517b7242bc5f1b80ca0380fd160db50ac7390e3fa472c72b66c537a"
RDEPENDS:glibc-langpack-ss = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ssy = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ssy-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ssy;unpack=0"
SRC_URI += "${URI_glibc-langpack-ssy}"
SRC_URI[glibc-langpack-ssy.sha256sum] = "3e4017299b3f6e661b5ec2188391db2e3a0fd373a04178bbfdf2c11ec0365951"
RDEPENDS:glibc-langpack-ssy = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-st = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-st-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-st;unpack=0"
SRC_URI += "${URI_glibc-langpack-st}"
SRC_URI[glibc-langpack-st.sha256sum] = "3335bd036651f8cf335a497ad9ceefac898addd44e7b95dfcbf923e8a9e8ecc8"
RDEPENDS:glibc-langpack-st = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-su = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-su-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-su;unpack=0"
SRC_URI += "${URI_glibc-langpack-su}"
SRC_URI[glibc-langpack-su.sha256sum] = "6dd7a9f3ee37e345b1d8a736e03a5bde381849f7681799bc3f4e2a46dcd9acee"
RDEPENDS:glibc-langpack-su = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-sv = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sv-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-sv;unpack=0"
SRC_URI += "${URI_glibc-langpack-sv}"
SRC_URI[glibc-langpack-sv.sha256sum] = "4a1063420aae8b2f5ab8a0022d53e9ff104be8c505ef61c9677ebc3bb0787817"
RDEPENDS:glibc-langpack-sv = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-sw = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sw-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-sw;unpack=0"
SRC_URI += "${URI_glibc-langpack-sw}"
SRC_URI[glibc-langpack-sw.sha256sum] = "d9889f2aaceaf269c31ba53871eafa0f5a6604d3e2f23a5bdcff9e5d94a7fb17"
RDEPENDS:glibc-langpack-sw = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-syr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-syr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-syr;unpack=0"
SRC_URI += "${URI_glibc-langpack-syr}"
SRC_URI[glibc-langpack-syr.sha256sum] = "62ed6ac7b9fcda62d01317755b8a231524f9bcad485bc13b700db0953ac67f08"
RDEPENDS:glibc-langpack-syr = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-szl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-szl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-szl;unpack=0"
SRC_URI += "${URI_glibc-langpack-szl}"
SRC_URI[glibc-langpack-szl.sha256sum] = "8ad2333526c777bf813a6b4875bca22e0358ca498bab7a4f7494d2126dc4d966"
RDEPENDS:glibc-langpack-szl = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ta = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ta-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ta;unpack=0"
SRC_URI += "${URI_glibc-langpack-ta}"
SRC_URI[glibc-langpack-ta.sha256sum] = "f48090daa7e7c6eb3fe0621c99473ea75ac5e833f68330d39c07e1ef8a742edd"
RDEPENDS:glibc-langpack-ta = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-tcy = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tcy-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-tcy;unpack=0"
SRC_URI += "${URI_glibc-langpack-tcy}"
SRC_URI[glibc-langpack-tcy.sha256sum] = "9e291289a3780468d86c425737fb341ab1ad5a036ab0c05ee51cddac55dc4834"
RDEPENDS:glibc-langpack-tcy = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-te = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-te-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-te;unpack=0"
SRC_URI += "${URI_glibc-langpack-te}"
SRC_URI[glibc-langpack-te.sha256sum] = "138a2a2461d9a43e242c374220f8aa6a32f9cb0d812fb5a9f26d710cba498760"
RDEPENDS:glibc-langpack-te = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-tg = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tg-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-tg;unpack=0"
SRC_URI += "${URI_glibc-langpack-tg}"
SRC_URI[glibc-langpack-tg.sha256sum] = "903e88d961072677bd21158de52c676c0c0690aa70cad32f304c3c43637fb953"
RDEPENDS:glibc-langpack-tg = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-th = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-th-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-th;unpack=0"
SRC_URI += "${URI_glibc-langpack-th}"
SRC_URI[glibc-langpack-th.sha256sum] = "0b85f2cce1fd5ecb1a9ac596973e2a4abf7552dc10fba007571c1cf86874f0ef"
RDEPENDS:glibc-langpack-th = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-the = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-the-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-the;unpack=0"
SRC_URI += "${URI_glibc-langpack-the}"
SRC_URI[glibc-langpack-the.sha256sum] = "d17c1481b789128472bcc2f41892a4d78c359ac421a071af29b040ca36f19288"
RDEPENDS:glibc-langpack-the = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ti = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ti-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ti;unpack=0"
SRC_URI += "${URI_glibc-langpack-ti}"
SRC_URI[glibc-langpack-ti.sha256sum] = "89f96310c5fca941524e6cd09df7970d2b38d6807531b6c54836ac001a978151"
RDEPENDS:glibc-langpack-ti = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-tig = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tig-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-tig;unpack=0"
SRC_URI += "${URI_glibc-langpack-tig}"
SRC_URI[glibc-langpack-tig.sha256sum] = "ee18c9788e91ece7091d941978834d3502ca49683f0ccefd4fd254668e7db951"
RDEPENDS:glibc-langpack-tig = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-tk = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tk-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-tk;unpack=0"
SRC_URI += "${URI_glibc-langpack-tk}"
SRC_URI[glibc-langpack-tk.sha256sum] = "7dffa1baddf503d2238506462d69f5e51c104be6d6095ab65cb43ad24d99e1bc"
RDEPENDS:glibc-langpack-tk = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-tl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-tl;unpack=0"
SRC_URI += "${URI_glibc-langpack-tl}"
SRC_URI[glibc-langpack-tl.sha256sum] = "e9d7a48ba2e791913df08c0693e64f6713c99c12007edcefc3201f084b4be15d"
RDEPENDS:glibc-langpack-tl = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-tn = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-tn;unpack=0"
SRC_URI += "${URI_glibc-langpack-tn}"
SRC_URI[glibc-langpack-tn.sha256sum] = "2ed33848eff6b48cc02f66a5e448f6474f51c11fc5f28841307c6fa66b070489"
RDEPENDS:glibc-langpack-tn = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-to = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-to-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-to;unpack=0"
SRC_URI += "${URI_glibc-langpack-to}"
SRC_URI[glibc-langpack-to.sha256sum] = "54ce17ab3649d8ee2cbb10c62d60a7b952bbb5b744424950c2b7f2e3a2172c0e"
RDEPENDS:glibc-langpack-to = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-tok = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tok-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-tok;unpack=0"
SRC_URI += "${URI_glibc-langpack-tok}"
SRC_URI[glibc-langpack-tok.sha256sum] = "1d2a81efafd8dae4816f5e1945ac99b7651f97b66b16ea0e17e507e69f9664b6"
RDEPENDS:glibc-langpack-tok = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-tpi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tpi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-tpi;unpack=0"
SRC_URI += "${URI_glibc-langpack-tpi}"
SRC_URI[glibc-langpack-tpi.sha256sum] = "43d85b4c75df83dc43a947ebd54a82cdf47fe23cd2e3f7a46b95e1519751ad91"
RDEPENDS:glibc-langpack-tpi = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-tr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-tr;unpack=0"
SRC_URI += "${URI_glibc-langpack-tr}"
SRC_URI[glibc-langpack-tr.sha256sum] = "c126068ee43cf3619c872a27f7b4ebb5bee27e20f22a64b5f60c2c339fcc5fa6"
RDEPENDS:glibc-langpack-tr = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ts = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ts-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ts;unpack=0"
SRC_URI += "${URI_glibc-langpack-ts}"
SRC_URI[glibc-langpack-ts.sha256sum] = "06c0408e18315ac7fcadd72518c2c0a5f0c92d2ed17ba88a8e60021754a514f7"
RDEPENDS:glibc-langpack-ts = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-tt = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tt-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-tt;unpack=0"
SRC_URI += "${URI_glibc-langpack-tt}"
SRC_URI[glibc-langpack-tt.sha256sum] = "249271de2fb38b9f95b869577f556dc698708ca78ad88b5535774fd1d57a5224"
RDEPENDS:glibc-langpack-tt = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ug = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ug-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ug;unpack=0"
SRC_URI += "${URI_glibc-langpack-ug}"
SRC_URI[glibc-langpack-ug.sha256sum] = "d235c10d332470121d89edd66494070d8ddf591ca3903201754c8d8e1e26e47a"
RDEPENDS:glibc-langpack-ug = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-uk = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-uk-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-uk;unpack=0"
SRC_URI += "${URI_glibc-langpack-uk}"
SRC_URI[glibc-langpack-uk.sha256sum] = "22dfaf91752bc1d30123f1a4e88b2e8f65d9b79350e20b84ed539061812cf8dd"
RDEPENDS:glibc-langpack-uk = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-unm = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-unm-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-unm;unpack=0"
SRC_URI += "${URI_glibc-langpack-unm}"
SRC_URI[glibc-langpack-unm.sha256sum] = "102a663f7166b07ba3bfad1144885f56742d98bdc0fbf1bef2421ece8f5d00eb"
RDEPENDS:glibc-langpack-unm = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ur = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ur-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ur;unpack=0"
SRC_URI += "${URI_glibc-langpack-ur}"
SRC_URI[glibc-langpack-ur.sha256sum] = "9ad3fbb1f30cfc81c5993219499456c8c6d35719869c6ab3ee864c7a543b34cd"
RDEPENDS:glibc-langpack-ur = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-uz = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-uz-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-uz;unpack=0"
SRC_URI += "${URI_glibc-langpack-uz}"
SRC_URI[glibc-langpack-uz.sha256sum] = "d040eee4aa8d736b1ca23824c792dd8b5762162c0654c609b32af2015684cf39"
RDEPENDS:glibc-langpack-uz = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-ve = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ve-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-ve;unpack=0"
SRC_URI += "${URI_glibc-langpack-ve}"
SRC_URI[glibc-langpack-ve.sha256sum] = "972e266237cefda8ada2009eb30faffd9c43def9210bddc3ef1cefcd8353c901"
RDEPENDS:glibc-langpack-ve = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-vi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-vi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-vi;unpack=0"
SRC_URI += "${URI_glibc-langpack-vi}"
SRC_URI[glibc-langpack-vi.sha256sum] = "3ad4115e125e40902e007ca771cdb5d10ccd821e27cfc08831ea293bedfcb344"
RDEPENDS:glibc-langpack-vi = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-wa = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wa-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-wa;unpack=0"
SRC_URI += "${URI_glibc-langpack-wa}"
SRC_URI[glibc-langpack-wa.sha256sum] = "7eac5e7dbfc71d04104dbe9e4604eaa8b54424d74e7adb47446e8a8123885605"
RDEPENDS:glibc-langpack-wa = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-wae = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wae-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-wae;unpack=0"
SRC_URI += "${URI_glibc-langpack-wae}"
SRC_URI[glibc-langpack-wae.sha256sum] = "b42cc3f4c77db6f3194876d0f8c35427510cd6aed0437b7aa0366b1191f585a2"
RDEPENDS:glibc-langpack-wae = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-wal = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wal-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-wal;unpack=0"
SRC_URI += "${URI_glibc-langpack-wal}"
SRC_URI[glibc-langpack-wal.sha256sum] = "3188dadc7c043575a93414e7e0c69b0c143d238a07632a8a10db45e5cac03e8d"
RDEPENDS:glibc-langpack-wal = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-wo = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wo-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-wo;unpack=0"
SRC_URI += "${URI_glibc-langpack-wo}"
SRC_URI[glibc-langpack-wo.sha256sum] = "c8952bdb065ec3a2718d23cc0cdbb6da751af2cc5c8b621c43b576feb0d40406"
RDEPENDS:glibc-langpack-wo = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-xh = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-xh-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-xh;unpack=0"
SRC_URI += "${URI_glibc-langpack-xh}"
SRC_URI[glibc-langpack-xh.sha256sum] = "e8b23bf01c7e2a4f3c6ca3790851806631931381c89d2c3fd4e8922ddcf3deea"
RDEPENDS:glibc-langpack-xh = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-yi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-yi;unpack=0"
SRC_URI += "${URI_glibc-langpack-yi}"
SRC_URI[glibc-langpack-yi.sha256sum] = "f483284d676dac90b68447357bf2c372bf512d356d3c9801daf9f03eb9237205"
RDEPENDS:glibc-langpack-yi = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-yo = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yo-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-yo;unpack=0"
SRC_URI += "${URI_glibc-langpack-yo}"
SRC_URI[glibc-langpack-yo.sha256sum] = "838b19155ee5ce5de8eebcc66c58209be34ac92544b2b3867efbaefa0aba51b4"
RDEPENDS:glibc-langpack-yo = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-yue = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yue-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-yue;unpack=0"
SRC_URI += "${URI_glibc-langpack-yue}"
SRC_URI[glibc-langpack-yue.sha256sum] = "e9d32cfc5237e0c7e981ad6056ad827b4e96e57ee06c07fb4e8a48842a25fa8e"
RDEPENDS:glibc-langpack-yue = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-yuw = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yuw-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-yuw;unpack=0"
SRC_URI += "${URI_glibc-langpack-yuw}"
SRC_URI[glibc-langpack-yuw.sha256sum] = "726ad8dc06edbbfbc6806205a30b539b47b31319fe884cd476834bee151ee20d"
RDEPENDS:glibc-langpack-yuw = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-zgh = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-zgh-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-zgh;unpack=0"
SRC_URI += "${URI_glibc-langpack-zgh}"
SRC_URI[glibc-langpack-zgh.sha256sum] = "85408a21feff2b94ee9e6e18e91a6508a1832a395f34bc891ea5148af4882bf4"
RDEPENDS:glibc-langpack-zgh = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-zh = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-zh-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-zh;unpack=0"
SRC_URI += "${URI_glibc-langpack-zh}"
SRC_URI[glibc-langpack-zh.sha256sum] = "6a56cd57f8d676db91ec40033fe5cdd07c0f433f6b0f8ae7419a7eb762fedad2"
RDEPENDS:glibc-langpack-zh = " \
 glibc-common \
 glibc \
"

URI_glibc-langpack-zu = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-langpack-zu-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-langpack-zu;unpack=0"
SRC_URI += "${URI_glibc-langpack-zu}"
SRC_URI[glibc-langpack-zu.sha256sum] = "ec512dda875304939070bf64e22b56219f17973ba444a03616c0e1c93194b67d"
RDEPENDS:glibc-langpack-zu = " \
 glibc-common \
 glibc \
"

URI_glibc-minimal-langpack = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glibc-minimal-langpack-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-minimal-langpack;unpack=0"
SRC_URI += "${URI_glibc-minimal-langpack}"
SRC_URI[glibc-minimal-langpack.sha256sum] = "03a104e2792d877edd06efd040f5aed1c628231512cc02ea28b1c82250503644"
RDEPENDS:glibc-minimal-langpack = " \
 glibc-common \
 glibc \
"

URI_libnsl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libnsl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=libnsl;unpack=0"
SRC_URI += "${URI_libnsl}"
SRC_URI[libnsl.sha256sum] = "5e5c6edb7b71d06c1e2641b4853abebb1b6f8835fc0b46741dcab023a42fd9d9"
RDEPENDS:libnsl = " \
 glibc \
"

URI_glibc-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/glibc-devel-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-devel;unpack=0"
SRC_URI += "${URI_glibc-devel}"
SRC_URI[glibc-devel.sha256sum] = "c31fe58a113534655bf8e17ed4aba3e9b3c1045e11f05f039e5f7d034ce66a0c"
RDEPENDS:glibc-devel = " \
 glibc \
 kernel-headers \
 libxcrypt-devel \
"

URI_glibc-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/glibc-doc-2.39-46.el10_0.4.alma.1.noarch.rpm;name=glibc-doc;unpack=0"
SRC_URI += "${URI_glibc-doc}"
SRC_URI[glibc-doc.sha256sum] = "d425eba84ead05dbb4a8da01c44663ed00c93a16e93fcb9e6c07fb5047b499d1"
RDEPENDS:glibc-doc = " \
 glibc \
"

URI_glibc-locale-source = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/glibc-locale-source-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-locale-source;unpack=0"
SRC_URI += "${URI_glibc-locale-source}"
SRC_URI[glibc-locale-source.sha256sum] = "8290806821c9c95005305ccf0df641af27f4bf45c6849980b9f6f6df758b5b04"
RDEPENDS:glibc-locale-source = " \
 glibc \
 glibc-common \
"

URI_glibc-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/glibc-utils-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-utils;unpack=0"
SRC_URI += "${URI_glibc-utils}"
SRC_URI[glibc-utils.sha256sum] = "7111e5c5f8ade3714d14730817ad86fba6e67c60cf661e93e5eac25c6b6343e1"
RDEPENDS:glibc-utils = " \
 gd \
 zlib-ng-compat \
 libpng \
 bash \
 glibc \
 perl-interpreter \
"

URI_glibc-benchtests = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/glibc-benchtests-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-benchtests;unpack=0"
SRC_URI += "${URI_glibc-benchtests}"
SRC_URI[glibc-benchtests.sha256sum] = "61aec7c297435b2a5234295089c3e7bd2853c0879c8b7a5dbdd720208a49c727"
RDEPENDS:glibc-benchtests = " \
 glibc \
 bash \
 python3 \
"

URI_glibc-nss-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/glibc-nss-devel-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-nss-devel;unpack=0"
SRC_URI += "${URI_glibc-nss-devel}"
SRC_URI[glibc-nss-devel.sha256sum] = "d284ea832fb96f3c0cd516f1bfa00fb4923d879f0cf19f9bb27f1f880d8447e4"
RDEPENDS:glibc-nss-devel = " \
 nss_db \
 glibc \
 nss_hesiod \
"

URI_glibc-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/glibc-static-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc-static;unpack=0"
SRC_URI += "${URI_glibc-static}"
SRC_URI[glibc-static.sha256sum] = "2a034916b7f071cbdbd75dfba04338acfbf9eb2554ec39b7eafdb0b2540d01a6"
RDEPENDS:glibc-static = " \
 glibc-devel \
 libxcrypt-static \
"

URI_nss_db = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/nss_db-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=nss_db;unpack=0"
SRC_URI += "${URI_nss_db}"
SRC_URI[nss_db.sha256sum] = "8d70e5ffbd4ff7589d095bfd679c205f72395bc45a6e1ac3db7d8996cf554cf0"
RDEPENDS:nss_db = " \
 glibc \
 libselinux \
"

URI_nss_hesiod = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/nss_hesiod-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=nss_hesiod;unpack=0"
SRC_URI += "${URI_nss_hesiod}"
SRC_URI[nss_hesiod.sha256sum] = "6fa2cea253dc6ced149dcfbf715bdfe6855cf742a6cde808014f1473f24b75cb"
RDEPENDS:nss_hesiod = " \
 glibc \
"

URI_compat-libpthread-nonshared = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/compat-libpthread-nonshared-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=compat-libpthread-nonshared;unpack=0"
SRC_URI += "${URI_compat-libpthread-nonshared}"
SRC_URI[compat-libpthread-nonshared.sha256sum] = "8d971e30ec33273ded19b53de3e9ef2851193835e2094ad8f21d5045c86f0e7c"
RDEPENDS:compat-libpthread-nonshared = ""

URI_glibc32 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/glibc32-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=glibc32;unpack=0"
SRC_URI += "${URI_glibc32}"
SRC_URI[glibc32.sha256sum] = "b0c5c8e5ef5f6cb83174c88a2d6ee89a4b7bee185bc1e8826301887fef4201e1"
RDEPENDS:glibc32 = ""

URI_sysroot-aarch64-el10-glibc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sysroot-aarch64-el10-glibc-2.39-46.el10_0.4.alma.1.noarch.rpm;name=sysroot-aarch64-el10-glibc;unpack=0"
SRC_URI += "${URI_sysroot-aarch64-el10-glibc}"
SRC_URI[sysroot-aarch64-el10-glibc.sha256sum] = "d712c3b49c7d0b609b0632811002daed793f57c4addbff3e3fa6430293992907"
RDEPENDS:sysroot-aarch64-el10-glibc = ""

URI_sysroot-ppc64le-el10-glibc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sysroot-ppc64le-el10-glibc-2.39-46.el10_0.4.alma.1.noarch.rpm;name=sysroot-ppc64le-el10-glibc;unpack=0"
SRC_URI += "${URI_sysroot-ppc64le-el10-glibc}"
SRC_URI[sysroot-ppc64le-el10-glibc.sha256sum] = "ea28b429f77d85e6fc11fdeb31c91d0d6deaa7486c7ff4abc3e651163e17cb1d"
RDEPENDS:sysroot-ppc64le-el10-glibc = ""

URI_sysroot-s390x-el10-glibc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sysroot-s390x-el10-glibc-2.39-46.el10_0.4.alma.1.noarch.rpm;name=sysroot-s390x-el10-glibc;unpack=0"
SRC_URI += "${URI_sysroot-s390x-el10-glibc}"
SRC_URI[sysroot-s390x-el10-glibc.sha256sum] = "93b336dd98ccf7a862afc242bfa74a1f2ee0d2b1b099cff882f5e4edc683902a"
RDEPENDS:sysroot-s390x-el10-glibc = ""

URI_sysroot-x86_64-el10-glibc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sysroot-x86_64-el10-glibc-2.39-46.el10_0.4.alma.1.noarch.rpm;name=sysroot-x86_64-el10-glibc;unpack=0"
SRC_URI += "${URI_sysroot-x86_64-el10-glibc}"
SRC_URI[sysroot-x86_64-el10-glibc.sha256sum] = "0693e9920c439cec762e6ef6a0603a1274295a642c7bccf5a48ad0f500a3721e"
RDEPENDS:sysroot-x86_64-el10-glibc = ""
