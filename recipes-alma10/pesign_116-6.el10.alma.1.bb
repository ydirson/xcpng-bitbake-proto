# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pesign"
PE = "0"
PV = "116"
PR = "6.el10.alma.1"
PACKAGES = "pesign"
PROVIDES = "rpm/pesign"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/pesign-116-6.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "967bb3b5bf1297de5e804fc79465875a407aca27b5a12c773fa09f70fd552d4b"

URI_pesign = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pesign-116-6.el10.alma.1.x86_64_v2.rpm;name=pesign;unpack=0"
SRC_URI += "${URI_pesign}"
SRC_URI[pesign.sha256sum] = "14575391c554de0aec3fb86935ddcf971fdfeccf628073c7827b7a9e7ee77c48"
RDEPENDS:pesign = " \
 python3 \
 libuuid \
 shadow-utils \
 nss \
 efivar-libs \
 nss-tools \
 bash \
 nss-util \
 popt \
 glibc \
 rpm \
 nspr \
"
