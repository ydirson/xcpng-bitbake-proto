# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "kbd"
PE = "0"
PV = "2.6.4"
PR = "7.el10"
PACKAGES = "kbd kbd-legacy kbd-misc"
PROVIDES = "rpm/kbd rpm/kbd-legacy rpm/kbd-misc"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/kbd-2.6.4-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed225971b242dabbc6c9a679bf3ac3e54245aa1a69b7650853dcedd411b55370"

URI_kbd = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kbd-2.6.4-7.el10.x86_64_v2.rpm;name=kbd;unpack=0"
SRC_URI += "${URI_kbd}"
SRC_URI[kbd.sha256sum] = "3b8c3257453a8997c532d30942fcba8420dccde0aa4b837b3cf5234295ba323d"
RDEPENDS:kbd = " \
 kbd-legacy \
 pam-libs \
 kbd-misc \
 bash \
 glibc \
"

URI_kbd-legacy = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kbd-legacy-2.6.4-7.el10.noarch.rpm;name=kbd-legacy;unpack=0"
SRC_URI += "${URI_kbd-legacy}"
SRC_URI[kbd-legacy.sha256sum] = "917c3a364af51906ed6f2cda6a8cf96fbd289db4a89fe00ebac05c891b376cc3"
RDEPENDS:kbd-legacy = ""

URI_kbd-misc = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kbd-misc-2.6.4-7.el10.noarch.rpm;name=kbd-misc;unpack=0"
SRC_URI += "${URI_kbd-misc}"
SRC_URI[kbd-misc.sha256sum] = "31fe9f6cf4d15b62d605263bd749cb1f37842b4fa3517b37b9bdbf35b855f8c3"
RDEPENDS:kbd-misc = ""
