# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mutt"
PE = "5"
PV = "2.2.13"
PR = "4.el10"
PACKAGES = "mutt"
PROVIDES = "rpm/mutt"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mutt-2.2.13-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11a6f56b136625ce46dc45f191609fa3ab279df554f8d4e9308a519dfea6925e"

URI_mutt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mutt-2.2.13-4.el10.x86_64_v2.rpm;name=mutt;unpack=0"
SRC_URI += "${URI_mutt}"
SRC_URI[mutt.sha256sum] = "3219313069aba95d5a7747fa27cb5a58a36946449b3bf17dcb8a6a0206750b83"
RDEPENDS:mutt = " \
 zlib-ng-compat \
 perl-libs \
 gnutls \
 gpgme \
 mailcap \
 urlview \
 libgpg-error \
 krb5-libs \
 cyrus-sasl-lib \
 perl-File-Copy \
 ncurses-libs \
 libidn2 \
 tokyocabinet \
 glibc \
 perl-interpreter \
 perl-File-Temp \
 perl-Time-Local \
"
