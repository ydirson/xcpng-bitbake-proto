# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "emacs-auctex"
PE = "0"
PV = "13.3"
PR = "5.el10"
PACKAGES = "emacs-auctex tex-preview emacs-auctex-doc"
PROVIDES = "rpm/emacs-auctex rpm/tex-preview rpm/emacs-auctex-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/emacs-auctex-13.3-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c823e3da07bee594a1c8d278fbe4a574886026cee7465bff4e1b6e1ef7805711"

URI_emacs-auctex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/emacs-auctex-13.3-5.el10.noarch.rpm;name=emacs-auctex;unpack=0"
SRC_URI += "${URI_emacs-auctex}"
SRC_URI[emacs-auctex.sha256sum] = "90bf98e1edda6961ee7d2a0bb4923a1f0e5a9a350bf66b9d53e6bcb115ec9ec7"
RDEPENDS:emacs-auctex = " \
 emacs \
 texlive-collection-latexrecommended \
 tex-preview \
 texlive-dvipng \
 texlive-dvips \
 ghostscript \
"

URI_tex-preview = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tex-preview-13.3-5.el10.noarch.rpm;name=tex-preview;unpack=0"
SRC_URI += "${URI_tex-preview}"
SRC_URI[tex-preview.sha256sum] = "15081a6ea3f78aa532220806d4d3e27550d99d74f76284340fa26dac0385e672"
RDEPENDS:tex-preview = " \
 texlive-collection-latexrecommended \
"

URI_emacs-auctex-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/emacs-auctex-doc-13.3-5.el10.noarch.rpm;name=emacs-auctex-doc;unpack=0"
SRC_URI += "${URI_emacs-auctex-doc}"
SRC_URI[emacs-auctex-doc.sha256sum] = "75faa821af9c85e0dce07b35319369f4f317b733ac8ab1675694fce372c8ba15"
RDEPENDS:emacs-auctex-doc = ""
