# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "maven-antrun-plugin"
PE = "0"
PV = "3.1.0"
PR = "10.el10"
PACKAGES = "maven-antrun-plugin maven-antrun-plugin-javadoc"
PROVIDES = "rpm/maven-antrun-plugin rpm/maven-antrun-plugin-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/maven-antrun-plugin-3.1.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2bd39c8a4150e7ceba8a6057d0d43db3f5f50cd136ac60f262d19d26a17f391c"

URI_maven-antrun-plugin = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-antrun-plugin-3.1.0-10.el10.noarch.rpm;name=maven-antrun-plugin;unpack=0"
SRC_URI += "${URI_maven-antrun-plugin}"
SRC_URI[maven-antrun-plugin.sha256sum] = "297b94aa8ef1b5d2baaf8c920d5f424377efbae80ac3b8cc160f8cc494d5b111"
RDEPENDS:maven-antrun-plugin = " \
 ant-lib \
 plexus-utils \
 javapackages-filesystem \
"

URI_maven-antrun-plugin-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-antrun-plugin-javadoc-3.1.0-10.el10.noarch.rpm;name=maven-antrun-plugin-javadoc;unpack=0"
SRC_URI += "${URI_maven-antrun-plugin-javadoc}"
SRC_URI[maven-antrun-plugin-javadoc.sha256sum] = "a01a6eb5a5994cddf5cd05fa1d70910a12789739ba47c8d40d735c6b67a9c69c"
RDEPENDS:maven-antrun-plugin-javadoc = " \
 javapackages-filesystem \
"
