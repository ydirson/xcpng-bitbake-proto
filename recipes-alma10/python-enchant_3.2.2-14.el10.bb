# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-enchant"
PE = "0"
PV = "3.2.2"
PR = "14.el10"
PACKAGES = "python3-enchant"
PROVIDES = "rpm/python3-enchant"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-enchant-3.2.2-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9611c447aea15ac2d6e6fbbec11a3364706ba62d9003af5ce3760c6b5087a550"

URI_python3-enchant = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-enchant-3.2.2-14.el10.noarch.rpm;name=python3-enchant;unpack=0"
SRC_URI += "${URI_python3-enchant}"
SRC_URI[python3-enchant.sha256sum] = "0b2d1dbb8eec45a800627ad11fdf54ef643ae2d0597d6f13cc8e6b7acc73b57c"
RDEPENDS:python3-enchant = " \
 python3 \
 enchant2 \
"
