# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "flatpak"
PE = "0"
PV = "1.16.0"
PR = "5.el10"
PACKAGES = "flatpak flatpak-libs flatpak-selinux flatpak-session-helper flatpak-devel flatpak-tests"
PROVIDES = "rpm/flatpak rpm/flatpak-libs rpm/flatpak-selinux rpm/flatpak-session-helper rpm/flatpak-devel rpm/flatpak-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/flatpak-1.16.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55e294911c165f756f7be1731f0f3290f9f6aff8097eb7a1f2893cb664166fe9"

URI_flatpak = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/flatpak-1.16.0-5.el10.x86_64_v2.rpm;name=flatpak;unpack=0"
SRC_URI += "${URI_flatpak}"
SRC_URI[flatpak.sha256sum] = "7787f0a62064f49afe9f7684ee4625d524ac9896634de24c252cdf4b08e2d885"
RDEPENDS:flatpak = " \
 python3 \
 ostree-libs \
 xdg-dbus-proxy \
 flatpak-session-helper \
 flatpak-selinux \
 systemd-libs \
 appstream \
 libXau \
 libseccomp \
 libarchive \
 json-glib \
 dconf \
 libcurl \
 shadow-utils \
 libwayland-client \
 librsvg2 \
 libgcc \
 libxml2 \
 gdk-pixbuf2 \
 libzstd \
 bash \
 bubblewrap \
 fuse3 \
 fuse3-libs \
 polkit-libs \
 glib2 \
 glibc \
"

URI_flatpak-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/flatpak-libs-1.16.0-5.el10.x86_64_v2.rpm;name=flatpak-libs;unpack=0"
SRC_URI += "${URI_flatpak-libs}"
SRC_URI[flatpak-libs.sha256sum] = "2bda00819d730bd4df06ba525655f6dab38abbaad4b69891e23b369941094ac8"
RDEPENDS:flatpak-libs = " \
 ostree-libs \
 bubblewrap \
 systemd-libs \
 libarchive \
 libwayland-client \
 libseccomp \
 libgcc \
 libxml2 \
 json-glib \
 libzstd \
 libXau \
 glib2 \
 dconf \
 libcurl \
 glibc \
"

URI_flatpak-selinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/flatpak-selinux-1.16.0-5.el10.noarch.rpm;name=flatpak-selinux;unpack=0"
SRC_URI += "${URI_flatpak-selinux}"
SRC_URI[flatpak-selinux.sha256sum] = "a6dc6492d0087c5dab9dc6a8613097f98f6eb5d3f2e525f9cf1579b62ddeeabf"
RDEPENDS:flatpak-selinux = " \
 policycoreutils-python-utils \
 policycoreutils \
 bash \
 selinux-policy \
 libselinux-utils \
"

URI_flatpak-session-helper = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/flatpak-session-helper-1.16.0-5.el10.x86_64_v2.rpm;name=flatpak-session-helper;unpack=0"
SRC_URI += "${URI_flatpak-session-helper}"
SRC_URI[flatpak-session-helper.sha256sum] = "02c26682412ee49fda65134089401328e8e29892926c90e3463579675565210f"
RDEPENDS:flatpak-session-helper = " \
 glibc \
 libgcc \
 systemd \
 glib2 \
"

URI_flatpak-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/flatpak-devel-1.16.0-5.el10.x86_64_v2.rpm;name=flatpak-devel;unpack=0"
SRC_URI += "${URI_flatpak-devel}"
SRC_URI[flatpak-devel.sha256sum] = "21a3330c02644a06be2cafbfda6f12b182ab36d4656e68eb07f0d2be212cf7f8"
RDEPENDS:flatpak-devel = " \
 json-glib-devel \
 wayland-devel \
 flatpak-libs \
 glib2-devel \
 libarchive-devel \
 gpgme-devel \
 libxml2-devel \
 ostree-devel \
 systemd-devel \
 libzstd-devel \
 polkit-devel \
 pkgconf-pkg-config \
 libseccomp-devel \
 libXau-devel \
 libcurl-devel \
 dconf-devel \
 flatpak \
"

URI_flatpak-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/flatpak-tests-1.16.0-5.el10.x86_64_v2.rpm;name=flatpak-tests;unpack=0"
SRC_URI += "${URI_flatpak-tests}"
SRC_URI[flatpak-tests.sha256sum] = "f6ff9142a262cc0fbe19fc8441ae6a0cb27f9c0372e050bf6e8c7e2d40132b74"
RDEPENDS:flatpak-tests = " \
 python3 \
 flatpak-libs \
 ostree-libs \
 flatpak-session-helper \
 appstream \
 libXau \
 libseccomp \
 libarchive \
 json-glib \
 dconf \
 libcurl \
 libwayland-client \
 libgcc \
 bash \
 bubblewrap \
 fuse3-libs \
 glib2 \
 glibc \
 ostree \
 flatpak \
"
