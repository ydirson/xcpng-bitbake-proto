# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-editables"
PE = "0"
PV = "0.5"
PR = "3.el10"
PACKAGES = "python3-editables"
PROVIDES = "rpm/python3-editables"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/python-editables-0.5-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05ef6341cf96161a6be2bf0110938d77417adac60f62d32e6c21dbaf9c9bbd7d"

URI_python3-editables = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-editables-0.5-3.el10.noarch.rpm;name=python3-editables;unpack=0"
SRC_URI += "${URI_python3-editables}"
SRC_URI[python3-editables.sha256sum] = "7372b5e3497f28d4658f874f28feafe000878947ae59d58661289dfdd0aae167"
RDEPENDS:python3-editables = " \
 python3 \
"
