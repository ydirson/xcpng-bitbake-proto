# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libconfig"
PE = "0"
PV = "1.7.3"
PR = "10.el10"
PACKAGES = "libconfig libconfig-devel"
PROVIDES = "rpm/libconfig rpm/libconfig-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libconfig-1.7.3-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "13b829ca635604b51afebd889d3431ca5258882ff68998d6d29528687c7ee220"

URI_libconfig = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libconfig-1.7.3-10.el10.x86_64_v2.rpm;name=libconfig;unpack=0"
SRC_URI += "${URI_libconfig}"
SRC_URI[libconfig.sha256sum] = "1cde43f4f490fe36a3036444e58e3f22d7b9fdcbf6564ca2201811d51cc23e7a"
RDEPENDS:libconfig = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_libconfig-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libconfig-devel-1.7.3-10.el10.x86_64_v2.rpm;name=libconfig-devel;unpack=0"
SRC_URI += "${URI_libconfig-devel}"
SRC_URI[libconfig-devel.sha256sum] = "31e158b85e5043dcd2bac93a37717e4fd734b34a45b5b8020aeba372429db399"
RDEPENDS:libconfig-devel = " \
 libconfig \
 pkgconf-pkg-config \
"
