# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libell"
PE = "0"
PV = "0.62"
PR = "3.el10"
PACKAGES = "libell libell-devel"
PROVIDES = "rpm/libell rpm/libell-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libell-0.62-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "681ac4bb306f39e8feeac21ce4bae88c1b0eb7d4c89a42043bdd675a36dad61d"

URI_libell = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libell-0.62-3.el10.x86_64_v2.rpm;name=libell;unpack=0"
SRC_URI += "${URI_libell}"
SRC_URI[libell.sha256sum] = "6c37004ecd99b31d599f730f7c94a65d5fa88405bc05dd6ac12bcd01593a5d9a"
RDEPENDS:libell = " \
 glibc \
 libgcc \
"

URI_libell-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libell-devel-0.62-3.el10.x86_64_v2.rpm;name=libell-devel;unpack=0"
SRC_URI += "${URI_libell-devel}"
SRC_URI[libell-devel.sha256sum] = "2bfc436e98a4980a9cfcc31f3dc48390248b7d2d472c129b15514b56219ec4f2"
RDEPENDS:libell-devel = " \
 libell \
 pkgconf-pkg-config \
"
