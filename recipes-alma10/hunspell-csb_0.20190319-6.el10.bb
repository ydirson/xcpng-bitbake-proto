# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-csb"
PE = "0"
PV = "0.20190319"
PR = "6.el10"
PACKAGES = "hunspell-csb"
PROVIDES = "rpm/hunspell-csb"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-csb-0.20190319-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "783b619b30070283acb3d3a71592e0ddc622ef2c15eb7554baab3bbd9c0a0e2e"

URI_hunspell-csb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-csb-0.20190319-6.el10.noarch.rpm;name=hunspell-csb;unpack=0"
SRC_URI += "${URI_hunspell-csb}"
SRC_URI[hunspell-csb.sha256sum] = "c11a26ab6f958f370511c53201a6076a22703b49ff7cbf608cd591ebedbd7e83"
RDEPENDS:hunspell-csb = " \
 hunspell-filesystem \
"
