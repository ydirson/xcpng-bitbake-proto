# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mozilla-filesystem"
PE = "0"
PV = "1.9"
PR = "35.el10"
PACKAGES = "mozilla-filesystem"
PROVIDES = "rpm/mozilla-filesystem"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mozilla-filesystem-1.9-35.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4407bb8cd0ed6576bbe2151a556c9ec549ede56ed3c3cdddc9a20e30c504ebf"

URI_mozilla-filesystem = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mozilla-filesystem-1.9-35.el10.x86_64_v2.rpm;name=mozilla-filesystem;unpack=0"
SRC_URI += "${URI_mozilla-filesystem}"
SRC_URI[mozilla-filesystem.sha256sum] = "635b6da1a656263beb868153486b43c5cff8d1cc3085deabfd17a922e631d728"
RDEPENDS:mozilla-filesystem = ""
