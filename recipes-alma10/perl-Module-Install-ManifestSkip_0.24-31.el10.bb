# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Module-Install-ManifestSkip"
PE = "0"
PV = "0.24"
PR = "31.el10"
PACKAGES = "perl-Module-Install-ManifestSkip perl-Module-Install-ManifestSkip-tests"
PROVIDES = "rpm/perl-Module-Install-ManifestSkip rpm/perl-Module-Install-ManifestSkip-tests"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-Module-Install-ManifestSkip-0.24-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f700353278eabfea9a42c453e03e16bcc505f3cb7c197e36c65c4e03a1e6d8b3"

URI_perl-Module-Install-ManifestSkip = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Module-Install-ManifestSkip-0.24-31.el10.noarch.rpm;name=perl-Module-Install-ManifestSkip;unpack=0"
SRC_URI += "${URI_perl-Module-Install-ManifestSkip}"
SRC_URI[perl-Module-Install-ManifestSkip.sha256sum] = "1b826f277fd048a2560f5a65cf3f80b37db7d5661d5c511fd7ab0bf71993f7af"
RDEPENDS:perl-Module-Install-ManifestSkip = " \
 perl-Module-Install \
 perl-Module-Manifest-Skip \
 perl-libs \
 perl-base \
"

URI_perl-Module-Install-ManifestSkip-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Module-Install-ManifestSkip-tests-0.24-31.el10.noarch.rpm;name=perl-Module-Install-ManifestSkip-tests;unpack=0"
SRC_URI += "${URI_perl-Module-Install-ManifestSkip-tests}"
SRC_URI[perl-Module-Install-ManifestSkip-tests.sha256sum] = "31d2992fd0943d8920624c5a1db7a583b12e2a8f414dc4b95d288642431bd2bd"
RDEPENDS:perl-Module-Install-ManifestSkip-tests = " \
 perl-Module-Install-ManifestSkip \
 perl-Test-Harness \
 perl-Test-Simple \
 bash \
 perl-interpreter \
"
