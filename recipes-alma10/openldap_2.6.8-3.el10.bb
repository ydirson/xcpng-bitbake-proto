# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "openldap"
PE = "0"
PV = "2.6.8"
PR = "3.el10"
PACKAGES = "openldap openldap-clients openldap-compat openldap-devel"
PROVIDES = "rpm/openldap rpm/openldap-clients rpm/openldap-compat rpm/openldap-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/openldap-2.6.8-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae5435865581601c97775138899ab24742380fbae8118bee4781f9e4baebab0a"

URI_openldap = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/openldap-2.6.8-3.el10.x86_64_v2.rpm;name=openldap;unpack=0"
SRC_URI += "${URI_openldap}"
SRC_URI[openldap.sha256sum] = "d848551a02bb8edcfb8535238d88497357add4797950bb4593bc5d78a8a59a6c"
RDEPENDS:openldap = " \
 shadow-utils \
 libevent \
 openssl-libs \
 cyrus-sasl-lib \
 glibc \
"

URI_openldap-clients = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/openldap-clients-2.6.8-3.el10.x86_64_v2.rpm;name=openldap-clients;unpack=0"
SRC_URI += "${URI_openldap-clients}"
SRC_URI[openldap-clients.sha256sum] = "9ed3f2be5e965eb50b72e0ea9930e205e95d84ac916ec532d7f6f517fa2408ce"
RDEPENDS:openldap-clients = " \
 glibc \
 cyrus-sasl-lib \
 openldap \
"

URI_openldap-compat = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/openldap-compat-2.6.8-3.el10.x86_64_v2.rpm;name=openldap-compat;unpack=0"
SRC_URI += "${URI_openldap-compat}"
SRC_URI[openldap-compat.sha256sum] = "96c53de98ca5aa30068bec4ccdcac60210fb15ede2f405aa016a6ab2ab917528"
RDEPENDS:openldap-compat = " \
 glibc \
 openldap \
"

URI_openldap-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/openldap-devel-2.6.8-3.el10.x86_64_v2.rpm;name=openldap-devel;unpack=0"
SRC_URI += "${URI_openldap-devel}"
SRC_URI[openldap-devel.sha256sum] = "50e4152f221ccb4cd7740b4f13ef489430d6747e32b733d2e9024aaa524da1ca"
RDEPENDS:openldap-devel = " \
 openldap \
 cyrus-sasl-devel \
 pkgconf-pkg-config \
 openldap-devel \
"
