# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lttng-ust"
PE = "0"
PV = "2.13.7"
PR = "5.el10"
PACKAGES = "lttng-ust lttng-ust-devel python3-lttngust"
PROVIDES = "rpm/lttng-ust rpm/lttng-ust-devel rpm/python3-lttngust"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/lttng-ust-2.13.7-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cdf62b3b1781c3f922d5d2171255d536a619237766fcd7ad2fe67220674bd694"

URI_lttng-ust = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/lttng-ust-2.13.7-5.el10.x86_64_v2.rpm;name=lttng-ust;unpack=0"
SRC_URI += "${URI_lttng-ust}"
SRC_URI[lttng-ust.sha256sum] = "f0708030e079712c7f3d2e4a9dc537931ee2c4cd95bffc0df7b5122f9c8761ee"
RDEPENDS:lttng-ust = " \
 glibc \
 numactl-libs \
"

URI_lttng-ust-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/lttng-ust-devel-2.13.7-5.el10.x86_64_v2.rpm;name=lttng-ust-devel;unpack=0"
SRC_URI += "${URI_lttng-ust-devel}"
SRC_URI[lttng-ust-devel.sha256sum] = "574c72bf2ad4db7a0a12e4226095149e2fe95aad1875ef238451dbd021fdd43d"
RDEPENDS:lttng-ust-devel = " \
 python3 \
 userspace-rcu-devel \
 pkgconf-pkg-config \
 systemtap-sdt-devel \
 lttng-ust \
"

URI_python3-lttngust = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-lttngust-2.13.7-5.el10.x86_64_v2.rpm;name=python3-lttngust;unpack=0"
SRC_URI += "${URI_python3-lttngust}"
SRC_URI[python3-lttngust.sha256sum] = "68ded08e02665d8ee103630a75cb6824119f48c35018f6ad5c6c7daa768a816d"
RDEPENDS:python3-lttngust = " \
 python3 \
 lttng-ust \
"
