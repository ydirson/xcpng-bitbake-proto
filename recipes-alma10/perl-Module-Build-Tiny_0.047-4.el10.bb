# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Module-Build-Tiny"
PE = "0"
PV = "0.047"
PR = "4.el10"
PACKAGES = "perl-Module-Build-Tiny"
PROVIDES = "rpm/perl-Module-Build-Tiny"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-Module-Build-Tiny-0.047-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ccbff7099b64ad1f58e31c91c15a71162cc4c0a748b6b6e0091a0e03043910a"

URI_perl-Module-Build-Tiny = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Module-Build-Tiny-0.047-4.el10.noarch.rpm;name=perl-Module-Build-Tiny;unpack=0"
SRC_URI += "${URI_perl-Module-Build-Tiny}"
SRC_URI[perl-Module-Build-Tiny.sha256sum] = "c080080f1ca7bb593d04fb83643b71a5e1e91d5c76873d27472729c3b78eabe2"
RDEPENDS:perl-Module-Build-Tiny = " \
 perl-CPAN-Meta \
 perl-ExtUtils-Install \
 perl-Test-Harness \
 perl-libs \
 perl-ExtUtils-Config \
 perl-ExtUtils-Helpers \
 perl-ExtUtils-ParseXS \
 perl-ExtUtils-InstallPaths \
 perl-Getopt-Long \
 perl-File-Basename \
 perl-DynaLoader \
 perl-PathTools \
 perl-JSON-PP \
 perl-File-Find \
 perl-podlators \
 perl-Exporter \
 perl-File-Path \
 perl-ExtUtils-CBuilder \
"
