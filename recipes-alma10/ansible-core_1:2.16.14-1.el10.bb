# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ansible-core"
PE = "1"
PV = "2.16.14"
PR = "1.el10"
PACKAGES = "ansible-core ansible-test"
PROVIDES = "rpm/ansible-core rpm/ansible-test"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ansible-core-2.16.14-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3151792d2b3a3caa910b04accf919f3677bef442dfebd72628aff96697af757b"

URI_ansible-core = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ansible-core-2.16.14-1.el10.noarch.rpm;name=ansible-core;unpack=0"
SRC_URI += "${URI_ansible-core}"
SRC_URI[ansible-core.sha256sum] = "8f966c697abbc20f3f6b03b7964d283d0664e07dc94e13b0c265e80c8a8d0072"
RDEPENDS:ansible-core = " \
 python3 \
 python3-pyyaml \
 git-core \
 python3-cryptography \
 python3-jinja2 \
 python3-packaging \
 python3-resolvelib \
"

URI_ansible-test = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ansible-test-2.16.14-1.el10.noarch.rpm;name=ansible-test;unpack=0"
SRC_URI += "${URI_ansible-test}"
SRC_URI[ansible-test.sha256sum] = "6aa9ca9f5a216af4152c837da34ebfd5dde379385b40291ed0e0d54ed01b607e"
RDEPENDS:ansible-test = " \
 python3 \
 ansible-core \
"
