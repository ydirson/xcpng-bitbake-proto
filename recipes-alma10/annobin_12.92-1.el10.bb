# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "annobin"
PE = "0"
PV = "12.92"
PR = "1.el10"
PACKAGES = "annobin-annocheck annobin-docs annobin-libannocheck annobin-plugin-clang annobin-plugin-gcc annobin-plugin-llvm"
PROVIDES = "rpm/annobin-annocheck rpm/annobin-docs rpm/annobin-libannocheck rpm/annobin-plugin-clang rpm/annobin-plugin-gcc rpm/annobin-plugin-llvm"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/annobin-12.92-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "216a510a3d24b44b9c825acbbd162180ef287103c4db56e7a233b6ea7eef9db2"

URI_annobin-annocheck = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/annobin-annocheck-12.92-1.el10.x86_64_v2.rpm;name=annobin-annocheck;unpack=0"
SRC_URI += "${URI_annobin-annocheck}"
SRC_URI[annobin-annocheck.sha256sum] = "88e39c31de21ea56613bbef43a334c7bc87248139afaca1cefe148d50c29c62e"
RDEPENDS:annobin-annocheck = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 rpm \
 cpio \
 rpm-libs \
 annobin-docs \
"

URI_annobin-docs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/annobin-docs-12.92-1.el10.noarch.rpm;name=annobin-docs;unpack=0"
SRC_URI += "${URI_annobin-docs}"
SRC_URI[annobin-docs.sha256sum] = "f964b5ca270613fda5cfb3d8b686da4d4c5f054b1afdc30fc259c609e3c5b4a8"
RDEPENDS:annobin-docs = ""

URI_annobin-libannocheck = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/annobin-libannocheck-12.92-1.el10.x86_64_v2.rpm;name=annobin-libannocheck;unpack=0"
SRC_URI += "${URI_annobin-libannocheck}"
SRC_URI[annobin-libannocheck.sha256sum] = "b440591e2428346862f25beeec06945026617540c4b55ec972aa4ab6208799f3"
RDEPENDS:annobin-libannocheck = " \
 glibc \
 pkgconf-pkg-config \
 annobin-docs \
"

URI_annobin-plugin-clang = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/annobin-plugin-clang-12.92-1.el10.x86_64_v2.rpm;name=annobin-plugin-clang;unpack=0"
SRC_URI += "${URI_annobin-plugin-clang}"
SRC_URI[annobin-plugin-clang.sha256sum] = "91ec08b996e5f330afecff377c92f255cf899b6ad8233a8869f4560cc67154a4"
RDEPENDS:annobin-plugin-clang = " \
 libgcc \
 libstdc++ \
 glibc \
 llvm-libs \
 annobin-docs \
"

URI_annobin-plugin-gcc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/annobin-plugin-gcc-12.92-1.el10.x86_64_v2.rpm;name=annobin-plugin-gcc;unpack=0"
SRC_URI += "${URI_annobin-plugin-gcc}"
SRC_URI[annobin-plugin-gcc.sha256sum] = "3f2bef6958bfbd6cb232b14782711f3e0a0ba90e06a257af4c751212853324ff"
RDEPENDS:annobin-plugin-gcc = " \
 libgcc \
 libstdc++ \
 gcc \
 glibc \
 annobin-docs \
"

URI_annobin-plugin-llvm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/annobin-plugin-llvm-12.92-1.el10.x86_64_v2.rpm;name=annobin-plugin-llvm;unpack=0"
SRC_URI += "${URI_annobin-plugin-llvm}"
SRC_URI[annobin-plugin-llvm.sha256sum] = "b1ff1ea0efe021f454e0a33f7f61068f7c65dcde9a623a57cc3af1cf6224e6c5"
RDEPENDS:annobin-plugin-llvm = " \
 libgcc \
 libstdc++ \
 glibc \
 llvm-libs \
 annobin-docs \
"
