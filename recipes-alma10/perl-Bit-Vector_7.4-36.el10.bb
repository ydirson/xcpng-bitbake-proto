# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Bit-Vector"
PE = "0"
PV = "7.4"
PR = "36.el10"
PACKAGES = "perl-Bit-Vector perl-Bit-Vector-tests"
PROVIDES = "rpm/perl-Bit-Vector rpm/perl-Bit-Vector-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Bit-Vector-7.4-36.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8caa0245eb5246c5586d557bfaf1220ab8da278445a05a4decde8af989d32898"

URI_perl-Bit-Vector = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Bit-Vector-7.4-36.el10.x86_64_v2.rpm;name=perl-Bit-Vector;unpack=0"
SRC_URI += "${URI_perl-Bit-Vector}"
SRC_URI[perl-Bit-Vector.sha256sum] = "23e09e749c9eaa73fcd3e910439f6efe3f78c15cfb7a10f0016614b10597edeb"
RDEPENDS:perl-Bit-Vector = " \
 perl-libs \
 perl-Carp-Clan \
 perl-vars \
 perl-Storable \
 perl-DynaLoader \
 perl-overload \
 glibc \
 perl-Exporter \
"

URI_perl-Bit-Vector-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Bit-Vector-tests-7.4-36.el10.x86_64_v2.rpm;name=perl-Bit-Vector-tests;unpack=0"
SRC_URI += "${URI_perl-Bit-Vector-tests}"
SRC_URI[perl-Bit-Vector-tests.sha256sum] = "8bcff3e2388a784c6216875f220e9f98e36268c2cd097e0bbaad6b9e9f93a52e"
RDEPENDS:perl-Bit-Vector-tests = " \
 perl-Test-Harness \
 perl-libs \
 bash \
 perl-interpreter \
 perl-Bit-Vector \
"
