# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-lt"
PE = "0"
PV = "1.2.1"
PR = "35.el10"
PACKAGES = "hunspell-lt"
PROVIDES = "rpm/hunspell-lt"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-lt-1.2.1-35.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd94b4c6e4a84110978cc3bc2b6a5b36778266b7d775eac7c3399de34e86bc83"

URI_hunspell-lt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-lt-1.2.1-35.el10.noarch.rpm;name=hunspell-lt;unpack=0"
SRC_URI += "${URI_hunspell-lt}"
SRC_URI[hunspell-lt.sha256sum] = "84edb0ca3ffdabaed4cae90cbc226c0349aaf2e7f681dc506abc08ae75479469"
RDEPENDS:hunspell-lt = " \
 hunspell-filesystem \
"
