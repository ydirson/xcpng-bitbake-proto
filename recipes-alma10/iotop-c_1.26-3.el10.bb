# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "iotop-c"
PE = "0"
PV = "1.26"
PR = "3.el10"
PACKAGES = "iotop-c"
PROVIDES = "rpm/iotop-c"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/iotop-c-1.26-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fa5ba0999fced0d65a4efc176c880d1ccebe7473c4cbeef73ab7a9def5a1df2"

URI_iotop-c = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/iotop-c-1.26-3.el10.x86_64_v2.rpm;name=iotop-c;unpack=0"
SRC_URI += "${URI_iotop-c}"
SRC_URI[iotop-c.sha256sum] = "4f6025b33c4b38037a9060f5bc6f129a02e2fd34889ea8295a215979c7360f8b"
RDEPENDS:iotop-c = " \
 glibc \
 ncurses-libs \
"
