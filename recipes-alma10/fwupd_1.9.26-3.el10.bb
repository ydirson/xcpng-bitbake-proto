# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "fwupd"
PE = "0"
PV = "1.9.26"
PR = "3.el10"
PACKAGES = "fwupd fwupd-plugin-flashrom fwupd-devel fwupd-plugin-uefi-capsule-data fwupd-tests"
PROVIDES = "rpm/fwupd rpm/fwupd-plugin-flashrom rpm/fwupd-devel rpm/fwupd-plugin-uefi-capsule-data rpm/fwupd-tests"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/fwupd-1.9.26-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e463e52fb73554073f37372df20d4f7699ed5dd4934e28ad07998f42934e0f24"

URI_fwupd = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/fwupd-1.9.26-3.el10.x86_64_v2.rpm;name=fwupd;unpack=0"
SRC_URI += "${URI_fwupd}"
SRC_URI[fwupd.sha256sum] = "b2fd71415fd76b376646a6c462b995d847b54e3eec452fcd3d2d3e3873e9c58f"
RDEPENDS:fwupd = " \
 systemd \
 systemd-libs \
 tpm2-tss \
 libarchive \
 json-glib \
 libcurl \
 xz-libs \
 zlib-ng-compat \
 gnutls \
 shared-mime-info \
 libgcc \
 libxmlb \
 libgudev \
 sqlite-libs \
 libgusb \
 bash \
 libjcat \
 polkit-libs \
 glib2 \
 glibc \
"

URI_fwupd-plugin-flashrom = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fwupd-plugin-flashrom-1.9.26-3.el10.x86_64_v2.rpm;name=fwupd-plugin-flashrom;unpack=0"
SRC_URI += "${URI_fwupd-plugin-flashrom}"
SRC_URI[fwupd-plugin-flashrom.sha256sum] = "18412c19d7401db5bf203c5aed880325e70bce0e9d5e9f5e8452d0b9fd095a06"
RDEPENDS:fwupd-plugin-flashrom = " \
 fwupd \
 libgcc \
 glib2 \
 glibc \
 flashrom \
"

URI_fwupd-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/fwupd-devel-1.9.26-3.el10.x86_64_v2.rpm;name=fwupd-devel;unpack=0"
SRC_URI += "${URI_fwupd-devel}"
SRC_URI[fwupd-devel.sha256sum] = "7758d8d65d13a312353b11f1214926a4c641c48edb13985c58dba3e882a7bd36"
RDEPENDS:fwupd-devel = " \
 json-glib-devel \
 glib2-devel \
 libjcat-devel \
 fwupd \
 pkgconf-pkg-config \
 libcurl-devel \
"

URI_fwupd-plugin-uefi-capsule-data = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/fwupd-plugin-uefi-capsule-data-1.9.26-3.el10.x86_64_v2.rpm;name=fwupd-plugin-uefi-capsule-data;unpack=0"
SRC_URI += "${URI_fwupd-plugin-uefi-capsule-data}"
SRC_URI[fwupd-plugin-uefi-capsule-data.sha256sum] = "556b70105e94fcf845af73ff16354ec1efad9287b6731a311e0239c772a1c96a"
RDEPENDS:fwupd-plugin-uefi-capsule-data = " \
 fwupd \
"

URI_fwupd-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/fwupd-tests-1.9.26-3.el10.x86_64_v2.rpm;name=fwupd-tests;unpack=0"
SRC_URI += "${URI_fwupd-tests}"
SRC_URI[fwupd-tests.sha256sum] = "ecaf7a235b81712914c2767bc2e4ebad44a387370667d2b96c2756bd67b42d28"
RDEPENDS:fwupd-tests = " \
 gnutls \
 fwupd \
 libgcc \
 json-glib \
 libxmlb \
 libgudev \
 libgusb \
 bash \
 glib2 \
 libcurl \
 glibc \
"
