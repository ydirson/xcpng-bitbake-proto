# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-rpm-macros"
PE = "0"
PV = "3.12"
PR = "9.1.el10"
PACKAGES = "python-rpm-macros python-srpm-macros python3-rpm-macros"
PROVIDES = "rpm/python-rpm-macros rpm/python-srpm-macros rpm/python3-rpm-macros"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-rpm-macros-3.12-9.1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1d4405ee652b8fe4e79848895d58af8733753c4370222a22984adc1267d9fc3"

URI_python-rpm-macros = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python-rpm-macros-3.12-9.1.el10.noarch.rpm;name=python-rpm-macros;unpack=0"
SRC_URI += "${URI_python-rpm-macros}"
SRC_URI[python-rpm-macros.sha256sum] = "59267287dfd846d1b24763250f0a0ededcf17020a20837b5c2f41943c1bb5c53"
RDEPENDS:python-rpm-macros = " \
 python-srpm-macros \
"

URI_python-srpm-macros = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python-srpm-macros-3.12-9.1.el10.noarch.rpm;name=python-srpm-macros;unpack=0"
SRC_URI += "${URI_python-srpm-macros}"
SRC_URI[python-srpm-macros.sha256sum] = "d75a2cbf30f4f7c5b29c63db56c4e6189b19cadf878f606dc6e6d864c358356f"
RDEPENDS:python-srpm-macros = " \
 redhat-rpm-config \
 bash \
"

URI_python3-rpm-macros = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-rpm-macros-3.12-9.1.el10.noarch.rpm;name=python3-rpm-macros;unpack=0"
SRC_URI += "${URI_python3-rpm-macros}"
SRC_URI[python3-rpm-macros.sha256sum] = "ac250f9118daa3a735e704037d7dae5cc85c3db566480616a7547d5389dd0296"
RDEPENDS:python3-rpm-macros = " \
 python-rpm-macros \
 python-srpm-macros \
"
