# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-PathTools"
PE = "0"
PV = "3.91"
PR = "512.el10"
PACKAGES = "perl-PathTools perl-PathTools-tests"
PROVIDES = "rpm/perl-PathTools rpm/perl-PathTools-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-PathTools-3.91-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a88e6c4296928f41deacae4678e7b7c481e3a11392c3196e027273775e1633ca"

URI_perl-PathTools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-PathTools-3.91-512.el10.x86_64_v2.rpm;name=perl-PathTools;unpack=0"
SRC_URI += "${URI_perl-PathTools}"
SRC_URI[perl-PathTools.sha256sum] = "7b5d53498f02c865a0860814c45f7fb9806bebd6aba1f0922315d7e233a72924"
RDEPENDS:perl-PathTools = " \
 perl-constant \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-Errno \
 perl-PathTools \
 glibc \
 perl-Exporter \
"

URI_perl-PathTools-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-PathTools-tests-3.91-512.el10.x86_64_v2.rpm;name=perl-PathTools-tests;unpack=0"
SRC_URI += "${URI_perl-PathTools-tests}"
SRC_URI[perl-PathTools-tests.sha256sum] = "8a9db1ec2d760ba0d64c4939ce4a1aac62d45ed8eda45f73eb7d6413a82c8961"
RDEPENDS:perl-PathTools-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-Scalar-List-Utils \
 perl-File-Temp \
 bash \
 perl-PathTools \
 perl-Errno \
 perl-interpreter \
 perl-File-Path \
 perl-lib \
"
