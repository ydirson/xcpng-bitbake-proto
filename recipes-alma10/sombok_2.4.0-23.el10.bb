# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sombok"
PE = "0"
PV = "2.4.0"
PR = "23.el10"
PACKAGES = "sombok sombok-devel"
PROVIDES = "rpm/sombok rpm/sombok-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/sombok-2.4.0-23.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8de52f1746d4de95a3082e3fada031f6e31324c7a70f4e0bea1f28769025850"

URI_sombok = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sombok-2.4.0-23.el10.x86_64_v2.rpm;name=sombok;unpack=0"
SRC_URI += "${URI_sombok}"
SRC_URI[sombok.sha256sum] = "2e61248e3f3e90bc080afb8221c85fa123181c6bd8e4bca09d73c3c08fd68330"
RDEPENDS:sombok = " \
 glibc \
 libthai \
"

URI_sombok-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/sombok-devel-2.4.0-23.el10.x86_64_v2.rpm;name=sombok-devel;unpack=0"
SRC_URI += "${URI_sombok-devel}"
SRC_URI[sombok-devel.sha256sum] = "9299ecca7ffb806427284e39488f30719eaadfd8408020ae7ef4fdda967062fc"
RDEPENDS:sombok-devel = " \
 sombok \
 pkgconf-pkg-config \
"
