# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "disruptor"
PE = "0"
PV = "3.4.4"
PR = "12.el10"
PACKAGES = "disruptor disruptor-javadoc"
PROVIDES = "rpm/disruptor rpm/disruptor-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/disruptor-3.4.4-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3923b0ec9accbcbfc71277e5d875903a0566a32affda365007cf4c428713d39f"

URI_disruptor = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/disruptor-3.4.4-12.el10.noarch.rpm;name=disruptor;unpack=0"
SRC_URI += "${URI_disruptor}"
SRC_URI[disruptor.sha256sum] = "05a74e2070a8c9eecfefbf49dae062a8e6fcae6e31cdc6e66620fe86c40bd491"
RDEPENDS:disruptor = " \
 javapackages-filesystem \
"

URI_disruptor-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/disruptor-javadoc-3.4.4-12.el10.noarch.rpm;name=disruptor-javadoc;unpack=0"
SRC_URI += "${URI_disruptor-javadoc}"
SRC_URI[disruptor-javadoc.sha256sum] = "336abfbc7c2d627b9ef0ada6b6cc42dcece02d7b66c5dde912614bcdd527ed62"
RDEPENDS:disruptor-javadoc = " \
 javapackages-filesystem \
"
