# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "smc-tools"
PE = "0"
PV = "1.8.4"
PR = "1.el10"
PACKAGES = "smc-tools"
PROVIDES = "rpm/smc-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/smc-tools-1.8.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a7ea9cdede4c146e25f0bc36705be9a7e8d1b0a56432caf470c211ac2090216"

URI_smc-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/smc-tools-1.8.4-1.el10.x86_64_v2.rpm;name=smc-tools;unpack=0"
SRC_URI += "${URI_smc-tools}"
SRC_URI[smc-tools.sha256sum] = "e17458eedbf291057833275a1e9eebd9f7c906e2f17c3aefe5f8453aea403e84"
RDEPENDS:smc-tools = " \
 glibc \
 bash \
 libnl3 \
"
