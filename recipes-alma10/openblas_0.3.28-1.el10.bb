# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "openblas"
PE = "0"
PV = "0.3.28"
PR = "1.el10"
PACKAGES = "openblas openblas-openmp openblas-openmp64 openblas-serial openblas-devel openblas-openmp64_ openblas-serial64 openblas-serial64_ openblas-static openblas-threads openblas-threads64 openblas-threads64_"
PROVIDES = "rpm/openblas rpm/openblas-openmp rpm/openblas-openmp64 rpm/openblas-serial rpm/openblas-devel rpm/openblas-openmp64_ rpm/openblas-serial64 rpm/openblas-serial64_ rpm/openblas-static rpm/openblas-threads rpm/openblas-threads64 rpm/openblas-threads64_"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/openblas-0.3.28-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf59953af366f511a62c2fa6c465ad413ec83ae58fe234dbb276912658a8ce2f"

URI_openblas = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/openblas-0.3.28-1.el10.x86_64_v2.rpm;name=openblas;unpack=0"
SRC_URI += "${URI_openblas}"
SRC_URI[openblas.sha256sum] = "cbcf1c4db99c4be6eeb9e8480f811a108a891a79b0b2da3f0b2752acc2093b04"
RDEPENDS:openblas = ""

URI_openblas-openmp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/openblas-openmp-0.3.28-1.el10.x86_64_v2.rpm;name=openblas-openmp;unpack=0"
SRC_URI += "${URI_openblas-openmp}"
SRC_URI[openblas-openmp.sha256sum] = "6dabc7c352ad9712f7c382925e2587c13dbe5219beb87691ee8884079ecdc02f"
RDEPENDS:openblas-openmp = " \
 libgcc \
 libgfortran \
 libgomp \
 glibc \
 openblas \
"

URI_openblas-openmp64 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/openblas-openmp64-0.3.28-1.el10.x86_64_v2.rpm;name=openblas-openmp64;unpack=0"
SRC_URI += "${URI_openblas-openmp64}"
SRC_URI[openblas-openmp64.sha256sum] = "1702ab113a904b43d4fc22a3388066ad2a5e91c677e5395bcbba8099970ace5d"
RDEPENDS:openblas-openmp64 = " \
 libgcc \
 libgfortran \
 libgomp \
 glibc \
 openblas \
"

URI_openblas-serial = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/openblas-serial-0.3.28-1.el10.x86_64_v2.rpm;name=openblas-serial;unpack=0"
SRC_URI += "${URI_openblas-serial}"
SRC_URI[openblas-serial.sha256sum] = "a5b906497cbba98624517231b16d3f601640ebbe99400f9a6cd67b45cb3a8bc4"
RDEPENDS:openblas-serial = " \
 glibc \
 openblas \
 libgfortran \
"

URI_openblas-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/openblas-devel-0.3.28-1.el10.x86_64_v2.rpm;name=openblas-devel;unpack=0"
SRC_URI += "${URI_openblas-devel}"
SRC_URI[openblas-devel.sha256sum] = "b3296c0b07e6cad63c201841043da993f034f510553171c852678decce3b8e6c"
RDEPENDS:openblas-devel = " \
 openblas-openmp64_ \
 openblas-serial64 \
 openblas-serial64_ \
 openblas-threads \
 openblas-threads64 \
 openblas-threads64_ \
 openblas \
 openblas-openmp \
 openblas-openmp64 \
 openblas-serial \
 openblas-srpm-macros \
"

URI_openblas-openmp64_ = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/openblas-openmp64_-0.3.28-1.el10.x86_64_v2.rpm;name=openblas-openmp64_;unpack=0"
SRC_URI += "${URI_openblas-openmp64_}"
SRC_URI[openblas-openmp64_.sha256sum] = "e623010c69444ab245997f8bccdb09457d1ed392f43d39efe2081829418c44d6"
RDEPENDS:openblas-openmp64_ = " \
 libgcc \
 libgfortran \
 libgomp \
 glibc \
 openblas \
"

URI_openblas-serial64 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/openblas-serial64-0.3.28-1.el10.x86_64_v2.rpm;name=openblas-serial64;unpack=0"
SRC_URI += "${URI_openblas-serial64}"
SRC_URI[openblas-serial64.sha256sum] = "e402ba9a3b41963763e6ccf734f35ae0424e2c349a9b6a110ace89aba9b91f53"
RDEPENDS:openblas-serial64 = " \
 glibc \
 openblas \
 libgfortran \
"

URI_openblas-serial64_ = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/openblas-serial64_-0.3.28-1.el10.x86_64_v2.rpm;name=openblas-serial64_;unpack=0"
SRC_URI += "${URI_openblas-serial64_}"
SRC_URI[openblas-serial64_.sha256sum] = "1c846fa85e19e7bcc0820c5f52b5545d3fd383b2203497e95bff8f86b093a416"
RDEPENDS:openblas-serial64_ = " \
 glibc \
 openblas \
 libgfortran \
"

URI_openblas-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/openblas-static-0.3.28-1.el10.x86_64_v2.rpm;name=openblas-static;unpack=0"
SRC_URI += "${URI_openblas-static}"
SRC_URI[openblas-static.sha256sum] = "2ac618b2aa43f8c252b40eb760e9b6a4b16d19695150da666383cd8ad79c35ac"
RDEPENDS:openblas-static = " \
 openblas-devel \
"

URI_openblas-threads = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/openblas-threads-0.3.28-1.el10.x86_64_v2.rpm;name=openblas-threads;unpack=0"
SRC_URI += "${URI_openblas-threads}"
SRC_URI[openblas-threads.sha256sum] = "359a98c1f0592f759d8ca2efa1556373eaecc645ad1d7cdb3194720d6f59a307"
RDEPENDS:openblas-threads = " \
 glibc \
 openblas \
 libgfortran \
"

URI_openblas-threads64 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/openblas-threads64-0.3.28-1.el10.x86_64_v2.rpm;name=openblas-threads64;unpack=0"
SRC_URI += "${URI_openblas-threads64}"
SRC_URI[openblas-threads64.sha256sum] = "8333c7fe71fd22ff2812d9c2ba8fcf2e4b0009be96ac3b81bc31bc57be6d3ee9"
RDEPENDS:openblas-threads64 = " \
 glibc \
 openblas \
 libgfortran \
"

URI_openblas-threads64_ = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/openblas-threads64_-0.3.28-1.el10.x86_64_v2.rpm;name=openblas-threads64_;unpack=0"
SRC_URI += "${URI_openblas-threads64_}"
SRC_URI[openblas-threads64_.sha256sum] = "17842ce17821fc5e31c23d099b1aff6070bf161c9468aa855960a1055ab6f486"
RDEPENDS:openblas-threads64_ = " \
 glibc \
 openblas \
 libgfortran \
"
