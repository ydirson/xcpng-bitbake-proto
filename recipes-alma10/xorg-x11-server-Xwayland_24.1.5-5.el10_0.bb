# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xorg-x11-server-Xwayland"
PE = "0"
PV = "24.1.5"
PR = "5.el10_0"
PACKAGES = "xorg-x11-server-Xwayland xorg-x11-server-Xwayland-devel"
PROVIDES = "rpm/xorg-x11-server-Xwayland rpm/xorg-x11-server-Xwayland-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xorg-x11-server-Xwayland-24.1.5-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf4872913481ac32170816dc02166cf49db31b12ec863ffd44ab0ca9809c88d6"

URI_xorg-x11-server-Xwayland = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xorg-x11-server-Xwayland-24.1.5-5.el10_0.x86_64_v2.rpm;name=xorg-x11-server-Xwayland;unpack=0"
SRC_URI += "${URI_xorg-x11-server-Xwayland}"
SRC_URI[xorg-x11-server-Xwayland.sha256sum] = "87de622f9850bbed37768cf901e6ee44fdd14d9ba956200f4bb63d256c3eb383"
RDEPENDS:xorg-x11-server-Xwayland = " \
 libXau \
 xkeyboard-config \
 xkbcomp \
 libselinux \
 libdecor \
 libXdmcp \
 libdrm \
 liboeffis \
 libXfont2 \
 libei \
 libepoxy \
 libtirpc \
 libwayland-client \
 libglvnd-egl \
 libglvnd-glx \
 audit-libs \
 openssl-libs \
 mesa-libgbm \
 libxcvt \
 pixman \
 libxshmfence \
 glibc \
"

URI_xorg-x11-server-Xwayland-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xorg-x11-server-Xwayland-devel-24.1.5-5.el10_0.x86_64_v2.rpm;name=xorg-x11-server-Xwayland-devel;unpack=0"
SRC_URI += "${URI_xorg-x11-server-Xwayland-devel}"
SRC_URI[xorg-x11-server-Xwayland-devel.sha256sum] = "4fbed2a1e870f006ef8fc34316359bbddb3d308d3642ff9925ad43cc8d4c2b5a"
RDEPENDS:xorg-x11-server-Xwayland-devel = " \
 xorg-x11-server-Xwayland \
 pkgconf-pkg-config \
"
