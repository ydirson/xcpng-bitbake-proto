# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-File-Path"
PE = "0"
PV = "2.18"
PR = "511.el10"
PACKAGES = "perl-File-Path perl-File-Path-tests"
PROVIDES = "rpm/perl-File-Path rpm/perl-File-Path-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-File-Path-2.18-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09e6228449ea9b8ba46e70da0a52ffde07c059cdf41008eb01a5ec1b44ebe4d7"

URI_perl-File-Path = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-File-Path-2.18-511.el10.noarch.rpm;name=perl-File-Path;unpack=0"
SRC_URI += "${URI_perl-File-Path}"
SRC_URI[perl-File-Path.sha256sum] = "dc36e3a86a5566ca0b83afa49a9ec40a2568fe37378a39e132e175c316342cfd"
RDEPENDS:perl-File-Path = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-File-Basename \
 perl-PathTools \
 perl-Exporter \
"

URI_perl-File-Path-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-File-Path-tests-2.18-511.el10.noarch.rpm;name=perl-File-Path-tests;unpack=0"
SRC_URI += "${URI_perl-File-Path-tests}"
SRC_URI[perl-File-Path-tests.sha256sum] = "b433bb821f62772b9f1b980f3cb9fee652e886afb822ba11ceb10f5a7206f240"
RDEPENDS:perl-File-Path-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-SelectSaver \
 perl-Fcntl \
 perl-Symbol \
 bash \
 perl-base \
 perl-PathTools \
 perl-Errno \
 perl-interpreter \
 perl-File-Path \
 perl-Exporter \
 perl-lib \
"
