# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libzpc"
PE = "0"
PV = "1.2.0"
PR = "8.el10"
PACKAGES = ""
PROVIDES = ""


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libzpc-1.2.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92d84346eabd8b4f33842359b4e12f070964f6e8d24f968d57d3ccf820e91401"
