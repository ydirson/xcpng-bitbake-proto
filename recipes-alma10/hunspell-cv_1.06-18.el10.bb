# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-cv"
PE = "0"
PV = "1.06"
PR = "18.el10"
PACKAGES = "hunspell-cv"
PROVIDES = "rpm/hunspell-cv"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-cv-1.06-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f319a50acc3eeda93f56597ae9d6a513dc189a391747b71f5bfe75405550821a"

URI_hunspell-cv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-cv-1.06-18.el10.noarch.rpm;name=hunspell-cv;unpack=0"
SRC_URI += "${URI_hunspell-cv}"
SRC_URI[hunspell-cv.sha256sum] = "9d61e85ef9326e225efd72a7873d04d311c737a24425a4c8b50b26ba95155722"
RDEPENDS:hunspell-cv = " \
 hunspell-filesystem \
"
