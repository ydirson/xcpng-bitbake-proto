# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "snappy"
PE = "0"
PV = "1.1.10"
PR = "7.el10"
PACKAGES = "snappy snappy-devel"
PROVIDES = "rpm/snappy rpm/snappy-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/snappy-1.1.10-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0bf9429c2823917beddaed0f5c2e9881ee12b89fd54aa10f34182edb7ce099be"

URI_snappy = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/snappy-1.1.10-7.el10.x86_64_v2.rpm;name=snappy;unpack=0"
SRC_URI += "${URI_snappy}"
SRC_URI[snappy.sha256sum] = "a88a8903c5d10ad2ae33763362075228af3300ccc6cae9b1da9b5f0c0242250d"
RDEPENDS:snappy = " \
 glibc \
 libstdc++ \
"

URI_snappy-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/snappy-devel-1.1.10-7.el10.x86_64_v2.rpm;name=snappy-devel;unpack=0"
SRC_URI += "${URI_snappy-devel}"
SRC_URI[snappy-devel.sha256sum] = "bb5269ce8af8113c5f6152ae732280332d291b8cf49cd5e3257f9a9ebe8ef4b8"
RDEPENDS:snappy-devel = " \
 snappy \
 cmake-filesystem \
 pkgconf-pkg-config \
"
