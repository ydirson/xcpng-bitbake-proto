# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "vulkan-volk"
PE = "0"
PV = "1.4.304.0"
PR = "1.el10"
PACKAGES = "vulkan-volk-devel"
PROVIDES = "rpm/vulkan-volk-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/vulkan-volk-1.4.304.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd475918072347c00ffa994cc499fff0ca835dc6fc170a48a071969d71a68a5a"

URI_vulkan-volk-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/vulkan-volk-devel-1.4.304.0-1.el10.x86_64_v2.rpm;name=vulkan-volk-devel;unpack=0"
SRC_URI += "${URI_vulkan-volk-devel}"
SRC_URI[vulkan-volk-devel.sha256sum] = "e19b8a66a5cf6cfd06d27245c80915aaae9ac4144f63c3571a3b3dbf8da50745"
RDEPENDS:vulkan-volk-devel = " \
 vulkan-headers \
 cmake-filesystem \
"
