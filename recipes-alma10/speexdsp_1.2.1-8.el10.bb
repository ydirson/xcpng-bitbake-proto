# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "speexdsp"
PE = "0"
PV = "1.2.1"
PR = "8.el10"
PACKAGES = "speexdsp speexdsp-devel"
PROVIDES = "rpm/speexdsp rpm/speexdsp-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/speexdsp-1.2.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37336065207169a18b68110f40f4aad7536cff198da5eb2b6e0e0e136ba95442"

URI_speexdsp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/speexdsp-1.2.1-8.el10.x86_64_v2.rpm;name=speexdsp;unpack=0"
SRC_URI += "${URI_speexdsp}"
SRC_URI[speexdsp.sha256sum] = "9328ebbdc61a4af196a386e32b6eed1ddbb2715819cc91a2c8a6586d9a0a30d5"
RDEPENDS:speexdsp = " \
 glibc \
"

URI_speexdsp-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/speexdsp-devel-1.2.1-8.el10.x86_64_v2.rpm;name=speexdsp-devel;unpack=0"
SRC_URI += "${URI_speexdsp-devel}"
SRC_URI[speexdsp-devel.sha256sum] = "519560e85f8e2e9f448588da684a6f279c288db7f465e35780541e8c67e0b7b7"
RDEPENDS:speexdsp-devel = " \
 speexdsp \
 pkgconf-pkg-config \
"
