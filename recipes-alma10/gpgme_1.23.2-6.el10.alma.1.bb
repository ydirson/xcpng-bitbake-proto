# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gpgme"
PE = "0"
PV = "1.23.2"
PR = "6.el10.alma.1"
PACKAGES = "gpgme python3-gpg gpgmepp gpgme-devel gpgmepp-devel qgpgme-common-devel qgpgme-qt6 qgpgme-qt6-devel"
PROVIDES = "rpm/gpgme rpm/python3-gpg rpm/gpgmepp rpm/gpgme-devel rpm/gpgmepp-devel rpm/qgpgme-common-devel rpm/qgpgme-qt6 rpm/qgpgme-qt6-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/gpgme-1.23.2-6.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e93d1c6a7bfcc12a2a91d59dceb15cfa9305d8e9f16f7dbc01d7f90cf0f4ada"

URI_gpgme = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/gpgme-1.23.2-6.el10.alma.1.x86_64_v2.rpm;name=gpgme;unpack=0"
SRC_URI += "${URI_gpgme}"
SRC_URI[gpgme.sha256sum] = "d76f49b03971411cffd4c42baa5af3ea7e1d55da675fbcfb2e483eeff886336d"
RDEPENDS:gpgme = " \
 glibc \
 gnupg2 \
 libassuan \
 libgpg-error \
"

URI_python3-gpg = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-gpg-1.23.2-6.el10.alma.1.x86_64_v2.rpm;name=python3-gpg;unpack=0"
SRC_URI += "${URI_python3-gpg}"
SRC_URI[python3-gpg.sha256sum] = "2e5c4afa35ea573972349ebfd306275ad7d08103c9995e95ffaa730daabe6ad9"
RDEPENDS:python3-gpg = " \
 glibc \
 gpgme \
 python3 \
"

URI_gpgmepp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gpgmepp-1.23.2-6.el10.alma.1.x86_64_v2.rpm;name=gpgmepp;unpack=0"
SRC_URI += "${URI_gpgmepp}"
SRC_URI[gpgmepp.sha256sum] = "3545284869b3f2cac47785c1b589067256fb5515238676378eb87ab4bfe0f26b"
RDEPENDS:gpgmepp = " \
 libassuan \
 gpgme \
 libgcc \
 libstdc++ \
 glibc \
"

URI_gpgme-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gpgme-devel-1.23.2-6.el10.alma.1.x86_64_v2.rpm;name=gpgme-devel;unpack=0"
SRC_URI += "${URI_gpgme-devel}"
SRC_URI[gpgme-devel.sha256sum] = "d2befd24f0b77d134e7dee8941c8b58286adec7370ea049561ac6164e9537fb1"
RDEPENDS:gpgme-devel = " \
 glib2-devel \
 libassuan \
 libassuan-devel \
 gpgme \
 pkgconf-pkg-config \
 libgpg-error-devel \
 libgpg-error \
 bash \
 glibc \
"

URI_gpgmepp-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gpgmepp-devel-1.23.2-6.el10.alma.1.x86_64_v2.rpm;name=gpgmepp-devel;unpack=0"
SRC_URI += "${URI_gpgmepp-devel}"
SRC_URI[gpgmepp-devel.sha256sum] = "8fedcc09c9f2b414637969372ba1f05247bfe2da3e7605433009861ae197599a"
RDEPENDS:gpgmepp-devel = " \
 gpgme-devel \
 cmake-filesystem \
 gpgmepp \
"

URI_qgpgme-common-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qgpgme-common-devel-1.23.2-6.el10.alma.1.x86_64_v2.rpm;name=qgpgme-common-devel;unpack=0"
SRC_URI += "${URI_qgpgme-common-devel}"
SRC_URI[qgpgme-common-devel.sha256sum] = "d243062645af95c6d47f787b326d4c8036c33251b318994d7e0b5fd3efb716a8"
RDEPENDS:qgpgme-common-devel = " \
 gpgmepp-devel \
"

URI_qgpgme-qt6 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qgpgme-qt6-1.23.2-6.el10.alma.1.x86_64_v2.rpm;name=qgpgme-qt6;unpack=0"
SRC_URI += "${URI_qgpgme-qt6}"
SRC_URI[qgpgme-qt6.sha256sum] = "2db8b3772055e3d5e15151b6b31f8074cefa5daa06ca58e9a6e8d96a22fc424e"
RDEPENDS:qgpgme-qt6 = " \
 libassuan \
 gpgme \
 libgcc \
 gpgmepp \
 qt6-qtbase \
 libgpg-error \
 libstdc++ \
 glibc \
"

URI_qgpgme-qt6-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qgpgme-qt6-devel-1.23.2-6.el10.alma.1.x86_64_v2.rpm;name=qgpgme-qt6-devel;unpack=0"
SRC_URI += "${URI_qgpgme-qt6-devel}"
SRC_URI[qgpgme-qt6-devel.sha256sum] = "710cce68af3aebb088af502b9af8223b4669c129fd6f5cb9cc744530c4b716f4"
RDEPENDS:qgpgme-qt6-devel = " \
 cmake-filesystem \
 qgpgme-common-devel \
 qgpgme-qt6 \
"
