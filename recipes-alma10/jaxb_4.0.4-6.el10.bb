# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jaxb"
PE = "0"
PV = "4.0.4"
PR = "6.el10"
PACKAGES = "jaxb-codemodel jaxb-core jaxb-relaxng-datatype jaxb-rngom jaxb-runtime jaxb-txw2 jaxb-xjc jaxb-xsom jaxb-codemodel-annotation-compiler jaxb-txwc2"
PROVIDES = "rpm/jaxb-codemodel rpm/jaxb-core rpm/jaxb-relaxng-datatype rpm/jaxb-rngom rpm/jaxb-runtime rpm/jaxb-txw2 rpm/jaxb-xjc rpm/jaxb-xsom rpm/jaxb-codemodel-annotation-compiler rpm/jaxb-txwc2"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/jaxb-4.0.4-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "042930238ef08b648d63272bb612585b5bc280fd808bfee9bb644927973d8f88"

URI_jaxb-codemodel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jaxb-codemodel-4.0.4-6.el10.noarch.rpm;name=jaxb-codemodel;unpack=0"
SRC_URI += "${URI_jaxb-codemodel}"
SRC_URI[jaxb-codemodel.sha256sum] = "49748689daa445821e3da4d6b1a4e850bc1719cd85ef1694e3b77db94366bc1c"
RDEPENDS:jaxb-codemodel = " \
 javapackages-filesystem \
"

URI_jaxb-core = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jaxb-core-4.0.4-6.el10.noarch.rpm;name=jaxb-core;unpack=0"
SRC_URI += "${URI_jaxb-core}"
SRC_URI[jaxb-core.sha256sum] = "378ebd749dacddbcbe56c870aa6e5821a2c8912ce083f3c7178a94001e9194b2"
RDEPENDS:jaxb-core = " \
 jakarta-activation \
 javapackages-filesystem \
 jaxb-api \
 jaxb-istack-commons-runtime \
 jaxb-txw2 \
"

URI_jaxb-relaxng-datatype = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jaxb-relaxng-datatype-4.0.4-6.el10.noarch.rpm;name=jaxb-relaxng-datatype;unpack=0"
SRC_URI += "${URI_jaxb-relaxng-datatype}"
SRC_URI[jaxb-relaxng-datatype.sha256sum] = "bf6e65a6d85f3741431c1cb45d94c46fe8b75f026f25276ce7f61ed3eaa11962"
RDEPENDS:jaxb-relaxng-datatype = " \
 javapackages-filesystem \
"

URI_jaxb-rngom = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jaxb-rngom-4.0.4-6.el10.noarch.rpm;name=jaxb-rngom;unpack=0"
SRC_URI += "${URI_jaxb-rngom}"
SRC_URI[jaxb-rngom.sha256sum] = "4f68766c705b64e5d59622bb53a7a4983b985b432cfb736bf2947d601b5ca6bb"
RDEPENDS:jaxb-rngom = " \
 javapackages-filesystem \
 jaxb-relaxng-datatype \
"

URI_jaxb-runtime = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jaxb-runtime-4.0.4-6.el10.noarch.rpm;name=jaxb-runtime;unpack=0"
SRC_URI += "${URI_jaxb-runtime}"
SRC_URI[jaxb-runtime.sha256sum] = "21bf94855f211f3e23117897eb4fb6d375ff08213b558b808011e6914a042658"
RDEPENDS:jaxb-runtime = " \
 jaxb-core \
 javapackages-filesystem \
"

URI_jaxb-txw2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jaxb-txw2-4.0.4-6.el10.noarch.rpm;name=jaxb-txw2;unpack=0"
SRC_URI += "${URI_jaxb-txw2}"
SRC_URI[jaxb-txw2.sha256sum] = "5db67aae4693fbbabca9b39a60fa3a2c43aa2688e6906a02e3f0283effd78147"
RDEPENDS:jaxb-txw2 = " \
 javapackages-filesystem \
"

URI_jaxb-xjc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jaxb-xjc-4.0.4-6.el10.noarch.rpm;name=jaxb-xjc;unpack=0"
SRC_URI += "${URI_jaxb-xjc}"
SRC_URI[jaxb-xjc.sha256sum] = "3e380614c1c90df140987a4273aeafe9aede4657d552ae64ee11f3cc8dd4769c"
RDEPENDS:jaxb-xjc = " \
 javapackages-filesystem \
 jaxb-codemodel \
 jaxb-core \
 jaxb-dtd-parser \
 jaxb-istack-commons-tools \
 jaxb-rngom \
 jaxb-xsom \
"

URI_jaxb-xsom = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jaxb-xsom-4.0.4-6.el10.noarch.rpm;name=jaxb-xsom;unpack=0"
SRC_URI += "${URI_jaxb-xsom}"
SRC_URI[jaxb-xsom.sha256sum] = "468e6d095f5542b4115453d87d9c0ca48e5a8741c533ce8e8413c84b21f7a056"
RDEPENDS:jaxb-xsom = " \
 javapackages-filesystem \
 jaxb-relaxng-datatype \
"

URI_jaxb-codemodel-annotation-compiler = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jaxb-codemodel-annotation-compiler-4.0.4-6.el10.noarch.rpm;name=jaxb-codemodel-annotation-compiler;unpack=0"
SRC_URI += "${URI_jaxb-codemodel-annotation-compiler}"
SRC_URI[jaxb-codemodel-annotation-compiler.sha256sum] = "5fc469ed4c1afecd22cda5c70d9dd7ea40619b9d8e7a3b7c2bdc4a453ba9c9ae"
RDEPENDS:jaxb-codemodel-annotation-compiler = " \
 jaxb-codemodel \
 javapackages-filesystem \
"

URI_jaxb-txwc2 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jaxb-txwc2-4.0.4-6.el10.noarch.rpm;name=jaxb-txwc2;unpack=0"
SRC_URI += "${URI_jaxb-txwc2}"
SRC_URI[jaxb-txwc2.sha256sum] = "cb296e791f39d0548ddeac55e72ae44adc57b023aaa48cdfc0c29671d3a15156"
RDEPENDS:jaxb-txwc2 = " \
 javapackages-filesystem \
 jaxb-codemodel \
 jaxb-rngom \
 jaxb-txw2 \
 jaxb-xsom \
"
