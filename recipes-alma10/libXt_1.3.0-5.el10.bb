# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libXt"
PE = "0"
PV = "1.3.0"
PR = "5.el10"
PACKAGES = "libXt libXt-devel"
PROVIDES = "rpm/libXt rpm/libXt-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libXt-1.3.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "289f22361174066bbaaabb266ebc8443c5faf19c8fade6b787c44009ea140ae7"

URI_libXt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXt-1.3.0-5.el10.x86_64_v2.rpm;name=libXt;unpack=0"
SRC_URI += "${URI_libXt}"
SRC_URI[libXt.sha256sum] = "8cda6fb244a9f576f794f4469f37c5aab03202e0c61c7d1d9ef907bec839d7fb"
RDEPENDS:libXt = " \
 glibc \
 libICE \
 libX11 \
 libSM \
"

URI_libXt-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXt-devel-1.3.0-5.el10.x86_64_v2.rpm;name=libXt-devel;unpack=0"
SRC_URI += "${URI_libXt-devel}"
SRC_URI[libXt-devel.sha256sum] = "53ce32f39b6d134b95025d7c6b79ae821ce2e3c43304e6ef1f1b7392c10f27b3"
RDEPENDS:libXt-devel = " \
 pkgconf-pkg-config \
 libICE-devel \
 libSM-devel \
 libX11-devel \
 libXt \
 xorg-x11-proto-devel \
"
