# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rust-zram-generator"
PE = "0"
PV = "1.1.2"
PR = "14.el10"
PACKAGES = "zram-generator zram-generator-defaults"
PROVIDES = "rpm/zram-generator rpm/zram-generator-defaults"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/rust-zram-generator-1.1.2-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e55a92d23fc0e5e89d71486fdb1cc896ae55adf79f2df7c7bd39876c733cdca"

URI_zram-generator = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/zram-generator-1.1.2-14.el10.x86_64_v2.rpm;name=zram-generator;unpack=0"
SRC_URI += "${URI_zram-generator}"
SRC_URI[zram-generator.sha256sum] = "c5b42f90cb44461939a298438e12f59c30d25251bec7c9693566cec4598c1c01"
RDEPENDS:zram-generator = " \
 glibc \
 libgcc \
"

URI_zram-generator-defaults = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/zram-generator-defaults-1.1.2-14.el10.noarch.rpm;name=zram-generator-defaults;unpack=0"
SRC_URI += "${URI_zram-generator-defaults}"
SRC_URI[zram-generator-defaults.sha256sum] = "3c809f484f1767265d781b37a9f8a346ceb0aaed10905bf623b887f26b51c427"
RDEPENDS:zram-generator-defaults = " \
 zram-generator \
"
