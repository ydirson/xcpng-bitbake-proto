# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "php"
PE = "0"
PV = "8.3.19"
PR = "1.el10_0"
PACKAGES = "php php-bcmath php-cli php-common php-dba php-dbg php-devel php-embedded php-enchant php-ffi php-fpm php-gd php-gmp php-intl php-ldap php-mbstring php-mysqlnd php-odbc php-opcache php-pdo php-pgsql php-process php-snmp php-soap php-xml"
PROVIDES = "rpm/php rpm/php-bcmath rpm/php-cli rpm/php-common rpm/php-dba rpm/php-dbg rpm/php-devel rpm/php-embedded rpm/php-enchant rpm/php-ffi rpm/php-fpm rpm/php-gd rpm/php-gmp rpm/php-intl rpm/php-ldap rpm/php-mbstring rpm/php-mysqlnd rpm/php-odbc rpm/php-opcache rpm/php-pdo rpm/php-pgsql rpm/php-process rpm/php-snmp rpm/php-soap rpm/php-xml"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/php-8.3.19-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68dff872a1f075afb5e0843c490260ae17c0f7dd8c1444a5b9e16fee2fe499df"

URI_php = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-8.3.19-1.el10_0.x86_64_v2.rpm;name=php;unpack=0"
SRC_URI += "${URI_php}"
SRC_URI[php.sha256sum] = "5ce1d74e3a04fd1dd6a4839e4715a0ec5b39587e88ccbd4dadc268fb53fea471"
RDEPENDS:php = " \
 php-common \
"

URI_php-bcmath = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-bcmath-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-bcmath;unpack=0"
SRC_URI += "${URI_php-bcmath}"
SRC_URI[php-bcmath.sha256sum] = "46e5087fd9b8de5868bbcd0e517b6133e5628863f241f7d5d8dd483cbcdfa9dc"
RDEPENDS:php-bcmath = " \
 glibc \
 php-common \
"

URI_php-cli = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-cli-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-cli;unpack=0"
SRC_URI += "${URI_php-cli}"
SRC_URI[php-cli.sha256sum] = "dfa129f5f3e11d077abc88e2ee1a5f2f02589cd31aecfbfdf76028cbb06ecd0c"
RDEPENDS:php-cli = " \
 zlib-ng-compat \
 libxcrypt \
 openssl-libs \
 libxml2 \
 php-common \
 bash \
 pcre2 \
 glibc \
 libedit \
"

URI_php-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-common-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-common;unpack=0"
SRC_URI += "${URI_php-common}"
SRC_URI[php-common.sha256sum] = "5232359061e2c41309bc7db8ecf50d36e59f260ffbb67e4ed61a07e9a443b220"
RDEPENDS:php-common = " \
 tzdata \
 bzip2-libs \
 openssl-libs \
 libcurl \
 glibc \
"

URI_php-dba = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-dba-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-dba;unpack=0"
SRC_URI += "${URI_php-dba}"
SRC_URI[php-dba.sha256sum] = "e5508cf3d7376c3bb12c04d78d0f51fca99c0d81e2bcd9d828307b561ab0babe"
RDEPENDS:php-dba = " \
 glibc \
 php-common \
 tokyocabinet \
 lmdb-libs \
"

URI_php-dbg = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-dbg-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-dbg;unpack=0"
SRC_URI += "${URI_php-dbg}"
SRC_URI[php-dbg.sha256sum] = "8c5218ccba43521431917b4ee7160f9f03c28e1786895a459a245085cba134d5"
RDEPENDS:php-dbg = " \
 zlib-ng-compat \
 libxcrypt \
 openssl-libs \
 libxml2 \
 php-common \
 pcre2 \
 glibc \
 libedit \
"

URI_php-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-devel-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-devel;unpack=0"
SRC_URI += "${URI_php-devel}"
SRC_URI[php-devel.sha256sum] = "87f9fa2c9b6547d5576e922ca10a8f358620f60598279e4243b05fa6dff7b80b"
RDEPENDS:php-devel = " \
 libxml2-devel \
 libtool \
 autoconf \
 automake \
 zlib-ng-compat-devel \
 make \
 pcre2-devel \
 php-cli \
 openssl-devel \
 bash \
 gcc \
 gcc-c++ \
 krb5-devel \
"

URI_php-embedded = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-embedded-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-embedded;unpack=0"
SRC_URI += "${URI_php-embedded}"
SRC_URI[php-embedded.sha256sum] = "2b100cca33ca2a26ff127a400348caaeac04e68bb876af7cde87927d001ca96a"
RDEPENDS:php-embedded = " \
 zlib-ng-compat \
 libxcrypt \
 openssl-libs \
 libxml2 \
 krb5-libs \
 php-common \
 libcom_err \
 pcre2 \
 glibc \
"

URI_php-enchant = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-enchant-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-enchant;unpack=0"
SRC_URI += "${URI_php-enchant}"
SRC_URI[php-enchant.sha256sum] = "c111d8db7626ea6357721f6e7fb52228a3111da535ad6fcbe85f337c8c429c9b"
RDEPENDS:php-enchant = " \
 glibc \
 php-common \
 enchant2 \
"

URI_php-ffi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-ffi-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-ffi;unpack=0"
SRC_URI += "${URI_php-ffi}"
SRC_URI[php-ffi.sha256sum] = "4cb756fc81e4d7d0374d4c6d1f370255c04a61afad7830e15c7c53ca1f6c56c7"
RDEPENDS:php-ffi = " \
 glibc \
 php-common \
 libffi \
"

URI_php-fpm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-fpm-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-fpm;unpack=0"
SRC_URI += "${URI_php-fpm}"
SRC_URI[php-fpm.sha256sum] = "62e992febaa8c0c8fc30d99569a1ad5ae982ed2225f54fd3bf7e72808f3c21ef"
RDEPENDS:php-fpm = " \
 libacl \
 systemd \
 zlib-ng-compat \
 systemd-libs \
 libxcrypt \
 httpd-filesystem \
 openssl-libs \
 libxml2 \
 php-common \
 bash \
 pcre2 \
 glibc \
 libselinux \
 nginx-filesystem \
"

URI_php-gd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-gd-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-gd;unpack=0"
SRC_URI += "${URI_php-gd}"
SRC_URI[php-gd.sha256sum] = "2c299c6021fa62591bd5adfba6bfe0e6bfe26fe8c52fb229973181d19af7196e"
RDEPENDS:php-gd = " \
 glibc \
 gd \
 php-common \
"

URI_php-gmp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-gmp-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-gmp;unpack=0"
SRC_URI += "${URI_php-gmp}"
SRC_URI[php-gmp.sha256sum] = "99fd0a115903cdf6822e8efb198dc458672592c542f80b7cc329dfecdaae7f56"
RDEPENDS:php-gmp = " \
 glibc \
 gmp \
 php-common \
"

URI_php-intl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-intl-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-intl;unpack=0"
SRC_URI += "${URI_php-intl}"
SRC_URI[php-intl.sha256sum] = "6688cfe1945adeac40958575c09fb11fbcabc616aa8446f48c4aa0d4711a0d70"
RDEPENDS:php-intl = " \
 libgcc \
 php-common \
 libstdc++ \
 glibc \
 libicu \
"

URI_php-ldap = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-ldap-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-ldap;unpack=0"
SRC_URI += "${URI_php-ldap}"
SRC_URI[php-ldap.sha256sum] = "e622ec12b6d584f80500d3964e1c3005a462eac442dbcf43c35209d6f899a46d"
RDEPENDS:php-ldap = " \
 glibc \
 cyrus-sasl-lib \
 php-common \
 openldap \
"

URI_php-mbstring = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-mbstring-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-mbstring;unpack=0"
SRC_URI += "${URI_php-mbstring}"
SRC_URI[php-mbstring.sha256sum] = "8578bf9f48e82f22a52d2b238f924b5d096ac043f7371902aa3b93a50c216c94"
RDEPENDS:php-mbstring = " \
 glibc \
 oniguruma \
 php-common \
"

URI_php-mysqlnd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-mysqlnd-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-mysqlnd;unpack=0"
SRC_URI += "${URI_php-mysqlnd}"
SRC_URI[php-mysqlnd.sha256sum] = "e166e42a5b3d91b1b14385855529fcd41ac2bbc247c5d7e5066014deae03fe7b"
RDEPENDS:php-mysqlnd = " \
 glibc \
 php-pdo \
"

URI_php-odbc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-odbc-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-odbc;unpack=0"
SRC_URI += "${URI_php-odbc}"
SRC_URI[php-odbc.sha256sum] = "c10386a24ec07b8d5793005d59cce15140dc597e8385e97bf9b317e1c51c98c0"
RDEPENDS:php-odbc = " \
 glibc \
 php-pdo \
 unixODBC \
"

URI_php-opcache = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-opcache-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-opcache;unpack=0"
SRC_URI += "${URI_php-opcache}"
SRC_URI[php-opcache.sha256sum] = "e4ebf4c7fe58b83079c4963afe2bb430ce34886c50dc8d3ea43f414eda940d92"
RDEPENDS:php-opcache = " \
 glibc \
 capstone \
 libgcc \
 php-common \
"

URI_php-pdo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-pdo-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-pdo;unpack=0"
SRC_URI += "${URI_php-pdo}"
SRC_URI[php-pdo.sha256sum] = "00024deeb9666a3be53b67c4cce0e4475319f124e1a4e95ad30a92d33d52d592"
RDEPENDS:php-pdo = " \
 glibc \
 sqlite-libs \
 php-common \
"

URI_php-pgsql = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-pgsql-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-pgsql;unpack=0"
SRC_URI += "${URI_php-pgsql}"
SRC_URI[php-pgsql.sha256sum] = "76a1f08fb1429d33349cbbe8716a5aaa228aee149418ce30a1695c33c5de8ca6"
RDEPENDS:php-pgsql = " \
 glibc \
 php-pdo \
 libpq \
"

URI_php-process = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-process-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-process;unpack=0"
SRC_URI += "${URI_php-process}"
SRC_URI[php-process.sha256sum] = "59815da3ee9fa9a681904ece2415c27ff1f0277a7854f7249997eba2b8143148"
RDEPENDS:php-process = " \
 glibc \
 php-common \
"

URI_php-snmp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-snmp-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-snmp;unpack=0"
SRC_URI += "${URI_php-snmp}"
SRC_URI[php-snmp.sha256sum] = "a334921bb11e6ac31033abe055a582133a3a8324038db1ac25c959b677bc395f"
RDEPENDS:php-snmp = " \
 net-snmp \
 net-snmp-libs \
 openssl-libs \
 php-common \
 glibc \
"

URI_php-soap = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-soap-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-soap;unpack=0"
SRC_URI += "${URI_php-soap}"
SRC_URI[php-soap.sha256sum] = "6dd01ec2c35597b7ea6326cf2eeea73c53b6efab555f2f974ae4b3e5548e9b9c"
RDEPENDS:php-soap = " \
 glibc \
 php-common \
 libxml2 \
"

URI_php-xml = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-xml-8.3.19-1.el10_0.x86_64_v2.rpm;name=php-xml;unpack=0"
SRC_URI += "${URI_php-xml}"
SRC_URI[php-xml.sha256sum] = "2027583649d21e9904773f81a8a5d3e6d7c882a2409884d66783f652fdd9a6ab"
RDEPENDS:php-xml = " \
 glibc \
 php-common \
 libxslt \
 libxml2 \
"
