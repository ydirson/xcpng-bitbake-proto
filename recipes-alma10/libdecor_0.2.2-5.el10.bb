# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libdecor"
PE = "0"
PV = "0.2.2"
PR = "5.el10"
PACKAGES = "libdecor libdecor-devel"
PROVIDES = "rpm/libdecor rpm/libdecor-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libdecor-0.2.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25ba4155dabf184aab56f3fe659e11e431b3bc1526509f788cca0fa49b025e1b"

URI_libdecor = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libdecor-0.2.2-5.el10.x86_64_v2.rpm;name=libdecor;unpack=0"
SRC_URI += "${URI_libdecor}"
SRC_URI[libdecor.sha256sum] = "23fa06af0d25c316ece5606f974c6d291bd5d916185fb9d584e5dcd5a2795fef"
RDEPENDS:libdecor = " \
 libwayland-client \
 libwayland-cursor \
 pango \
 cairo \
 gtk3 \
 glib2 \
 glibc \
 dbus-libs \
"

URI_libdecor-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libdecor-devel-0.2.2-5.el10.x86_64_v2.rpm;name=libdecor-devel;unpack=0"
SRC_URI += "${URI_libdecor-devel}"
SRC_URI[libdecor-devel.sha256sum] = "4f9be00febc3596258087a7ed2ac98bca9966cb7ccccc8b15f8960ec2efd6b9e"
RDEPENDS:libdecor-devel = " \
 wayland-devel \
 libdecor \
 pkgconf-pkg-config \
"
