# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "wget"
PE = "0"
PV = "1.24.5"
PR = "5.el10"
PACKAGES = "wget"
PROVIDES = "rpm/wget"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/wget-1.24.5-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "280e47599884351a832ce434ccdbbb426c558ebc7c52c8a7a0f919e80efbd252"

URI_wget = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/wget-1.24.5-5.el10.x86_64_v2.rpm;name=wget;unpack=0"
SRC_URI += "${URI_wget}"
SRC_URI[wget.sha256sum] = "eea675266553c4117e2f354f04fc323b059bd30f6785dd7b9fa35b2306cdb2f7"
RDEPENDS:wget = " \
 libuuid \
 zlib-ng-compat \
 gnutls \
 libpsl \
 pcre2 \
 glibc \
 libidn2 \
"
