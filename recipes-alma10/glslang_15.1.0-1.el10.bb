# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "glslang"
PE = "0"
PV = "15.1.0"
PR = "1.el10"
PACKAGES = "glslang glslang-devel"
PROVIDES = "rpm/glslang rpm/glslang-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/glslang-15.1.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b65efacdc5778457175e70d1fc394c974d354a253f8a5b1da270214010c288f"

URI_glslang = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/glslang-15.1.0-1.el10.x86_64_v2.rpm;name=glslang;unpack=0"
SRC_URI += "${URI_glslang}"
SRC_URI[glslang.sha256sum] = "8015f3a4febfb1947aebca9d0951abea441b0eee1edb7cdf49402d565039d367"
RDEPENDS:glslang = " \
 glibc \
 spirv-tools-libs \
 libstdc++ \
"

URI_glslang-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/glslang-devel-15.1.0-1.el10.x86_64_v2.rpm;name=glslang-devel;unpack=0"
SRC_URI += "${URI_glslang-devel}"
SRC_URI[glslang-devel.sha256sum] = "51b7e8b03835d3ef89cd291b19eb36b7ebf948d093890c69f6563e0dacbea76c"
RDEPENDS:glslang-devel = " \
 glslang \
 cmake-filesystem \
 pkgconf-pkg-config \
"
