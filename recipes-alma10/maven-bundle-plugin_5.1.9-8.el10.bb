# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "maven-bundle-plugin"
PE = "0"
PV = "5.1.9"
PR = "8.el10"
PACKAGES = "maven-bundle-plugin maven-bundle-plugin-javadoc"
PROVIDES = "rpm/maven-bundle-plugin rpm/maven-bundle-plugin-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/maven-bundle-plugin-5.1.9-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b4bf2260b18fdf8c66dc27c012753117297f2d3e7af8d0757e91bb093bbd43b"

URI_maven-bundle-plugin = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-bundle-plugin-5.1.9-8.el10.noarch.rpm;name=maven-bundle-plugin;unpack=0"
SRC_URI += "${URI_maven-bundle-plugin}"
SRC_URI[maven-bundle-plugin.sha256sum] = "60c5e315e76a262c4cb9c8e9b8bc77bb89b941719a8bbca45e0cc712ba7d38ef"
RDEPENDS:maven-bundle-plugin = " \
 aqute-bndlib \
 plexus-utils \
 javapackages-filesystem \
 maven-archiver \
 plexus-build-api0 \
 felix-utils \
 slf4j \
 maven-dependency-tree \
"

URI_maven-bundle-plugin-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-bundle-plugin-javadoc-5.1.9-8.el10.noarch.rpm;name=maven-bundle-plugin-javadoc;unpack=0"
SRC_URI += "${URI_maven-bundle-plugin-javadoc}"
SRC_URI[maven-bundle-plugin-javadoc.sha256sum] = "8b04bd85d42933dc6b14f01017e92fdb216ae7e136ee62e1dbc9182950ae93ba"
RDEPENDS:maven-bundle-plugin-javadoc = " \
 javapackages-filesystem \
"
