# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-simpleline"
PE = "0"
PV = "1.9.0"
PR = "12.el10"
PACKAGES = "python3-simpleline"
PROVIDES = "rpm/python3-simpleline"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-simpleline-1.9.0-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0049688496174446e468085da1040dc1b0061dbe27579e5097a0bf5b37dfa363"

URI_python3-simpleline = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-simpleline-1.9.0-12.el10.noarch.rpm;name=python3-simpleline;unpack=0"
SRC_URI += "${URI_python3-simpleline}"
SRC_URI[python3-simpleline.sha256sum] = "7547746a0943dc98fb44edcd858e8cff6cb4552f577993234edde5ea575efa91"
RDEPENDS:python3-simpleline = " \
 python3 \
 python3-rpm \
"
