# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "chrpath"
PE = "0"
PV = "0.16"
PR = "25.el10"
PACKAGES = "chrpath"
PROVIDES = "rpm/chrpath"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/chrpath-0.16-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9d060f5c1f9ec2aa3e82925d3a08f1ffb9d02d66a10dc61a478ceaee101ec60"

URI_chrpath = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/chrpath-0.16-25.el10.x86_64_v2.rpm;name=chrpath;unpack=0"
SRC_URI += "${URI_chrpath}"
SRC_URI[chrpath.sha256sum] = "30c0d827226ae2f4f94c2439bf671cb5273dd269263ea1596c0b702b0103dc1f"
RDEPENDS:chrpath = " \
 glibc \
"
