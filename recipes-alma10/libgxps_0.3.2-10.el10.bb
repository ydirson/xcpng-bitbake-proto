# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libgxps"
PE = "0"
PV = "0.3.2"
PR = "10.el10"
PACKAGES = "libgxps libgxps-devel libgxps-tools"
PROVIDES = "rpm/libgxps rpm/libgxps-devel rpm/libgxps-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libgxps-0.3.2-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1190889190f707d986e90ab81c38460379125a5814eec0441661f660c2394a86"

URI_libgxps = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libgxps-0.3.2-10.el10.x86_64_v2.rpm;name=libgxps;unpack=0"
SRC_URI += "${URI_libgxps}"
SRC_URI[libgxps.sha256sum] = "d8a3d9ea4cf6cd761aeaae5445763d83bfec18875c838848cf908b2029cca8f2"
RDEPENDS:libgxps = " \
 freetype \
 lcms2 \
 libpng \
 libarchive \
 cairo \
 glib2 \
 glibc \
 libjpeg-turbo \
 libtiff \
"

URI_libgxps-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libgxps-devel-0.3.2-10.el10.x86_64_v2.rpm;name=libgxps-devel;unpack=0"
SRC_URI += "${URI_libgxps-devel}"
SRC_URI[libgxps-devel.sha256sum] = "aa64e01277c45774704eea7b63a99b75570a7308a9059e763eda3d12db656305"
RDEPENDS:libgxps-devel = " \
 libgxps \
 libarchive-devel \
 glib2-devel \
 pkgconf-pkg-config \
 cairo-devel \
"

URI_libgxps-tools = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libgxps-tools-0.3.2-10.el10.x86_64_v2.rpm;name=libgxps-tools;unpack=0"
SRC_URI += "${URI_libgxps-tools}"
SRC_URI[libgxps-tools.sha256sum] = "01f875f2fb3c627387e94ebf0a906bfb5ca85296b03f02edd7b1f4f0b2f6ca8b"
RDEPENDS:libgxps-tools = " \
 libgxps \
 libpng \
 cairo \
 glib2 \
 glibc \
 libjpeg-turbo \
"
