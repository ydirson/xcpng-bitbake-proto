# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lsof"
PE = "0"
PV = "4.98.0"
PR = "7.el10"
PACKAGES = "lsof"
PROVIDES = "rpm/lsof"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/lsof-4.98.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "023dbe535c276b494f96a39f5fa3aee27475f356f7c458492ceebe97c1c877c5"

URI_lsof = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/lsof-4.98.0-7.el10.x86_64_v2.rpm;name=lsof;unpack=0"
SRC_URI += "${URI_lsof}"
SRC_URI[lsof.sha256sum] = "a0594904788bd22158d574017e6c6fa0d5790ffcb0a54d0b224f9422a1795f7c"
RDEPENDS:lsof = " \
 glibc \
 libselinux \
 libtirpc \
"
