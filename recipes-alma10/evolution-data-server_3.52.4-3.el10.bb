# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "evolution-data-server"
PE = "0"
PV = "3.52.4"
PR = "3.el10"
PACKAGES = "evolution-data-server evolution-data-server-langpacks evolution-data-server-perl evolution-data-server-devel evolution-data-server-doc evolution-data-server-tests"
PROVIDES = "rpm/evolution-data-server rpm/evolution-data-server-langpacks rpm/evolution-data-server-perl rpm/evolution-data-server-devel rpm/evolution-data-server-doc rpm/evolution-data-server-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/evolution-data-server-3.52.4-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04eb34c14db2438adfb2711edff537692f37b960527caa01bf2f13cb2df7833d"

URI_evolution-data-server = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/evolution-data-server-3.52.4-3.el10.x86_64_v2.rpm;name=evolution-data-server;unpack=0"
SRC_URI += "${URI_evolution-data-server}"
SRC_URI[evolution-data-server.sha256sum] = "81c443444f5b7ae1d749252de311eff6d4cc5d316e2ce36abc32009c7a066491"
RDEPENDS:evolution-data-server = " \
 nss \
 pango \
 libcanberra \
 libcanberra-gtk3 \
 krb5-libs \
 evolution-data-server-langpacks \
 json-glib \
 libstdc++ \
 cairo \
 gnome-online-accounts \
 openldap \
 zlib-ng-compat \
 libgcc \
 libxml2 \
 sqlite-libs \
 libsecret \
 libicu \
 libgweather \
 libsoup3 \
 libical \
 libical-glib \
 glib2 \
 gtk3 \
 glibc \
 gtk4 \
 nspr \
"

URI_evolution-data-server-langpacks = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/evolution-data-server-langpacks-3.52.4-3.el10.noarch.rpm;name=evolution-data-server-langpacks;unpack=0"
SRC_URI += "${URI_evolution-data-server-langpacks}"
SRC_URI[evolution-data-server-langpacks.sha256sum] = "2561b6b0c2218e48f6c5b6015131fc585341492bcef7bfb9c1bf50ad3251e89a"
RDEPENDS:evolution-data-server-langpacks = " \
 evolution-data-server \
"

URI_evolution-data-server-perl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/evolution-data-server-perl-3.52.4-3.el10.x86_64_v2.rpm;name=evolution-data-server-perl;unpack=0"
SRC_URI += "${URI_evolution-data-server-perl}"
SRC_URI[evolution-data-server-perl.sha256sum] = "ab686dba6c68515a5cd7d221f4c3e0bb0b0524837ab98462c6ba87ea0e9c1dec"
RDEPENDS:evolution-data-server-perl = " \
 evolution-data-server \
 perl-interpreter \
"

URI_evolution-data-server-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/evolution-data-server-devel-3.52.4-3.el10.x86_64_v2.rpm;name=evolution-data-server-devel;unpack=0"
SRC_URI += "${URI_evolution-data-server-devel}"
SRC_URI[evolution-data-server-devel.sha256sum] = "54f0f397d694e1103744d72a7518fbe8c7452cd866c9b70bbb793c80f962e76a"
RDEPENDS:evolution-data-server-devel = " \
 libxml2-devel \
 json-glib-devel \
 glib2-devel \
 evolution-data-server-devel \
 libsoup3-devel \
 evolution-data-server \
 pkgconf-pkg-config \
 gnome-online-accounts-devel \
 libsecret-devel \
 libgweather-devel \
 gtk3-devel \
 libical-glib-devel \
 gtk4-devel \
 sqlite-devel \
"

URI_evolution-data-server-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/evolution-data-server-doc-3.52.4-3.el10.noarch.rpm;name=evolution-data-server-doc;unpack=0"
SRC_URI += "${URI_evolution-data-server-doc}"
SRC_URI[evolution-data-server-doc.sha256sum] = "04d7f95df67b26b48c4f2fdc5ad4697b3505a81bbb7a644e82ead29f6cd13d85"
RDEPENDS:evolution-data-server-doc = ""

URI_evolution-data-server-tests = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/evolution-data-server-tests-3.52.4-3.el10.x86_64_v2.rpm;name=evolution-data-server-tests;unpack=0"
SRC_URI += "${URI_evolution-data-server-tests}"
SRC_URI[evolution-data-server-tests.sha256sum] = "9904d880d67a79f45e863bd3fb99aa22bb0069358ed51c0b3b1c78c4179f4acb"
RDEPENDS:evolution-data-server-tests = " \
 glibc \
 evolution-data-server \
 libical-glib \
 glib2 \
"
