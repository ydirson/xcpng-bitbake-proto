# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-gl"
PE = "0"
PV = "0.20080515"
PR = "32.el10"
PACKAGES = "hunspell-gl"
PROVIDES = "rpm/hunspell-gl"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-gl-0.20080515-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3fbd172b9db7a3826b2d9a4369166c9b2c4471434aa322f9af942addb216562d"

URI_hunspell-gl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-gl-0.20080515-32.el10.noarch.rpm;name=hunspell-gl;unpack=0"
SRC_URI += "${URI_hunspell-gl}"
SRC_URI[hunspell-gl.sha256sum] = "3172cb3a8b547a3a2d8a70f472f95d76eabdde817782cf82b26af52f049dee9f"
RDEPENDS:hunspell-gl = " \
 hunspell-filesystem \
"
