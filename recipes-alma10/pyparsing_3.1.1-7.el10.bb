# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pyparsing"
PE = "0"
PV = "3.1.1"
PR = "7.el10"
PACKAGES = "python3-pyparsing pyparsing-doc"
PROVIDES = "rpm/python3-pyparsing rpm/pyparsing-doc"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/pyparsing-3.1.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bef2b60aa34fda9d1e539fe6c6d51950d94713543616bf6c054507995f414a7f"

URI_python3-pyparsing = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-pyparsing-3.1.1-7.el10.noarch.rpm;name=python3-pyparsing;unpack=0"
SRC_URI += "${URI_python3-pyparsing}"
SRC_URI[python3-pyparsing.sha256sum] = "bddd7ddda39e05a7ce9430b7407eaf7f832f9145aaa1380acfafb31b927fc904"
RDEPENDS:python3-pyparsing = " \
 python3 \
"

URI_pyparsing-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/pyparsing-doc-3.1.1-7.el10.noarch.rpm;name=pyparsing-doc;unpack=0"
SRC_URI += "${URI_pyparsing-doc}"
SRC_URI[pyparsing-doc.sha256sum] = "2e5df3e4e04703640480d7c704ecc0af825a29ff1fe318a114ef27b08c40d665"
RDEPENDS:pyparsing-doc = ""
