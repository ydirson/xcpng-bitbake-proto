# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "iso-codes"
PE = "0"
PV = "4.16.0"
PR = "6.el10"
PACKAGES = "iso-codes iso-codes-devel"
PROVIDES = "rpm/iso-codes rpm/iso-codes-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/iso-codes-4.16.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f37828f488f0d8face64a7d6169e716c46e05b7b85653e36644f31bd082a18a5"

URI_iso-codes = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/iso-codes-4.16.0-6.el10.noarch.rpm;name=iso-codes;unpack=0"
SRC_URI += "${URI_iso-codes}"
SRC_URI[iso-codes.sha256sum] = "e0747ff8aeb0fb0d5acd8923bfeed507f1234ff867733e46caf57bcb0f98a35d"
RDEPENDS:iso-codes = " \
 xml-common \
"

URI_iso-codes-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/iso-codes-devel-4.16.0-6.el10.noarch.rpm;name=iso-codes-devel;unpack=0"
SRC_URI += "${URI_iso-codes-devel}"
SRC_URI[iso-codes-devel.sha256sum] = "970193ea22babb8b9922cbd0a958325a4bd55f72aeee368ad787732e4b8a8ad2"
RDEPENDS:iso-codes-devel = " \
 pkgconf-pkg-config \
 iso-codes \
"
