# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mpich"
PE = "0"
PV = "4.1.2"
PR = "15.el10"
PACKAGES = "mpich mpich-autoload mpich-devel mpich-doc python3-mpich"
PROVIDES = "rpm/mpich rpm/mpich-autoload rpm/mpich-devel rpm/mpich-doc rpm/python3-mpich"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mpich-4.1.2-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "efb199e5e931718f7eebeb5d098e7b3c2eb8adaf970042f68f8f3b9943246c28"

URI_mpich = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mpich-4.1.2-15.el10.x86_64_v2.rpm;name=mpich;unpack=0"
SRC_URI += "${URI_mpich}"
SRC_URI[mpich.sha256sum] = "392f104152172e7a2a45ced28729f23f90e56d5aa638508a5fc6c3797f7e0d41"
RDEPENDS:mpich = " \
 python3 \
 libgcc \
 libgfortran \
 hwloc-libs \
 environment-modules \
 libfabric \
 libstdc++ \
 glibc \
 perl-interpreter \
"

URI_mpich-autoload = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mpich-autoload-4.1.2-15.el10.x86_64_v2.rpm;name=mpich-autoload;unpack=0"
SRC_URI += "${URI_mpich-autoload}"
SRC_URI[mpich-autoload.sha256sum] = "eda4074c119c3d8be5acc1a9f4684d54b4dba6d17df4850e2d0b12623a7f80f4"
RDEPENDS:mpich-autoload = " \
 mpich \
"

URI_mpich-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mpich-devel-4.1.2-15.el10.x86_64_v2.rpm;name=mpich-devel;unpack=0"
SRC_URI += "${URI_mpich-devel}"
SRC_URI[mpich-devel.sha256sum] = "d546cd5835c20799d905e28dc923c7bedbed8cbd3285c7b0ae30eb673f13eea7"
RDEPENDS:mpich-devel = " \
 redhat-rpm-config \
 pkgconf-pkg-config \
 rpm-mpi-hooks \
 bash \
 gcc-gfortran \
 mpich \
"

URI_mpich-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mpich-doc-4.1.2-15.el10.noarch.rpm;name=mpich-doc;unpack=0"
SRC_URI += "${URI_mpich-doc}"
SRC_URI[mpich-doc.sha256sum] = "f6afababdf38703258401ae5974b290d19fe8378ef9b7c300f06268bd0cae190"
RDEPENDS:mpich-doc = " \
 mpich-devel \
"

URI_python3-mpich = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-mpich-4.1.2-15.el10.x86_64_v2.rpm;name=python3-mpich;unpack=0"
SRC_URI += "${URI_python3-mpich}"
SRC_URI[python3-mpich.sha256sum] = "981e0b6cecf33a81bfa3e2278c78a862faf7b4a2394d4ae5093e5f913016590f"
RDEPENDS:python3-mpich = " \
 python3 \
 mpich \
"
