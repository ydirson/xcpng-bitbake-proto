# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Tie-IxHash"
PE = "0"
PV = "1.23"
PR = "40.el10"
PACKAGES = "perl-Tie-IxHash"
PROVIDES = "rpm/perl-Tie-IxHash"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Tie-IxHash-1.23-40.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0fbbe072b62d96682dff818fcf96c071e1f4528579c57c57f4a1e27737e032a0"

URI_perl-Tie-IxHash = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Tie-IxHash-1.23-40.el10.noarch.rpm;name=perl-Tie-IxHash;unpack=0"
SRC_URI += "${URI_perl-Tie-IxHash}"
SRC_URI[perl-Tie-IxHash.sha256sum] = "656d39990056bf6dff88ea305dc71076e3948baed279e1b10dbdb2a18e3cd3eb"
RDEPENDS:perl-Tie-IxHash = " \
 perl-libs \
 perl-vars \
"
