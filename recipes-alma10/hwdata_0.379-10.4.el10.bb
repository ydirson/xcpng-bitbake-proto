# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hwdata"
PE = "0"
PV = "0.379"
PR = "10.4.el10"
PACKAGES = "hwdata hwdata-devel"
PROVIDES = "rpm/hwdata rpm/hwdata-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/hwdata-0.379-10.4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1768c83cabb6a95eddf3247cf36a86c6725e023088b5e4211f62fc461cac6b93"

URI_hwdata = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/hwdata-0.379-10.4.el10.noarch.rpm;name=hwdata;unpack=0"
SRC_URI += "${URI_hwdata}"
SRC_URI[hwdata.sha256sum] = "8791f482deedf0489e583f12f5c0093596083901277f1d875f80bc333008150e"
RDEPENDS:hwdata = ""

URI_hwdata-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/hwdata-devel-0.379-10.4.el10.noarch.rpm;name=hwdata-devel;unpack=0"
SRC_URI += "${URI_hwdata-devel}"
SRC_URI[hwdata-devel.sha256sum] = "39960cb2c778971be67cffd9699f5c7d9661122c21d070e8a6c450a6c95b802d"
RDEPENDS:hwdata-devel = " \
 pkgconf-pkg-config \
 hwdata \
"
