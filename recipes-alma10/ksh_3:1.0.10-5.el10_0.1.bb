# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ksh"
PE = "3"
PV = "1.0.10"
PR = "5.el10_0.1"
PACKAGES = "ksh"
PROVIDES = "rpm/ksh"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ksh-1.0.10-5.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "965d4f68c98d91f2f49378393ff679c1a475e61def3a519c4e5936ee41d74c0b"

URI_ksh = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ksh-1.0.10-5.el10_0.1.x86_64_v2.rpm;name=ksh;unpack=0"
SRC_URI += "${URI_ksh}"
SRC_URI[ksh.sha256sum] = "31bf4893eb436201d433bcd99b6927bcffbd88d9533750c87dc322ccf5d1f3f2"
RDEPENDS:ksh = " \
 systemd \
 diffutils \
 grep \
 bash \
 glibc \
 coreutils \
 sed \
"
