# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lynx"
PE = "0"
PV = "2.9.0"
PR = "6.el10"
PACKAGES = "lynx"
PROVIDES = "rpm/lynx"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/lynx-2.9.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "efd97e65f02db5696c1116d0b2deb86c059a1116c51faf6f196e7e948ed72834"

URI_lynx = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lynx-2.9.0-6.el10.x86_64_v2.rpm;name=lynx;unpack=0"
SRC_URI += "${URI_lynx}"
SRC_URI[lynx.sha256sum] = "0b80ef6ca398c93a4939190210ba9326480b1fba2c56241bd6e121f0cdf36f9a"
RDEPENDS:lynx = " \
 zlib-ng-compat \
 bzip2-libs \
 openssl-libs \
 libbrotli \
 ncurses-libs \
 almalinux-indexhtml \
 glibc \
 libidn2 \
"
