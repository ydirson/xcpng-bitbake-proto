# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "iptraf-ng"
PE = "0"
PV = "1.2.2"
PR = "2.el10"
PACKAGES = "iptraf-ng"
PROVIDES = "rpm/iptraf-ng"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/iptraf-ng-1.2.2-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52b483524fef7f445bd5a95c7574105d6c18c38da52acfb46581702a0c2ee8fe"

URI_iptraf-ng = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/iptraf-ng-1.2.2-2.el10.x86_64_v2.rpm;name=iptraf-ng;unpack=0"
SRC_URI += "${URI_iptraf-ng}"
SRC_URI[iptraf-ng.sha256sum] = "fca61a8fb695ec6581b338fa8e9e33d75836ccece48ed282eaebd660ef49d909"
RDEPENDS:iptraf-ng = " \
 glibc \
 logrotate \
 ncurses-libs \
"
