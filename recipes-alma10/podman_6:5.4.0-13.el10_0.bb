# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "podman"
PE = "6"
PV = "5.4.0"
PR = "13.el10_0"
PACKAGES = "podman podman-docker podman-remote podman-tests podman-machine podmansh"
PROVIDES = "rpm/podman rpm/podman-docker rpm/podman-remote rpm/podman-tests rpm/podman-machine rpm/podmansh"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/podman-5.4.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8bf09fc85643813004796f994940235af6b79d484f1a81d0824c0125f7991251"

URI_podman = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/podman-5.4.0-13.el10_0.x86_64_v2.rpm;name=podman;unpack=0"
SRC_URI += "${URI_podman}"
SRC_URI[podman.sha256sum] = "26c6c576e89f9091de4b12ef8522dc26c10507de7376a3c05e406f5607b1460d"
RDEPENDS:podman = " \
 containers-common-extra \
 shadow-utils-subid \
 gpgme \
 libgcc \
 libseccomp \
 glibc \
 conmon \
 catatonit \
"

URI_podman-docker = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/podman-docker-5.4.0-13.el10_0.noarch.rpm;name=podman-docker;unpack=0"
SRC_URI += "${URI_podman-docker}"
SRC_URI[podman-docker.sha256sum] = "8abbc5400a991c98ba4d8bee821b158581877b40360242c50dfad6f9a4bb9aad"
RDEPENDS:podman-docker = " \
 bash \
 podman \
"

URI_podman-remote = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/podman-remote-5.4.0-13.el10_0.x86_64_v2.rpm;name=podman-remote;unpack=0"
SRC_URI += "${URI_podman-remote}"
SRC_URI[podman-remote.sha256sum] = "d9b0fb5321d7ff07d053b18a5529c254d57f6f160be00408145f738f15ffa517"
RDEPENDS:podman-remote = " \
 glibc \
 gpgme \
 libgcc \
 shadow-utils-subid \
"

URI_podman-tests = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/podman-tests-5.4.0-13.el10_0.x86_64_v2.rpm;name=podman-tests;unpack=0"
SRC_URI += "${URI_podman-tests}"
SRC_URI[podman-tests.sha256sum] = "9e138a23559d5f9ee489937810dc0140ed60ede95721bf0a015bf0e589c2c534"
RDEPENDS:podman-tests = " \
 gnupg2 \
 shadow-utils-subid \
 nmap-ncat \
 attr \
 openssl \
 buildah \
 libgcc \
 jq \
 gpgme \
 httpd-tools \
 skopeo \
 bash \
 libseccomp \
 glibc \
 podman \
 socat \
"

URI_podman-machine = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/podman-machine-5.4.0-13.el10_0.x86_64_v2.rpm;name=podman-machine;unpack=0"
SRC_URI += "${URI_podman-machine}"
SRC_URI[podman-machine.sha256sum] = "1c78a15e09f6cc2877acb11d041b2b258f8702c71fadafb3832dfaa044ed6966"
RDEPENDS:podman-machine = " \
 qemu-img \
 gvisor-tap-vsock \
 qemu-kvm \
 virtiofsd \
 podman \
"

URI_podmansh = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/podmansh-5.4.0-13.el10_0.x86_64_v2.rpm;name=podmansh;unpack=0"
SRC_URI += "${URI_podmansh}"
SRC_URI[podmansh.sha256sum] = "26e1c3dc32afa85b2e8e767fbd7d40102ea4d88b680bb8f7c20d5049bfc49b4e"
RDEPENDS:podmansh = " \
 podman \
"
