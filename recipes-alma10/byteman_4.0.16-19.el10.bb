# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "byteman"
PE = "0"
PV = "4.0.16"
PR = "19.el10"
PACKAGES = "byteman byteman-bmunit byteman-javadoc byteman-dtest byteman-rulecheck-maven-plugin"
PROVIDES = "rpm/byteman rpm/byteman-bmunit rpm/byteman-javadoc rpm/byteman-dtest rpm/byteman-rulecheck-maven-plugin"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/byteman-4.0.16-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eda9af23ea99d0558154995ff56b8d74a269736f731607a48ac535d6184d8304"

URI_byteman = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/byteman-4.0.16-19.el10.noarch.rpm;name=byteman;unpack=0"
SRC_URI += "${URI_byteman}"
SRC_URI[byteman.sha256sum] = "cab6181151a1952bb1f79939884bf6d08e6e55d68558901f36918efaf53fe08c"
RDEPENDS:byteman = " \
 javapackages-filesystem \
 apache-commons-lang3 \
 byteman-bmunit \
 bash \
 java-21-openjdk-headless \
"

URI_byteman-bmunit = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/byteman-bmunit-4.0.16-19.el10.noarch.rpm;name=byteman-bmunit;unpack=0"
SRC_URI += "${URI_byteman-bmunit}"
SRC_URI[byteman-bmunit.sha256sum] = "311c13d388dfca8556e972b9428c6904937d1b89e2d3f656a0d8dd60397821a7"
RDEPENDS:byteman-bmunit = " \
 javapackages-filesystem \
 byteman \
"

URI_byteman-javadoc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/byteman-javadoc-4.0.16-19.el10.noarch.rpm;name=byteman-javadoc;unpack=0"
SRC_URI += "${URI_byteman-javadoc}"
SRC_URI[byteman-javadoc.sha256sum] = "d167c41c2592c484393a1c00709b21e0da6d422ad93a4d2ebb4009787491bab4"
RDEPENDS:byteman-javadoc = " \
 javapackages-filesystem \
"

URI_byteman-dtest = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/byteman-dtest-4.0.16-19.el10.noarch.rpm;name=byteman-dtest;unpack=0"
SRC_URI += "${URI_byteman-dtest}"
SRC_URI[byteman-dtest.sha256sum] = "9f565e9362ddf763f1a40f56bf73796ba1edfd6af71ebdb53788a621b26c33c7"
RDEPENDS:byteman-dtest = " \
 junit \
 javapackages-filesystem \
 byteman \
"

URI_byteman-rulecheck-maven-plugin = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/byteman-rulecheck-maven-plugin-4.0.16-19.el10.noarch.rpm;name=byteman-rulecheck-maven-plugin;unpack=0"
SRC_URI += "${URI_byteman-rulecheck-maven-plugin}"
SRC_URI[byteman-rulecheck-maven-plugin.sha256sum] = "85a0c454b71c7e46a5a0f24eb17b03c8b6645327f85b389520518c1003be5afe"
RDEPENDS:byteman-rulecheck-maven-plugin = " \
 plexus-utils \
 byteman \
 javapackages-filesystem \
 maven-lib \
"
