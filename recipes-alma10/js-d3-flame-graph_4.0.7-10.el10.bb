# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "js-d3-flame-graph"
PE = "0"
PV = "4.0.7"
PR = "10.el10"
PACKAGES = "js-d3-flame-graph js-d3-flame-graph-doc"
PROVIDES = "rpm/js-d3-flame-graph rpm/js-d3-flame-graph-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/js-d3-flame-graph-4.0.7-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0222f5a2db70a10c7fd4f3202dd176c0b436a5ab682e8edb242163becdab5120"

URI_js-d3-flame-graph = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/js-d3-flame-graph-4.0.7-10.el10.noarch.rpm;name=js-d3-flame-graph;unpack=0"
SRC_URI += "${URI_js-d3-flame-graph}"
SRC_URI[js-d3-flame-graph.sha256sum] = "b09387b211f37d629d26b5928a40239fa5942e2fb2e2765f8fee61cff6daa247"
RDEPENDS:js-d3-flame-graph = ""

URI_js-d3-flame-graph-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/js-d3-flame-graph-doc-4.0.7-10.el10.noarch.rpm;name=js-d3-flame-graph-doc;unpack=0"
SRC_URI += "${URI_js-d3-flame-graph-doc}"
SRC_URI[js-d3-flame-graph-doc.sha256sum] = "9c99c9bf1bce7c8c56ab7ca391bdc6d19f3c13adf0268640bc1526ede0f80341"
RDEPENDS:js-d3-flame-graph-doc = ""
