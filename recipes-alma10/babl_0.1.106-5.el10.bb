# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "babl"
PE = "0"
PV = "0.1.106"
PR = "5.el10"
PACKAGES = "babl babl-devel babl-devel-docs"
PROVIDES = "rpm/babl rpm/babl-devel rpm/babl-devel-docs"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/babl-0.1.106-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9662c01fd63e970c0e63d96d625c72fbdbe6986b457a50db75d4884ce367e5de"

URI_babl = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/babl-0.1.106-5.el10.x86_64_v2.rpm;name=babl;unpack=0"
SRC_URI += "${URI_babl}"
SRC_URI[babl.sha256sum] = "9c4a8dda948b5056ba150f2cfef53b795f20a46895fc324b869135c43f92b68d"
RDEPENDS:babl = " \
 glibc \
 lcms2 \
"

URI_babl-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/babl-devel-0.1.106-5.el10.x86_64_v2.rpm;name=babl-devel;unpack=0"
SRC_URI += "${URI_babl-devel}"
SRC_URI[babl-devel.sha256sum] = "296f639b6a98c837cd12e2c4856137088e4e39fc9dbb2807d31b9237614986e2"
RDEPENDS:babl-devel = " \
 babl \
 pkgconf-pkg-config \
 lcms2-devel \
"

URI_babl-devel-docs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/babl-devel-docs-0.1.106-5.el10.noarch.rpm;name=babl-devel-docs;unpack=0"
SRC_URI += "${URI_babl-devel-docs}"
SRC_URI[babl-devel-docs.sha256sum] = "abeb25ee109355850c25da496534ccf9fb4374e7cf68d14b539bc36065c9d795"
RDEPENDS:babl-devel-docs = " \
 babl-devel \
"
