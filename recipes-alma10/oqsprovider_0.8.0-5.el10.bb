# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "oqsprovider"
PE = "0"
PV = "0.8.0"
PR = "5.el10"
PACKAGES = "oqsprovider"
PROVIDES = "rpm/oqsprovider"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/oqsprovider-0.8.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e0298d0067e0e1b994190c441da43d8c82656c9b9fff00234f26b5132d9e1bb"

URI_oqsprovider = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/oqsprovider-0.8.0-5.el10.x86_64_v2.rpm;name=oqsprovider;unpack=0"
SRC_URI += "${URI_oqsprovider}"
SRC_URI[oqsprovider.sha256sum] = "74391a9187cca4565f52260f3b7eea20a0e00bd22c9dab8382959c9004f9d0ee"
RDEPENDS:oqsprovider = " \
 glibc \
 openssl \
 openssl-libs \
 liboqs \
"
