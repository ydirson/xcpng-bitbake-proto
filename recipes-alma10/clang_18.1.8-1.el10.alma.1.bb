# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "clang"
PE = "0"
PV = "18.1.8"
PR = "1.el10.alma.1"
PACKAGES = "clang-resource-filesystem"
PROVIDES = "rpm/clang-resource-filesystem"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/clang-18.1.8-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c20d7da70684c631c197405e67ab62590e01b3f35adeee22a9cca44b4c8aaaa1"

URI_clang-resource-filesystem = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/clang-resource-filesystem-18.1.8-1.el10.alma.1.noarch.rpm;name=clang-resource-filesystem;unpack=0"
SRC_URI += "${URI_clang-resource-filesystem}"
SRC_URI[clang-resource-filesystem.sha256sum] = "71f42d93197b493f47591c8e0aaacecd5ede72eb68387cac568b94f1954e01ac"
RDEPENDS:clang-resource-filesystem = ""
