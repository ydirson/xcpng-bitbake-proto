# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-systemd"
PE = "0"
PV = "235"
PR = "11.el10"
PACKAGES = "python3-systemd python-systemd-doc"
PROVIDES = "rpm/python3-systemd rpm/python-systemd-doc"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/python-systemd-235-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4230f54b5efa3a1e57fcc7f51398336e394e9567c9710dde353d11656025e93c"

URI_python3-systemd = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-systemd-235-11.el10.x86_64_v2.rpm;name=python3-systemd;unpack=0"
SRC_URI += "${URI_python3-systemd}"
SRC_URI[python3-systemd.sha256sum] = "5a15af009b2a4a8cf6c41893d670ae3ee55f654a09722841e31b76efeccbfbe1"
RDEPENDS:python3-systemd = " \
 glibc \
 python3 \
 libgcc \
 systemd-libs \
"

URI_python-systemd-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python-systemd-doc-235-11.el10.x86_64_v2.rpm;name=python-systemd-doc;unpack=0"
SRC_URI += "${URI_python-systemd-doc}"
SRC_URI[python-systemd-doc.sha256sum] = "ea7e3598693309be7675e4b64cd87597716ae643ea5c64433cfa655c9567d23f"
RDEPENDS:python-systemd-doc = " \
 js-jquery \
"
