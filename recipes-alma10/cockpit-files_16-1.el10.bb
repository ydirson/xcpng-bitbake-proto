# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cockpit-files"
PE = "0"
PV = "16"
PR = "1.el10"
PACKAGES = "cockpit-files"
PROVIDES = "rpm/cockpit-files"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/cockpit-files-16-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7fa66ff911fdc144760f253766d6ff6490d4b5c35959816ef2cacf3b4ce248e"

URI_cockpit-files = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cockpit-files-16-1.el10.noarch.rpm;name=cockpit-files;unpack=0"
SRC_URI += "${URI_cockpit-files}"
SRC_URI[cockpit-files.sha256sum] = "b90a0e7cc3c35b25a7b7a61905091d2e160f6b729b02b4e112697586dd92c742"
RDEPENDS:cockpit-files = " \
 cockpit-bridge \
"
