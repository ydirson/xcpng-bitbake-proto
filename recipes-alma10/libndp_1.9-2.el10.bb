# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libndp"
PE = "0"
PV = "1.9"
PR = "2.el10"
PACKAGES = "libndp libndp-devel"
PROVIDES = "rpm/libndp rpm/libndp-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libndp-1.9-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "decb8592a934b661781cec791cc940bf02984deff1119ce0ab19991fd6d6d578"

URI_libndp = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libndp-1.9-2.el10.x86_64_v2.rpm;name=libndp;unpack=0"
SRC_URI += "${URI_libndp}"
SRC_URI[libndp.sha256sum] = "ff63c97876136775ff9f3c49f7af8a09a08cec5715f9487241ed27f3140e1a0c"
RDEPENDS:libndp = " \
 glibc \
"

URI_libndp-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libndp-devel-1.9-2.el10.x86_64_v2.rpm;name=libndp-devel;unpack=0"
SRC_URI += "${URI_libndp-devel}"
SRC_URI[libndp-devel.sha256sum] = "62bac654cfef4c1ab9979fcf5cffcba6c74d33eab47e84abc78265e6ddc44489"
RDEPENDS:libndp-devel = " \
 pkgconf-pkg-config \
 libndp \
"
