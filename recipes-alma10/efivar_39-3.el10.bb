# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "efivar"
PE = "0"
PV = "39"
PR = "3.el10"
PACKAGES = "efivar-libs efivar efivar-devel"
PROVIDES = "rpm/efivar-libs rpm/efivar rpm/efivar-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/efivar-39-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c9706643660205d8dc59b1b7523856a7744beb4571324dd871ceb96a000039d"

URI_efivar-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/efivar-libs-39-3.el10.x86_64_v2.rpm;name=efivar-libs;unpack=0"
SRC_URI += "${URI_efivar-libs}"
SRC_URI[efivar-libs.sha256sum] = "e9bea7306dbfa4cf6e77b4d9b6d4152f99ab2f7bd62608205620fa8eb7f62c3c"
RDEPENDS:efivar-libs = " \
 glibc \
"

URI_efivar = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/efivar-39-3.el10.x86_64_v2.rpm;name=efivar;unpack=0"
SRC_URI += "${URI_efivar}"
SRC_URI[efivar.sha256sum] = "bcfc297d4020f363d7c24fad15a59c8abd195900e6812e13d86de7214fd49d0b"
RDEPENDS:efivar = " \
 glibc \
 efivar-libs \
"

URI_efivar-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/efivar-devel-39-3.el10.x86_64_v2.rpm;name=efivar-devel;unpack=0"
SRC_URI += "${URI_efivar-devel}"
SRC_URI[efivar-devel.sha256sum] = "a1c0338eca9e5811a921acc7cdab8078cdf7a426e68c30409099d3ff6d3fc164"
RDEPENDS:efivar-devel = " \
 efivar-devel \
 pkgconf-pkg-config \
 efivar-libs \
"
