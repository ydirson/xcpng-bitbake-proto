# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python3.12"
PE = "0"
PV = "3.12.9"
PR = "2.el10_0.3"
PACKAGES = "python3 python3-libs python-unversioned-command python3-devel python3-tkinter python3-debug python3-idle python3-test"
PROVIDES = "rpm/python3 rpm/python3-libs rpm/python-unversioned-command rpm/python3-devel rpm/python3-tkinter rpm/python3-debug rpm/python3-idle rpm/python3-test"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/python3.12-3.12.9-2.el10_0.3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "160a1da806e0e2787893690f57162e67fc3ebbff48f85fc5dd44dff0cf0238c7"

URI_python3 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-3.12.9-2.el10_0.3.x86_64_v2.rpm;name=python3;unpack=0"
SRC_URI += "${URI_python3}"
SRC_URI[python3.sha256sum] = "01ca8a51e1752b995cfa87099996a64f08bd43edd1330ae4ddbbd9c5bbd33143"
RDEPENDS:python3 = " \
 glibc \
 python3-libs \
"

URI_python3-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-libs-3.12.9-2.el10_0.3.x86_64_v2.rpm;name=python3-libs;unpack=0"
SRC_URI += "${URI_python3-libs}"
SRC_URI[python3-libs.sha256sum] = "50e67397f679a7fb0d35d5d5946055037e499d14b0871c919ccfbfd542418e07"
RDEPENDS:python3-libs = " \
 libuuid \
 zlib-ng-compat \
 tzdata \
 bzip2-libs \
 mpdecimal \
 libffi \
 libxcrypt \
 openssl-libs \
 readline \
 gdbm-libs \
 sqlite-libs \
 bash \
 ncurses-libs \
 expat \
 glibc \
 python3-pip-wheel \
 xz-libs \
"

URI_python-unversioned-command = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python-unversioned-command-3.12.9-2.el10_0.3.noarch.rpm;name=python-unversioned-command;unpack=0"
SRC_URI += "${URI_python-unversioned-command}"
SRC_URI[python-unversioned-command.sha256sum] = "c92f0df9edffbf73d01895a506c80c94c3c1873b611329019ae5c7a4a3df76c7"
RDEPENDS:python-unversioned-command = " \
 python3 \
"

URI_python3-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-devel-3.12.9-2.el10_0.3.x86_64_v2.rpm;name=python3-devel;unpack=0"
SRC_URI += "${URI_python3-devel}"
SRC_URI[python3-devel.sha256sum] = "0c3198837e7d12b37119fbad4c7e6dc9b1d5bac168984cb3ca9ef428077e06a3"
RDEPENDS:python3-devel = " \
 python3 \
 pkgconf-pkg-config \
 python3-libs \
 python-rpm-macros \
 bash \
 python3-rpm-generators \
 python3-rpm-macros \
"

URI_python3-tkinter = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-tkinter-3.12.9-2.el10_0.3.x86_64_v2.rpm;name=python3-tkinter;unpack=0"
SRC_URI += "${URI_python3-tkinter}"
SRC_URI[python3-tkinter.sha256sum] = "408dc226e831266e6bb569cd4a9e136b597bebecf916a6629aa8fa2e1b7324c5"
RDEPENDS:python3-tkinter = " \
 glibc \
 python3 \
 tk \
 tcl \
"

URI_python3-debug = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-debug-3.12.9-2.el10_0.3.x86_64_v2.rpm;name=python3-debug;unpack=0"
SRC_URI += "${URI_python3-debug}"
SRC_URI[python3-debug.sha256sum] = "3c26cae3a163f5e562761cc012eb12899b049a1aa25bcab4a186b652566ceca1"
RDEPENDS:python3-debug = " \
 python3 \
 mpdecimal \
 tcl \
 python3-tkinter \
 ncurses-libs \
 python3-test \
 tk \
 python3-libs \
 xz-libs \
 libuuid \
 zlib-ng-compat \
 libffi \
 libxcrypt \
 openssl-libs \
 sqlite-libs \
 bash \
 expat \
 bzip2-libs \
 readline \
 pkgconf-pkg-config \
 gdbm-libs \
 python3-devel \
 glibc \
 python3-idle \
"

URI_python3-idle = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-idle-3.12.9-2.el10_0.3.x86_64_v2.rpm;name=python3-idle;unpack=0"
SRC_URI += "${URI_python3-idle}"
SRC_URI[python3-idle.sha256sum] = "3f72061d895d074ccc4afad1bdebc06e2a2084209760000b47d4747f808e8f04"
RDEPENDS:python3-idle = " \
 python3 \
 python3-tkinter \
"

URI_python3-test = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-test-3.12.9-2.el10_0.3.x86_64_v2.rpm;name=python3-test;unpack=0"
SRC_URI += "${URI_python3-test}"
SRC_URI[python3-test.sha256sum] = "f03b1dd5836c718e8bdedccc87be53e30b799fdc672c0bef4012bc5607b34208"
RDEPENDS:python3-test = " \
 python3 \
 python3-wheel-wheel \
 python3-libs \
 bash \
 glibc \
 python3-setuptools-wheel \
"
