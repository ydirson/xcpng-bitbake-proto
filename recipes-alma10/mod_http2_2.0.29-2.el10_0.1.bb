# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mod_http2"
PE = "0"
PV = "2.0.29"
PR = "2.el10_0.1"
PACKAGES = "mod_http2"
PROVIDES = "rpm/mod_http2"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mod_http2-2.0.29-2.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af6262f988b5a6c5abdfc12773b16a4903a79d4eb3944e5ff694f9a14251dee0"

URI_mod_http2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mod_http2-2.0.29-2.el10_0.1.x86_64_v2.rpm;name=mod_http2;unpack=0"
SRC_URI += "${URI_mod_http2}"
SRC_URI[mod_http2.sha256sum] = "5a4b4ee456b79b41494aa40ed2984eb75211245ee1b46012d1504b1872c3b5bd"
RDEPENDS:mod_http2 = " \
 glibc \
 openssl-libs \
 httpd-core \
 libnghttp2 \
"
