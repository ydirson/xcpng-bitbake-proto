# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-ky"
PE = "0"
PV = "0.20090415"
PR = "34.el10"
PACKAGES = "hunspell-ky"
PROVIDES = "rpm/hunspell-ky"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-ky-0.20090415-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74c75d577e8acc9440406129356083d7a4f458ce5d8e7214318b6238940ac03f"

URI_hunspell-ky = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-ky-0.20090415-34.el10.noarch.rpm;name=hunspell-ky;unpack=0"
SRC_URI += "${URI_hunspell-ky}"
SRC_URI[hunspell-ky.sha256sum] = "c9ec0dba383fe2b30133745ebf869525f041584e2f3e8ccced3423f0b5d16e3d"
RDEPENDS:hunspell-ky = " \
 hunspell-filesystem \
"
