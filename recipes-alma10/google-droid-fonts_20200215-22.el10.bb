# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "google-droid-fonts"
PE = "0"
PV = "20200215"
PR = "22.el10"
PACKAGES = "google-droid-sans-fonts google-droid-sans-mono-fonts google-droid-serif-fonts google-droid-fonts-all"
PROVIDES = "rpm/google-droid-sans-fonts rpm/google-droid-sans-mono-fonts rpm/google-droid-serif-fonts rpm/google-droid-fonts-all"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/google-droid-fonts-20200215-22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19e1af2c27e513029d24bdd4833d7d69813a2600cc7bfe4c11e03a524e019588"

URI_google-droid-sans-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-droid-sans-fonts-20200215-22.el10.noarch.rpm;name=google-droid-sans-fonts;unpack=0"
SRC_URI += "${URI_google-droid-sans-fonts}"
SRC_URI[google-droid-sans-fonts.sha256sum] = "fef5bcffb2f9324c00c6f5d616951698d441b9662d771edf78d7b2c7747e2e09"
RDEPENDS:google-droid-sans-fonts = " \
 fonts-filesystem \
"

URI_google-droid-sans-mono-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-droid-sans-mono-fonts-20200215-22.el10.noarch.rpm;name=google-droid-sans-mono-fonts;unpack=0"
SRC_URI += "${URI_google-droid-sans-mono-fonts}"
SRC_URI[google-droid-sans-mono-fonts.sha256sum] = "1866d0c7c24dafe4f19f270323418b3c0b8cd4b9001d68247d2ec0e7d3ad5fb6"
RDEPENDS:google-droid-sans-mono-fonts = " \
 fonts-filesystem \
"

URI_google-droid-serif-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-droid-serif-fonts-20200215-22.el10.noarch.rpm;name=google-droid-serif-fonts;unpack=0"
SRC_URI += "${URI_google-droid-serif-fonts}"
SRC_URI[google-droid-serif-fonts.sha256sum] = "ec3c2d0456f4774ed22f71f18e1045c8a8ddc771544f5250b7cb783309d62dcb"
RDEPENDS:google-droid-serif-fonts = " \
 fonts-filesystem \
"

URI_google-droid-fonts-all = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/google-droid-fonts-all-20200215-22.el10.noarch.rpm;name=google-droid-fonts-all;unpack=0"
SRC_URI += "${URI_google-droid-fonts-all}"
SRC_URI[google-droid-fonts-all.sha256sum] = "777cbd075e7098451e0e864fb7a60f17737a620e31400124e84e4c1853f57e6b"
RDEPENDS:google-droid-fonts-all = " \
 google-droid-sans-fonts \
 google-droid-sans-mono-fonts \
 google-droid-serif-fonts \
"
