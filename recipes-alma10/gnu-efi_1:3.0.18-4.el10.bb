# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnu-efi"
PE = "1"
PV = "3.0.18"
PR = "4.el10"
PACKAGES = "gnu-efi gnu-efi-devel gnu-efi-utils"
PROVIDES = "rpm/gnu-efi rpm/gnu-efi-devel rpm/gnu-efi-utils"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnu-efi-3.0.18-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2572d9604c185518cc9def8557951288fab4fb24db836c563c79b5de7138202"

URI_gnu-efi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnu-efi-3.0.18-4.el10.x86_64_v2.rpm;name=gnu-efi;unpack=0"
SRC_URI += "${URI_gnu-efi}"
SRC_URI[gnu-efi.sha256sum] = "9b804bffab923ec43e6215691b15e676dbee6b4e03f294928142e21a159c1f6f"
RDEPENDS:gnu-efi = ""

URI_gnu-efi-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gnu-efi-devel-3.0.18-4.el10.x86_64_v2.rpm;name=gnu-efi-devel;unpack=0"
SRC_URI += "${URI_gnu-efi-devel}"
SRC_URI[gnu-efi-devel.sha256sum] = "8ce2db05b0236bd4e6bd4b6443e0f616da71b4bb085d280a041c289c1b77c67a"
RDEPENDS:gnu-efi-devel = " \
 gnu-efi \
 pkgconf-pkg-config \
"

URI_gnu-efi-utils = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gnu-efi-utils-3.0.18-4.el10.x86_64_v2.rpm;name=gnu-efi-utils;unpack=0"
SRC_URI += "${URI_gnu-efi-utils}"
SRC_URI[gnu-efi-utils.sha256sum] = "a6cdb3167cbf2ef21990e4e96d84fcd31ad971f92810a54e709accaf23b0ab62"
RDEPENDS:gnu-efi-utils = ""
