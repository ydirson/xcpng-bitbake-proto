# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "postgresql16-pgaudit"
PE = "0"
PV = "16.0"
PR = "7.el10"
PACKAGES = "pgaudit"
PROVIDES = "rpm/pgaudit"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/postgresql16-pgaudit-16.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "acdc12af193b56454e67e1da5f2d49c484d7853345fe6cb66609123922d5566c"

URI_pgaudit = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pgaudit-16.0-7.el10.x86_64_v2.rpm;name=pgaudit;unpack=0"
SRC_URI += "${URI_pgaudit}"
SRC_URI[pgaudit.sha256sum] = "9d36c8721f82bc06e414fdf61df1934d52ba45bbb730dadafed323de671fce43"
RDEPENDS:pgaudit = " \
 glibc \
 postgresql-server \
"
