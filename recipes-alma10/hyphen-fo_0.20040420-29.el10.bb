# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-fo"
PE = "0"
PV = "0.20040420"
PR = "29.el10"
PACKAGES = "hyphen-fo"
PROVIDES = "rpm/hyphen-fo"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-fo-0.20040420-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff1fab9b2f7c0aaa47c4bdd3803c4fed43d75f88bd2762ffa396f20fcb6e36c4"

URI_hyphen-fo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-fo-0.20040420-29.el10.noarch.rpm;name=hyphen-fo;unpack=0"
SRC_URI += "${URI_hyphen-fo}"
SRC_URI[hyphen-fo.sha256sum] = "75d6ba2f1d83c9d147efc3b7c2616c69ed0d18cd48356c1868478b5f03938bc3"
RDEPENDS:hyphen-fo = " \
 hyphen \
"
