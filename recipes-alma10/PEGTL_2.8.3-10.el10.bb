# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "PEGTL"
PE = "0"
PV = "2.8.3"
PR = "10.el10"
PACKAGES = "PEGTL-devel"
PROVIDES = "rpm/PEGTL-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/PEGTL-2.8.3-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16808ab15c9d55727824cfcb6173bf83126876e06f6a50498f75f921b1d4c836"

URI_PEGTL-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/PEGTL-devel-2.8.3-10.el10.x86_64_v2.rpm;name=PEGTL-devel;unpack=0"
SRC_URI += "${URI_PEGTL-devel}"
SRC_URI[PEGTL-devel.sha256sum] = "4e4715b261cfc1e2801fd13e70de41e23b1f876daf12a50db4108aceabd5e522"
RDEPENDS:PEGTL-devel = " \
 libstdc++-devel \
"
