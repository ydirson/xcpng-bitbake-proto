# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cifs-utils"
PE = "0"
PV = "7.2"
PR = "0.el10_0.1"
PACKAGES = "cifs-utils pam_cifscreds cifs-utils-devel cifs-utils-info"
PROVIDES = "rpm/cifs-utils rpm/pam_cifscreds rpm/cifs-utils-devel rpm/cifs-utils-info"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/cifs-utils-7.2-0.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82473fea90d320a651850521e35f00af0df9e0ce475d5b88eed9177d3ed573aa"

URI_cifs-utils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cifs-utils-7.2-0.el10_0.1.x86_64_v2.rpm;name=cifs-utils;unpack=0"
SRC_URI += "${URI_cifs-utils}"
SRC_URI[cifs-utils.sha256sum] = "436b4dfe8f367fc6d566481b363c91bf6b5c2b7e13aa4bad06ae93236711ad9f"
RDEPENDS:cifs-utils = " \
 libwbclient \
 keyutils-libs \
 keyutils \
 libcap-ng \
 krb5-libs \
 bash \
 libtalloc \
 glibc \
 alternatives \
"

URI_pam_cifscreds = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pam_cifscreds-7.2-0.el10_0.1.x86_64_v2.rpm;name=pam_cifscreds;unpack=0"
SRC_URI += "${URI_pam_cifscreds}"
SRC_URI[pam_cifscreds.sha256sum] = "a280b837d6beea6ca25ffd9ab299b119913308bf81cb64ac096129317f251eef"
RDEPENDS:pam_cifscreds = " \
 glibc \
 keyutils-libs \
 pam-libs \
 libtalloc \
"

URI_cifs-utils-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/cifs-utils-devel-7.2-0.el10_0.1.x86_64_v2.rpm;name=cifs-utils-devel;unpack=0"
SRC_URI += "${URI_cifs-utils-devel}"
SRC_URI[cifs-utils-devel.sha256sum] = "ffaf98ea2fd66510cfea9e77b24b8fa4087a818aace068babb399fa226b71b5e"
RDEPENDS:cifs-utils-devel = ""

URI_cifs-utils-info = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/cifs-utils-info-7.2-0.el10_0.1.x86_64_v2.rpm;name=cifs-utils-info;unpack=0"
SRC_URI += "${URI_cifs-utils-info}"
SRC_URI[cifs-utils-info.sha256sum] = "a4a61158e4c8520e319735556e9e4b96c23ba20a4331f9d29f30658327f3fcb2"
RDEPENDS:cifs-utils-info = " \
 python3 \
 cifs-utils \
"
