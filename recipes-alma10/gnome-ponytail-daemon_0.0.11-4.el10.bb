# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-ponytail-daemon"
PE = "0"
PV = "0.0.11"
PR = "4.el10"
PACKAGES = "gnome-ponytail-daemon python3-gnome-ponytail-daemon"
PROVIDES = "rpm/gnome-ponytail-daemon rpm/python3-gnome-ponytail-daemon"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-ponytail-daemon-0.0.11-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90ad1e4f9b48ad16b285dd1ee544348cadb6f418873d37d57be4efe3073f22dd"

URI_gnome-ponytail-daemon = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-ponytail-daemon-0.0.11-4.el10.x86_64_v2.rpm;name=gnome-ponytail-daemon;unpack=0"
SRC_URI += "${URI_gnome-ponytail-daemon}"
SRC_URI[gnome-ponytail-daemon.sha256sum] = "66f6bbf326dfd4e380ccd47df70dfd8d6a813aa82fb30f3398ca803c0a4b6f32"
RDEPENDS:gnome-ponytail-daemon = " \
 systemd \
 libei \
 libgcc \
 bash \
 glib2 \
 glibc \
 libxkbcommon \
"

URI_python3-gnome-ponytail-daemon = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-gnome-ponytail-daemon-0.0.11-4.el10.noarch.rpm;name=python3-gnome-ponytail-daemon;unpack=0"
SRC_URI += "${URI_python3-gnome-ponytail-daemon}"
SRC_URI[python3-gnome-ponytail-daemon.sha256sum] = "13eb4cb9455eeaed6901670bfc9414d0fba447f3144aaa6027426eae8c8a29d1"
RDEPENDS:python3-gnome-ponytail-daemon = " \
 python3 \
 python3-gobject \
 python3-dbus \
 gnome-ponytail-daemon \
"
