# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Import-Into"
PE = "0"
PV = "1.002005"
PR = "29.el10"
PACKAGES = "perl-Import-Into perl-Import-Into-tests"
PROVIDES = "rpm/perl-Import-Into rpm/perl-Import-Into-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Import-Into-1.002005-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1211e39d80839c2bbcb43c6a16b6432d72969df68d1aae1ad6f5b9d76aa99daf"

URI_perl-Import-Into = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Import-Into-1.002005-29.el10.noarch.rpm;name=perl-Import-Into;unpack=0"
SRC_URI += "${URI_perl-Import-Into}"
SRC_URI[perl-Import-Into.sha256sum] = "801d29f85085efbd9b8db8734a15b8568f37aae1d83422db1431398a7404cbbe"
RDEPENDS:perl-Import-Into = " \
 perl-Module-Runtime \
 perl-libs \
"

URI_perl-Import-Into-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Import-Into-tests-1.002005-29.el10.noarch.rpm;name=perl-Import-Into-tests;unpack=0"
SRC_URI += "${URI_perl-Import-Into-tests}"
SRC_URI[perl-Import-Into-tests.sha256sum] = "c90821559b29615711f0aa586ae8d49cfa2af577ca14af92f79af7fc7fdca949"
RDEPENDS:perl-Import-Into-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Import-Into \
 bash \
 perl-base \
 perl-interpreter \
 perl-Exporter \
"
