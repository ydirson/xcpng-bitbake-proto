# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "protobuf-c"
PE = "0"
PV = "1.5.0"
PR = "6.el10"
PACKAGES = "protobuf-c protobuf-c-compiler protobuf-c-devel"
PROVIDES = "rpm/protobuf-c rpm/protobuf-c-compiler rpm/protobuf-c-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/protobuf-c-1.5.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f2bf29024bcbfcf6af42f0415fadcfc85de8454003e8511a2034af473cc660a"

URI_protobuf-c = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/protobuf-c-1.5.0-6.el10.x86_64_v2.rpm;name=protobuf-c;unpack=0"
SRC_URI += "${URI_protobuf-c}"
SRC_URI[protobuf-c.sha256sum] = "a640b425640bf7ae1d2ddb42941157f25b6baded2029ea517dec01e5535457cb"
RDEPENDS:protobuf-c = " \
 glibc \
"

URI_protobuf-c-compiler = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/protobuf-c-compiler-1.5.0-6.el10.x86_64_v2.rpm;name=protobuf-c-compiler;unpack=0"
SRC_URI += "${URI_protobuf-c-compiler}"
SRC_URI[protobuf-c-compiler.sha256sum] = "ae9bb0846d9d11121aa70d7fd78a69d90b264f38ea130d2a41d4be184b3896b4"
RDEPENDS:protobuf-c-compiler = " \
 protobuf \
 libgcc \
 libstdc++ \
 glibc \
 protobuf-c \
 protobuf-compiler \
"

URI_protobuf-c-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/protobuf-c-devel-1.5.0-6.el10.x86_64_v2.rpm;name=protobuf-c-devel;unpack=0"
SRC_URI += "${URI_protobuf-c-devel}"
SRC_URI[protobuf-c-devel.sha256sum] = "9dbedea1f137f893cb5b369880d5d569da4ce78147dd3b0ab208ad01f00e4eb4"
RDEPENDS:protobuf-c-devel = " \
 protobuf-c \
 protobuf-c-compiler \
 pkgconf-pkg-config \
"
