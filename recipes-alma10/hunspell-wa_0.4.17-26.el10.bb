# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-wa"
PE = "0"
PV = "0.4.17"
PR = "26.el10"
PACKAGES = "hunspell-wa"
PROVIDES = "rpm/hunspell-wa"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-wa-0.4.17-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7828883c23007da0bd5f96893e0781707bba5e39a822776aefdf7b99b70040b"

URI_hunspell-wa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-wa-0.4.17-26.el10.noarch.rpm;name=hunspell-wa;unpack=0"
SRC_URI += "${URI_hunspell-wa}"
SRC_URI[hunspell-wa.sha256sum] = "33c7043bee17983ff432e22782b78bdb1ed6acd098cbd870e5d8723338493c8b"
RDEPENDS:hunspell-wa = " \
 hunspell-filesystem \
"
