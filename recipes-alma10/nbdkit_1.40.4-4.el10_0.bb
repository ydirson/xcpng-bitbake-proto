# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "nbdkit"
PE = "0"
PV = "1.40.4"
PR = "4.el10_0"
PACKAGES = "nbdkit nbdkit-bash-completion nbdkit-basic-filters nbdkit-basic-plugins nbdkit-curl-plugin nbdkit-linuxdisk-plugin nbdkit-nbd-plugin nbdkit-python-plugin nbdkit-selinux nbdkit-server nbdkit-ssh-plugin nbdkit-tar-filter nbdkit-tmpdisk-plugin nbdkit-vddk-plugin nbdkit-xz-filter nbdkit-devel nbdkit-example-plugins nbdkit-srpm-macros nbdkit-blkio-plugin nbdkit-bzip2-filter nbdkit-stats-filter"
PROVIDES = "rpm/nbdkit rpm/nbdkit-bash-completion rpm/nbdkit-basic-filters rpm/nbdkit-basic-plugins rpm/nbdkit-curl-plugin rpm/nbdkit-linuxdisk-plugin rpm/nbdkit-nbd-plugin rpm/nbdkit-python-plugin rpm/nbdkit-selinux rpm/nbdkit-server rpm/nbdkit-ssh-plugin rpm/nbdkit-tar-filter rpm/nbdkit-tmpdisk-plugin rpm/nbdkit-vddk-plugin rpm/nbdkit-xz-filter rpm/nbdkit-devel rpm/nbdkit-example-plugins rpm/nbdkit-srpm-macros rpm/nbdkit-blkio-plugin rpm/nbdkit-bzip2-filter rpm/nbdkit-stats-filter"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/nbdkit-1.40.4-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36db921d645261cf34ff9d685545358527599fdc667dff92f1269910844dcb29"

URI_nbdkit = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nbdkit-1.40.4-4.el10_0.x86_64_v2.rpm;name=nbdkit;unpack=0"
SRC_URI += "${URI_nbdkit}"
SRC_URI[nbdkit.sha256sum] = "91035a744f04a090020e46eab76acaf78ab14e6dbd5ee881d236b3de7c26fa78"
RDEPENDS:nbdkit = " \
 nbdkit-basic-plugins \
 nbdkit-selinux \
 nbdkit-server \
 nbdkit-basic-filters \
"

URI_nbdkit-bash-completion = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nbdkit-bash-completion-1.40.4-4.el10_0.noarch.rpm;name=nbdkit-bash-completion;unpack=0"
SRC_URI += "${URI_nbdkit-bash-completion}"
SRC_URI[nbdkit-bash-completion.sha256sum] = "cfa6a5e80fc664ae79b09e61b6047a9d7559d8e89efd56cef6a02a23abec498c"
RDEPENDS:nbdkit-bash-completion = " \
 nbdkit-server \
 bash-completion \
"

URI_nbdkit-basic-filters = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nbdkit-basic-filters-1.40.4-4.el10_0.x86_64_v2.rpm;name=nbdkit-basic-filters;unpack=0"
SRC_URI += "${URI_nbdkit-basic-filters}"
SRC_URI[nbdkit-basic-filters.sha256sum] = "bd73231543656454b4f9e40a2588066ed92898943c9c1dfadd284c83643b8c67"
RDEPENDS:nbdkit-basic-filters = " \
 zlib-ng-compat \
 gnutls \
 libgcc \
 nbdkit-server \
 glibc \
"

URI_nbdkit-basic-plugins = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nbdkit-basic-plugins-1.40.4-4.el10_0.x86_64_v2.rpm;name=nbdkit-basic-plugins;unpack=0"
SRC_URI += "${URI_nbdkit-basic-plugins}"
SRC_URI[nbdkit-basic-plugins.sha256sum] = "7fa52e4dd9671f07097b4949942be8a86b6d5597aea56d28c21146dcd3c532c6"
RDEPENDS:nbdkit-basic-plugins = " \
 gnutls \
 libgcc \
 libzstd \
 nbdkit-server \
 glibc \
"

URI_nbdkit-curl-plugin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nbdkit-curl-plugin-1.40.4-4.el10_0.x86_64_v2.rpm;name=nbdkit-curl-plugin;unpack=0"
SRC_URI += "${URI_nbdkit-curl-plugin}"
SRC_URI[nbdkit-curl-plugin.sha256sum] = "318b5de21dca4abc46f9ccc2da64c3066ac683f33597ca8479edd323aafb5fa2"
RDEPENDS:nbdkit-curl-plugin = " \
 glibc \
 libgcc \
 nbdkit-server \
 libcurl \
"

URI_nbdkit-linuxdisk-plugin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nbdkit-linuxdisk-plugin-1.40.4-4.el10_0.x86_64_v2.rpm;name=nbdkit-linuxdisk-plugin;unpack=0"
SRC_URI += "${URI_nbdkit-linuxdisk-plugin}"
SRC_URI[nbdkit-linuxdisk-plugin.sha256sum] = "5139766a03e42eef10657666eb7871195f4279e581130b66dded8864fc9ed747"
RDEPENDS:nbdkit-linuxdisk-plugin = " \
 glibc \
 e2fsprogs \
 libgcc \
 nbdkit-server \
"

URI_nbdkit-nbd-plugin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nbdkit-nbd-plugin-1.40.4-4.el10_0.x86_64_v2.rpm;name=nbdkit-nbd-plugin;unpack=0"
SRC_URI += "${URI_nbdkit-nbd-plugin}"
SRC_URI[nbdkit-nbd-plugin.sha256sum] = "c1012f5103e2d6827a8149aecca0799fff3bccc001d121506639d68b30092f3c"
RDEPENDS:nbdkit-nbd-plugin = " \
 glibc \
 libgcc \
 nbdkit-server \
 libnbd \
"

URI_nbdkit-python-plugin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nbdkit-python-plugin-1.40.4-4.el10_0.x86_64_v2.rpm;name=nbdkit-python-plugin;unpack=0"
SRC_URI += "${URI_nbdkit-python-plugin}"
SRC_URI[nbdkit-python-plugin.sha256sum] = "ee73c8cb8bbd0a011d5f0ce0689947179f1968e3068103d7c41a22f0357eec9b"
RDEPENDS:nbdkit-python-plugin = " \
 glibc \
 libgcc \
 nbdkit-server \
 python3-libs \
"

URI_nbdkit-selinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nbdkit-selinux-1.40.4-4.el10_0.noarch.rpm;name=nbdkit-selinux;unpack=0"
SRC_URI += "${URI_nbdkit-selinux}"
SRC_URI[nbdkit-selinux.sha256sum] = "191bf14ad202fe97804ce5eadea20fb4ffc7b139d5b9def0afd1cdbc2a4d302b"
RDEPENDS:nbdkit-selinux = " \
 policycoreutils-python-utils \
 policycoreutils \
 bash \
 selinux-policy \
 libselinux-utils \
 selinux-policy-targeted \
"

URI_nbdkit-server = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nbdkit-server-1.40.4-4.el10_0.x86_64_v2.rpm;name=nbdkit-server;unpack=0"
SRC_URI += "${URI_nbdkit-server}"
SRC_URI[nbdkit-server.sha256sum] = "0ec5cb1abf0ebbc772f0522508f47ae9f8554c973e05bccd73d2c0757e02dbf6"
RDEPENDS:nbdkit-server = " \
 glibc \
 libselinux \
 libgcc \
 gnutls \
"

URI_nbdkit-ssh-plugin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nbdkit-ssh-plugin-1.40.4-4.el10_0.x86_64_v2.rpm;name=nbdkit-ssh-plugin;unpack=0"
SRC_URI += "${URI_nbdkit-ssh-plugin}"
SRC_URI[nbdkit-ssh-plugin.sha256sum] = "86e599de82f912a2f99222d683ae28f072f761dfdc33b0d092d28dfa1b892e35"
RDEPENDS:nbdkit-ssh-plugin = " \
 glibc \
 libgcc \
 nbdkit-server \
 libssh \
"

URI_nbdkit-tar-filter = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nbdkit-tar-filter-1.40.4-4.el10_0.x86_64_v2.rpm;name=nbdkit-tar-filter;unpack=0"
SRC_URI += "${URI_nbdkit-tar-filter}"
SRC_URI[nbdkit-tar-filter.sha256sum] = "d3ecbb62335ec3dc9d4ae870b39c9f2ecf7cd708f3ddcebb2e9be5df986bd551"
RDEPENDS:nbdkit-tar-filter = " \
 glibc \
 libgcc \
 tar \
 nbdkit-server \
"

URI_nbdkit-tmpdisk-plugin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nbdkit-tmpdisk-plugin-1.40.4-4.el10_0.x86_64_v2.rpm;name=nbdkit-tmpdisk-plugin;unpack=0"
SRC_URI += "${URI_nbdkit-tmpdisk-plugin}"
SRC_URI[nbdkit-tmpdisk-plugin.sha256sum] = "fd9b429ad43f238c570a60a615a840bc4bce00604ee8a36ed362ab20d13e04f5"
RDEPENDS:nbdkit-tmpdisk-plugin = " \
 e2fsprogs \
 util-linux \
 libgcc \
 nbdkit-server \
 glibc \
"

URI_nbdkit-vddk-plugin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nbdkit-vddk-plugin-1.40.4-4.el10_0.x86_64_v2.rpm;name=nbdkit-vddk-plugin;unpack=0"
SRC_URI += "${URI_nbdkit-vddk-plugin}"
SRC_URI[nbdkit-vddk-plugin.sha256sum] = "f8d801a95053dab5009320df9227b1ad82af323c3ded8dabc5a0e8799aba5674"
RDEPENDS:nbdkit-vddk-plugin = " \
 glibc \
 libxcrypt-compat \
 libgcc \
 nbdkit-server \
"

URI_nbdkit-xz-filter = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nbdkit-xz-filter-1.40.4-4.el10_0.x86_64_v2.rpm;name=nbdkit-xz-filter;unpack=0"
SRC_URI += "${URI_nbdkit-xz-filter}"
SRC_URI[nbdkit-xz-filter.sha256sum] = "c16e950917c128ff10256bbb6c5f5c447a9a36f1c60739d0d91cd679d9b87bef"
RDEPENDS:nbdkit-xz-filter = " \
 glibc \
 libgcc \
 nbdkit-server \
 xz-libs \
"

URI_nbdkit-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/nbdkit-devel-1.40.4-4.el10_0.x86_64_v2.rpm;name=nbdkit-devel;unpack=0"
SRC_URI += "${URI_nbdkit-devel}"
SRC_URI[nbdkit-devel.sha256sum] = "860ec505c9a6a8b2e0ca1e8672fa96e6198b938a76bfc4555afa3c7ba77f42e1"
RDEPENDS:nbdkit-devel = " \
 nbdkit-server \
 pkgconf-pkg-config \
"

URI_nbdkit-example-plugins = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/nbdkit-example-plugins-1.40.4-4.el10_0.x86_64_v2.rpm;name=nbdkit-example-plugins;unpack=0"
SRC_URI += "${URI_nbdkit-example-plugins}"
SRC_URI[nbdkit-example-plugins.sha256sum] = "1b26db98f43f80ebe7a24ae527d9622dff913ea3b22109891739c87e304b447e"
RDEPENDS:nbdkit-example-plugins = " \
 glibc \
 nbdkit-server \
"

URI_nbdkit-srpm-macros = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/nbdkit-srpm-macros-1.40.4-4.el10_0.noarch.rpm;name=nbdkit-srpm-macros;unpack=0"
SRC_URI += "${URI_nbdkit-srpm-macros}"
SRC_URI[nbdkit-srpm-macros.sha256sum] = "2c569b88f522821633bc5d6d6addf53242e9b0db0bd98b93ad33282b4ebddb00"
RDEPENDS:nbdkit-srpm-macros = " \
 bash \
"

URI_nbdkit-blkio-plugin = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/nbdkit-blkio-plugin-1.40.4-4.el10_0.x86_64_v2.rpm;name=nbdkit-blkio-plugin;unpack=0"
SRC_URI += "${URI_nbdkit-blkio-plugin}"
SRC_URI[nbdkit-blkio-plugin.sha256sum] = "1a2f882bb98b8cbf2b0c12960f2d454112c48a8798672028daefd288980f7daa"
RDEPENDS:nbdkit-blkio-plugin = " \
 glibc \
 libblkio \
 nbdkit-server \
"

URI_nbdkit-bzip2-filter = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/nbdkit-bzip2-filter-1.40.4-4.el10_0.x86_64_v2.rpm;name=nbdkit-bzip2-filter;unpack=0"
SRC_URI += "${URI_nbdkit-bzip2-filter}"
SRC_URI[nbdkit-bzip2-filter.sha256sum] = "904bc92ea30c81c9b00237ff8febae82136e487905b724a7c335f2a61d5bdc78"
RDEPENDS:nbdkit-bzip2-filter = " \
 glibc \
 libgcc \
 nbdkit-server \
 bzip2-libs \
"

URI_nbdkit-stats-filter = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/nbdkit-stats-filter-1.40.4-4.el10_0.x86_64_v2.rpm;name=nbdkit-stats-filter;unpack=0"
SRC_URI += "${URI_nbdkit-stats-filter}"
SRC_URI[nbdkit-stats-filter.sha256sum] = "aab48315e4f73381bd1bf0df014428769f722dfede7d6dec20d1925a40fd9648"
RDEPENDS:nbdkit-stats-filter = " \
 glibc \
 libgcc \
 nbdkit-server \
 libstdc++ \
"
