# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-fa"
PE = "0"
PV = "0.20070116"
PR = "36.el10"
PACKAGES = "hunspell-fa"
PROVIDES = "rpm/hunspell-fa"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-fa-0.20070116-36.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "34efb41705d97c35d01cee517aa7be9bf03fde4ffa7be1da00faf32321917ad8"

URI_hunspell-fa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-fa-0.20070116-36.el10.noarch.rpm;name=hunspell-fa;unpack=0"
SRC_URI += "${URI_hunspell-fa}"
SRC_URI[hunspell-fa.sha256sum] = "12bc62dc739dcd54e0b9848a9c9492b10815b82d47e9090e605e9a95058518e2"
RDEPENDS:hunspell-fa = " \
 hunspell-filesystem \
"
