# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rust-prefixdevname"
PE = "0"
PV = "0.2.0"
PR = "4.el10"
PACKAGES = "prefixdevname"
PROVIDES = "rpm/prefixdevname"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/rust-prefixdevname-0.2.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef1998f6cecd075cf6a35e5518c0d3ad0543a4e66e9bb21f9479430e6b3b7cbc"

URI_prefixdevname = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/prefixdevname-0.2.0-4.el10.x86_64_v2.rpm;name=prefixdevname;unpack=0"
SRC_URI += "${URI_prefixdevname}"
SRC_URI[prefixdevname.sha256sum] = "4af828e23461e86ac5c8662ae420a9eb37bcf613bf138ab7d339711dc061f0a4"
RDEPENDS:prefixdevname = " \
 glibc \
 libgcc \
 bash \
 systemd-libs \
"
