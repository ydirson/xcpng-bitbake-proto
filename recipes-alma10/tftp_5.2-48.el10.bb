# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tftp"
PE = "0"
PV = "5.2"
PR = "48.el10"
PACKAGES = "tftp tftp-server"
PROVIDES = "rpm/tftp rpm/tftp-server"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tftp-5.2-48.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7df5846a64510caa84c2eebb34c162a86f0072dc1ca93839ea4ce097f2a2097f"

URI_tftp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tftp-5.2-48.el10.x86_64_v2.rpm;name=tftp;unpack=0"
SRC_URI += "${URI_tftp}"
SRC_URI[tftp.sha256sum] = "ebe2935ea411c063057fa7253bdceefbd3a99676b81b9a2b3a75a15c81a1571b"
RDEPENDS:tftp = " \
 glibc \
 readline \
"

URI_tftp-server = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tftp-server-5.2-48.el10.x86_64_v2.rpm;name=tftp-server;unpack=0"
SRC_URI += "${URI_tftp-server}"
SRC_URI[tftp-server.sha256sum] = "459c2a48079349dd054695b6e57b8ea9de7107c203ea0d4a97f54b33a0f47bcf"
RDEPENDS:tftp-server = " \
 glibc \
 systemd \
 bash \
"
