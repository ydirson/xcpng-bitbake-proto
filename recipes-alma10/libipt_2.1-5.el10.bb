# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libipt"
PE = "0"
PV = "2.1"
PR = "5.el10"
PACKAGES = "libipt libipt-devel"
PROVIDES = "rpm/libipt rpm/libipt-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libipt-2.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f3b039c60ac39a08a2ae816f73ea03ff1d1440e27ffafe1ee881a5800fee1df"

URI_libipt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libipt-2.1-5.el10.x86_64_v2.rpm;name=libipt;unpack=0"
SRC_URI += "${URI_libipt}"
SRC_URI[libipt.sha256sum] = "3d31466d4e54474d3b164a6ed8cf0c71e044f4c621ec285ca7fe3fe21c9ae32a"
RDEPENDS:libipt = " \
 glibc \
"

URI_libipt-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libipt-devel-2.1-5.el10.x86_64_v2.rpm;name=libipt-devel;unpack=0"
SRC_URI += "${URI_libipt-devel}"
SRC_URI[libipt-devel.sha256sum] = "59f8245fb2cbe3f574426be1db2d601a542b16b8ceeea3cc83f0196698d1d1a0"
RDEPENDS:libipt-devel = " \
 libipt \
"
