# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-MakeMaker"
PE = "2"
PV = "7.70"
PR = "513.el10"
PACKAGES = "perl-ExtUtils-Command perl-ExtUtils-MM-Utils perl-ExtUtils-MakeMaker perl-ExtUtils-MakeMaker-tests"
PROVIDES = "rpm/perl-ExtUtils-Command rpm/perl-ExtUtils-MM-Utils rpm/perl-ExtUtils-MakeMaker rpm/perl-ExtUtils-MakeMaker-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-ExtUtils-MakeMaker-7.70-513.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cfafb8b1a0dbf1183eb05234720fb675a78a64075c61a0192f3e2f04f17e93ed"

URI_perl-ExtUtils-Command = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-ExtUtils-Command-7.70-513.el10.noarch.rpm;name=perl-ExtUtils-Command;unpack=0"
SRC_URI += "${URI_perl-ExtUtils-Command}"
SRC_URI[perl-ExtUtils-Command.sha256sum] = "1177483446c28371176a66dc2c7e9c3f94c4b358c37dbffea3ac9b0da69ea5d1"
RDEPENDS:perl-ExtUtils-Command = " \
 perl-libs \
 perl-Carp \
 perl-File-Copy \
 perl-File-Find \
 perl-Exporter \
 perl-File-Path \
"

URI_perl-ExtUtils-MM-Utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-ExtUtils-MM-Utils-7.70-513.el10.noarch.rpm;name=perl-ExtUtils-MM-Utils;unpack=0"
SRC_URI += "${URI_perl-ExtUtils-MM-Utils}"
SRC_URI[perl-ExtUtils-MM-Utils.sha256sum] = "dee9c8ba2297fa3f6b2959e5a2632ce74672511e41456a37634ee658cdbf63ca"
RDEPENDS:perl-ExtUtils-MM-Utils = " \
 perl-libs \
 perl-vars \
"

URI_perl-ExtUtils-MakeMaker = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-ExtUtils-MakeMaker-7.70-513.el10.noarch.rpm;name=perl-ExtUtils-MakeMaker;unpack=0"
SRC_URI += "${URI_perl-ExtUtils-MakeMaker}"
SRC_URI[perl-ExtUtils-MakeMaker.sha256sum] = "a0f0d1a419fbc64ed59a119758a83bde1ba4a052b6bf5130d9cfc3bffb03d9e6"
RDEPENDS:perl-ExtUtils-MakeMaker = " \
 perl-libs \
 perl-Getopt-Long \
 perl-podlators \
 perl-Test-Harness \
 perl-Carp \
 perl-vars \
 perl-IO \
 perl-version \
 perl-Text-ParseWords \
 perl-Data-Dumper \
 perl-DynaLoader \
 perl-Encode \
 perl-Exporter \
 perl-ExtUtils-Command \
 perl-ExtUtils-Install \
 perl-ExtUtils-MakeMaker \
 perl-ExtUtils-Manifest \
 perl-ExtUtils-ParseXS \
 perl-POSIX \
 perl-File-Basename \
 perl-PathTools \
 perl-File-Find \
 perl-interpreter \
 perl-File-Path \
 perl-lib \
"

URI_perl-ExtUtils-MakeMaker-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-ExtUtils-MakeMaker-tests-7.70-513.el10.noarch.rpm;name=perl-ExtUtils-MakeMaker-tests;unpack=0"
SRC_URI += "${URI_perl-ExtUtils-MakeMaker-tests}"
SRC_URI[perl-ExtUtils-MakeMaker-tests.sha256sum] = "9c6aa77b9c316ec4af0af1b759ff40c2fdebd25490afd2926f5193f060e7973f"
RDEPENDS:perl-ExtUtils-MakeMaker-tests = " \
 perl-libs \
 perl-podlators \
 perl-subs \
 perl-CPAN-Meta \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Carp \
 perl-vars \
 perl-version \
 perl-lib \
 perl-Data-Dumper \
 perl-DynaLoader \
 perl-Encode \
 bash \
 perl-Exporter \
 perl-ExtUtils-CBuilder \
 perl-base \
 perl-ExtUtils-Command \
 perl-ExtUtils-MakeMaker \
 perl-ExtUtils-Manifest \
 perl-devel \
 perl-File-Basename \
 perl-PathTools \
 perl-File-Find \
 perl-interpreter \
 perl-File-Path \
 perl-less \
 perl-File-Temp \
"
