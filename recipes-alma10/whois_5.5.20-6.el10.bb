# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "whois"
PE = "0"
PV = "5.5.20"
PR = "6.el10"
PACKAGES = "mkpasswd whois whois-nls"
PROVIDES = "rpm/mkpasswd rpm/whois rpm/whois-nls"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/whois-5.5.20-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52fd336e97a0aa7dbb23abd66b8fe8cb38808eb87730a0b62c29b2a340cffd11"

URI_mkpasswd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mkpasswd-5.5.20-6.el10.x86_64_v2.rpm;name=mkpasswd;unpack=0"
SRC_URI += "${URI_mkpasswd}"
SRC_URI[mkpasswd.sha256sum] = "d17523950be26e0c26d95d474f718fcc6e16eac580ceca42a226f2de8a304807"
RDEPENDS:mkpasswd = " \
 glibc \
 libxcrypt \
 whois-nls \
"

URI_whois = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/whois-5.5.20-6.el10.x86_64_v2.rpm;name=whois;unpack=0"
SRC_URI += "${URI_whois}"
SRC_URI[whois.sha256sum] = "e26d7d9a48e81b9a8c8b6f3647a5e1b83cbc6463d1c06edfb184fb33c71f28d6"
RDEPENDS:whois = " \
 whois-nls \
 bash \
 glibc \
 alternatives \
 libidn2 \
"

URI_whois-nls = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/whois-nls-5.5.20-6.el10.noarch.rpm;name=whois-nls;unpack=0"
SRC_URI += "${URI_whois-nls}"
SRC_URI[whois-nls.sha256sum] = "78d4e48b1ede5644312b3ce8f940aa0e79e88f15d9e7058990e0244628e8d629"
RDEPENDS:whois-nls = ""
