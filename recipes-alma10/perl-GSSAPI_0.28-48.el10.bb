# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-GSSAPI"
PE = "0"
PV = "0.28"
PR = "48.el10"
PACKAGES = "perl-GSSAPI"
PROVIDES = "rpm/perl-GSSAPI"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-GSSAPI-0.28-48.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5bccfb428130aa21b653d1a8dcff406896782f5755666509a5c17dceaec7524e"

URI_perl-GSSAPI = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-GSSAPI-0.28-48.el10.x86_64_v2.rpm;name=perl-GSSAPI;unpack=0"
SRC_URI += "${URI_perl-GSSAPI}"
SRC_URI[perl-GSSAPI.sha256sum] = "67b7234ff841714a330854c4b64ee8a102d6950d177530382b51f23b75267c5a"
RDEPENDS:perl-GSSAPI = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 krb5-libs \
 perl-overload \
 glibc \
 perl-Exporter \
"
