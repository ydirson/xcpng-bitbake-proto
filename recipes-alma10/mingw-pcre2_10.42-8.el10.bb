# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mingw-pcre2"
PE = "0"
PV = "10.42"
PR = "8.el10"
PACKAGES = "mingw32-pcre2 mingw32-pcre2-static mingw64-pcre2 mingw64-pcre2-static"
PROVIDES = "rpm/mingw32-pcre2 rpm/mingw32-pcre2-static rpm/mingw64-pcre2 rpm/mingw64-pcre2-static"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/mingw-pcre2-10.42-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b88948fd91298fcf687f47bc3b02bb8addf8018f0e32602043bf6a29af2e4ecf"

URI_mingw32-pcre2 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw32-pcre2-10.42-8.el10.noarch.rpm;name=mingw32-pcre2;unpack=0"
SRC_URI += "${URI_mingw32-pcre2}"
SRC_URI[mingw32-pcre2.sha256sum] = "7caef9a8235081454db10c4049b6a21723a9900a8516b724ed9a21482ddfb5a6"
RDEPENDS:mingw32-pcre2 = " \
 bash \
 mingw32-crt \
 mingw32-filesystem \
"

URI_mingw32-pcre2-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw32-pcre2-static-10.42-8.el10.noarch.rpm;name=mingw32-pcre2-static;unpack=0"
SRC_URI += "${URI_mingw32-pcre2-static}"
SRC_URI[mingw32-pcre2-static.sha256sum] = "7e5591c74a10fbf9071fc81c55c16e461a551fb68e3b13a6dfcc662a1646e98d"
RDEPENDS:mingw32-pcre2-static = ""

URI_mingw64-pcre2 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw64-pcre2-10.42-8.el10.noarch.rpm;name=mingw64-pcre2;unpack=0"
SRC_URI += "${URI_mingw64-pcre2}"
SRC_URI[mingw64-pcre2.sha256sum] = "f762f0472919caf5555eaa308922886884f161318b88979f43994c382cf3c2cd"
RDEPENDS:mingw64-pcre2 = " \
 bash \
 mingw64-crt \
 mingw64-filesystem \
"

URI_mingw64-pcre2-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw64-pcre2-static-10.42-8.el10.noarch.rpm;name=mingw64-pcre2-static;unpack=0"
SRC_URI += "${URI_mingw64-pcre2-static}"
SRC_URI[mingw64-pcre2-static.sha256sum] = "8e92ce698e145cb61fdf1e52ad2abc0e72cf87816e6f0ce10f95cfad79cbabc8"
RDEPENDS:mingw64-pcre2-static = ""
