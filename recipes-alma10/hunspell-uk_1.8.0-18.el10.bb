# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-uk"
PE = "0"
PV = "1.8.0"
PR = "18.el10"
PACKAGES = "hunspell-uk"
PROVIDES = "rpm/hunspell-uk"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-uk-1.8.0-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "912ae594f9c538caec02e01241c429a7da9c0d9682d77f936169b8f9b3093c23"

URI_hunspell-uk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-uk-1.8.0-18.el10.noarch.rpm;name=hunspell-uk;unpack=0"
SRC_URI += "${URI_hunspell-uk}"
SRC_URI[hunspell-uk.sha256sum] = "c46893ad629f88d24b1abfa7669e92cce926048c0337fb46f52d05a6a1bc1cb8"
RDEPENDS:hunspell-uk = " \
 hunspell-filesystem \
"
