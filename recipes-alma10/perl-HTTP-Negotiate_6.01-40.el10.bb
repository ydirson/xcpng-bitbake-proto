# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-HTTP-Negotiate"
PE = "0"
PV = "6.01"
PR = "40.el10"
PACKAGES = "perl-HTTP-Negotiate perl-HTTP-Negotiate-tests"
PROVIDES = "rpm/perl-HTTP-Negotiate rpm/perl-HTTP-Negotiate-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-HTTP-Negotiate-6.01-40.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37413b7ef5dffb3f5947c1129a0de4229b30d9f0d570e3731c5929cf513e2e49"

URI_perl-HTTP-Negotiate = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-HTTP-Negotiate-6.01-40.el10.noarch.rpm;name=perl-HTTP-Negotiate;unpack=0"
SRC_URI += "${URI_perl-HTTP-Negotiate}"
SRC_URI[perl-HTTP-Negotiate.sha256sum] = "c5dcb5682b97dd66e5f10e842c0115f8d83de15dbf0e709f066a25d20d2a8800"
RDEPENDS:perl-HTTP-Negotiate = " \
 perl-HTTP-Message \
 perl-Exporter \
 perl-libs \
"

URI_perl-HTTP-Negotiate-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-HTTP-Negotiate-tests-6.01-40.el10.noarch.rpm;name=perl-HTTP-Negotiate-tests;unpack=0"
SRC_URI += "${URI_perl-HTTP-Negotiate-tests}"
SRC_URI[perl-HTTP-Negotiate-tests.sha256sum] = "c0f7ccb63e319cc97ebb0b335a5b8533372918fe69f856d51ade32349619b70a"
RDEPENDS:perl-HTTP-Negotiate-tests = " \
 perl-Test \
 perl-Test-Harness \
 bash \
 perl-HTTP-Message \
 perl-interpreter \
 perl-HTTP-Negotiate \
"
