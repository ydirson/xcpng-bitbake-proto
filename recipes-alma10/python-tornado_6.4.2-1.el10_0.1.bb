# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-tornado"
PE = "0"
PV = "6.4.2"
PR = "1.el10_0.1"
PACKAGES = "python3-tornado python-tornado-doc"
PROVIDES = "rpm/python3-tornado rpm/python-tornado-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-tornado-6.4.2-1.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "241c0155d3962c18cd526c44667ae2480ebd6b4ac778f0ba459b13258bbadfc2"

URI_python3-tornado = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-tornado-6.4.2-1.el10_0.1.x86_64_v2.rpm;name=python3-tornado;unpack=0"
SRC_URI += "${URI_python3-tornado}"
SRC_URI[python3-tornado.sha256sum] = "df0492da9b931d50eda26e2266c25f50429749da024ca95f39a14fb1160cb69d"
RDEPENDS:python3-tornado = " \
 glibc \
 python3 \
"

URI_python-tornado-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python-tornado-doc-6.4.2-1.el10_0.1.x86_64_v2.rpm;name=python-tornado-doc;unpack=0"
SRC_URI += "${URI_python-tornado-doc}"
SRC_URI[python-tornado-doc.sha256sum] = "735fe2be19feccc5c7271393aab9bf0fb4fc51395c02a7ceafee565f5ea7b0dd"
RDEPENDS:python-tornado-doc = ""
