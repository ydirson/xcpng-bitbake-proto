# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libxcrypt"
PE = "0"
PV = "4.4.36"
PR = "10.el10"
PACKAGES = "libxcrypt libxcrypt-compat libxcrypt-devel libxcrypt-static"
PROVIDES = "rpm/libxcrypt rpm/libxcrypt-compat rpm/libxcrypt-devel rpm/libxcrypt-static"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libxcrypt-4.4.36-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c8c23ad1cca6c5ae9eb3ef5d42b6cfa6c48d1b4e53f12c8f20afe2b7744ed9a"

URI_libxcrypt = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libxcrypt-4.4.36-10.el10.x86_64_v2.rpm;name=libxcrypt;unpack=0"
SRC_URI += "${URI_libxcrypt}"
SRC_URI[libxcrypt.sha256sum] = "c184529c73318313d486a814a98c7e909dbd03dcf08e536d90b57e25b4a18c2e"
RDEPENDS:libxcrypt = " \
 glibc \
"

URI_libxcrypt-compat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libxcrypt-compat-4.4.36-10.el10.x86_64_v2.rpm;name=libxcrypt-compat;unpack=0"
SRC_URI += "${URI_libxcrypt-compat}"
SRC_URI[libxcrypt-compat.sha256sum] = "7fecba48f517a5cfaee49f127e8ea150b63dd701f7844c193205fb98962eddee"
RDEPENDS:libxcrypt-compat = " \
 glibc \
 libxcrypt \
"

URI_libxcrypt-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libxcrypt-devel-4.4.36-10.el10.x86_64_v2.rpm;name=libxcrypt-devel;unpack=0"
SRC_URI += "${URI_libxcrypt-devel}"
SRC_URI[libxcrypt-devel.sha256sum] = "d117408e5feca7cd9a28353c5abb04d87b5f2f5ccbba6d8a8ca699de7cef5c1f"
RDEPENDS:libxcrypt-devel = " \
 libxcrypt \
 pkgconf-pkg-config \
 glibc-devel \
"

URI_libxcrypt-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libxcrypt-static-4.4.36-10.el10.x86_64_v2.rpm;name=libxcrypt-static;unpack=0"
SRC_URI += "${URI_libxcrypt-static}"
SRC_URI[libxcrypt-static.sha256sum] = "7f4979029741d05b6ca18d72a355c304503a8676275ee0c4fddf8b9ab0ce3435"
RDEPENDS:libxcrypt-static = " \
 libxcrypt-devel \
 glibc-static \
"
