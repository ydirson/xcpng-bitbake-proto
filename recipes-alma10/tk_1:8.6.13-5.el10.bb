# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tk"
PE = "1"
PV = "8.6.13"
PR = "5.el10"
PACKAGES = "tk tk-devel"
PROVIDES = "rpm/tk rpm/tk-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tk-8.6.13-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8ba27da47113cc5e1de846721d546bcb3bb653844517ba2595e2af522af3424"

URI_tk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tk-8.6.13-5.el10.x86_64_v2.rpm;name=tk;unpack=0"
SRC_URI += "${URI_tk}"
SRC_URI[tk.sha256sum] = "0bd0498a9737db8f440a9af5fbe837dd94f3226f70824c32c936e289121aba2d"
RDEPENDS:tk = " \
 libXft \
 tcl \
 fontconfig \
 libX11 \
 bash \
 glibc \
"

URI_tk-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tk-devel-8.6.13-5.el10.x86_64_v2.rpm;name=tk-devel;unpack=0"
SRC_URI += "${URI_tk-devel}"
SRC_URI[tk-devel.sha256sum] = "72b1232f5263df2979b33cd11c4eaea951fa470f60a1798bf96ec44054719b7c"
RDEPENDS:tk-devel = " \
 tcl-devel \
 libXft-devel \
 tk \
 pkgconf-pkg-config \
 libX11-devel \
"
