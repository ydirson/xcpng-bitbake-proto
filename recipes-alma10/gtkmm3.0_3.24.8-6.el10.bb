# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gtkmm3.0"
PE = "0"
PV = "3.24.8"
PR = "6.el10"
PACKAGES = "gtkmm3.0 gtkmm3.0-devel gtkmm3.0-doc"
PROVIDES = "rpm/gtkmm3.0 rpm/gtkmm3.0-devel rpm/gtkmm3.0-doc"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/gtkmm3.0-3.24.8-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f08d3baaaf48a86a3c8f73c9d30f478f053cf449bec41eda8d9835b682fac46e"

URI_gtkmm3.0 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gtkmm3.0-3.24.8-6.el10.x86_64_v2.rpm;name=gtkmm3.0;unpack=0"
SRC_URI += "${URI_gtkmm3.0}"
SRC_URI[gtkmm3.0.sha256sum] = "bedba77680b81e2ff59755b7a8816ad224729a26ddab5249597ba7666af7883c"
RDEPENDS:gtkmm3.0 = " \
 cairomm \
 atkmm \
 libgcc \
 pangomm \
 gdk-pixbuf2 \
 libsigc++20 \
 libstdc++ \
 glib2 \
 gtk3 \
 glibc \
 glibmm2.4 \
"

URI_gtkmm3.0-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gtkmm3.0-devel-3.24.8-6.el10.x86_64_v2.rpm;name=gtkmm3.0-devel;unpack=0"
SRC_URI += "${URI_gtkmm3.0-devel}"
SRC_URI[gtkmm3.0-devel.sha256sum] = "122319dca3218ebd46cd94a93d87ee79978425fc19df12f9a25af13e7b7b781d"
RDEPENDS:gtkmm3.0-devel = " \
 cairomm-devel \
 atkmm-devel \
 pkgconf-pkg-config \
 pangomm-devel \
 gtkmm3.0 \
 gtkmm3.0-devel \
 gdk-pixbuf2-devel \
 gtk3-devel \
 glibmm2.4-devel \
"

URI_gtkmm3.0-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gtkmm3.0-doc-3.24.8-6.el10.noarch.rpm;name=gtkmm3.0-doc;unpack=0"
SRC_URI += "${URI_gtkmm3.0-doc}"
SRC_URI[gtkmm3.0-doc.sha256sum] = "3826b655951a64490316188282144bb3c4d08ec64bdd6e8079a26c636b93451e"
RDEPENDS:gtkmm3.0-doc = " \
 gtkmm3.0 \
 glibmm2.4-doc \
"
