# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-hr"
PE = "1"
PV = "0.20040608"
PR = "34.el10"
PACKAGES = "hunspell-hr hyphen-hr"
PROVIDES = "rpm/hunspell-hr rpm/hyphen-hr"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-hr-0.20040608-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dbb2217e29277ba3d871744a4ead9cf1181154ebc056b976147561ff43547c99"

URI_hunspell-hr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-hr-0.20040608-34.el10.noarch.rpm;name=hunspell-hr;unpack=0"
SRC_URI += "${URI_hunspell-hr}"
SRC_URI[hunspell-hr.sha256sum] = "0063aae175201e1b831a9e93a555df44a787bd62cd6f18eb1e38c2cf2d84714c"
RDEPENDS:hunspell-hr = " \
 hunspell-filesystem \
"

URI_hyphen-hr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-hr-0.20040608-34.el10.noarch.rpm;name=hyphen-hr;unpack=0"
SRC_URI += "${URI_hyphen-hr}"
SRC_URI[hyphen-hr.sha256sum] = "33f20c44052846ed9edb324a3f32bd0560c6b5a73d2b1b913999ee2c843a31b1"
RDEPENDS:hyphen-hr = " \
 hyphen \
"
