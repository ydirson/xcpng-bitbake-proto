# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libblockdev"
PE = "0"
PV = "3.2.0"
PR = "4.el10_0"
PACKAGES = "libblockdev libblockdev-crypto libblockdev-dm libblockdev-fs libblockdev-loop libblockdev-lvm libblockdev-lvm-dbus libblockdev-mdraid libblockdev-mpath libblockdev-nvdimm libblockdev-nvme libblockdev-part libblockdev-plugins-all libblockdev-smart libblockdev-smartmontools libblockdev-swap libblockdev-tools libblockdev-utils python3-blockdev libblockdev-crypto-devel libblockdev-devel libblockdev-dm-devel libblockdev-fs-devel libblockdev-loop-devel libblockdev-lvm-dbus-devel libblockdev-lvm-devel libblockdev-mdraid-devel libblockdev-mpath-devel libblockdev-nvdimm-devel libblockdev-nvme-devel libblockdev-part-devel libblockdev-smart-devel libblockdev-smartmontools-devel libblockdev-swap-devel libblockdev-utils-devel"
PROVIDES = "rpm/libblockdev rpm/libblockdev-crypto rpm/libblockdev-dm rpm/libblockdev-fs rpm/libblockdev-loop rpm/libblockdev-lvm rpm/libblockdev-lvm-dbus rpm/libblockdev-mdraid rpm/libblockdev-mpath rpm/libblockdev-nvdimm rpm/libblockdev-nvme rpm/libblockdev-part rpm/libblockdev-plugins-all rpm/libblockdev-smart rpm/libblockdev-smartmontools rpm/libblockdev-swap rpm/libblockdev-tools rpm/libblockdev-utils rpm/python3-blockdev rpm/libblockdev-crypto-devel rpm/libblockdev-devel rpm/libblockdev-dm-devel rpm/libblockdev-fs-devel rpm/libblockdev-loop-devel rpm/libblockdev-lvm-dbus-devel rpm/libblockdev-lvm-devel rpm/libblockdev-mdraid-devel rpm/libblockdev-mpath-devel rpm/libblockdev-nvdimm-devel rpm/libblockdev-nvme-devel rpm/libblockdev-part-devel rpm/libblockdev-smart-devel rpm/libblockdev-smartmontools-devel rpm/libblockdev-swap-devel rpm/libblockdev-utils-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libblockdev-3.2.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe11b9378ff419e4d7de11641a8a825c795ae9093a775651661e1dba9f97a7cd"

URI_libblockdev = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libblockdev-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev;unpack=0"
SRC_URI += "${URI_libblockdev}"
SRC_URI[libblockdev.sha256sum] = "63fc5e5dd95ae1fd145a77a75110296cee1a6efd2fd619e616b42bc503823a2b"
RDEPENDS:libblockdev = " \
 systemd-libs \
 kmod-libs \
 glib2 \
 glibc \
 libblockdev-utils \
"

URI_libblockdev-crypto = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libblockdev-crypto-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-crypto;unpack=0"
SRC_URI += "${URI_libblockdev-crypto}"
SRC_URI[libblockdev-crypto.sha256sum] = "5ba5aab620d3c2a23349f36b07fe8f786fa12c8e03d98af3c64115c16ba240ca"
RDEPENDS:libblockdev-crypto = " \
 nss \
 systemd-libs \
 cryptsetup-libs \
 keyutils-libs \
 libgcc \
 kmod-libs \
 libblkid \
 libblockdev-utils \
 nss-util \
 glib2 \
 volume_key-libs \
 glibc \
 nspr \
"

URI_libblockdev-dm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libblockdev-dm-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-dm;unpack=0"
SRC_URI += "${URI_libblockdev-dm}"
SRC_URI[libblockdev-dm.sha256sum] = "9e07e0e7d85feaac9a463cbdeb9cfd1ca2de7abc2ef6803a272eba8457bba0cb"
RDEPENDS:libblockdev-dm = " \
 device-mapper \
 device-mapper-libs \
 systemd-libs \
 kmod-libs \
 glib2 \
 glibc \
 libblockdev-utils \
"

URI_libblockdev-fs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libblockdev-fs-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-fs;unpack=0"
SRC_URI += "${URI_libblockdev-fs}"
SRC_URI[libblockdev-fs.sha256sum] = "c4a05060d3ae71cdd443ce664042b73263d74b0a89fb6a0f426ec1167b8f97fd"
RDEPENDS:libblockdev-fs = " \
 libuuid \
 e2fsprogs-libs \
 systemd-libs \
 libgcc \
 kmod-libs \
 libblkid \
 libmount \
 glib2 \
 glibc \
 libblockdev-utils \
"

URI_libblockdev-loop = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libblockdev-loop-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-loop;unpack=0"
SRC_URI += "${URI_libblockdev-loop}"
SRC_URI[libblockdev-loop.sha256sum] = "188c4c4c0faa1c1152fdb426ecad3abfcbe1b95d63261ef635dd0637c680eec9"
RDEPENDS:libblockdev-loop = " \
 systemd-libs \
 libgcc \
 kmod-libs \
 glib2 \
 glibc \
 libblockdev-utils \
"

URI_libblockdev-lvm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libblockdev-lvm-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-lvm;unpack=0"
SRC_URI += "${URI_libblockdev-lvm}"
SRC_URI[libblockdev-lvm.sha256sum] = "56090f1c94ef0c91e80b00911c85fb3393f043c248f1e54d0d2445a290ebf761"
RDEPENDS:libblockdev-lvm = " \
 device-mapper-libs \
 systemd-libs \
 lvm2 \
 libgcc \
 kmod-libs \
 libyaml \
 glib2 \
 glibc \
 libblockdev-utils \
"

URI_libblockdev-lvm-dbus = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libblockdev-lvm-dbus-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-lvm-dbus;unpack=0"
SRC_URI += "${URI_libblockdev-lvm-dbus}"
SRC_URI[libblockdev-lvm-dbus.sha256sum] = "d1d7d3bef0a69123434a5d7f0a5818670c17aea8f4a34521164ab25cbb75fde4"
RDEPENDS:libblockdev-lvm-dbus = " \
 device-mapper-libs \
 systemd-libs \
 libgcc \
 kmod-libs \
 libyaml \
 glib2 \
 glibc \
 lvm2-dbusd \
 libblockdev-utils \
"

URI_libblockdev-mdraid = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libblockdev-mdraid-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-mdraid;unpack=0"
SRC_URI += "${URI_libblockdev-mdraid}"
SRC_URI[libblockdev-mdraid.sha256sum] = "0fc83662a9923500eb84b439062c5a8d665b0ca2da9387cba869f76808e96d63"
RDEPENDS:libblockdev-mdraid = " \
 libbytesize \
 systemd-libs \
 libgcc \
 kmod-libs \
 glib2 \
 mdadm \
 glibc \
 libblockdev-utils \
"

URI_libblockdev-mpath = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libblockdev-mpath-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-mpath;unpack=0"
SRC_URI += "${URI_libblockdev-mpath}"
SRC_URI[libblockdev-mpath.sha256sum] = "350e00bd922104eb55a53a9ffe317c031520a89b7101260c045c40c6191ac520"
RDEPENDS:libblockdev-mpath = " \
 device-mapper-libs \
 systemd-libs \
 kmod-libs \
 glib2 \
 glibc \
 libblockdev-utils \
"

URI_libblockdev-nvdimm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libblockdev-nvdimm-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-nvdimm;unpack=0"
SRC_URI += "${URI_libblockdev-nvdimm}"
SRC_URI[libblockdev-nvdimm.sha256sum] = "3cb207e279103d38c5c6009d8fdc2dac8de79ece24a0abc10b411998e63b33ed"
RDEPENDS:libblockdev-nvdimm = " \
 libuuid \
 systemd-libs \
 kmod-libs \
 glib2 \
 ndctl \
 ndctl-libs \
 glibc \
 libblockdev-utils \
"

URI_libblockdev-nvme = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libblockdev-nvme-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-nvme;unpack=0"
SRC_URI += "${URI_libblockdev-nvme}"
SRC_URI[libblockdev-nvme.sha256sum] = "e0da6f0ea35d39e7c769b4c7c11bd440b20372a327e71dcaa36746952265bd6a"
RDEPENDS:libblockdev-nvme = " \
 systemd-libs \
 kmod-libs \
 glib2 \
 glibc \
 libnvme \
 libblockdev-utils \
"

URI_libblockdev-part = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libblockdev-part-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-part;unpack=0"
SRC_URI += "${URI_libblockdev-part}"
SRC_URI[libblockdev-part.sha256sum] = "4c6cc9c11dfc933e50856f26dcca6080a5fe03ecae5d9fcdf8962a8298806f9f"
RDEPENDS:libblockdev-part = " \
 systemd-libs \
 libfdisk \
 util-linux \
 kmod-libs \
 glib2 \
 glibc \
 libblockdev-utils \
"

URI_libblockdev-plugins-all = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libblockdev-plugins-all-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-plugins-all;unpack=0"
SRC_URI += "${URI_libblockdev-plugins-all}"
SRC_URI[libblockdev-plugins-all.sha256sum] = "6f46596471e19e6e1f64ca3726b5bda8e9e7f9dd047b617668a192f0bdab88c0"
RDEPENDS:libblockdev-plugins-all = " \
 libblockdev-mdraid \
 libblockdev-mpath \
 libblockdev-nvdimm \
 libblockdev-nvme \
 libblockdev \
 libblockdev-part \
 libblockdev-crypto \
 libblockdev-dm \
 libblockdev-smart \
 libblockdev-fs \
 libblockdev-smartmontools \
 libblockdev-loop \
 libblockdev-swap \
 libblockdev-lvm \
"

URI_libblockdev-smart = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libblockdev-smart-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-smart;unpack=0"
SRC_URI += "${URI_libblockdev-smart}"
SRC_URI[libblockdev-smart.sha256sum] = "4df1a233e73cb54ea3c4e97d06e9dc289576320e878c9af826d38d54402d988e"
RDEPENDS:libblockdev-smart = " \
 systemd-libs \
 libatasmart \
 kmod-libs \
 glib2 \
 glibc \
 libblockdev-utils \
"

URI_libblockdev-smartmontools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libblockdev-smartmontools-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-smartmontools;unpack=0"
SRC_URI += "${URI_libblockdev-smartmontools}"
SRC_URI[libblockdev-smartmontools.sha256sum] = "92e736813495be9102ee8d3f50f3022cbac38d7ba87fe78684e9781f252fbac6"
RDEPENDS:libblockdev-smartmontools = " \
 systemd-libs \
 smartmontools \
 kmod-libs \
 json-glib \
 glib2 \
 glibc \
 libblockdev-utils \
"

URI_libblockdev-swap = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libblockdev-swap-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-swap;unpack=0"
SRC_URI += "${URI_libblockdev-swap}"
SRC_URI[libblockdev-swap.sha256sum] = "caa0efd6e822c6fdc84a30a55d108216deb1c4fe2af40d278a42a146e547847d"
RDEPENDS:libblockdev-swap = " \
 libuuid \
 systemd-libs \
 util-linux \
 libgcc \
 kmod-libs \
 libblkid \
 glib2 \
 glibc \
 libblockdev-utils \
"

URI_libblockdev-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libblockdev-tools-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-tools;unpack=0"
SRC_URI += "${URI_libblockdev-tools}"
SRC_URI[libblockdev-tools.sha256sum] = "b6548a361d7251dd79d679950f62ee3d17ba60ecede4c41e02a350724fae9c09"
RDEPENDS:libblockdev-tools = " \
 libbytesize \
 libblockdev \
 parted \
 glib2 \
 glibc \
 libblockdev-lvm \
"

URI_libblockdev-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libblockdev-utils-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-utils;unpack=0"
SRC_URI += "${URI_libblockdev-utils}"
SRC_URI[libblockdev-utils.sha256sum] = "eb052609b3b0c4f5b229846643001629f6680d5d6d7994a1cf7748f983b34c79"
RDEPENDS:libblockdev-utils = " \
 glibc \
 kmod-libs \
 glib2 \
 systemd-libs \
"

URI_python3-blockdev = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-blockdev-3.2.0-4.el10_0.x86_64_v2.rpm;name=python3-blockdev;unpack=0"
SRC_URI += "${URI_python3-blockdev}"
SRC_URI[python3-blockdev.sha256sum] = "97d6b4892fab7fb46a7093780c8c53a99f657f879b0a188659e6bae899a49739"
RDEPENDS:python3-blockdev = " \
 python3 \
 python3-bytesize \
 libblockdev \
 python3-gobject-base \
"

URI_libblockdev-crypto-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libblockdev-crypto-devel-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-crypto-devel;unpack=0"
SRC_URI += "${URI_libblockdev-crypto-devel}"
SRC_URI[libblockdev-crypto-devel.sha256sum] = "f47632aa97a724dc5422a55e3a4f7fec93baab228ff1d10551da74a0c8dc2c7e"
RDEPENDS:libblockdev-crypto-devel = " \
 glib2-devel \
 libblockdev-utils-devel \
 libblockdev-crypto \
"

URI_libblockdev-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libblockdev-devel-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-devel;unpack=0"
SRC_URI += "${URI_libblockdev-devel}"
SRC_URI[libblockdev-devel.sha256sum] = "99c7645ab577d9e555f1b19d28f4fb9d76071ba79c820780958ae6a9b0f50aea"
RDEPENDS:libblockdev-devel = " \
 libblockdev-utils-devel \
 glib2-devel \
 libblockdev \
 pkgconf-pkg-config \
"

URI_libblockdev-dm-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libblockdev-dm-devel-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-dm-devel;unpack=0"
SRC_URI += "${URI_libblockdev-dm-devel}"
SRC_URI[libblockdev-dm-devel.sha256sum] = "17cedf34dbf9cc226f7065a48308e688eb71e419679b10d7ed6070307e644fd1"
RDEPENDS:libblockdev-dm-devel = " \
 glib2-devel \
 systemd-devel \
 libblockdev-dm \
 libblockdev-utils-devel \
 device-mapper-devel \
"

URI_libblockdev-fs-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libblockdev-fs-devel-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-fs-devel;unpack=0"
SRC_URI += "${URI_libblockdev-fs-devel}"
SRC_URI[libblockdev-fs-devel.sha256sum] = "c764d5b6d61a359e141cd951e6d513c22fa3744a991498b07a5d11a63ec4d252"
RDEPENDS:libblockdev-fs-devel = " \
 glib2-devel \
 libblockdev-utils-devel \
 libblockdev-fs \
"

URI_libblockdev-loop-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libblockdev-loop-devel-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-loop-devel;unpack=0"
SRC_URI += "${URI_libblockdev-loop-devel}"
SRC_URI[libblockdev-loop-devel.sha256sum] = "fba443a5109811fa4e79eddab8f38ee461c9214db7431284ff46d215dd3cb8c3"
RDEPENDS:libblockdev-loop-devel = " \
 libblockdev-loop \
 glib2-devel \
 libblockdev-utils-devel \
"

URI_libblockdev-lvm-dbus-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libblockdev-lvm-dbus-devel-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-lvm-dbus-devel;unpack=0"
SRC_URI += "${URI_libblockdev-lvm-dbus-devel}"
SRC_URI[libblockdev-lvm-dbus-devel.sha256sum] = "e1db16296e981f1b0327352215afa964a56fc9081757f49db3b9b19df6786178"
RDEPENDS:libblockdev-lvm-dbus-devel = " \
 glib2-devel \
 libblockdev-utils-devel \
 libblockdev-lvm-dbus \
"

URI_libblockdev-lvm-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libblockdev-lvm-devel-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-lvm-devel;unpack=0"
SRC_URI += "${URI_libblockdev-lvm-devel}"
SRC_URI[libblockdev-lvm-devel.sha256sum] = "07948d3d9b683c9a9491d632c3de22835a00e6cb110aae268d93c10f971e8b8e"
RDEPENDS:libblockdev-lvm-devel = " \
 glib2-devel \
 libblockdev-utils-devel \
 libblockdev-lvm \
"

URI_libblockdev-mdraid-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libblockdev-mdraid-devel-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-mdraid-devel;unpack=0"
SRC_URI += "${URI_libblockdev-mdraid-devel}"
SRC_URI[libblockdev-mdraid-devel.sha256sum] = "783beeda5814eda63698dd55c3e825e2e84331c4ed3fef6eb770f32c0a1f7a8d"
RDEPENDS:libblockdev-mdraid-devel = " \
 libblockdev-mdraid \
 glib2-devel \
 libblockdev-utils-devel \
"

URI_libblockdev-mpath-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libblockdev-mpath-devel-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-mpath-devel;unpack=0"
SRC_URI += "${URI_libblockdev-mpath-devel}"
SRC_URI[libblockdev-mpath-devel.sha256sum] = "28200b7b87f15a1dcff64ae85cf94663eaa23f286be4a2581557ea61aa90efe6"
RDEPENDS:libblockdev-mpath-devel = " \
 libblockdev-utils-devel \
 glib2-devel \
 libblockdev-mpath \
"

URI_libblockdev-nvdimm-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libblockdev-nvdimm-devel-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-nvdimm-devel;unpack=0"
SRC_URI += "${URI_libblockdev-nvdimm-devel}"
SRC_URI[libblockdev-nvdimm-devel.sha256sum] = "0291c35bc05f554199e16aa00e0c03c6471fb8066337c436f79052d0ce95a01f"
RDEPENDS:libblockdev-nvdimm-devel = " \
 glib2-devel \
 libblockdev-utils-devel \
 libblockdev-nvdimm \
"

URI_libblockdev-nvme-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libblockdev-nvme-devel-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-nvme-devel;unpack=0"
SRC_URI += "${URI_libblockdev-nvme-devel}"
SRC_URI[libblockdev-nvme-devel.sha256sum] = "09eb192979ded98a4b09ff21b36aeffb7ea0f42c2948a6d445494d7d5664c415"
RDEPENDS:libblockdev-nvme-devel = " \
 libblockdev-nvme \
 glib2-devel \
 libblockdev-utils-devel \
"

URI_libblockdev-part-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libblockdev-part-devel-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-part-devel;unpack=0"
SRC_URI += "${URI_libblockdev-part-devel}"
SRC_URI[libblockdev-part-devel.sha256sum] = "36d55c5deb78ad0b75df792aa6150e104eb14c8594dc1ba083a0256352a35b29"
RDEPENDS:libblockdev-part-devel = " \
 glib2-devel \
 libblockdev-utils-devel \
 libblockdev-part \
"

URI_libblockdev-smart-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libblockdev-smart-devel-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-smart-devel;unpack=0"
SRC_URI += "${URI_libblockdev-smart-devel}"
SRC_URI[libblockdev-smart-devel.sha256sum] = "50c39209b8b9ef4fdf1969e615ea7c3e3af4eea2b3c10844a4d512a5567b30c8"
RDEPENDS:libblockdev-smart-devel = " \
 glib2-devel \
 libblockdev-utils-devel \
 libblockdev-smart \
"

URI_libblockdev-smartmontools-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libblockdev-smartmontools-devel-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-smartmontools-devel;unpack=0"
SRC_URI += "${URI_libblockdev-smartmontools-devel}"
SRC_URI[libblockdev-smartmontools-devel.sha256sum] = "7fae4b980fedcd5d4c44d72dc1e4f7c0492cf057d5fe2abcdc594a88773a90d6"
RDEPENDS:libblockdev-smartmontools-devel = " \
 glib2-devel \
 libblockdev-utils-devel \
 libblockdev-smartmontools \
"

URI_libblockdev-swap-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libblockdev-swap-devel-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-swap-devel;unpack=0"
SRC_URI += "${URI_libblockdev-swap-devel}"
SRC_URI[libblockdev-swap-devel.sha256sum] = "f524d5af6797696888106c9fb9196a1d1880049c5015ba3b477f28a8ec2da3ac"
RDEPENDS:libblockdev-swap-devel = " \
 libblockdev-swap \
 glib2-devel \
 libblockdev-utils-devel \
"

URI_libblockdev-utils-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libblockdev-utils-devel-3.2.0-4.el10_0.x86_64_v2.rpm;name=libblockdev-utils-devel;unpack=0"
SRC_URI += "${URI_libblockdev-utils-devel}"
SRC_URI[libblockdev-utils-devel.sha256sum] = "2bf906de973740ca5e8834a6cc0b53941b69a53bf77a2db2a86cc1c487afc50a"
RDEPENDS:libblockdev-utils-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 libblockdev-utils \
"
