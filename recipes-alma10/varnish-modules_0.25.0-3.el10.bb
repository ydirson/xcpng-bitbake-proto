# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "varnish-modules"
PE = "0"
PV = "0.25.0"
PR = "3.el10"
PACKAGES = "varnish-modules"
PROVIDES = "rpm/varnish-modules"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/varnish-modules-0.25.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c38f503f421284b3bbb3839f44427a4e236534213890f54145f509dd32c20b70"

URI_varnish-modules = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/varnish-modules-0.25.0-3.el10.x86_64_v2.rpm;name=varnish-modules;unpack=0"
SRC_URI += "${URI_varnish-modules}"
SRC_URI[varnish-modules.sha256sum] = "427ac239e01292a703c782da3ae20e817e6ba3df664f02db85c1f9646ce85714"
RDEPENDS:varnish-modules = " \
 glibc \
 varnish \
"
