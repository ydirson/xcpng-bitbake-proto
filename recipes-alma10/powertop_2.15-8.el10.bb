# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "powertop"
PE = "0"
PV = "2.15"
PR = "8.el10"
PACKAGES = "powertop"
PROVIDES = "rpm/powertop"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/powertop-2.15-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2f7dd02ce2c54c655337fee03d1361b0348d7f1bfe39ef2f025b7903deb2695"

URI_powertop = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/powertop-2.15-8.el10.x86_64_v2.rpm;name=powertop;unpack=0"
SRC_URI += "${URI_powertop}"
SRC_URI[powertop.sha256sum] = "172d43c5169f8845b04f434e216567363e7e6837167396552d398e0875210785"
RDEPENDS:powertop = " \
 systemd \
 libgcc \
 libnl3 \
 libstdc++ \
 bash \
 ncurses-libs \
 pciutils-libs \
 glibc \
 coreutils \
"
