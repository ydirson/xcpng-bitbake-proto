# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-color-manager"
PE = "0"
PV = "3.36.0"
PR = "14.el10"
PACKAGES = "gnome-color-manager"
PROVIDES = "rpm/gnome-color-manager"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-color-manager-3.36.0-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b902e518751ff8ceca58de9a9e1eda7c41153d22a5397f016763522111786be3"

URI_gnome-color-manager = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-color-manager-3.36.0-14.el10.x86_64_v2.rpm;name=gnome-color-manager;unpack=0"
SRC_URI += "${URI_gnome-color-manager}"
SRC_URI[gnome-color-manager.sha256sum] = "a20004ae6fbcdd5e23903df83f349d480c1d17d506054c011af751102d1bd27b"
RDEPENDS:gnome-color-manager = " \
 lcms2 \
 shared-mime-info \
 libgcc \
 pango \
 gdk-pixbuf2 \
 cairo \
 glib2 \
 gtk3 \
 glibc \
 colord-libs \
"
