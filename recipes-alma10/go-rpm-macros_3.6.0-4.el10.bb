# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "go-rpm-macros"
PE = "0"
PV = "3.6.0"
PR = "4.el10"
PACKAGES = "go-filesystem go-rpm-macros go-rpm-templates go-srpm-macros"
PROVIDES = "rpm/go-filesystem rpm/go-rpm-macros rpm/go-rpm-templates rpm/go-srpm-macros"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/go-rpm-macros-3.6.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e93d3fca155655211429067b7dd89330b0d36b74e9253480b64b27a8c3ad570"

URI_go-filesystem = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/go-filesystem-3.6.0-4.el10.x86_64_v2.rpm;name=go-filesystem;unpack=0"
SRC_URI += "${URI_go-filesystem}"
SRC_URI[go-filesystem.sha256sum] = "292e289d78da956455924a08356536ab4a8739d3e58d07ba4d0730b56a817396"
RDEPENDS:go-filesystem = ""

URI_go-rpm-macros = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/go-rpm-macros-3.6.0-4.el10.x86_64_v2.rpm;name=go-rpm-macros;unpack=0"
SRC_URI += "${URI_go-rpm-macros}"
SRC_URI[go-rpm-macros.sha256sum] = "b103886a097f5604b5dd6035db128357e7df33c4ecd4a10ab4952b278c90dbb7"
RDEPENDS:go-rpm-macros = " \
 python3 \
 go-filesystem \
 go-srpm-macros \
 bash \
 glibc \
 golang \
"

URI_go-rpm-templates = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/go-rpm-templates-3.6.0-4.el10.x86_64_v2.rpm;name=go-rpm-templates;unpack=0"
SRC_URI += "${URI_go-rpm-templates}"
SRC_URI[go-rpm-templates.sha256sum] = "33708e2f0a99427c897f194a34f7bd0fb7125889c63d77a3a7a26f900a85fd10"
RDEPENDS:go-rpm-templates = " \
 go-rpm-macros \
"

URI_go-srpm-macros = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/go-srpm-macros-3.6.0-4.el10.noarch.rpm;name=go-srpm-macros;unpack=0"
SRC_URI += "${URI_go-srpm-macros}"
SRC_URI[go-srpm-macros.sha256sum] = "a94e5e5cdd5040cac24a47c98d09df36a1f20b0053dca855fc7a0f5b8cb60276"
RDEPENDS:go-srpm-macros = " \
 redhat-rpm-config \
"
