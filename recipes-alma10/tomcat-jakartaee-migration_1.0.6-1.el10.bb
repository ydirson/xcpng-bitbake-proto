# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tomcat-jakartaee-migration"
PE = "0"
PV = "1.0.6"
PR = "1.el10"
PACKAGES = "tomcat-jakartaee-migration tomcat-jakartaee-migration-javadoc"
PROVIDES = "rpm/tomcat-jakartaee-migration rpm/tomcat-jakartaee-migration-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tomcat-jakartaee-migration-1.0.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e68ef1dfc1bcc043cd2b3c7205fc716b43ce41eaa21ed4c7b8c0316082ab602"

URI_tomcat-jakartaee-migration = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tomcat-jakartaee-migration-1.0.6-1.el10.noarch.rpm;name=tomcat-jakartaee-migration;unpack=0"
SRC_URI += "${URI_tomcat-jakartaee-migration}"
SRC_URI[tomcat-jakartaee-migration.sha256sum] = "29856fe914bc0de870f761ac4fe0c8aa4b95e15a9c04428a2121d5d054e1bc53"
RDEPENDS:tomcat-jakartaee-migration = " \
 apache-commons-compress \
 apache-commons-io \
 javapackages-filesystem \
 bash \
 bcel \
"

URI_tomcat-jakartaee-migration-javadoc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/tomcat-jakartaee-migration-javadoc-1.0.6-1.el10.noarch.rpm;name=tomcat-jakartaee-migration-javadoc;unpack=0"
SRC_URI += "${URI_tomcat-jakartaee-migration-javadoc}"
SRC_URI[tomcat-jakartaee-migration-javadoc.sha256sum] = "150ce0a6767924d197554a75daff260f1a359768d0b6433c1dab7180c4447651"
RDEPENDS:tomcat-jakartaee-migration-javadoc = " \
 javapackages-filesystem \
"
