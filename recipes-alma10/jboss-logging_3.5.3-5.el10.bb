# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jboss-logging"
PE = "0"
PV = "3.5.3"
PR = "5.el10"
PACKAGES = "jboss-logging"
PROVIDES = "rpm/jboss-logging"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/jboss-logging-3.5.3-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01454f8b53484320738bece01f775f176445ac044a3284a0410b223a21d7f047"

URI_jboss-logging = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/jboss-logging-3.5.3-5.el10.noarch.rpm;name=jboss-logging;unpack=0"
SRC_URI += "${URI_jboss-logging}"
SRC_URI[jboss-logging.sha256sum] = "41f78c7079b6f4d7a86925dc4749d91a2cee942afcf3918283d8c3a79d083386"
RDEPENDS:jboss-logging = " \
 javapackages-filesystem \
 java-21-openjdk-headless \
"
