# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "patchutils"
PE = "0"
PV = "0.4.2"
PR = "15.el10"
PACKAGES = "patchutils"
PROVIDES = "rpm/patchutils"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/patchutils-0.4.2-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c8f5fbe7f7a1268886285cabc033f9e62a1dca77ce5c5f484f2e8e13262950d"

URI_patchutils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/patchutils-0.4.2-15.el10.x86_64_v2.rpm;name=patchutils;unpack=0"
SRC_URI += "${URI_patchutils}"
SRC_URI[patchutils.sha256sum] = "84ffe0bab083bbfcd17ba7bdd76c46397e8df0170ed0597bfec9cc9c83ece60a"
RDEPENDS:patchutils = " \
 python3 \
 patch \
 perl-Getopt-Std \
 bash \
 glibc \
 perl-interpreter \
"
