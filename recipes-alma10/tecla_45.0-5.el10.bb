# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tecla"
PE = "0"
PV = "45.0"
PR = "5.el10"
PACKAGES = "tecla tecla-devel"
PROVIDES = "rpm/tecla rpm/tecla-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tecla-45.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80e15279938f0b3f8e7762e2d8b57da716737e70166674388594d1234e16c354"

URI_tecla = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tecla-45.0-5.el10.x86_64_v2.rpm;name=tecla;unpack=0"
SRC_URI += "${URI_tecla}"
SRC_URI[tecla.sha256sum] = "657569828ba22fc78471bb2e66e3dd5aeb92559fca9d3db3c4744057370bcf91"
RDEPENDS:tecla = " \
 libwayland-client \
 libgcc \
 pango \
 glib2 \
 glibc \
 libxkbcommon \
 gtk4 \
 libadwaita \
"

URI_tecla-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/tecla-devel-45.0-5.el10.x86_64_v2.rpm;name=tecla-devel;unpack=0"
SRC_URI += "${URI_tecla-devel}"
SRC_URI[tecla-devel.sha256sum] = "15e89b8cf4fd1f87b9c3ad19eb1f2c98883ac0b6b630fb0557dd3d430ee7bf04"
RDEPENDS:tecla-devel = " \
 pkgconf-pkg-config \
 tecla \
"
