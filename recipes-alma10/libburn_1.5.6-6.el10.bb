# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libburn"
PE = "0"
PV = "1.5.6"
PR = "6.el10"
PACKAGES = "cdrskin libburn libburn-doc libburn-devel"
PROVIDES = "rpm/cdrskin rpm/libburn rpm/libburn-doc rpm/libburn-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libburn-1.5.6-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b37c285e685c1f386d88179ec3e089bbe9a88f9b1921f423502c08847955da2"

URI_cdrskin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cdrskin-1.5.6-6.el10.x86_64_v2.rpm;name=cdrskin;unpack=0"
SRC_URI += "${URI_cdrskin}"
SRC_URI[cdrskin.sha256sum] = "be61ba7291778159c80d90e7e8633d7ebf03a560fd8fe6ffeb23f59f881e8549"
RDEPENDS:cdrskin = " \
 libburn \
 bash \
 glibc \
 coreutils \
 alternatives \
"

URI_libburn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libburn-1.5.6-6.el10.x86_64_v2.rpm;name=libburn;unpack=0"
SRC_URI += "${URI_libburn}"
SRC_URI[libburn.sha256sum] = "32b4cd57ceab528af601635aa15f84c05f5dbfd8701a1506415acdb229cdc5f5"
RDEPENDS:libburn = " \
 glibc \
"

URI_libburn-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libburn-doc-1.5.6-6.el10.noarch.rpm;name=libburn-doc;unpack=0"
SRC_URI += "${URI_libburn-doc}"
SRC_URI[libburn-doc.sha256sum] = "cc266ea41520cee22114788f65c983bb19d3e3f48680388262de7a915ece8a3b"
RDEPENDS:libburn-doc = ""

URI_libburn-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libburn-devel-1.5.6-6.el10.x86_64_v2.rpm;name=libburn-devel;unpack=0"
SRC_URI += "${URI_libburn-devel}"
SRC_URI[libburn-devel.sha256sum] = "bd3098a63bb600e397523046f7bbd1fb55ff2012e48dc68a9a09e792064d2175"
RDEPENDS:libburn-devel = " \
 libburn \
 pkgconf-pkg-config \
"
