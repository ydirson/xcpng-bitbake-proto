# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "vsftpd"
PE = "0"
PV = "3.0.5"
PR = "9.el10"
PACKAGES = "vsftpd"
PROVIDES = "rpm/vsftpd"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/vsftpd-3.0.5-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4fb01ba935ed1fd3c039f4bbea6d2d7e03f751e1bf2faf510337043ebaf8b2c"

URI_vsftpd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/vsftpd-3.0.5-9.el10.x86_64_v2.rpm;name=vsftpd;unpack=0"
SRC_URI += "${URI_vsftpd}"
SRC_URI[vsftpd.sha256sum] = "77ed2e7c9d657e1ae23fb090badfeb0e78db32a5e67eda992dedb8542a94147e"
RDEPENDS:vsftpd = " \
 logrotate \
 openssl-libs \
 libcap \
 pam-libs \
 bash \
 glibc \
"
