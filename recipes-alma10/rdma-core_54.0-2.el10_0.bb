# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rdma-core"
PE = "0"
PV = "54.0"
PR = "2.el10_0"
PACKAGES = "ibacm iwpmd libibumad libibverbs libibverbs-utils librdmacm librdmacm-utils rdma-core srp_daemon infiniband-diags python3-pyverbs rdma-core-devel infiniband-diags-compat"
PROVIDES = "rpm/ibacm rpm/iwpmd rpm/libibumad rpm/libibverbs rpm/libibverbs-utils rpm/librdmacm rpm/librdmacm-utils rpm/rdma-core rpm/srp_daemon rpm/infiniband-diags rpm/python3-pyverbs rpm/rdma-core-devel rpm/infiniband-diags-compat"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/rdma-core-54.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "114bfac27f103728de906e39331eff517713251065cac672ca653bd712527d72"

URI_ibacm = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/ibacm-54.0-2.el10_0.x86_64_v2.rpm;name=ibacm;unpack=0"
SRC_URI += "${URI_ibacm}"
SRC_URI[ibacm.sha256sum] = "7a793e3321ae17db984440f4c6df8d010818e9f92e6f75b42f30de7ad5fba0e5"
RDEPENDS:ibacm = " \
 systemd \
 systemd-libs \
 libnl3 \
 libibumad \
 bash \
 libibverbs \
 glibc \
"

URI_iwpmd = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/iwpmd-54.0-2.el10_0.x86_64_v2.rpm;name=iwpmd;unpack=0"
SRC_URI += "${URI_iwpmd}"
SRC_URI[iwpmd.sha256sum] = "0554526db8d1f2641260bbbcf303bc9835b3b00c6384f4040ce7a44ad4ee887d"
RDEPENDS:iwpmd = " \
 systemd \
 systemd-libs \
 libnl3 \
 bash \
 glibc \
"

URI_libibumad = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libibumad-54.0-2.el10_0.x86_64_v2.rpm;name=libibumad;unpack=0"
SRC_URI += "${URI_libibumad}"
SRC_URI[libibumad.sha256sum] = "262b548d7ab7da944d428743fd95a444bed173a345c9d185348e5a208ee91080"
RDEPENDS:libibumad = " \
 glibc \
"

URI_libibverbs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libibverbs-54.0-2.el10_0.x86_64_v2.rpm;name=libibverbs;unpack=0"
SRC_URI += "${URI_libibverbs}"
SRC_URI[libibverbs.sha256sum] = "737eda6b1eac51eb915fe3bd8bcbb17e20b45821e0801eadcdba59cab571f5f2"
RDEPENDS:libibverbs = " \
 glibc \
 libnl3 \
"

URI_libibverbs-utils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libibverbs-utils-54.0-2.el10_0.x86_64_v2.rpm;name=libibverbs-utils;unpack=0"
SRC_URI += "${URI_libibverbs-utils}"
SRC_URI[libibverbs-utils.sha256sum] = "ebf39599116d27beff62fc6541c0f219490f6ee2c492dc4a72f1fa777f6636c5"
RDEPENDS:libibverbs-utils = " \
 glibc \
 libibverbs \
"

URI_librdmacm = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/librdmacm-54.0-2.el10_0.x86_64_v2.rpm;name=librdmacm;unpack=0"
SRC_URI += "${URI_librdmacm}"
SRC_URI[librdmacm.sha256sum] = "1b8a7d37c97eee33c78f93369958a43ef95b529a16df1983dee25d01ce9d936e"
RDEPENDS:librdmacm = " \
 glibc \
 libnl3 \
 libibverbs \
"

URI_librdmacm-utils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/librdmacm-utils-54.0-2.el10_0.x86_64_v2.rpm;name=librdmacm-utils;unpack=0"
SRC_URI += "${URI_librdmacm-utils}"
SRC_URI[librdmacm-utils.sha256sum] = "cf03f9fe81ba7e5f3496e1dca8bc9eac5060c63cf0dfad7cbdeeac722446dd73"
RDEPENDS:librdmacm-utils = " \
 glibc \
 libibverbs \
 librdmacm \
"

URI_rdma-core = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/rdma-core-54.0-2.el10_0.x86_64_v2.rpm;name=rdma-core;unpack=0"
SRC_URI += "${URI_rdma-core}"
SRC_URI[rdma-core.sha256sum] = "3bfc64a9709754cb5ee67ff0b135161dc843fffcb32df38a08fd17976bb9416c"
RDEPENDS:rdma-core = " \
 systemd-libs \
 libnl3 \
 pciutils \
 bash \
 glibc \
"

URI_srp_daemon = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/srp_daemon-54.0-2.el10_0.x86_64_v2.rpm;name=srp_daemon;unpack=0"
SRC_URI += "${URI_srp_daemon}"
SRC_URI[srp_daemon.sha256sum] = "ea92c92a937505ec905175b612f1c29ac2c0607af9c6ba3c1c72ffdfb22c0542"
RDEPENDS:srp_daemon = " \
 systemd \
 libibumad \
 bash \
 libibverbs \
 glibc \
"

URI_infiniband-diags = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/infiniband-diags-54.0-2.el10_0.x86_64_v2.rpm;name=infiniband-diags;unpack=0"
SRC_URI += "${URI_infiniband-diags}"
SRC_URI[infiniband-diags.sha256sum] = "5385b48aff3f536e4b28253697f4df9e3a88d2ca6cb7314cbef444483ce235fa"
RDEPENDS:infiniband-diags = " \
 perl-libs \
 perl-Getopt-Std \
 libibumad \
 bash \
 glibc \
 perl-interpreter \
"

URI_python3-pyverbs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-pyverbs-54.0-2.el10_0.x86_64_v2.rpm;name=python3-pyverbs;unpack=0"
SRC_URI += "${URI_python3-pyverbs}"
SRC_URI[python3-pyverbs.sha256sum] = "411b87111b32945310206a21fca0d49b3aa320d23c62a3600548ff5ee6bf8763"
RDEPENDS:python3-pyverbs = " \
 python3 \
 python3-libs \
 librdmacm \
 libibverbs \
 glibc \
"

URI_rdma-core-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rdma-core-devel-54.0-2.el10_0.x86_64_v2.rpm;name=rdma-core-devel;unpack=0"
SRC_URI += "${URI_rdma-core-devel}"
SRC_URI[rdma-core-devel.sha256sum] = "cb5cec5b26015fe32fb9748863686d8591df67c1e7f810b53fac0dfa0f47338c"
RDEPENDS:rdma-core-devel = " \
 infiniband-diags \
 pkgconf-pkg-config \
 librdmacm \
 libibumad \
 libibverbs \
 rdma-core-devel \
"

URI_infiniband-diags-compat = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/infiniband-diags-compat-54.0-2.el10_0.x86_64_v2.rpm;name=infiniband-diags-compat;unpack=0"
SRC_URI += "${URI_infiniband-diags-compat}"
SRC_URI[infiniband-diags-compat.sha256sum] = "29295a1fba338faad5036700580d46f61effd438288caa1e948b48521c46cf73"
RDEPENDS:infiniband-diags-compat = " \
 infiniband-diags \
 perl-libs \
 perl-Getopt-Std \
 bash \
 perl-interpreter \
"
