# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libepoxy"
PE = "0"
PV = "1.5.10"
PR = "9.el10"
PACKAGES = "libepoxy libepoxy-devel"
PROVIDES = "rpm/libepoxy rpm/libepoxy-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libepoxy-1.5.10-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15d98821f5c4955dbd280ae05b527711a6ea963f5c0c77ca6c3acc26a13002df"

URI_libepoxy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libepoxy-1.5.10-9.el10.x86_64_v2.rpm;name=libepoxy;unpack=0"
SRC_URI += "${URI_libepoxy}"
SRC_URI[libepoxy.sha256sum] = "329ded071a62f7526aaf08625ec726950b47fc712b68f63c7d6d353d82bfa425"
RDEPENDS:libepoxy = " \
 glibc \
"

URI_libepoxy-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libepoxy-devel-1.5.10-9.el10.x86_64_v2.rpm;name=libepoxy-devel;unpack=0"
SRC_URI += "${URI_libepoxy-devel}"
SRC_URI[libepoxy-devel.sha256sum] = "6775e7d971e355a4eb914a77e9f545ec550e3bd2a906efd038a82eef51f7b09b"
RDEPENDS:libepoxy-devel = " \
 libX11-devel \
 libepoxy \
 pkgconf-pkg-config \
 libglvnd-devel \
"
