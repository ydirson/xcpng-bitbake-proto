# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mesa-demos"
PE = "0"
PV = "9.0.0"
PR = "8.el10"
PACKAGES = "egl-utils glx-utils mesa-demos"
PROVIDES = "rpm/egl-utils rpm/glx-utils rpm/mesa-demos"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mesa-demos-9.0.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "003cb657eebca179fc3ab04b368932831e34a3aea1e927d570b13cb887f06689"

URI_egl-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/egl-utils-9.0.0-8.el10.x86_64_v2.rpm;name=egl-utils;unpack=0"
SRC_URI += "${URI_egl-utils}"
SRC_URI[egl-utils.sha256sum] = "9fe9f344f4565355981616d0868a9a3572cbddb4e359aa92ab48c9504bd177cd"
RDEPENDS:egl-utils = " \
 glibc \
 libglvnd-gles \
 libX11 \
 libglvnd-egl \
"

URI_glx-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/glx-utils-9.0.0-8.el10.x86_64_v2.rpm;name=glx-utils;unpack=0"
SRC_URI += "${URI_glx-utils}"
SRC_URI[glx-utils.sha256sum] = "9731b36912f9a93350865e11f25959cd46d61ab6ab881ee080893eca2adcc383"
RDEPENDS:glx-utils = " \
 glibc \
 libglvnd-glx \
 libX11 \
"

URI_mesa-demos = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mesa-demos-9.0.0-8.el10.x86_64_v2.rpm;name=mesa-demos;unpack=0"
SRC_URI += "${URI_mesa-demos}"
SRC_URI[mesa-demos.sha256sum] = "6c8000c3128b916c5a7715f60f50a96e3af74a96abd8dbc9b5bc3fb12d18235c"
RDEPENDS:mesa-demos = " \
 libwayland-client \
 libglvnd-egl \
 libglvnd-glx \
 libglvnd-gles \
 libglvnd-opengl \
 libwayland-egl \
 libxkbcommon-x11 \
 freeglut \
 libX11 \
 libxcb \
 mesa-libGLU \
 mesa-libgbm \
 glibc \
 libxkbcommon \
 vulkan-loader \
 libdecor \
 libdrm \
 libXext \
"
