# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libcpuid"
PE = "0"
PV = "0.7.0"
PR = "2.el10"
PACKAGES = "libcpuid python3-libcpuid libcpuid-devel"
PROVIDES = "rpm/libcpuid rpm/python3-libcpuid rpm/libcpuid-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libcpuid-0.7.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c685055c33342f74838ec16de4c2154ee244d90cd78236547ad624b09c1c3b6"

URI_libcpuid = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libcpuid-0.7.0-2.el10.x86_64_v2.rpm;name=libcpuid;unpack=0"
SRC_URI += "${URI_libcpuid}"
SRC_URI[libcpuid.sha256sum] = "b4b5db3c001dac4ac3a86c59a98e38c7e1b87dc4faf0c30204c9999ed6e3b55c"
RDEPENDS:libcpuid = " \
 glibc \
"

URI_python3-libcpuid = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-libcpuid-0.7.0-2.el10.x86_64_v2.rpm;name=python3-libcpuid;unpack=0"
SRC_URI += "${URI_python3-libcpuid}"
SRC_URI[python3-libcpuid.sha256sum] = "768a7fbb842a6fca4cd657e109de58ccb350a8a8e005f8e39dd71139a2446e39"
RDEPENDS:python3-libcpuid = " \
 glibc \
 python3-cffi \
 python3 \
 libcpuid \
"

URI_libcpuid-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libcpuid-devel-0.7.0-2.el10.x86_64_v2.rpm;name=libcpuid-devel;unpack=0"
SRC_URI += "${URI_libcpuid-devel}"
SRC_URI[libcpuid-devel.sha256sum] = "f51cc830b2f01c59c8d3f28b8fa9876dcdf5ab847fa70de88d853489ffdfda56"
RDEPENDS:libcpuid-devel = " \
 glibc \
 pkgconf-pkg-config \
 libcpuid \
"
