# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-srpm-macros"
PE = "0"
PV = "1"
PR = "57.el10"
PACKAGES = "perl-srpm-macros"
PROVIDES = "rpm/perl-srpm-macros"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-srpm-macros-1-57.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48b4f485e9ce15fa39e9d4c326c45251af6eb0462b251eda448556dab3339b9d"

URI_perl-srpm-macros = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-srpm-macros-1-57.el10.noarch.rpm;name=perl-srpm-macros;unpack=0"
SRC_URI += "${URI_perl-srpm-macros}"
SRC_URI[perl-srpm-macros.sha256sum] = "c36cdcd1cb756cfddedd26684ee17c6b160abb0b3fffe845457b3191a322d881"
RDEPENDS:perl-srpm-macros = ""
