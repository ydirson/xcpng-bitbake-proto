# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jboss-jaxrs-2.0-api"
PE = "0"
PV = "1.0.0"
PR = "27.el10"
PACKAGES = "jboss-jaxrs-2.0-api"
PROVIDES = "rpm/jboss-jaxrs-2.0-api"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/jboss-jaxrs-2.0-api-1.0.0-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d136b915ee3ed85037fadbbb4765702070d5d4fe04607ca2f94ad723e80007d"

URI_jboss-jaxrs-2.0-api = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/jboss-jaxrs-2.0-api-1.0.0-27.el10.noarch.rpm;name=jboss-jaxrs-2.0-api;unpack=0"
SRC_URI += "${URI_jboss-jaxrs-2.0-api}"
SRC_URI[jboss-jaxrs-2.0-api.sha256sum] = "d9592c703868e49bd1b2dfcaa25d97433966f51006af503c78683bc45d87d0e6"
RDEPENDS:jboss-jaxrs-2.0-api = " \
 javapackages-filesystem \
 java-21-openjdk-headless \
 jaxb-api \
"
