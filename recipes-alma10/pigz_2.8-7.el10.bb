# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pigz"
PE = "0"
PV = "2.8"
PR = "7.el10"
PACKAGES = "pigz"
PROVIDES = "rpm/pigz"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/pigz-2.8-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19706ca446f1c29fab66f9f7f9f4d51d12ffe359edab3fd873baa56d2a905b85"

URI_pigz = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/pigz-2.8-7.el10.x86_64_v2.rpm;name=pigz;unpack=0"
SRC_URI += "${URI_pigz}"
SRC_URI[pigz.sha256sum] = "08cd9be54e1b85026ac255c1287a2ac1b6ef396aadd05adde968acb260fad001"
RDEPENDS:pigz = " \
 glibc \
 libgcc \
 zlib-ng-compat \
"
