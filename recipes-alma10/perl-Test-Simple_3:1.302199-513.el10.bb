# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Test-Simple"
PE = "3"
PV = "1.302199"
PR = "513.el10"
PACKAGES = "perl-Test-Simple perl-Test-Simple-tests"
PROVIDES = "rpm/perl-Test-Simple rpm/perl-Test-Simple-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Test-Simple-1.302199-513.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26c889164fdcab64d0bd7ff5563813f93b2474d4b00ce7b2aa9c22ef63d5bb53"

URI_perl-Test-Simple = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Test-Simple-1.302199-513.el10.noarch.rpm;name=perl-Test-Simple;unpack=0"
SRC_URI += "${URI_perl-Test-Simple}"
SRC_URI[perl-Test-Simple.sha256sum] = "f7ad13060a6ce8c7350f38ac58bf877d7d3a5a044cbeb996be20ef71442458cf"
RDEPENDS:perl-Test-Simple = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Storable \
 perl-mro \
 perl-Symbol \
 perl-Term-ANSIColor \
 perl-Term-Table \
 perl-Carp \
 perl-Test-Simple \
 perl-vars \
 perl-IO \
 perl-JSON-PP \
 perl-Data-Dumper \
 perl-Time-HiRes \
 perl-Exporter \
 perl-base \
 perl-POSIX \
 perl-PathTools \
 perl-File-Temp \
"

URI_perl-Test-Simple-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Test-Simple-tests-1.302199-513.el10.noarch.rpm;name=perl-Test-Simple-tests;unpack=0"
SRC_URI += "${URI_perl-Test-Simple-tests}"
SRC_URI[perl-Test-Simple-tests.sha256sum] = "78d51554b7882e723ac89e094d435fd2497c99e63063598460d3569e84bf29c8"
RDEPENDS:perl-Test-Simple-tests = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-overload \
 perl-Symbol \
 perl-threads \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Carp \
 perl-vars \
 perl-IO \
 perl-IPC-Open3 \
 perl-lib \
 perl-Data-Dumper \
 bash \
 perl-Exporter \
 perl-base \
 perl-File-Basename \
 perl-PathTools \
 perl-interpreter \
 perl-File-Temp \
"
