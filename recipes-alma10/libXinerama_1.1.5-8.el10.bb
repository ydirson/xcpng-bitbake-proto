# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libXinerama"
PE = "0"
PV = "1.1.5"
PR = "8.el10"
PACKAGES = "libXinerama libXinerama-devel"
PROVIDES = "rpm/libXinerama rpm/libXinerama-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libXinerama-1.1.5-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "188a9c52e42e7af40b284e942aea990175d454a68e662843d2d1142ee1e53824"

URI_libXinerama = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXinerama-1.1.5-8.el10.x86_64_v2.rpm;name=libXinerama;unpack=0"
SRC_URI += "${URI_libXinerama}"
SRC_URI[libXinerama.sha256sum] = "40e7426d696eb4ee8b362b1b567cb5be1a4e197c5c934b5e9036d8bde7748a3d"
RDEPENDS:libXinerama = " \
 glibc \
 libX11 \
 libXext \
"

URI_libXinerama-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXinerama-devel-1.1.5-8.el10.x86_64_v2.rpm;name=libXinerama-devel;unpack=0"
SRC_URI += "${URI_libXinerama-devel}"
SRC_URI[libXinerama-devel.sha256sum] = "cd8e27f2491a8ae72591d7b814b563d8bd1ddea84f4c8a05b982fdec3620f459"
RDEPENDS:libXinerama-devel = " \
 libXext-devel \
 libXinerama \
 pkgconf-pkg-config \
 libX11-devel \
 xorg-x11-proto-devel \
"
