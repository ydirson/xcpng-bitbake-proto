# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "wsdd"
PE = "0"
PV = "0.8"
PR = "3.el10"
PACKAGES = "wsdd"
PROVIDES = "rpm/wsdd"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/wsdd-0.8-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "801b515a84eafcbb477d367a2c6c1428560c2841c9c9baa62a7fe608cc12458b"

URI_wsdd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/wsdd-0.8-3.el10.noarch.rpm;name=wsdd;unpack=0"
SRC_URI += "${URI_wsdd}"
SRC_URI[wsdd.sha256sum] = "4fb2bb72fd4dce963d1e959f24a7d7cf2646ee67eacd8b99c65d4afc9d58f343"
RDEPENDS:wsdd = " \
 python3 \
 shadow-utils \
 bash \
"
