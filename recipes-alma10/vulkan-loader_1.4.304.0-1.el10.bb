# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "vulkan-loader"
PE = "0"
PV = "1.4.304.0"
PR = "1.el10"
PACKAGES = "vulkan-loader vulkan-loader-devel"
PROVIDES = "rpm/vulkan-loader rpm/vulkan-loader-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/vulkan-loader-1.4.304.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "497b51111af6df75730e861212e72f90854949cea2705952ac8fad6840c13ade"

URI_vulkan-loader = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/vulkan-loader-1.4.304.0-1.el10.x86_64_v2.rpm;name=vulkan-loader;unpack=0"
SRC_URI += "${URI_vulkan-loader}"
SRC_URI[vulkan-loader.sha256sum] = "bc6d3075ef91bc47819f150a6aa6ba136db7ddb52003a9b0f3d17725c73da50b"
RDEPENDS:vulkan-loader = " \
 glibc \
 mesa-vulkan-drivers \
"

URI_vulkan-loader-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/vulkan-loader-devel-1.4.304.0-1.el10.x86_64_v2.rpm;name=vulkan-loader-devel;unpack=0"
SRC_URI += "${URI_vulkan-loader-devel}"
SRC_URI[vulkan-loader-devel.sha256sum] = "26a0b2416acc8a6ae4d64312f1ceb622ff1960de383bc560434936692be91a12"
RDEPENDS:vulkan-loader-devel = " \
 vulkan-headers \
 vulkan-loader \
 cmake-filesystem \
 pkgconf-pkg-config \
"
