# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dconf-editor"
PE = "0"
PV = "45.0.1"
PR = "6.el10"
PACKAGES = "dconf-editor"
PROVIDES = "rpm/dconf-editor"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/dconf-editor-45.0.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3367f6eaaf7f02f0db712ac7d01f943a7003e6133d6f297aef46b3de7ed92c9f"

URI_dconf-editor = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dconf-editor-45.0.1-6.el10.x86_64_v2.rpm;name=dconf-editor;unpack=0"
SRC_URI += "${URI_dconf-editor}"
SRC_URI[dconf-editor.sha256sum] = "36bb1e36ae7cf6b2cf203143d6263754f8af6ca3c5d73feba7478ccdca0e7b93"
RDEPENDS:dconf-editor = " \
 libhandy \
 glib2 \
 gtk3 \
 dconf \
 glibc \
"
