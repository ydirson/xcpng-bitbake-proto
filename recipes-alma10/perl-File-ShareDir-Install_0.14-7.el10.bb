# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-File-ShareDir-Install"
PE = "0"
PV = "0.14"
PR = "7.el10"
PACKAGES = "perl-File-ShareDir-Install"
PROVIDES = "rpm/perl-File-ShareDir-Install"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-File-ShareDir-Install-0.14-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85f8eb4be7ab4991dd1eb08a71fcf60cb7bbbf177bbf14e6c4c827a0d523474e"

URI_perl-File-ShareDir-Install = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-File-ShareDir-Install-0.14-7.el10.noarch.rpm;name=perl-File-ShareDir-Install;unpack=0"
SRC_URI += "${URI_perl-File-ShareDir-Install}"
SRC_URI[perl-File-ShareDir-Install.sha256sum] = "277385d6f3f72f1311db92934b9f3bf1e6f8947692c4c5ea8ea1e125d5037ef7"
RDEPENDS:perl-File-ShareDir-Install = " \
 perl-libs \
 perl-Carp \
 perl-IO \
 perl-PathTools \
 perl-Exporter \
"
