# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pt-sans-fonts"
PE = "0"
PV = "20141121"
PR = "30.el10"
PACKAGES = "pt-sans-fonts pt-sans-fonts-doc"
PROVIDES = "rpm/pt-sans-fonts rpm/pt-sans-fonts-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/pt-sans-fonts-20141121-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "264093baaeffa673d7d44aa78422955e5eaaf2570dc2f4df4f31d82ee08e5853"

URI_pt-sans-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pt-sans-fonts-20141121-30.el10.noarch.rpm;name=pt-sans-fonts;unpack=0"
SRC_URI += "${URI_pt-sans-fonts}"
SRC_URI[pt-sans-fonts.sha256sum] = "3cd70f2a67fd40bd30f17018d923e323daa19c59106fd461feb59c7dcc79d774"
RDEPENDS:pt-sans-fonts = " \
 fonts-filesystem \
"

URI_pt-sans-fonts-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/pt-sans-fonts-doc-20141121-30.el10.noarch.rpm;name=pt-sans-fonts-doc;unpack=0"
SRC_URI += "${URI_pt-sans-fonts-doc}"
SRC_URI[pt-sans-fonts-doc.sha256sum] = "e75ef00e6369c9bc3e82d90af3b5f16c4538d78ebbf42dd54a2e28e1293995ad"
RDEPENDS:pt-sans-fonts-doc = ""
