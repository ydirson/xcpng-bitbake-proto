# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Path-Tiny"
PE = "0"
PV = "0.144"
PR = "9.el10"
PACKAGES = "perl-Path-Tiny perl-Path-Tiny-tests"
PROVIDES = "rpm/perl-Path-Tiny rpm/perl-Path-Tiny-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Path-Tiny-0.144-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bdb77eee2aa5959e39800aadfe5d5f9a9571c297eda0d7ea8ccf4b34986a9810"

URI_perl-Path-Tiny = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Path-Tiny-0.144-9.el10.noarch.rpm;name=perl-Path-Tiny;unpack=0"
SRC_URI += "${URI_perl-Path-Tiny}"
SRC_URI[perl-Path-Tiny.sha256sum] = "090ae1a8a8f986c299a394bb5824d217c5ce1f8439231d361aeb51f151c7b605"
RDEPENDS:perl-Path-Tiny = " \
 perl-constant \
 perl-threads \
 perl-File-stat \
 perl-libs \
 perl-Carp \
 perl-Digest \
 perl-Digest-SHA \
 perl-Unicode-UTF8 \
 perl-Fcntl \
 perl-Encode \
 perl-overload \
 perl-File-Copy \
 perl-PathTools \
 perl-File-Compare \
 perl-Exporter \
 perl-File-Path \
 perl-File-Temp \
"

URI_perl-Path-Tiny-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Path-Tiny-tests-0.144-9.el10.noarch.rpm;name=perl-Path-Tiny-tests;unpack=0"
SRC_URI += "${URI_perl-Path-Tiny-tests}"
SRC_URI[perl-Path-Tiny-tests.sha256sum] = "2c5c99f3c6ca9e47dc80073ddfc7cbfce37841b31b043c5961a64cbc7cdd37cb"
RDEPENDS:perl-Path-Tiny-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Carp \
 perl-ExtUtils-MakeMaker \
 perl-Digest \
 perl-Test-Simple \
 perl-Digest-MD5 \
 perl-Fcntl \
 perl-Path-Tiny \
 perl-File-Basename \
 perl-open \
 perl-File-Temp \
 perl-PathTools \
 bash \
 perl-interpreter \
 perl-Exporter \
 perl-lib \
"
