# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "stalld"
PE = "0"
PV = "1.19.8"
PR = "2.el10_0"
PACKAGES = "stalld"
PROVIDES = "rpm/stalld"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/stalld-1.19.8-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c797983e8e115447094ebb29761876e23fcbff53a0815eb660915a7c57971358"

URI_stalld = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/stalld-1.19.8-2.el10_0.x86_64_v2.rpm;name=stalld;unpack=0"
SRC_URI += "${URI_stalld}"
SRC_URI[stalld.sha256sum] = "779e132264f974ef1324e96df24506f8bc5729175cf6bcbd141a2826ac672963"
RDEPENDS:stalld = " \
 glibc \
 systemd \
 bash \
 libbpf \
"
