# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "memcached"
PE = "0"
PV = "1.6.23"
PR = "7.el10"
PACKAGES = "memcached memcached-selinux memcached-devel"
PROVIDES = "rpm/memcached rpm/memcached-selinux rpm/memcached-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/memcached-1.6.23-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e72859b4660d02a7cfc4b3d6feb1e7f94b128d50a2608581161bb58f2acbc2a"

URI_memcached = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/memcached-1.6.23-7.el10.x86_64_v2.rpm;name=memcached;unpack=0"
SRC_URI += "${URI_memcached}"
SRC_URI[memcached.sha256sum] = "f9427301df951253811e9e63a1414a09a106d7daf9a6914777dd47b19615e626"
RDEPENDS:memcached = " \
 memcached-selinux \
 shadow-utils \
 perl-libs \
 systemd \
 libevent \
 perl-IO \
 openssl-libs \
 cyrus-sasl-lib \
 bash \
 glibc \
 perl-interpreter \
"

URI_memcached-selinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/memcached-selinux-1.6.23-7.el10.x86_64_v2.rpm;name=memcached-selinux;unpack=0"
SRC_URI += "${URI_memcached-selinux}"
SRC_URI[memcached-selinux.sha256sum] = "b36a7a21dc10f1d8459f46874ebd9eea040cc08b9fa1f67d1362a2e6c0eda762"
RDEPENDS:memcached-selinux = " \
 policycoreutils-python-utils \
 policycoreutils \
 bash \
 selinux-policy \
 libselinux-utils \
"

URI_memcached-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/memcached-devel-1.6.23-7.el10.x86_64_v2.rpm;name=memcached-devel;unpack=0"
SRC_URI += "${URI_memcached-devel}"
SRC_URI[memcached-devel.sha256sum] = "a3f9b6f5cc42accbcd930a612945870e7a8c4773a98696d8fb67a27d506918a6"
RDEPENDS:memcached-devel = " \
 memcached \
"
