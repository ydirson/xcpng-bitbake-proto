# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rootfiles"
PE = "0"
PV = "8.1"
PR = "41.el10"
PACKAGES = "rootfiles"
PROVIDES = "rpm/rootfiles"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/rootfiles-8.1-41.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45235af9f4f321bf24b43ebe742bef723c606afb3186e08b38994583e958cd2c"

URI_rootfiles = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/rootfiles-8.1-41.el10.noarch.rpm;name=rootfiles;unpack=0"
SRC_URI += "${URI_rootfiles}"
SRC_URI[rootfiles.sha256sum] = "9e32372c2a140aae06343032b8f854b41a8150cf90acc29b24ee372e09f4c58e"
RDEPENDS:rootfiles = " \
 bash \
"
