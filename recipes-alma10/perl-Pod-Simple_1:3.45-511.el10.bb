# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Pod-Simple"
PE = "1"
PV = "3.45"
PR = "511.el10"
PACKAGES = "perl-Pod-Simple perl-Pod-Simple-tests"
PROVIDES = "rpm/perl-Pod-Simple rpm/perl-Pod-Simple-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Pod-Simple-3.45-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9e0b1785e8d732ef97210adbeda0c4bace6b9ae682249f1f05156ea7d21f0cc"

URI_perl-Pod-Simple = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Pod-Simple-3.45-511.el10.noarch.rpm;name=perl-Pod-Simple;unpack=0"
SRC_URI += "${URI_perl-Pod-Simple}"
SRC_URI[perl-Pod-Simple.sha256sum] = "1c80846cd751a8d0cd6779e19acc2e9f93c627caa548522928abb64d7fcd4b59"
RDEPENDS:perl-Pod-Simple = " \
 perl-libs \
 perl-Carp \
 perl-Text-Tabs+Wrap \
 perl-Getopt-Long \
 perl-File-Basename \
 perl-Encode \
 perl-overload \
 perl-Symbol \
 perl-PathTools \
 perl-if \
 perl-Pod-Escapes \
 perl-Pod-Simple \
"

URI_perl-Pod-Simple-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Pod-Simple-tests-3.45-511.el10.noarch.rpm;name=perl-Pod-Simple-tests;unpack=0"
SRC_URI += "${URI_perl-Pod-Simple-tests}"
SRC_URI[perl-Pod-Simple-tests.sha256sum] = "ae9e5115fc4bd2b2d90b4b8ed641fcd4817c32825b3fe17c07a19dcfcae82765"
RDEPENDS:perl-Pod-Simple-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-vars \
 perl-FindBin \
 perl-File-Basename \
 bash \
 perl-PathTools \
 perl-base \
 perl-File-Find \
 perl-interpreter \
 perl-File-Path \
 perl-Data-Dumper \
 perl-Exporter \
 perl-Pod-Simple \
"
