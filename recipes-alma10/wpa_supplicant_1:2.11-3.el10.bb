# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "wpa_supplicant"
PE = "1"
PV = "2.11"
PR = "3.el10"
PACKAGES = "wpa_supplicant"
PROVIDES = "rpm/wpa_supplicant"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/wpa_supplicant-2.11-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a66ad1d81a4b7470363e0ae45d7401e6da5b985f2b557d579b8214773820221"

URI_wpa_supplicant = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/wpa_supplicant-2.11-3.el10.x86_64_v2.rpm;name=wpa_supplicant;unpack=0"
SRC_URI += "${URI_wpa_supplicant}"
SRC_URI[wpa_supplicant.sha256sum] = "324804a84912accc744cd20f964afa96f061763e47b02971874405c87f613711"
RDEPENDS:wpa_supplicant = " \
 systemd \
 openssl-libs \
 libnl3 \
 bash \
 glibc \
 dbus-libs \
"
