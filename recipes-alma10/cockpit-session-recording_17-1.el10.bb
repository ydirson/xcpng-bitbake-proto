# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cockpit-session-recording"
PE = "0"
PV = "17"
PR = "1.el10"
PACKAGES = "cockpit-session-recording"
PROVIDES = "rpm/cockpit-session-recording"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/cockpit-session-recording-17-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f147217cadee657611b41cba901dcce61a32a2869f2d516eafe8bc542fa8b290"

URI_cockpit-session-recording = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cockpit-session-recording-17-1.el10.noarch.rpm;name=cockpit-session-recording;unpack=0"
SRC_URI += "${URI_cockpit-session-recording}"
SRC_URI[cockpit-session-recording.sha256sum] = "c78166f52fc4e7a3144ad83235d4fed9dd8da1ff680e4e853029079ba6149088"
RDEPENDS:cockpit-session-recording = " \
 sssd-proxy \
 cockpit-system \
 tlog \
"
