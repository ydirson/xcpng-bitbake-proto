# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "zaf"
PE = "0"
PV = "0"
PR = "0.31.20080714svn.el10"
PACKAGES = "hyphen-af hyphen-zu"
PROVIDES = "rpm/hyphen-af rpm/hyphen-zu"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/zaf-0-0.31.20080714svn.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7bf6d88d3a1fddda144e0ce2eeeea0f875fa74eb866a1e6b84b39a658e86207"

URI_hyphen-af = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-af-0-0.31.20080714svn.el10.noarch.rpm;name=hyphen-af;unpack=0"
SRC_URI += "${URI_hyphen-af}"
SRC_URI[hyphen-af.sha256sum] = "2ccddc357a2c58ac663b3d133053a3bd8c55fe71f05df125628beb017236241a"
RDEPENDS:hyphen-af = " \
 hyphen \
"

URI_hyphen-zu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-zu-0-0.31.20080714svn.el10.noarch.rpm;name=hyphen-zu;unpack=0"
SRC_URI += "${URI_hyphen-zu}"
SRC_URI[hyphen-zu.sha256sum] = "bade7ff0adbe36d4c949c121a7a4a5af351e9ca23d05292ff548ade99a000b53"
RDEPENDS:hyphen-zu = " \
 hyphen \
"
