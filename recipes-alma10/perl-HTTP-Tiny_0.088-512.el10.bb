# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-HTTP-Tiny"
PE = "0"
PV = "0.088"
PR = "512.el10"
PACKAGES = "perl-HTTP-Tiny perl-HTTP-Tiny-tests"
PROVIDES = "rpm/perl-HTTP-Tiny rpm/perl-HTTP-Tiny-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-HTTP-Tiny-0.088-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c426772e0a7e5df93a002fcfb7db6bb67bb5acb0a0c2d628d98f67c85ea9aca"

URI_perl-HTTP-Tiny = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-HTTP-Tiny-0.088-512.el10.noarch.rpm;name=perl-HTTP-Tiny;unpack=0"
SRC_URI += "${URI_perl-HTTP-Tiny}"
SRC_URI[perl-HTTP-Tiny.sha256sum] = "2a09877a0cb847971f262574e289db1ab6011a6dae3b95252ad0abcf797146d3"
RDEPENDS:perl-HTTP-Tiny = " \
 perl-libs \
 perl-Carp \
 perl-IO \
 perl-Socket \
 perl-Fcntl \
 perl-IO-Socket-SSL \
 perl-Mozilla-CA \
 perl-Errno \
 perl-Net-SSLeay \
 perl-Time-Local \
 perl-MIME-Base64 \
"

URI_perl-HTTP-Tiny-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-HTTP-Tiny-tests-0.088-512.el10.noarch.rpm;name=perl-HTTP-Tiny-tests;unpack=0"
SRC_URI += "${URI_perl-HTTP-Tiny-tests}"
SRC_URI[perl-HTTP-Tiny-tests.sha256sum] = "ae38a055b708c900cd614e357d6c7220ec822dceafd002b4cb6273932b540ed7"
RDEPENDS:perl-HTTP-Tiny-tests = " \
 perl-libs \
 perl-open \
 perl-HTTP-Tiny \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-IO \
 perl-IO-Socket-IP \
 perl-IO-Socket-SSL \
 perl-IPC-Cmd \
 perl-lib \
 openssl \
 perl-Mozilla-CA \
 bash \
 perl-Net-SSLeay \
 perl-ExtUtils-MakeMaker \
 perl-File-Basename \
 perl-PathTools \
 perl-interpreter \
 perl-File-Temp \
"
