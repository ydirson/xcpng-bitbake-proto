# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "chan"
PE = "0"
PV = "0.0.4"
PR = "14.el10"
PACKAGES = "chan chan-devel"
PROVIDES = "rpm/chan rpm/chan-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/chan-0.0.4-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2010fb43c06eaf6ede0d135c22db22eeef5476479e0248d22fd8704d535a78bc"

URI_chan = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/chan-0.0.4-14.el10.x86_64_v2.rpm;name=chan;unpack=0"
SRC_URI += "${URI_chan}"
SRC_URI[chan.sha256sum] = "d5930415d78868123137f923902fef217126b2370535896419b7c2ce5e23934c"
RDEPENDS:chan = " \
 glibc \
"

URI_chan-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/chan-devel-0.0.4-14.el10.x86_64_v2.rpm;name=chan-devel;unpack=0"
SRC_URI += "${URI_chan-devel}"
SRC_URI[chan-devel.sha256sum] = "1873ae6748b85b6cbd1d0f5cacd5a045df84a2186af124ba7ab24c04b785bba2"
RDEPENDS:chan-devel = " \
 chan \
"
