# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libpq"
PE = "0"
PV = "16.8"
PR = "2.el10_0"
PACKAGES = "libpq libpq-devel"
PROVIDES = "rpm/libpq rpm/libpq-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libpq-16.8-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "025be9ffa939a639076e7994dab662117f14c5c53633c234d2792a6c8e8e8ba5"

URI_libpq = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libpq-16.8-2.el10_0.x86_64_v2.rpm;name=libpq;unpack=0"
SRC_URI += "${URI_libpq}"
SRC_URI[libpq.sha256sum] = "ab25500af0c440cc9a440efbabdedbee34c7f474d38824c53622ab71e5460fa8"
RDEPENDS:libpq = " \
 glibc \
 krb5-libs \
 openssl-libs \
 openldap \
"

URI_libpq-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libpq-devel-16.8-2.el10_0.x86_64_v2.rpm;name=libpq-devel;unpack=0"
SRC_URI += "${URI_libpq-devel}"
SRC_URI[libpq-devel.sha256sum] = "4a3608cf21b694d98d9ba287546a043a1f2a1fc754cea25342b468ff7d0ec566"
RDEPENDS:libpq-devel = " \
 glibc \
 openssl-devel \
 pkgconf-pkg-config \
 libpq \
"
