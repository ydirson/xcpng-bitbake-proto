# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libogg"
PE = "2"
PV = "1.3.5"
PR = "10.el10"
PACKAGES = "libogg libogg-devel libogg-devel-docs"
PROVIDES = "rpm/libogg rpm/libogg-devel rpm/libogg-devel-docs"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libogg-1.3.5-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4fbff4f3e764271be03d3bb5b8042858057b308485d9ba6a8001df661dea296a"

URI_libogg = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libogg-1.3.5-10.el10.x86_64_v2.rpm;name=libogg;unpack=0"
SRC_URI += "${URI_libogg}"
SRC_URI[libogg.sha256sum] = "f81cd4f1b93ff9163e6ffd541797c02e62defc8595b82cec96e714d9d9c7fddb"
RDEPENDS:libogg = " \
 glibc \
"

URI_libogg-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libogg-devel-1.3.5-10.el10.x86_64_v2.rpm;name=libogg-devel;unpack=0"
SRC_URI += "${URI_libogg-devel}"
SRC_URI[libogg-devel.sha256sum] = "20af54bbb0b7e2fdc384be8837c2cc090bfd807aa5648907b8034aa65a89490d"
RDEPENDS:libogg-devel = " \
 automake \
 libogg \
 pkgconf-pkg-config \
"

URI_libogg-devel-docs = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libogg-devel-docs-1.3.5-10.el10.noarch.rpm;name=libogg-devel-docs;unpack=0"
SRC_URI += "${URI_libogg-devel-docs}"
SRC_URI[libogg-devel-docs.sha256sum] = "2ec1e31c27e004ec51c94382b81029a634b10e057b4dc97ae184cc188e1ab145"
RDEPENDS:libogg-devel-docs = ""
