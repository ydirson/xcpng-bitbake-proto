# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cmake"
PE = "0"
PV = "3.30.5"
PR = "3.el10_0"
PACKAGES = "cmake cmake-data cmake-doc cmake-filesystem cmake-gui cmake-rpm-macros"
PROVIDES = "rpm/cmake rpm/cmake-data rpm/cmake-doc rpm/cmake-filesystem rpm/cmake-gui rpm/cmake-rpm-macros"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/cmake-3.30.5-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f5c69fc9dd081be8bd4349d83caaf40438d417d281f31d64ca963c21d47fbf0"

URI_cmake = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cmake-3.30.5-3.el10_0.x86_64_v2.rpm;name=cmake;unpack=0"
SRC_URI += "${URI_cmake}"
SRC_URI[cmake.sha256sum] = "6df31a40956d5b80fbd1d3f32f13bd632c5101931d05a15ff12fc49dc04cc6d8"
RDEPENDS:cmake = " \
 cmake-data \
 zlib-ng-compat \
 cmake-filesystem \
 libarchive \
 cmake-rpm-macros \
 libgcc \
 make \
 libstdc++ \
 ncurses-libs \
 libuv \
 libcurl \
 glibc \
 expat \
"

URI_cmake-data = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cmake-data-3.30.5-3.el10_0.noarch.rpm;name=cmake-data;unpack=0"
SRC_URI += "${URI_cmake-data}"
SRC_URI[cmake-data.sha256sum] = "8a325779b601baf5c11cf97966d584e6c3461c519f83db02c048aed42d72046d"
RDEPENDS:cmake-data = " \
 emacs-filesystem \
 cmake-filesystem \
 cmake-rpm-macros \
 vim-filesystem \
 cmake \
"

URI_cmake-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cmake-doc-3.30.5-3.el10_0.noarch.rpm;name=cmake-doc;unpack=0"
SRC_URI += "${URI_cmake-doc}"
SRC_URI[cmake-doc.sha256sum] = "ede5fd77c8ff7676cce538df71ed06649a06ffb461c2ae9a832b1dc8d9c8753a"
RDEPENDS:cmake-doc = ""

URI_cmake-filesystem = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cmake-filesystem-3.30.5-3.el10_0.x86_64_v2.rpm;name=cmake-filesystem;unpack=0"
SRC_URI += "${URI_cmake-filesystem}"
SRC_URI[cmake-filesystem.sha256sum] = "4cfb6f62506c5de0e18c538448fac1e332c863555f733bd3141cb0f87b90e225"
RDEPENDS:cmake-filesystem = ""

URI_cmake-gui = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cmake-gui-3.30.5-3.el10_0.x86_64_v2.rpm;name=cmake-gui;unpack=0"
SRC_URI += "${URI_cmake-gui}"
SRC_URI[cmake-gui.sha256sum] = "01d9ab1972a6d9fbe4e397c8a28f51c02619836148a25e6aa88526915c3f003b"
RDEPENDS:cmake-gui = " \
 zlib-ng-compat \
 shared-mime-info \
 libarchive \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 libuv \
 libcurl \
 glibc \
 hicolor-icon-theme \
 cmake \
"

URI_cmake-rpm-macros = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cmake-rpm-macros-3.30.5-3.el10_0.noarch.rpm;name=cmake-rpm-macros;unpack=0"
SRC_URI += "${URI_cmake-rpm-macros}"
SRC_URI[cmake-rpm-macros.sha256sum] = "fbff46632b94941136186b03331c1137170e16f91812331d974923cc6b344c22"
RDEPENDS:cmake-rpm-macros = " \
 python3 \
 rpm \
"
