# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtsensors"
PE = "0"
PV = "6.8.1"
PR = "2.el10"
PACKAGES = "qt6-qtsensors qt6-qtsensors-devel qt6-qtsensors-examples qt6-qtsensors-tests"
PROVIDES = "rpm/qt6-qtsensors rpm/qt6-qtsensors-devel rpm/qt6-qtsensors-examples rpm/qt6-qtsensors-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtsensors-6.8.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dfad9f0ddae98039a76710cb8c453315772498a5cc91485120b2ed7131fd2a46"

URI_qt6-qtsensors = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtsensors-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtsensors;unpack=0"
SRC_URI += "${URI_qt6-qtsensors}"
SRC_URI[qt6-qtsensors.sha256sum] = "e1877c4e8008fd54cf60bf0e89cb549ffc57e232f495d33c50b8fba1bc13b915"
RDEPENDS:qt6-qtsensors = " \
 glibc \
 qt6-qtdeclarative \
 libstdc++ \
 qt6-qtbase \
"

URI_qt6-qtsensors-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtsensors-devel-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtsensors-devel;unpack=0"
SRC_URI += "${URI_qt6-qtsensors-devel}"
SRC_URI[qt6-qtsensors-devel.sha256sum] = "3bd6e14070d4ae4687afdb936b0dd39c9b4f4de1fc50c77807840711c4ae8b03"
RDEPENDS:qt6-qtsensors-devel = " \
 qt6-qtdeclarative-devel \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtsensors \
 qt6-qtsensors-devel \
"

URI_qt6-qtsensors-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtsensors-examples-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtsensors-examples;unpack=0"
SRC_URI += "${URI_qt6-qtsensors-examples}"
SRC_URI[qt6-qtsensors-examples.sha256sum] = "eef1642874d245bc0d76d5b70b47a35e3975770b6ab0ae8e371927a61138af38"
RDEPENDS:qt6-qtsensors-examples = " \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtsensors \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qtsensors-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtsensors-tests-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtsensors-tests;unpack=0"
SRC_URI += "${URI_qt6-qtsensors-tests}"
SRC_URI[qt6-qtsensors-tests.sha256sum] = "fecb8157a8ef7598c44465a50d8e95d865c116201cd05a43d7d9dbbb38df9bbc"
RDEPENDS:qt6-qtsensors-tests = " \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtsensors \
 qt6-qtbase \
 libstdc++ \
 glibc \
"
