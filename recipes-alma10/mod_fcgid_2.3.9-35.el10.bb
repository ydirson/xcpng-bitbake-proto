# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mod_fcgid"
PE = "0"
PV = "2.3.9"
PR = "35.el10"
PACKAGES = "mod_fcgid"
PROVIDES = "rpm/mod_fcgid"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mod_fcgid-2.3.9-35.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44a1cc808951df88a5c56485e21eb0ea8660a581eba93894ada1f2e9bfec3723"

URI_mod_fcgid = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mod_fcgid-2.3.9-35.el10.x86_64_v2.rpm;name=mod_fcgid;unpack=0"
SRC_URI += "${URI_mod_fcgid}"
SRC_URI[mod_fcgid.sha256sum] = "7563976a9ca377ddffaddf546b78cca2f56d8e029cc17991d5f1dbbb6788c43e"
RDEPENDS:mod_fcgid = " \
 glibc \
 systemd \
 httpd-core \
"
