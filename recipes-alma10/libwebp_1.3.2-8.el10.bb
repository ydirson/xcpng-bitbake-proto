# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libwebp"
PE = "0"
PV = "1.3.2"
PR = "8.el10"
PACKAGES = "libwebp libwebp-devel libwebp-tools"
PROVIDES = "rpm/libwebp rpm/libwebp-devel rpm/libwebp-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libwebp-1.3.2-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82e7b54269ae5f52de75aec768d431e48928e16f48b648bc850ae6ee9af2987d"

URI_libwebp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libwebp-1.3.2-8.el10.x86_64_v2.rpm;name=libwebp;unpack=0"
SRC_URI += "${URI_libwebp}"
SRC_URI[libwebp.sha256sum] = "137c8c9a4b0b8d0285622b4a530383ace32346a36f5f7caaf454d7c4ab774300"
RDEPENDS:libwebp = " \
 glibc \
"

URI_libwebp-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libwebp-devel-1.3.2-8.el10.x86_64_v2.rpm;name=libwebp-devel;unpack=0"
SRC_URI += "${URI_libwebp-devel}"
SRC_URI[libwebp-devel.sha256sum] = "6c0b6d6b06f6a75b4ccf2df3c2f8759e5ae72557e99a1d97e7731a511736b4db"
RDEPENDS:libwebp-devel = " \
 libwebp \
 cmake-filesystem \
 pkgconf-pkg-config \
 libwebp-devel \
"

URI_libwebp-tools = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libwebp-tools-1.3.2-8.el10.x86_64_v2.rpm;name=libwebp-tools;unpack=0"
SRC_URI += "${URI_libwebp-tools}"
SRC_URI[libwebp-tools.sha256sum] = "f8224318ac017d08a0066c90f6adc8a89cc5b4b0308e4035749fbfe8e3a620ee"
RDEPENDS:libwebp-tools = " \
 giflib \
 libpng \
 libglvnd-glx \
 libglvnd-opengl \
 libwebp \
 glibc \
 freeglut \
 libjpeg-turbo \
 libtiff \
"
