# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "stunnel"
PE = "0"
PV = "5.72"
PR = "8.el10"
PACKAGES = "stunnel"
PROVIDES = "rpm/stunnel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/stunnel-5.72-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "087f7135187314ca5265f941713999907085ade0265b5589422e533c478ca097"

URI_stunnel = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/stunnel-5.72-8.el10.x86_64_v2.rpm;name=stunnel;unpack=0"
SRC_URI += "${URI_stunnel}"
SRC_URI[stunnel.sha256sum] = "42cf1de635d5dfd61607e1e245fe1d3f525c95ff26b2ebd17393ab882b758e19"
RDEPENDS:stunnel = " \
 systemd \
 systemd-libs \
 openssl-libs \
 bash \
 glibc \
"
