# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cups-filters"
PE = "1"
PV = "2.0.0"
PR = "9.el10"
PACKAGES = "cups-filters cups-filters-driverless"
PROVIDES = "rpm/cups-filters rpm/cups-filters-driverless"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/cups-filters-2.0.0-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b305105a8f244574d377085bf731e85414d0165d4310f7eb0ebf111655a448b4"

URI_cups-filters = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cups-filters-2.0.0-9.el10.x86_64_v2.rpm;name=cups-filters;unpack=0"
SRC_URI += "${URI_cups-filters}"
SRC_URI[cups-filters.sha256sum] = "b5b4d76fb7acd25ae4e99f9326c688e353942a9771fcdecb48e34ed72b90cc12"
RDEPENDS:cups-filters = " \
 cups-filesystem \
 cups-libs \
 bash \
 libcupsfilters \
 glibc \
 libppd \
"

URI_cups-filters-driverless = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cups-filters-driverless-2.0.0-9.el10.x86_64_v2.rpm;name=cups-filters-driverless;unpack=0"
SRC_URI += "${URI_cups-filters-driverless}"
SRC_URI[cups-filters-driverless.sha256sum] = "16ff05284b1e0b21b4468c6e0f4fac166322790594f563612642df978dab269a"
RDEPENDS:cups-filters-driverless = " \
 cups-ipptool \
 cups-filesystem \
 cups-libs \
 avahi \
 bash \
 libcupsfilters \
 glibc \
 libppd \
"
