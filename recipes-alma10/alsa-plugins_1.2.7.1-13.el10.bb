# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "alsa-plugins"
PE = "0"
PV = "1.2.7.1"
PR = "13.el10"
PACKAGES = "alsa-plugins-arcamav alsa-plugins-maemo alsa-plugins-oss alsa-plugins-pulseaudio alsa-plugins-samplerate alsa-plugins-speex alsa-plugins-upmix alsa-plugins-usbstream alsa-plugins-vdownmix"
PROVIDES = "rpm/alsa-plugins-arcamav rpm/alsa-plugins-maemo rpm/alsa-plugins-oss rpm/alsa-plugins-pulseaudio rpm/alsa-plugins-samplerate rpm/alsa-plugins-speex rpm/alsa-plugins-upmix rpm/alsa-plugins-usbstream rpm/alsa-plugins-vdownmix"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/alsa-plugins-1.2.7.1-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c13cec17a9b73a516fba3cb23986437ebec03df6e41d63ba16bc1263694cd382"

URI_alsa-plugins-arcamav = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/alsa-plugins-arcamav-1.2.7.1-13.el10.x86_64_v2.rpm;name=alsa-plugins-arcamav;unpack=0"
SRC_URI += "${URI_alsa-plugins-arcamav}"
SRC_URI[alsa-plugins-arcamav.sha256sum] = "098efdfdc3de0856587e4c136856edb3cea0e736b79f46b976213042f3333796"
RDEPENDS:alsa-plugins-arcamav = " \
 glibc \
 alsa-lib \
"

URI_alsa-plugins-maemo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/alsa-plugins-maemo-1.2.7.1-13.el10.x86_64_v2.rpm;name=alsa-plugins-maemo;unpack=0"
SRC_URI += "${URI_alsa-plugins-maemo}"
SRC_URI[alsa-plugins-maemo.sha256sum] = "71f4477031c2d387269e01025e94912e3679a25388491bb53b90e4809232bfd2"
RDEPENDS:alsa-plugins-maemo = " \
 glibc \
 alsa-lib \
 dbus-libs \
"

URI_alsa-plugins-oss = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/alsa-plugins-oss-1.2.7.1-13.el10.x86_64_v2.rpm;name=alsa-plugins-oss;unpack=0"
SRC_URI += "${URI_alsa-plugins-oss}"
SRC_URI[alsa-plugins-oss.sha256sum] = "47e26a8cf844c516f4f601e914f187aad2bb6aa3d8b67b4388d643bbe56873f3"
RDEPENDS:alsa-plugins-oss = " \
 glibc \
 alsa-lib \
"

URI_alsa-plugins-pulseaudio = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/alsa-plugins-pulseaudio-1.2.7.1-13.el10.x86_64_v2.rpm;name=alsa-plugins-pulseaudio;unpack=0"
SRC_URI += "${URI_alsa-plugins-pulseaudio}"
SRC_URI[alsa-plugins-pulseaudio.sha256sum] = "be847607f3d816a62e72d57f3da6ecc2afd75c0c06edff413f9994ef12953145"
RDEPENDS:alsa-plugins-pulseaudio = " \
 glibc \
 pulseaudio-libs \
 alsa-lib \
"

URI_alsa-plugins-samplerate = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/alsa-plugins-samplerate-1.2.7.1-13.el10.x86_64_v2.rpm;name=alsa-plugins-samplerate;unpack=0"
SRC_URI += "${URI_alsa-plugins-samplerate}"
SRC_URI[alsa-plugins-samplerate.sha256sum] = "20e559078112c73dffa4a6a1436cd64eb42d3804f0b6729275c5ba9694b07a0a"
RDEPENDS:alsa-plugins-samplerate = " \
 glibc \
 alsa-lib \
 libsamplerate \
"

URI_alsa-plugins-speex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/alsa-plugins-speex-1.2.7.1-13.el10.x86_64_v2.rpm;name=alsa-plugins-speex;unpack=0"
SRC_URI += "${URI_alsa-plugins-speex}"
SRC_URI[alsa-plugins-speex.sha256sum] = "4a91a8395f5e926ab9be0074774c54d6279c5706902ca56d0765945df0e2f501"
RDEPENDS:alsa-plugins-speex = " \
 glibc \
 speex \
 alsa-lib \
 speexdsp \
"

URI_alsa-plugins-upmix = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/alsa-plugins-upmix-1.2.7.1-13.el10.x86_64_v2.rpm;name=alsa-plugins-upmix;unpack=0"
SRC_URI += "${URI_alsa-plugins-upmix}"
SRC_URI[alsa-plugins-upmix.sha256sum] = "68a1dcf1e1d0b463f2ec9b89e1109d8bc16ebd7009e8b46e1db6987983402ded"
RDEPENDS:alsa-plugins-upmix = " \
 glibc \
 alsa-lib \
"

URI_alsa-plugins-usbstream = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/alsa-plugins-usbstream-1.2.7.1-13.el10.x86_64_v2.rpm;name=alsa-plugins-usbstream;unpack=0"
SRC_URI += "${URI_alsa-plugins-usbstream}"
SRC_URI[alsa-plugins-usbstream.sha256sum] = "c1ac8e4e08f0691eb4acae8b4be1c362d26913b25f3a825274d3d5be0c8dbe41"
RDEPENDS:alsa-plugins-usbstream = " \
 glibc \
 alsa-lib \
"

URI_alsa-plugins-vdownmix = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/alsa-plugins-vdownmix-1.2.7.1-13.el10.x86_64_v2.rpm;name=alsa-plugins-vdownmix;unpack=0"
SRC_URI += "${URI_alsa-plugins-vdownmix}"
SRC_URI[alsa-plugins-vdownmix.sha256sum] = "eee424fb0d8d9e67a560b24a15c1bcf67f505f2cfb7a65b1863778a19e36a94d"
RDEPENDS:alsa-plugins-vdownmix = " \
 glibc \
 alsa-lib \
"
