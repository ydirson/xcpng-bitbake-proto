# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-setuptools-rust"
PE = "0"
PV = "1.10.2"
PR = "1.el10"
PACKAGES = "python3-setuptools-rust"
PROVIDES = "rpm/python3-setuptools-rust"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/python-setuptools-rust-1.10.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7384655958e253b7c90a96768a4d6f1140b18daf1f5d1d29a2d6d6ea80cf0e16"

URI_python3-setuptools-rust = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-setuptools-rust-1.10.2-1.el10.noarch.rpm;name=python3-setuptools-rust;unpack=0"
SRC_URI += "${URI_python3-setuptools-rust}"
SRC_URI[python3-setuptools-rust.sha256sum] = "78920b24416e19836113737d04fca51b2efd6c201d3594fbc6f8a7b2d4cd556f"
RDEPENDS:python3-setuptools-rust = " \
 python3 \
 cargo \
 python3-semantic_version \
 python3-setuptools \
"
