# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libdvdnav"
PE = "0"
PV = "6.1.1"
PR = "10.el10"
PACKAGES = "libdvdnav libdvdnav-devel"
PROVIDES = "rpm/libdvdnav rpm/libdvdnav-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libdvdnav-6.1.1-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d65a2df2f0feaaa31c9d9896242572847824c9d792d87a8854d8effd58bace9a"

URI_libdvdnav = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libdvdnav-6.1.1-10.el10.x86_64_v2.rpm;name=libdvdnav;unpack=0"
SRC_URI += "${URI_libdvdnav}"
SRC_URI[libdvdnav.sha256sum] = "6a875527039e1c6826f6c96d0d4d90d3986b16771a76e7d082bb400d02ff211d"
RDEPENDS:libdvdnav = " \
 glibc \
 libdvdread \
"

URI_libdvdnav-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libdvdnav-devel-6.1.1-10.el10.x86_64_v2.rpm;name=libdvdnav-devel;unpack=0"
SRC_URI += "${URI_libdvdnav-devel}"
SRC_URI[libdvdnav-devel.sha256sum] = "dbf4219663c9e55911ce02e120648be4a3220d1be07b8af3419edd8591b5001b"
RDEPENDS:libdvdnav-devel = " \
 libdvdnav \
 pkgconf-pkg-config \
 libdvdread-devel \
"
