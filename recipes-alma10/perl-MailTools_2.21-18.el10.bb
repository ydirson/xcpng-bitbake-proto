# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-MailTools"
PE = "0"
PV = "2.21"
PR = "18.el10"
PACKAGES = "perl-MailTools"
PROVIDES = "rpm/perl-MailTools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-MailTools-2.21-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36cce1eadd1dd84b788454a9eb87889f44555901b1eec467475a398810305b76"

URI_perl-MailTools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-MailTools-2.21-18.el10.noarch.rpm;name=perl-MailTools;unpack=0"
SRC_URI += "${URI_perl-MailTools}"
SRC_URI[perl-MailTools.sha256sum] = "bfc32bd60c77f671b9b84916341b333df469138ccbbcf24402bd1eb1614044a2"
RDEPENDS:perl-MailTools = " \
 perl-libnet \
 perl-TimeDate \
 perl-MailTools \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-IO \
 perl-POSIX \
 perl-Net-SMTP-SSL \
 perl-Exporter \
 perl-base \
"
