# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Devel-PPPort"
PE = "0"
PV = "3.72"
PR = "512.el10"
PACKAGES = "perl-Devel-PPPort perl-Devel-PPPort-tests"
PROVIDES = "rpm/perl-Devel-PPPort rpm/perl-Devel-PPPort-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Devel-PPPort-3.72-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3d6cc0531f33f8e7038d3e26171dbacdce56528ff6fd66801624801bc4944c5"

URI_perl-Devel-PPPort = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Devel-PPPort-3.72-512.el10.x86_64_v2.rpm;name=perl-Devel-PPPort;unpack=0"
SRC_URI += "${URI_perl-Devel-PPPort}"
SRC_URI[perl-Devel-PPPort.sha256sum] = "986b1c50f96621be2d1fccce436b7f55c332c45cfbfc1534e54fa3b6d5ab2f0d"
RDEPENDS:perl-Devel-PPPort = " \
 glibc \
 perl-libs \
 perl-vars \
"

URI_perl-Devel-PPPort-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Devel-PPPort-tests-3.72-512.el10.x86_64_v2.rpm;name=perl-Devel-PPPort-tests;unpack=0"
SRC_URI += "${URI_perl-Devel-PPPort-tests}"
SRC_URI[perl-Devel-PPPort-tests.sha256sum] = "b9b1abc470b12ba6ffc133f84b39d8c84881f0cf0e3ac4f10fa6252dfe1db584"
RDEPENDS:perl-Devel-PPPort-tests = " \
 perl-Devel-PPPort \
 perl-Test-Harness \
 perl-libs \
 perl-vars \
 perl-FindBin \
 perl-DynaLoader \
 perl-overload \
 perl-PathTools \
 bash \
 perl-interpreter \
 perl-File-Path \
 perl-less \
 perl-lib \
"
