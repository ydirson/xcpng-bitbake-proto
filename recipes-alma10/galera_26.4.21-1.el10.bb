# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "galera"
PE = "0"
PV = "26.4.21"
PR = "1.el10"
PACKAGES = "galera"
PROVIDES = "rpm/galera"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/galera-26.4.21-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3eada1efddcd3e66fbbbf5815dcedf67e98eb883a9691ddd14c6f51dd24b4635"

URI_galera = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/galera-26.4.21-1.el10.x86_64_v2.rpm;name=galera;unpack=0"
SRC_URI += "${URI_galera}"
SRC_URI[galera.sha256sum] = "af4569dcc98c81d1d87dfa964e8d5dfd72e6f39434653c277d562dd05fff12d1"
RDEPENDS:galera = " \
 shadow-utils \
 systemd \
 nmap-ncat \
 boost-program-options \
 libgcc \
 openssl-libs \
 libstdc++ \
 bash \
 procps-ng \
 glibc \
"
