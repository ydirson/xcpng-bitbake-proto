# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Text-CharWidth"
PE = "0"
PV = "0.04"
PR = "57.el10"
PACKAGES = "perl-Text-CharWidth perl-Text-CharWidth-tests"
PROVIDES = "rpm/perl-Text-CharWidth rpm/perl-Text-CharWidth-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Text-CharWidth-0.04-57.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "34781d0c24f7326efe082d9f38c49410e52253c941b8fbcf96706e46d694e3e7"

URI_perl-Text-CharWidth = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Text-CharWidth-0.04-57.el10.x86_64_v2.rpm;name=perl-Text-CharWidth;unpack=0"
SRC_URI += "${URI_perl-Text-CharWidth}"
SRC_URI[perl-Text-CharWidth.sha256sum] = "39688d285dae1a390d330a42fa4562bd56673ec5f791cc0b4b69d00ba4553500"
RDEPENDS:perl-Text-CharWidth = " \
 glibc \
 perl-Exporter \
 perl-libs \
"

URI_perl-Text-CharWidth-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Text-CharWidth-tests-0.04-57.el10.x86_64_v2.rpm;name=perl-Text-CharWidth-tests;unpack=0"
SRC_URI += "${URI_perl-Text-CharWidth-tests}"
SRC_URI[perl-Text-CharWidth-tests.sha256sum] = "ad546cc34b280c52f47f555a22829d9e73eb7e844b4ebc3cbb2e5538ddc2b627"
RDEPENDS:perl-Text-CharWidth-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Text-CharWidth \
 bash \
 perl-interpreter \
"
