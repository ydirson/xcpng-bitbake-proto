# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xkeyboard-config"
PE = "0"
PV = "2.41"
PR = "3.el10"
PACKAGES = "xkeyboard-config xkeyboard-config-devel"
PROVIDES = "rpm/xkeyboard-config rpm/xkeyboard-config-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xkeyboard-config-2.41-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4886065816e6140615bb3e3766193ac3bb7e7a8c23f3b64397186988cde485bd"

URI_xkeyboard-config = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xkeyboard-config-2.41-3.el10.noarch.rpm;name=xkeyboard-config;unpack=0"
SRC_URI += "${URI_xkeyboard-config}"
SRC_URI[xkeyboard-config.sha256sum] = "314888f0735303e7173cbe8750947cd02b6c817f689001cde60f22887b665dff"
RDEPENDS:xkeyboard-config = ""

URI_xkeyboard-config-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xkeyboard-config-devel-2.41-3.el10.noarch.rpm;name=xkeyboard-config-devel;unpack=0"
SRC_URI += "${URI_xkeyboard-config-devel}"
SRC_URI[xkeyboard-config-devel.sha256sum] = "889fa9600ca07832a1489f190d4d88b0c1dceaaf49afb4eb89aff1fc379123db"
RDEPENDS:xkeyboard-config-devel = " \
 xkeyboard-config \
 pkgconf-pkg-config \
"
