# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "openwsman"
PE = "0"
PV = "2.7.2"
PR = "9.el10"
PACKAGES = "libwsman1 openwsman-python3 openwsman-selinux openwsman-server libwsman-devel openwsman-client openwsman-perl openwsman-winrs rubygem-openwsman rubygem-openwsman-doc"
PROVIDES = "rpm/libwsman1 rpm/openwsman-python3 rpm/openwsman-selinux rpm/openwsman-server rpm/libwsman-devel rpm/openwsman-client rpm/openwsman-perl rpm/openwsman-winrs rpm/rubygem-openwsman rpm/rubygem-openwsman-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/openwsman-2.7.2-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c62bf3f045216b9d3da899fd72ad8ca741ef6a22d7a0f5db32195d35584c0458"

URI_libwsman1 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libwsman1-2.7.2-9.el10.x86_64_v2.rpm;name=libwsman1;unpack=0"
SRC_URI += "${URI_libwsman1}"
SRC_URI[libwsman1.sha256sum] = "9152950a849f5784612de83d9dfa14c1926491a8d81994203ca7c0cf12344b94"
RDEPENDS:libwsman1 = " \
 glibc \
 libxml2 \
 libcurl \
"

URI_openwsman-python3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/openwsman-python3-2.7.2-9.el10.x86_64_v2.rpm;name=openwsman-python3;unpack=0"
SRC_URI += "${URI_openwsman-python3}"
SRC_URI[openwsman-python3.sha256sum] = "f3105899eeb293dbbff93121fa899352acd2b91df95a15b1f640e910c7d3cd19"
RDEPENDS:openwsman-python3 = " \
 glibc \
 libwsman1 \
 python3 \
"

URI_openwsman-selinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/openwsman-selinux-2.7.2-9.el10.noarch.rpm;name=openwsman-selinux;unpack=0"
SRC_URI += "${URI_openwsman-selinux}"
SRC_URI[openwsman-selinux.sha256sum] = "7a97009a0c48090f2e274535e82238700e4dd516a7f58b399ad86fe516b09edd"
RDEPENDS:openwsman-selinux = " \
 policycoreutils-python-utils \
 policycoreutils \
 bash \
 selinux-policy \
 libselinux-utils \
 selinux-policy-targeted \
"

URI_openwsman-server = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/openwsman-server-2.7.2-9.el10.x86_64_v2.rpm;name=openwsman-server;unpack=0"
SRC_URI += "${URI_openwsman-server}"
SRC_URI[openwsman-server.sha256sum] = "14f43fe47de1c0e9ead308ce983063cd17fc93cfbf965535a3839c165d42c268"
RDEPENDS:openwsman-server = " \
 libxcrypt \
 openssl-libs \
 sblim-sfcc \
 pam-libs \
 libwsman1 \
 bash \
 ruby-libs \
 glibc \
 openwsman-selinux \
"

URI_libwsman-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libwsman-devel-2.7.2-9.el10.x86_64_v2.rpm;name=libwsman-devel;unpack=0"
SRC_URI += "${URI_libwsman-devel}"
SRC_URI[libwsman-devel.sha256sum] = "b55911c579319d9f9de4f2072e785cc86d7343883a9e3e50b4e6e09531c5663a"
RDEPENDS:libwsman-devel = " \
 libxml2-devel \
 sblim-sfcc-devel \
 pam-devel \
 pkgconf-pkg-config \
 libwsman1 \
 libcurl-devel \
 openwsman-client \
 openwsman-server \
"

URI_openwsman-client = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/openwsman-client-2.7.2-9.el10.x86_64_v2.rpm;name=openwsman-client;unpack=0"
SRC_URI += "${URI_openwsman-client}"
SRC_URI[openwsman-client.sha256sum] = "9c7990b2c32b8705513ef2592836ce977ad6b551973920e64f594a6cf24a56fd"
RDEPENDS:openwsman-client = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_openwsman-perl = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/openwsman-perl-2.7.2-9.el10.x86_64_v2.rpm;name=openwsman-perl;unpack=0"
SRC_URI += "${URI_openwsman-perl}"
SRC_URI[openwsman-perl.sha256sum] = "be3a35afd6ece619937faa3eeb04e1ea3e3734507e6e6021a9e60c4914562b67"
RDEPENDS:openwsman-perl = " \
 perl-libs \
 perl-vars \
 perl-DynaLoader \
 libwsman1 \
 perl-overload \
 glibc \
 perl-Exporter \
 perl-base \
"

URI_openwsman-winrs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/openwsman-winrs-2.7.2-9.el10.x86_64_v2.rpm;name=openwsman-winrs;unpack=0"
SRC_URI += "${URI_openwsman-winrs}"
SRC_URI[openwsman-winrs.sha256sum] = "0d7f6772fe382de1d8a1bda51ab57a3666ec7390f1e1d2fa5826a5843ef18e6c"
RDEPENDS:openwsman-winrs = " \
 rubygem-openwsman \
 ruby \
"

URI_rubygem-openwsman = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-openwsman-2.7.2-9.el10.x86_64_v2.rpm;name=rubygem-openwsman;unpack=0"
SRC_URI += "${URI_rubygem-openwsman}"
SRC_URI[rubygem-openwsman.sha256sum] = "1a8677d49f932f47bdf839e7e667a147049e3cbc5524630078e83aa1143fee2a"
RDEPENDS:rubygem-openwsman = " \
 glibc \
 rubygems \
 libwsman1 \
 ruby-libs \
"

URI_rubygem-openwsman-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-openwsman-doc-2.7.2-9.el10.noarch.rpm;name=rubygem-openwsman-doc;unpack=0"
SRC_URI += "${URI_rubygem-openwsman-doc}"
SRC_URI[rubygem-openwsman-doc.sha256sum] = "60db5b12777987fb1cd730a83e45f329acc5017a4ef804e18e393bf6d998341d"
RDEPENDS:rubygem-openwsman-doc = " \
 rubygem-openwsman \
"
