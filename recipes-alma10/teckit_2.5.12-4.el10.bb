# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "teckit"
PE = "0"
PV = "2.5.12"
PR = "4.el10"
PACKAGES = "teckit teckit-devel"
PROVIDES = "rpm/teckit rpm/teckit-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/teckit-2.5.12-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9a5e358c0fa8cfbb6d0aacb211bb30ff4615e213d4d9f18c8ccca9dcf6f5456"

URI_teckit = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/teckit-2.5.12-4.el10.x86_64_v2.rpm;name=teckit;unpack=0"
SRC_URI += "${URI_teckit}"
SRC_URI[teckit.sha256sum] = "1dcce66c272e849825b3dd95a82d25dc8b3a313e36b058fbab47b06b0cc2d402"
RDEPENDS:teckit = " \
 zlib-ng-compat \
 libgcc \
 libstdc++ \
 expat \
 glibc \
"

URI_teckit-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/teckit-devel-2.5.12-4.el10.x86_64_v2.rpm;name=teckit-devel;unpack=0"
SRC_URI += "${URI_teckit-devel}"
SRC_URI[teckit-devel.sha256sum] = "e7d1ccad4ca08971b86cd72048053dcb3fef7d751833555f02cca8dd488d3243"
RDEPENDS:teckit-devel = " \
 teckit \
 pkgconf-pkg-config \
"
