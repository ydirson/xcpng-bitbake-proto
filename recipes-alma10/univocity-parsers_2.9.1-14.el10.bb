# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "univocity-parsers"
PE = "0"
PV = "2.9.1"
PR = "14.el10"
PACKAGES = "univocity-parsers univocity-parsers-javadoc"
PROVIDES = "rpm/univocity-parsers rpm/univocity-parsers-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/univocity-parsers-2.9.1-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ef05300fa91f02da591479666634926a4455417cf504834b733ad2c2fd0c633"

URI_univocity-parsers = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/univocity-parsers-2.9.1-14.el10.noarch.rpm;name=univocity-parsers;unpack=0"
SRC_URI += "${URI_univocity-parsers}"
SRC_URI[univocity-parsers.sha256sum] = "127240d4226a9ac7016bffef075eec73778534305a1a14f8665182f1294dbc43"
RDEPENDS:univocity-parsers = " \
 javapackages-filesystem \
"

URI_univocity-parsers-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/univocity-parsers-javadoc-2.9.1-14.el10.noarch.rpm;name=univocity-parsers-javadoc;unpack=0"
SRC_URI += "${URI_univocity-parsers-javadoc}"
SRC_URI[univocity-parsers-javadoc.sha256sum] = "48bd39747a486aaa15aff19f1e705f1a6f4ad41f36340a44e46c311e0ffb9cad"
RDEPENDS:univocity-parsers-javadoc = " \
 javapackages-filesystem \
"
