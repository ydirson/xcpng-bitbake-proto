# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jakarta-activation"
PE = "0"
PV = "2.1.2"
PR = "7.el10"
PACKAGES = "jakarta-activation jakarta-activation-javadoc"
PROVIDES = "rpm/jakarta-activation rpm/jakarta-activation-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/jakarta-activation-2.1.2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6a555a97017c52efdcc87b9404c8ddd0a9ae083b4f36f5e8915dcb7c717b89f"

URI_jakarta-activation = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jakarta-activation-2.1.2-7.el10.noarch.rpm;name=jakarta-activation;unpack=0"
SRC_URI += "${URI_jakarta-activation}"
SRC_URI[jakarta-activation.sha256sum] = "47b7607d0f4a80aca613756d22ca6fb400bc8629d69589a4af8fba813cbf8b6d"
RDEPENDS:jakarta-activation = " \
 javapackages-filesystem \
"

URI_jakarta-activation-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jakarta-activation-javadoc-2.1.2-7.el10.noarch.rpm;name=jakarta-activation-javadoc;unpack=0"
SRC_URI += "${URI_jakarta-activation-javadoc}"
SRC_URI[jakarta-activation-javadoc.sha256sum] = "c856c3c3d878d410a1448114f5ae520cc2431112f97d9cdd73f901fca910b344"
RDEPENDS:jakarta-activation-javadoc = " \
 javapackages-filesystem \
"
