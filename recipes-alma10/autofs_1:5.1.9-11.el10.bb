# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "autofs"
PE = "1"
PV = "5.1.9"
PR = "11.el10"
PACKAGES = "autofs"
PROVIDES = "rpm/autofs"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/autofs-5.1.9-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b16995e09a445aa5dbc2c1a19cb12b956f8c2a9bc6fd8daf9a44a61d92ac9f78"

URI_autofs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/autofs-5.1.9-11.el10.x86_64_v2.rpm;name=autofs;unpack=0"
SRC_URI += "${URI_autofs}"
SRC_URI[autofs.sha256sum] = "d6a0dc693b5987e91765438f068cacebc0aa7de768b44b9c5196e792d1e6caa8"
RDEPENDS:autofs = " \
 systemd \
 systemd-libs \
 kmod \
 libgcc \
 gawk \
 grep \
 libxml2 \
 krb5-libs \
 cyrus-sasl-lib \
 libcom_err \
 bash \
 libtirpc \
 procps-ng \
 glibc \
 coreutils \
 sed \
 openldap \
"
