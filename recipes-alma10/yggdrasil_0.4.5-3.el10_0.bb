# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "yggdrasil"
PE = "0"
PV = "0.4.5"
PR = "3.el10_0"
PACKAGES = "yggdrasil yggdrasil-devel yggdrasil-examples"
PROVIDES = "rpm/yggdrasil rpm/yggdrasil-devel rpm/yggdrasil-examples"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/yggdrasil-0.4.5-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0447b143f2e115bda75ee118b99e0a3d1d619206f4a4d5425e740ea569705699"

URI_yggdrasil = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/yggdrasil-0.4.5-3.el10_0.x86_64_v2.rpm;name=yggdrasil;unpack=0"
SRC_URI += "${URI_yggdrasil}"
SRC_URI[yggdrasil.sha256sum] = "4f2193da43e2f356d9ff8c13e9f9df50cba26f2ed1a80c12a4a8882923276a14"
RDEPENDS:yggdrasil = " \
 glibc \
 shadow-utils \
 bash \
"

URI_yggdrasil-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/yggdrasil-devel-0.4.5-3.el10_0.x86_64_v2.rpm;name=yggdrasil-devel;unpack=0"
SRC_URI += "${URI_yggdrasil-devel}"
SRC_URI[yggdrasil-devel.sha256sum] = "5da2dea6dbefc5f3f44e38cfba724a9806c165074226cc34ab02addf6ee64021"
RDEPENDS:yggdrasil-devel = " \
 pkgconf-pkg-config \
"

URI_yggdrasil-examples = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/yggdrasil-examples-0.4.5-3.el10_0.x86_64_v2.rpm;name=yggdrasil-examples;unpack=0"
SRC_URI += "${URI_yggdrasil-examples}"
SRC_URI[yggdrasil-examples.sha256sum] = "4098fb591069d0af117760159407830748896e4c7736949f91ce464c51f31662"
RDEPENDS:yggdrasil-examples = " \
 glibc \
 yggdrasil \
"
