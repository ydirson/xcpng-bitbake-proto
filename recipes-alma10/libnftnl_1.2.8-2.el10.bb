# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libnftnl"
PE = "0"
PV = "1.2.8"
PR = "2.el10"
PACKAGES = "libnftnl libnftnl-devel"
PROVIDES = "rpm/libnftnl rpm/libnftnl-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libnftnl-1.2.8-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "650f1ffd3a0c7a7be32f48c9fcec4f5ba771d87f597a16eb8e9bcd4a81ea6e34"

URI_libnftnl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libnftnl-1.2.8-2.el10.x86_64_v2.rpm;name=libnftnl;unpack=0"
SRC_URI += "${URI_libnftnl}"
SRC_URI[libnftnl.sha256sum] = "70ab899a60391aa0ae3c66b5c4321e40228a65bee2fff924ac51fc6e7f8d0e64"
RDEPENDS:libnftnl = " \
 glibc \
 libmnl \
"

URI_libnftnl-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libnftnl-devel-1.2.8-2.el10.x86_64_v2.rpm;name=libnftnl-devel;unpack=0"
SRC_URI += "${URI_libnftnl-devel}"
SRC_URI[libnftnl-devel.sha256sum] = "38a37ea43f11ec14559f99387cf10d03066a216437abe7428416c66eb600b754"
RDEPENDS:libnftnl-devel = " \
 pkgconf-pkg-config \
 libnftnl \
 libmnl-devel \
"
