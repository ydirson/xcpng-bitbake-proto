# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rpmlint"
PE = "0"
PV = "2.5.0"
PR = "6.el10"
PACKAGES = "rpmlint"
PROVIDES = "rpm/rpmlint"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/rpmlint-2.5.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cfbc437c63801087074ecdf845dcdcd02439b2a71be93004d3a43614aae7a798"

URI_rpmlint = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rpmlint-2.5.0-6.el10.noarch.rpm;name=rpmlint;unpack=0"
SRC_URI += "${URI_rpmlint}"
SRC_URI[rpmlint.sha256sum] = "4c4c04ee5382732561ed6f42b32079adf046070eef54f681b17b441bc56f7028"
RDEPENDS:rpmlint = " \
 python3 \
 desktop-file-utils \
 python3-rpm \
 python3-file-magic \
 python3-tomli-w \
 python3-zstandard \
 rpm-build \
 python3-pyxdg \
 python3-packaging \
 python3-enchant \
 libappstream-glib \
"
