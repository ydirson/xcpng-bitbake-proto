# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "util-linux"
PE = "0"
PV = "2.40.2"
PR = "10.el10"
PACKAGES = "libblkid libfdisk libmount libsmartcols libuuid util-linux util-linux-core libblkid-devel libmount-devel libuuid-devel python3-libmount uuidd libfdisk-devel libsmartcols-devel util-linux-i18n"
PROVIDES = "rpm/libblkid rpm/libfdisk rpm/libmount rpm/libsmartcols rpm/libuuid rpm/util-linux rpm/util-linux-core rpm/libblkid-devel rpm/libmount-devel rpm/libuuid-devel rpm/python3-libmount rpm/uuidd rpm/libfdisk-devel rpm/libsmartcols-devel rpm/util-linux-i18n"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/util-linux-2.40.2-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7eff49d41760112c82d4012a8d4328dcd1b51fb4441eb23b1dfe17b76b51b0c9"

URI_libblkid = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libblkid-2.40.2-10.el10.x86_64_v2.rpm;name=libblkid;unpack=0"
SRC_URI += "${URI_libblkid}"
SRC_URI[libblkid.sha256sum] = "bfe7ae86ee4fd922864bd0b3d3b06639f5c04b207ddf993119b83f8c82d2848f"
RDEPENDS:libblkid = " \
 glibc \
 libuuid \
"

URI_libfdisk = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libfdisk-2.40.2-10.el10.x86_64_v2.rpm;name=libfdisk;unpack=0"
SRC_URI += "${URI_libfdisk}"
SRC_URI[libfdisk.sha256sum] = "36fc44a075a97301e0872fc27b23302de9a9efb6ec0e5d2b146ec0ce388d7ba7"
RDEPENDS:libfdisk = " \
 glibc \
 libuuid \
 libblkid \
"

URI_libmount = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libmount-2.40.2-10.el10.x86_64_v2.rpm;name=libmount;unpack=0"
SRC_URI += "${URI_libmount}"
SRC_URI[libmount.sha256sum] = "a0217b313ca72bc39dfce5cd2f720151a0911c6e2488f0d532990f091b40cd66"
RDEPENDS:libmount = " \
 glibc \
 libselinux \
 libuuid \
 libblkid \
"

URI_libsmartcols = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libsmartcols-2.40.2-10.el10.x86_64_v2.rpm;name=libsmartcols;unpack=0"
SRC_URI += "${URI_libsmartcols}"
SRC_URI[libsmartcols.sha256sum] = "afddc119a8b68b5533328884ab40fdaea0b6589dd83995e4de1f78ce031f30e9"
RDEPENDS:libsmartcols = " \
 glibc \
"

URI_libuuid = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libuuid-2.40.2-10.el10.x86_64_v2.rpm;name=libuuid;unpack=0"
SRC_URI += "${URI_libuuid}"
SRC_URI[libuuid.sha256sum] = "99f0f12d1f57dd818419dc0e518bc70256d45658679ce376ca857545d87e37d7"
RDEPENDS:libuuid = " \
 glibc \
"

URI_util-linux = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/util-linux-2.40.2-10.el10.x86_64_v2.rpm;name=util-linux;unpack=0"
SRC_URI += "${URI_util-linux}"
SRC_URI[util-linux.sha256sum] = "164eef71aa979d0f1f782fd5c3d77074067eb61da76f67d56267f7096bd2ab3e"
RDEPENDS:util-linux = " \
 systemd-libs \
 ncurses-libs \
 libselinux \
 libsmartcols \
 util-linux-core \
 libblkid \
 libcap-ng \
 libutempter \
 libuuid \
 zlib-ng-compat \
 libfdisk \
 audit-libs \
 authselect-libs \
 pam \
 pam-libs \
 bash \
 readline \
 libmount \
 glibc \
 coreutils \
"

URI_util-linux-core = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/util-linux-core-2.40.2-10.el10.x86_64_v2.rpm;name=util-linux-core;unpack=0"
SRC_URI += "${URI_util-linux-core}"
SRC_URI[util-linux-core.sha256sum] = "bd4709bab9efe54f2914eea1266b16dae5ad8752b67f8934cd54a1b353e51eaa"
RDEPENDS:util-linux-core = " \
 libuuid \
 systemd-libs \
 libxcrypt \
 libblkid \
 libmount \
 ncurses-libs \
 glibc \
 libselinux \
 libsmartcols \
"

URI_libblkid-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libblkid-devel-2.40.2-10.el10.x86_64_v2.rpm;name=libblkid-devel;unpack=0"
SRC_URI += "${URI_libblkid-devel}"
SRC_URI[libblkid-devel.sha256sum] = "659a712edc12521326100b196cf2c3f81a5a806a6b82c9350c80cefed4cf39c7"
RDEPENDS:libblkid-devel = " \
 libblkid \
 pkgconf-pkg-config \
"

URI_libmount-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libmount-devel-2.40.2-10.el10.x86_64_v2.rpm;name=libmount-devel;unpack=0"
SRC_URI += "${URI_libmount-devel}"
SRC_URI[libmount-devel.sha256sum] = "f089f665fe3c2792e68b4ad42a77541c62f766dc65b33ffdce07c7cbdbbfcf2d"
RDEPENDS:libmount-devel = " \
 libblkid-devel \
 libmount \
 libselinux-devel \
 pkgconf-pkg-config \
"

URI_libuuid-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libuuid-devel-2.40.2-10.el10.x86_64_v2.rpm;name=libuuid-devel;unpack=0"
SRC_URI += "${URI_libuuid-devel}"
SRC_URI[libuuid-devel.sha256sum] = "d750a4844f41d9ec88f329fda7d0645cf3895314c7d57e8b844016b8f688a748"
RDEPENDS:libuuid-devel = " \
 libuuid \
 pkgconf-pkg-config \
"

URI_python3-libmount = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-libmount-2.40.2-10.el10.x86_64_v2.rpm;name=python3-libmount;unpack=0"
SRC_URI += "${URI_python3-libmount}"
SRC_URI[python3-libmount.sha256sum] = "f2f272bb00d2a836d972ed596e5eb273e6ea27c2d1f863fedc72304bb4081dc9"
RDEPENDS:python3-libmount = " \
 python3 \
 libblkid \
 libmount \
 glibc \
 libselinux \
"

URI_uuidd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/uuidd-2.40.2-10.el10.x86_64_v2.rpm;name=uuidd;unpack=0"
SRC_URI += "${URI_uuidd}"
SRC_URI[uuidd.sha256sum] = "508588d206eb1cfde73aa06dafba48da4a13019859ffeea17a0b450c32e4c6ae"
RDEPENDS:uuidd = " \
 libuuid \
 shadow-utils \
 systemd-libs \
 bash \
 glibc \
"

URI_libfdisk-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libfdisk-devel-2.40.2-10.el10.x86_64_v2.rpm;name=libfdisk-devel;unpack=0"
SRC_URI += "${URI_libfdisk-devel}"
SRC_URI[libfdisk-devel.sha256sum] = "305602a96be3f70b0db9b7bf216450b2736b0699c130ac140fb4738f292d109c"
RDEPENDS:libfdisk-devel = " \
 libblkid-devel \
 libuuid-devel \
 pkgconf-pkg-config \
 libfdisk \
"

URI_libsmartcols-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libsmartcols-devel-2.40.2-10.el10.x86_64_v2.rpm;name=libsmartcols-devel;unpack=0"
SRC_URI += "${URI_libsmartcols-devel}"
SRC_URI[libsmartcols-devel.sha256sum] = "c6f5d13039821e92f69c122020b002cbf0af2c13ab7ac1e34415b40be537ee98"
RDEPENDS:libsmartcols-devel = " \
 pkgconf-pkg-config \
 libsmartcols \
"

URI_util-linux-i18n = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/util-linux-i18n-2.40.2-10.el10.x86_64_v2.rpm;name=util-linux-i18n;unpack=0"
SRC_URI += "${URI_util-linux-i18n}"
SRC_URI[util-linux-i18n.sha256sum] = "ae0c2fd1eae5c8477314c562f8f7e8fb431f4c3caa55ac1d129ef92ee6187e5f"
RDEPENDS:util-linux-i18n = " \
 util-linux \
"
