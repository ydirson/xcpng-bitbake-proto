# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "adcli"
PE = "0"
PV = "0.9.2"
PR = "9.el10"
PACKAGES = "adcli adcli-doc"
PROVIDES = "rpm/adcli rpm/adcli-doc"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/adcli-0.9.2-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6de52db5750c2ba8433a30adbc259d7866fb12e8a8d4e1ea33f59205d3f5e660"

URI_adcli = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/adcli-0.9.2-9.el10.x86_64_v2.rpm;name=adcli;unpack=0"
SRC_URI += "${URI_adcli}"
SRC_URI[adcli.sha256sum] = "779bbb8f582bf6779cb1a76eb8c65521cd54b1e016a08739f779d6f594407060"
RDEPENDS:adcli = " \
 glibc \
 krb5-libs \
 cyrus-sasl-gssapi \
 openldap \
"

URI_adcli-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/adcli-doc-0.9.2-9.el10.noarch.rpm;name=adcli-doc;unpack=0"
SRC_URI += "${URI_adcli-doc}"
SRC_URI[adcli-doc.sha256sum] = "c7a2b9d5a65468d7974b22c437887e89defa8015bdb4c36e98b37f82f4e9e3ab"
RDEPENDS:adcli-doc = ""
