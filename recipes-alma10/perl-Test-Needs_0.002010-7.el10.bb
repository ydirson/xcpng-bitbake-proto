# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Test-Needs"
PE = "0"
PV = "0.002010"
PR = "7.el10"
PACKAGES = "perl-Test-Needs perl-Test-Needs-tests"
PROVIDES = "rpm/perl-Test-Needs rpm/perl-Test-Needs-tests"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-Test-Needs-0.002010-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3fdbca31ac9434aed8e393602ffb706f5f5cb99bbe2bd98cfb7844f9e548810d"

URI_perl-Test-Needs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Test-Needs-0.002010-7.el10.noarch.rpm;name=perl-Test-Needs;unpack=0"
SRC_URI += "${URI_perl-Test-Needs}"
SRC_URI[perl-Test-Needs.sha256sum] = "e9a1090b521e3b3366ab9e4d428ea16fd391320a6ed4716c4eb480d32570ac24"
RDEPENDS:perl-Test-Needs = " \
 perl-libs \
"

URI_perl-Test-Needs-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Test-Needs-tests-0.002010-7.el10.noarch.rpm;name=perl-Test-Needs-tests;unpack=0"
SRC_URI += "${URI_perl-Test-Needs-tests}"
SRC_URI[perl-Test-Needs-tests.sha256sum] = "d0aec9ab597400653282ecab35956c3d9f6dba8d7ba142bfbaef2cadbcfd2be9"
RDEPENDS:perl-Test-Needs-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-IPC-Open3 \
 bash \
 perl-Test-Needs \
 perl-interpreter \
 perl-lib \
"
