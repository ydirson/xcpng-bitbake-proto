# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "alsa-lib"
PE = "0"
PV = "1.2.13"
PR = "2.el10"
PACKAGES = "alsa-lib alsa-lib-devel alsa-ucm alsa-topology"
PROVIDES = "rpm/alsa-lib rpm/alsa-lib-devel rpm/alsa-ucm rpm/alsa-topology"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/alsa-lib-1.2.13-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8fb90f0c6cb00235e5e35b769d206a45a1082b46d9fc726a86969bb7296db4e"

URI_alsa-lib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/alsa-lib-1.2.13-2.el10.x86_64_v2.rpm;name=alsa-lib;unpack=0"
SRC_URI += "${URI_alsa-lib}"
SRC_URI[alsa-lib.sha256sum] = "e4d8bd5330136498cd623878bfc16e01d37b415a32946cff0adb3bb5abaca452"
RDEPENDS:alsa-lib = " \
 glibc \
"

URI_alsa-lib-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/alsa-lib-devel-1.2.13-2.el10.x86_64_v2.rpm;name=alsa-lib-devel;unpack=0"
SRC_URI += "${URI_alsa-lib-devel}"
SRC_URI[alsa-lib-devel.sha256sum] = "d2f37e916ddbc0efa4c6dfa5a2081af01aee00c8d78d31a3010e65d69f6acf1e"
RDEPENDS:alsa-lib-devel = " \
 alsa-lib \
 alsa-lib-devel \
 pkgconf-pkg-config \
"

URI_alsa-ucm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/alsa-ucm-1.2.13-2.el10.noarch.rpm;name=alsa-ucm;unpack=0"
SRC_URI += "${URI_alsa-ucm}"
SRC_URI[alsa-ucm.sha256sum] = "1d897338a7e0478ebcc4aa0389e19ad1d25b89f937ab5f2715d9f69ccee9556a"
RDEPENDS:alsa-ucm = " \
 alsa-lib \
"

URI_alsa-topology = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/alsa-topology-1.2.13-2.el10.noarch.rpm;name=alsa-topology;unpack=0"
SRC_URI += "${URI_alsa-topology}"
SRC_URI[alsa-topology.sha256sum] = "113536a5815cedbec1d2f272bb58009f248ab973469da71bee013b5b2dfc32c4"
RDEPENDS:alsa-topology = " \
 alsa-lib \
"
