# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-decorator"
PE = "0"
PV = "5.1.1"
PR = "12.el10"
PACKAGES = "python3-decorator"
PROVIDES = "rpm/python3-decorator"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/python-decorator-5.1.1-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ee22cba4d1a7c2fabf34121223e3f2212040261318e4a9a7e716cf017e17ea3"

URI_python3-decorator = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-decorator-5.1.1-12.el10.noarch.rpm;name=python3-decorator;unpack=0"
SRC_URI += "${URI_python3-decorator}"
SRC_URI[python3-decorator.sha256sum] = "6424e661561fcc4d1aad01d23bd7362bca11c5071abeed91bc5583d81b194c51"
RDEPENDS:python3-decorator = " \
 python3 \
"
