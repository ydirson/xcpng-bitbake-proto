# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-el"
PE = "1"
PV = "0.9"
PR = "18.el10"
PACKAGES = "hunspell-el"
PROVIDES = "rpm/hunspell-el"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-el-0.9-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8114a48e35cf52e84c5064c111eede9ce0a0f5a5f8fc2f6f17fd577a7fef8dde"

URI_hunspell-el = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-el-0.9-18.el10.noarch.rpm;name=hunspell-el;unpack=0"
SRC_URI += "${URI_hunspell-el}"
SRC_URI[hunspell-el.sha256sum] = "8c57bba837ef173665238c03c2701cc06ef0616045af160041196e2f1cd75628"
RDEPENDS:hunspell-el = " \
 hunspell-filesystem \
"
