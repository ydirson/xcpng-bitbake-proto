# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Params-Util"
PE = "0"
PV = "1.102"
PR = "19.el10"
PACKAGES = "perl-Params-Util perl-Params-Util-tests"
PROVIDES = "rpm/perl-Params-Util rpm/perl-Params-Util-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Params-Util-1.102-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8898466f2815634de115a533c382cf51535cebfaf56ea1f0b01e8ca894c83a78"

URI_perl-Params-Util = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Params-Util-1.102-19.el10.x86_64_v2.rpm;name=perl-Params-Util;unpack=0"
SRC_URI += "${URI_perl-Params-Util}"
SRC_URI[perl-Params-Util.sha256sum] = "ac59bbb594b113f68799ca15ec6b53453e5a284c8e13c87db9691a21b5a017bc"
RDEPENDS:perl-Params-Util = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-overload \
 perl-Params-Util \
 perl-parent \
 glibc \
 perl-Exporter \
"

URI_perl-Params-Util-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Params-Util-tests-1.102-19.el10.x86_64_v2.rpm;name=perl-Params-Util-tests;unpack=0"
SRC_URI += "${URI_perl-Params-Util-tests}"
SRC_URI[perl-Params-Util-tests.sha256sum] = "c954dde562ae2b4de7b63dc702a13241a06869061612c18e9620d904a94d4073"
RDEPENDS:perl-Params-Util-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-vars \
 perl-overload \
 perl-Params-Util \
 bash \
 perl-PathTools \
 perl-interpreter \
"
