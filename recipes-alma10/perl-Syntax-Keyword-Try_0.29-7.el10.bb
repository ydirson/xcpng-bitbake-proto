# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Syntax-Keyword-Try"
PE = "0"
PV = "0.29"
PR = "7.el10"
PACKAGES = "perl-Syntax-Keyword-Try perl-Syntax-Keyword-Try-tests"
PROVIDES = "rpm/perl-Syntax-Keyword-Try rpm/perl-Syntax-Keyword-Try-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Syntax-Keyword-Try-0.29-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0254d24402de1f77ecf8a2e1313f55df02266cde2c4cf9499bffb690441321a"

URI_perl-Syntax-Keyword-Try = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Syntax-Keyword-Try-0.29-7.el10.x86_64_v2.rpm;name=perl-Syntax-Keyword-Try;unpack=0"
SRC_URI += "${URI_perl-Syntax-Keyword-Try}"
SRC_URI[perl-Syntax-Keyword-Try.sha256sum] = "886622aefa285454c4f555fd643c3b89c32ad7c6acc9fd306efa0162bd2fc1be"
RDEPENDS:perl-Syntax-Keyword-Try = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-XS-Parse-Keyword \
 perl-B \
 glibc \
"

URI_perl-Syntax-Keyword-Try-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Syntax-Keyword-Try-tests-0.29-7.el10.x86_64_v2.rpm;name=perl-Syntax-Keyword-Try-tests;unpack=0"
SRC_URI += "${URI_perl-Syntax-Keyword-Try-tests}"
SRC_URI[perl-Syntax-Keyword-Try-tests.sha256sum] = "ba4fa43b113a1d1a88a19eac8b1a7155efbe74c68f9da299ab3f907f7d912945"
RDEPENDS:perl-Syntax-Keyword-Try-tests = " \
 perl-threads \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Test2-Suite \
 perl-overload \
 bash \
 perl-B \
 perl-Syntax-Keyword-Try \
 perl-interpreter \
"
