# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "SDL3"
PE = "0"
PV = "3.2.4"
PR = "1.el10"
PACKAGES = "SDL3 SDL3-devel SDL3-test"
PROVIDES = "rpm/SDL3 rpm/SDL3-devel rpm/SDL3-test"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/SDL3-3.2.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f625a75ac88a1da4164ebd98cc4c0d85fe16e6728a25eb8c9eadbe7c2072142"

URI_SDL3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/SDL3-3.2.4-1.el10.x86_64_v2.rpm;name=SDL3;unpack=0"
SRC_URI += "${URI_SDL3}"
SRC_URI[SDL3.sha256sum] = "3553c4b8bf6d7627c0885cfcb4efa668c54544d41695866e24579f2f4b7994ff"
RDEPENDS:SDL3 = " \
 glibc \
 libdecor \
"

URI_SDL3-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/SDL3-devel-3.2.4-1.el10.x86_64_v2.rpm;name=SDL3-devel;unpack=0"
SRC_URI += "${URI_SDL3-devel}"
SRC_URI[SDL3-devel.sha256sum] = "ff20d297d179d830036721928077464ea821cae2dabc59587b8ce884acd975a7"
RDEPENDS:SDL3-devel = " \
 cmake-filesystem \
 libglvnd-devel \
 pkgconf-pkg-config \
 libX11-devel \
 xorg-x11-proto-devel \
 mesa-libGLU-devel \
 SDL3 \
"

URI_SDL3-test = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/SDL3-test-3.2.4-1.el10.x86_64_v2.rpm;name=SDL3-test;unpack=0"
SRC_URI += "${URI_SDL3-test}"
SRC_URI[SDL3-test.sha256sum] = "ee52a7f765687713b8b7c71ede87ab9e7f42c4893c550963c2dc10dfa73f63df"
RDEPENDS:SDL3-test = " \
 SDL3-devel \
"
