# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "stix-fonts"
PE = "0"
PV = "2.13b171"
PR = "8.el10"
PACKAGES = "stix-fonts stix-fonts-doc"
PROVIDES = "rpm/stix-fonts rpm/stix-fonts-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/stix-fonts-2.13b171-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99e229d6a4a02e87fd11a6dffb318d4f13796f4b6d5d8334c7050363ed13899b"

URI_stix-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/stix-fonts-2.13b171-8.el10.noarch.rpm;name=stix-fonts;unpack=0"
SRC_URI += "${URI_stix-fonts}"
SRC_URI[stix-fonts.sha256sum] = "061476ac526ba605bcf920265a3e64ea42011db467bd8c1841b7d26011406c5c"
RDEPENDS:stix-fonts = " \
 fonts-filesystem \
"

URI_stix-fonts-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/stix-fonts-doc-2.13b171-8.el10.noarch.rpm;name=stix-fonts-doc;unpack=0"
SRC_URI += "${URI_stix-fonts-doc}"
SRC_URI[stix-fonts-doc.sha256sum] = "b4650d26fb968c06471b33b3a49c9d18d7a03421b542746dd8a6089baea8308c"
RDEPENDS:stix-fonts-doc = ""
