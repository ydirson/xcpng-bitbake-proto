# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "texlive"
PE = "13"
PV = "20240311"
PR = "6.el10"
PACKAGES = "texlive texlive-acronym texlive-adjustbox texlive-ae texlive-algorithms texlive-alphalph texlive-amscls texlive-amsfonts texlive-amsmath texlive-anyfontsize texlive-anysize texlive-appendix texlive-arphic texlive-atbegshi texlive-attachfile texlive-attachfile2 texlive-atveryend texlive-auxhook texlive-avantgar texlive-awesomebox texlive-babel texlive-babel-english texlive-babelbib texlive-base texlive-beamer texlive-bera texlive-beton texlive-bibtex texlive-bibtopic texlive-bidi texlive-bigfoot texlive-bigintcalc texlive-bitset texlive-bookman texlive-bookmark texlive-booktabs texlive-breakurl texlive-breqn texlive-capt-of texlive-caption texlive-carlisle texlive-catchfile texlive-changebar texlive-changepage texlive-charter texlive-chngcntr texlive-cite texlive-classpack texlive-cm texlive-cm-lgc texlive-cm-super texlive-cmap texlive-cmextra texlive-cns texlive-collectbox texlive-collection-basic texlive-collection-fontsrecommended texlive-collection-htmlxml texlive-collection-latex texlive-collection-latexrecommended texlive-collection-xetex texlive-colorprofiles texlive-colortbl texlive-context texlive-count1to texlive-courier texlive-crop texlive-csquotes texlive-ctable texlive-ctablestack texlive-currfile texlive-datetime texlive-dehyph texlive-dvipdfmx texlive-dvipng texlive-dvips texlive-dvisvgm texlive-ec texlive-eepic texlive-enctex texlive-enumitem texlive-environ texlive-epsf texlive-epstopdf texlive-epstopdf-pkg texlive-eqparbox texlive-eso-pic texlive-etex texlive-etex-pkg texlive-etexcmds texlive-etoc texlive-etoolbox texlive-euenc texlive-euler texlive-euro texlive-eurosym texlive-everysel texlive-everyshi texlive-extsizes texlive-fancybox texlive-fancyhdr texlive-fancyref texlive-fancyvrb texlive-filecontents texlive-filehook texlive-finstrut texlive-firstaid texlive-fix2col texlive-fixlatvian texlive-float texlive-fmtcount texlive-fncychap texlive-fontawesome texlive-fontbook texlive-fonts-tlwg texlive-fontspec texlive-fontware texlive-fontwrap texlive-footmisc texlive-footnotehyper texlive-fp texlive-fpl texlive-framed texlive-garuda-c90 texlive-geometry texlive-gettitlestring texlive-glyphlist texlive-graphics texlive-graphics-cfg texlive-graphics-def texlive-grfext texlive-grffile texlive-gsftopk texlive-hanging texlive-helvetic texlive-hobsub texlive-hologo texlive-hopatch texlive-hycolor texlive-hypcap texlive-hypdoc texlive-hyperref texlive-hyph-utf8 texlive-hyphen-base texlive-hyphenat texlive-hyphenex texlive-ifmtarg texlive-ifoddpage texlive-ifplatform texlive-iftex texlive-import texlive-index texlive-infwarerr texlive-intcalc texlive-jadetex texlive-jknapltx texlive-kastrup texlive-kerkis texlive-knuth-lib texlive-knuth-local texlive-koma-script texlive-kpathsea texlive-kvdefinekeys texlive-kvoptions texlive-kvsetkeys texlive-l3backend texlive-l3experimental texlive-l3kernel texlive-l3packages texlive-lastpage texlive-latex texlive-latex-fonts texlive-latex2man texlive-latexbug texlive-latexconfig texlive-letltxmacro texlive-lettrine texlive-lib texlive-linegoal texlive-lineno texlive-listings texlive-listofitems texlive-lm texlive-lm-math texlive-ltabptch texlive-ltxcmds texlive-ltxmisc texlive-lua-alt-getopt texlive-lua-uni-algos texlive-luahbtex texlive-lualatex-math texlive-lualibs texlive-luaotfload texlive-luatex texlive-luatex85 texlive-luatexbase texlive-lwarp texlive-makecmds texlive-makeindex texlive-manfnt-font texlive-marginnote texlive-marvosym texlive-mathpazo texlive-mathspec texlive-mathtools texlive-mdwtools texlive-memoir texlive-metafont texlive-metalogo texlive-metapost texlive-mflogo texlive-mflogo-font texlive-mfnfss texlive-mfware texlive-microtype texlive-minitoc texlive-mnsymbol texlive-modes texlive-mparhack texlive-mptopdf texlive-multido texlive-multirow texlive-multitoc texlive-natbib texlive-ncctools texlive-ncntrsbk texlive-needspace texlive-newfloat texlive-newunicodechar texlive-norasi-c90 texlive-notoccite texlive-ntgclass texlive-oberdiek texlive-overpic texlive-palatino texlive-paralist texlive-parallel texlive-parskip texlive-passivetex texlive-pdfcol texlive-pdfcolfoot texlive-pdfcolmk texlive-pdfescape texlive-pdflscape texlive-pdfmanagement-testphase texlive-pdfpages texlive-pdftex texlive-pdftexcmds texlive-pgf texlive-philokalia texlive-placeins texlive-plain texlive-polyglossia texlive-powerdot texlive-preprint texlive-psfrag texlive-pslatex texlive-psnfss texlive-pspicture texlive-pst-3d texlive-pst-arrow texlive-pst-blur texlive-pst-coil texlive-pst-eps texlive-pst-fill texlive-pst-grad texlive-pst-math texlive-pst-node texlive-pst-plot texlive-pst-slpe texlive-pst-text texlive-pst-tools texlive-pst-tree texlive-pstricks texlive-pstricks-add texlive-ptext texlive-pxfonts texlive-qstest texlive-ragged2e texlive-rcs texlive-realscripts texlive-refcount texlive-relsize texlive-rerunfilecheck texlive-rsfs texlive-sansmath texlive-sansmathaccent texlive-sauerj texlive-scheme-basic texlive-section texlive-sectsty texlive-seminar texlive-sepnum texlive-setspace texlive-sfmath texlive-showexpl texlive-soul texlive-stackengine texlive-stmaryrd texlive-stringenc texlive-subfig texlive-subfigure texlive-svn-prov texlive-symbol texlive-t2 texlive-tabu texlive-tabulary texlive-tex texlive-tex-gyre texlive-tex-gyre-math texlive-tex-ini-files texlive-tex4ht texlive-texlive-common-doc texlive-texlive-en texlive-texlive-msg-translations texlive-texlive-scripts texlive-texlive-scripts-extra texlive-texlive.infra texlive-textcase texlive-textpos texlive-threeparttable texlive-thumbpdf texlive-times texlive-tipa texlive-titlesec texlive-titling texlive-tocloft texlive-tools texlive-translator texlive-trimspaces texlive-txfonts texlive-type1cm texlive-typehtml texlive-ucharcat texlive-ucharclasses texlive-ucs texlive-uhc texlive-ulem texlive-underscore texlive-unicode-data texlive-unicode-math texlive-uniquecounter texlive-unisugar texlive-upquote texlive-url texlive-utopia texlive-varwidth texlive-wadalab texlive-was texlive-wasy texlive-wasy-type1 texlive-wasysym texlive-wrapfig texlive-xcolor texlive-xecolor texlive-xecyr texlive-xeindex texlive-xepersian texlive-xesearch texlive-xetex texlive-xetex-itrans texlive-xetex-pstricks texlive-xetexconfig texlive-xetexfontinfo texlive-xfrac texlive-xifthen texlive-xkeyval texlive-xltxtra texlive-xmltex texlive-xpatch texlive-xstring texlive-xtab texlive-xunicode texlive-zapfchan texlive-zapfding texlive-zref texlive-gnu-freefont texlive-lib-devel"
PROVIDES = "rpm/texlive rpm/texlive-acronym rpm/texlive-adjustbox rpm/texlive-ae rpm/texlive-algorithms rpm/texlive-alphalph rpm/texlive-amscls rpm/texlive-amsfonts rpm/texlive-amsmath rpm/texlive-anyfontsize rpm/texlive-anysize rpm/texlive-appendix rpm/texlive-arphic rpm/texlive-atbegshi rpm/texlive-attachfile rpm/texlive-attachfile2 rpm/texlive-atveryend rpm/texlive-auxhook rpm/texlive-avantgar rpm/texlive-awesomebox rpm/texlive-babel rpm/texlive-babel-english rpm/texlive-babelbib rpm/texlive-base rpm/texlive-beamer rpm/texlive-bera rpm/texlive-beton rpm/texlive-bibtex rpm/texlive-bibtopic rpm/texlive-bidi rpm/texlive-bigfoot rpm/texlive-bigintcalc rpm/texlive-bitset rpm/texlive-bookman rpm/texlive-bookmark rpm/texlive-booktabs rpm/texlive-breakurl rpm/texlive-breqn rpm/texlive-capt-of rpm/texlive-caption rpm/texlive-carlisle rpm/texlive-catchfile rpm/texlive-changebar rpm/texlive-changepage rpm/texlive-charter rpm/texlive-chngcntr rpm/texlive-cite rpm/texlive-classpack rpm/texlive-cm rpm/texlive-cm-lgc rpm/texlive-cm-super rpm/texlive-cmap rpm/texlive-cmextra rpm/texlive-cns rpm/texlive-collectbox rpm/texlive-collection-basic rpm/texlive-collection-fontsrecommended rpm/texlive-collection-htmlxml rpm/texlive-collection-latex rpm/texlive-collection-latexrecommended rpm/texlive-collection-xetex rpm/texlive-colorprofiles rpm/texlive-colortbl rpm/texlive-context rpm/texlive-count1to rpm/texlive-courier rpm/texlive-crop rpm/texlive-csquotes rpm/texlive-ctable rpm/texlive-ctablestack rpm/texlive-currfile rpm/texlive-datetime rpm/texlive-dehyph rpm/texlive-dvipdfmx rpm/texlive-dvipng rpm/texlive-dvips rpm/texlive-dvisvgm rpm/texlive-ec rpm/texlive-eepic rpm/texlive-enctex rpm/texlive-enumitem rpm/texlive-environ rpm/texlive-epsf rpm/texlive-epstopdf rpm/texlive-epstopdf-pkg rpm/texlive-eqparbox rpm/texlive-eso-pic rpm/texlive-etex rpm/texlive-etex-pkg rpm/texlive-etexcmds rpm/texlive-etoc rpm/texlive-etoolbox rpm/texlive-euenc rpm/texlive-euler rpm/texlive-euro rpm/texlive-eurosym rpm/texlive-everysel rpm/texlive-everyshi rpm/texlive-extsizes rpm/texlive-fancybox rpm/texlive-fancyhdr rpm/texlive-fancyref rpm/texlive-fancyvrb rpm/texlive-filecontents rpm/texlive-filehook rpm/texlive-finstrut rpm/texlive-firstaid rpm/texlive-fix2col rpm/texlive-fixlatvian rpm/texlive-float rpm/texlive-fmtcount rpm/texlive-fncychap rpm/texlive-fontawesome rpm/texlive-fontbook rpm/texlive-fonts-tlwg rpm/texlive-fontspec rpm/texlive-fontware rpm/texlive-fontwrap rpm/texlive-footmisc rpm/texlive-footnotehyper rpm/texlive-fp rpm/texlive-fpl rpm/texlive-framed rpm/texlive-garuda-c90 rpm/texlive-geometry rpm/texlive-gettitlestring rpm/texlive-glyphlist rpm/texlive-graphics rpm/texlive-graphics-cfg rpm/texlive-graphics-def rpm/texlive-grfext rpm/texlive-grffile rpm/texlive-gsftopk rpm/texlive-hanging rpm/texlive-helvetic rpm/texlive-hobsub rpm/texlive-hologo rpm/texlive-hopatch rpm/texlive-hycolor rpm/texlive-hypcap rpm/texlive-hypdoc rpm/texlive-hyperref rpm/texlive-hyph-utf8 rpm/texlive-hyphen-base rpm/texlive-hyphenat rpm/texlive-hyphenex rpm/texlive-ifmtarg rpm/texlive-ifoddpage rpm/texlive-ifplatform rpm/texlive-iftex rpm/texlive-import rpm/texlive-index rpm/texlive-infwarerr rpm/texlive-intcalc rpm/texlive-jadetex rpm/texlive-jknapltx rpm/texlive-kastrup rpm/texlive-kerkis rpm/texlive-knuth-lib rpm/texlive-knuth-local rpm/texlive-koma-script rpm/texlive-kpathsea rpm/texlive-kvdefinekeys rpm/texlive-kvoptions rpm/texlive-kvsetkeys rpm/texlive-l3backend rpm/texlive-l3experimental rpm/texlive-l3kernel rpm/texlive-l3packages rpm/texlive-lastpage rpm/texlive-latex rpm/texlive-latex-fonts rpm/texlive-latex2man rpm/texlive-latexbug rpm/texlive-latexconfig rpm/texlive-letltxmacro rpm/texlive-lettrine rpm/texlive-lib rpm/texlive-linegoal rpm/texlive-lineno rpm/texlive-listings rpm/texlive-listofitems rpm/texlive-lm rpm/texlive-lm-math rpm/texlive-ltabptch rpm/texlive-ltxcmds rpm/texlive-ltxmisc rpm/texlive-lua-alt-getopt rpm/texlive-lua-uni-algos rpm/texlive-luahbtex rpm/texlive-lualatex-math rpm/texlive-lualibs rpm/texlive-luaotfload rpm/texlive-luatex rpm/texlive-luatex85 rpm/texlive-luatexbase rpm/texlive-lwarp rpm/texlive-makecmds rpm/texlive-makeindex rpm/texlive-manfnt-font rpm/texlive-marginnote rpm/texlive-marvosym rpm/texlive-mathpazo rpm/texlive-mathspec rpm/texlive-mathtools rpm/texlive-mdwtools rpm/texlive-memoir rpm/texlive-metafont rpm/texlive-metalogo rpm/texlive-metapost rpm/texlive-mflogo rpm/texlive-mflogo-font rpm/texlive-mfnfss rpm/texlive-mfware rpm/texlive-microtype rpm/texlive-minitoc rpm/texlive-mnsymbol rpm/texlive-modes rpm/texlive-mparhack rpm/texlive-mptopdf rpm/texlive-multido rpm/texlive-multirow rpm/texlive-multitoc rpm/texlive-natbib rpm/texlive-ncctools rpm/texlive-ncntrsbk rpm/texlive-needspace rpm/texlive-newfloat rpm/texlive-newunicodechar rpm/texlive-norasi-c90 rpm/texlive-notoccite rpm/texlive-ntgclass rpm/texlive-oberdiek rpm/texlive-overpic rpm/texlive-palatino rpm/texlive-paralist rpm/texlive-parallel rpm/texlive-parskip rpm/texlive-passivetex rpm/texlive-pdfcol rpm/texlive-pdfcolfoot rpm/texlive-pdfcolmk rpm/texlive-pdfescape rpm/texlive-pdflscape rpm/texlive-pdfmanagement-testphase rpm/texlive-pdfpages rpm/texlive-pdftex rpm/texlive-pdftexcmds rpm/texlive-pgf rpm/texlive-philokalia rpm/texlive-placeins rpm/texlive-plain rpm/texlive-polyglossia rpm/texlive-powerdot rpm/texlive-preprint rpm/texlive-psfrag rpm/texlive-pslatex rpm/texlive-psnfss rpm/texlive-pspicture rpm/texlive-pst-3d rpm/texlive-pst-arrow rpm/texlive-pst-blur rpm/texlive-pst-coil rpm/texlive-pst-eps rpm/texlive-pst-fill rpm/texlive-pst-grad rpm/texlive-pst-math rpm/texlive-pst-node rpm/texlive-pst-plot rpm/texlive-pst-slpe rpm/texlive-pst-text rpm/texlive-pst-tools rpm/texlive-pst-tree rpm/texlive-pstricks rpm/texlive-pstricks-add rpm/texlive-ptext rpm/texlive-pxfonts rpm/texlive-qstest rpm/texlive-ragged2e rpm/texlive-rcs rpm/texlive-realscripts rpm/texlive-refcount rpm/texlive-relsize rpm/texlive-rerunfilecheck rpm/texlive-rsfs rpm/texlive-sansmath rpm/texlive-sansmathaccent rpm/texlive-sauerj rpm/texlive-scheme-basic rpm/texlive-section rpm/texlive-sectsty rpm/texlive-seminar rpm/texlive-sepnum rpm/texlive-setspace rpm/texlive-sfmath rpm/texlive-showexpl rpm/texlive-soul rpm/texlive-stackengine rpm/texlive-stmaryrd rpm/texlive-stringenc rpm/texlive-subfig rpm/texlive-subfigure rpm/texlive-svn-prov rpm/texlive-symbol rpm/texlive-t2 rpm/texlive-tabu rpm/texlive-tabulary rpm/texlive-tex rpm/texlive-tex-gyre rpm/texlive-tex-gyre-math rpm/texlive-tex-ini-files rpm/texlive-tex4ht rpm/texlive-texlive-common-doc rpm/texlive-texlive-en rpm/texlive-texlive-msg-translations rpm/texlive-texlive-scripts rpm/texlive-texlive-scripts-extra rpm/texlive-texlive.infra rpm/texlive-textcase rpm/texlive-textpos rpm/texlive-threeparttable rpm/texlive-thumbpdf rpm/texlive-times rpm/texlive-tipa rpm/texlive-titlesec rpm/texlive-titling rpm/texlive-tocloft rpm/texlive-tools rpm/texlive-translator rpm/texlive-trimspaces rpm/texlive-txfonts rpm/texlive-type1cm rpm/texlive-typehtml rpm/texlive-ucharcat rpm/texlive-ucharclasses rpm/texlive-ucs rpm/texlive-uhc rpm/texlive-ulem rpm/texlive-underscore rpm/texlive-unicode-data rpm/texlive-unicode-math rpm/texlive-uniquecounter rpm/texlive-unisugar rpm/texlive-upquote rpm/texlive-url rpm/texlive-utopia rpm/texlive-varwidth rpm/texlive-wadalab rpm/texlive-was rpm/texlive-wasy rpm/texlive-wasy-type1 rpm/texlive-wasysym rpm/texlive-wrapfig rpm/texlive-xcolor rpm/texlive-xecolor rpm/texlive-xecyr rpm/texlive-xeindex rpm/texlive-xepersian rpm/texlive-xesearch rpm/texlive-xetex rpm/texlive-xetex-itrans rpm/texlive-xetex-pstricks rpm/texlive-xetexconfig rpm/texlive-xetexfontinfo rpm/texlive-xfrac rpm/texlive-xifthen rpm/texlive-xkeyval rpm/texlive-xltxtra rpm/texlive-xmltex rpm/texlive-xpatch rpm/texlive-xstring rpm/texlive-xtab rpm/texlive-xunicode rpm/texlive-zapfchan rpm/texlive-zapfding rpm/texlive-zref rpm/texlive-gnu-freefont rpm/texlive-lib-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/texlive-20240311-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc11136704c59ce5bf645e6f8a4d3558ecb52919ca663583fe135f6ed8c19d1b"

URI_texlive = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-20240311-6.el10.x86_64_v2.rpm;name=texlive;unpack=0"
SRC_URI += "${URI_texlive}"
SRC_URI[texlive.sha256sum] = "46baedf95e65d4fc6dabdbfdd333b15279050019b143d6f840d3304ef60472cc"
RDEPENDS:texlive = " \
 texlive-scheme-basic \
 texlive-collection-latexrecommended \
 texlive-kpathsea \
"

URI_texlive-acronym = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-acronym-20240311-6.el10.noarch.rpm;name=texlive-acronym;unpack=0"
SRC_URI += "${URI_texlive-acronym}"
SRC_URI[texlive-acronym.sha256sum] = "8ebfe009fc3ee905809b42382a7f3a9642b47db7f1360d62765d75c76745b9a0"
RDEPENDS:texlive-acronym = " \
 texlive-relsize \
 texlive-bigfoot \
 texlive-kpathsea \
 texlive-xstring \
 texlive-base \
"

URI_texlive-adjustbox = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-adjustbox-20240311-6.el10.noarch.rpm;name=texlive-adjustbox;unpack=0"
SRC_URI += "${URI_texlive-adjustbox}"
SRC_URI[texlive-adjustbox.sha256sum] = "050ef80bec4e63aed5aa36779ed607f9b24660664be97c573cb5730b7b2b3863"
RDEPENDS:texlive-adjustbox = " \
 texlive-pgf \
 texlive-varwidth \
 texlive-graphics \
 texlive-kpathsea \
 texlive-tools \
 texlive-xkeyval \
 texlive-ifoddpage \
 texlive-collectbox \
 texlive-base \
"

URI_texlive-ae = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-ae-20240311-6.el10.noarch.rpm;name=texlive-ae;unpack=0"
SRC_URI += "${URI_texlive-ae}"
SRC_URI[texlive-ae.sha256sum] = "448937bf45289972e3f920da4d5c14003348ce074c5ef1d923ed0d743b35a7f9"
RDEPENDS:texlive-ae = " \
 texlive-kpathsea \
 texlive-latex \
 texlive-base \
"

URI_texlive-algorithms = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-algorithms-20240311-6.el10.noarch.rpm;name=texlive-algorithms;unpack=0"
SRC_URI += "${URI_texlive-algorithms}"
SRC_URI[texlive-algorithms.sha256sum] = "ba8d182c052fc2baf6af369c9b7c0cf098d4a9f451e9a0feb2b57be41d3bdd00"
RDEPENDS:texlive-algorithms = " \
 texlive-graphics \
 texlive-kpathsea \
 texlive-latex \
 texlive-float \
 texlive-base \
"

URI_texlive-alphalph = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-alphalph-20240311-6.el10.noarch.rpm;name=texlive-alphalph;unpack=0"
SRC_URI += "${URI_texlive-alphalph}"
SRC_URI[texlive-alphalph.sha256sum] = "c93a570fcf2b97ca72634f1b163e1d0778b8a36634e099d387f11ec90eb4e17f"
RDEPENDS:texlive-alphalph = " \
 texlive-kpathsea \
"

URI_texlive-amscls = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-amscls-20240311-6.el10.noarch.rpm;name=texlive-amscls;unpack=0"
SRC_URI += "${URI_texlive-amscls}"
SRC_URI[texlive-amscls.sha256sum] = "8fb0beb912449c54901ef8a4a81bdaa46b750ede0c8f846dcb62753bd613ca4e"
RDEPENDS:texlive-amscls = " \
 texlive-url \
 texlive-kpathsea \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-latex \
 texlive-base \
"

URI_texlive-amsfonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-amsfonts-20240311-6.el10.noarch.rpm;name=texlive-amsfonts;unpack=0"
SRC_URI += "${URI_texlive-amsfonts}"
SRC_URI[texlive-amsfonts.sha256sum] = "9dc5bfd237ae6ba1241c1cfa0c026550681b2e0d4b4fc2b9e8ad78d4baac32df"
RDEPENDS:texlive-amsfonts = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-amsmath = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-amsmath-20240311-6.el10.noarch.rpm;name=texlive-amsmath;unpack=0"
SRC_URI += "${URI_texlive-amsmath}"
SRC_URI[texlive-amsmath.sha256sum] = "000e53b4859706852b926824082a77c106b6cc4a84c0250f823fe3045d2a0be4"
RDEPENDS:texlive-amsmath = " \
 texlive-kpathsea \
 texlive-base \
 texlive-amsmath \
"

URI_texlive-anyfontsize = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-anyfontsize-20240311-6.el10.noarch.rpm;name=texlive-anyfontsize;unpack=0"
SRC_URI += "${URI_texlive-anyfontsize}"
SRC_URI[texlive-anyfontsize.sha256sum] = "33b3308469d94392bf6e7eb0c65d599c424f9d2b32ee3cfe34ced0ed2a310c5a"
RDEPENDS:texlive-anyfontsize = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-anysize = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-anysize-20240311-6.el10.noarch.rpm;name=texlive-anysize;unpack=0"
SRC_URI += "${URI_texlive-anysize}"
SRC_URI[texlive-anysize.sha256sum] = "7db26b44fc4611f170a1a0abe301f79afac6994c96456c72652b06ef7742c62e"
RDEPENDS:texlive-anysize = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-appendix = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-appendix-20240311-6.el10.noarch.rpm;name=texlive-appendix;unpack=0"
SRC_URI += "${URI_texlive-appendix}"
SRC_URI[texlive-appendix.sha256sum] = "0f7925e876fbd1a0cbbefda5f030cdd118eae88fcec4c388c564f53d37e7a248"
RDEPENDS:texlive-appendix = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-arphic = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-arphic-20240311-6.el10.noarch.rpm;name=texlive-arphic;unpack=0"
SRC_URI += "${URI_texlive-arphic}"
SRC_URI[texlive-arphic.sha256sum] = "878839326bea628a8f2bd3a1232352019baea2240d1ea5d0232f8c32b397339e"
RDEPENDS:texlive-arphic = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-atbegshi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-atbegshi-20240311-6.el10.noarch.rpm;name=texlive-atbegshi;unpack=0"
SRC_URI += "${URI_texlive-atbegshi}"
SRC_URI[texlive-atbegshi.sha256sum] = "4fe9c3a5ff637debf1b7edfa9c3278c79c53803321725433ecaa062118157ad9"
RDEPENDS:texlive-atbegshi = " \
 texlive-kpathsea \
"

URI_texlive-attachfile = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-attachfile-20240311-6.el10.noarch.rpm;name=texlive-attachfile;unpack=0"
SRC_URI += "${URI_texlive-attachfile}"
SRC_URI[texlive-attachfile.sha256sum] = "dc73176f36b7fef5fef390eefda5ddaeed93b25caf6917b1cc114f2841fea9a2"
RDEPENDS:texlive-attachfile = " \
 texlive-graphics \
 texlive-kpathsea \
 texlive-tools \
 texlive-hyperref \
 texlive-iftex \
 texlive-base \
"

URI_texlive-attachfile2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-attachfile2-20240311-6.el10.noarch.rpm;name=texlive-attachfile2;unpack=0"
SRC_URI += "${URI_texlive-attachfile2}"
SRC_URI[texlive-attachfile2.sha256sum] = "ae12a00f770d1c92e59a7f1ed9d42e9474baf023bf5f2f964002f65869e638e3"
RDEPENDS:texlive-attachfile2 = " \
 perl-libs \
 texlive-kpathsea \
 perl-Digest-MD5 \
 perl-Getopt-Long \
 perl-POSIX \
 coreutils \
 texlive-base \
"

URI_texlive-atveryend = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-atveryend-20240311-6.el10.noarch.rpm;name=texlive-atveryend;unpack=0"
SRC_URI += "${URI_texlive-atveryend}"
SRC_URI[texlive-atveryend.sha256sum] = "df3ce6b65df6b55b93a232f814f8322a267e3f1d56e82ed28a102280bffa1036"
RDEPENDS:texlive-atveryend = " \
 texlive-kpathsea \
"

URI_texlive-auxhook = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-auxhook-20240311-6.el10.noarch.rpm;name=texlive-auxhook;unpack=0"
SRC_URI += "${URI_texlive-auxhook}"
SRC_URI[texlive-auxhook.sha256sum] = "0c3418addb6d360923e35c30869898e04974bfed3abdcfe6d7046f45c0b3800a"
RDEPENDS:texlive-auxhook = " \
 texlive-kpathsea \
"

URI_texlive-avantgar = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-avantgar-20240311-6.el10.noarch.rpm;name=texlive-avantgar;unpack=0"
SRC_URI += "${URI_texlive-avantgar}"
SRC_URI[texlive-avantgar.sha256sum] = "c0b47b566fe13e5dfcb4e26c2d7c5ff6b1dd52092ae0f5dd434ce60e67bf028a"
RDEPENDS:texlive-avantgar = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-awesomebox = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-awesomebox-20240311-6.el10.noarch.rpm;name=texlive-awesomebox;unpack=0"
SRC_URI += "${URI_texlive-awesomebox}"
SRC_URI[texlive-awesomebox.sha256sum] = "716ffb722231afdced27c7333c38db1a1396d9f35dd682571c1a11ad00504b88"
RDEPENDS:texlive-awesomebox = " \
 texlive-xltxtra \
 texlive-xcolor \
 texlive-tools \
 texlive-fontawesome \
 texlive-iftex \
 texlive-base \
"

URI_texlive-babel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-babel-20240311-6.el10.noarch.rpm;name=texlive-babel;unpack=0"
SRC_URI += "${URI_texlive-babel}"
SRC_URI[texlive-babel.sha256sum] = "41ff045ad6a3ee07f350797092d66c7bae728d0d0815407fa593eda743ddd58f"
RDEPENDS:texlive-babel = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-babel-english = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-babel-english-20240311-6.el10.noarch.rpm;name=texlive-babel-english;unpack=0"
SRC_URI += "${URI_texlive-babel-english}"
SRC_URI[texlive-babel-english.sha256sum] = "18fac7cdc1b9f6f9b504becbfa9525d7b1532e5127a7a538e46d4ad142c420f9"
RDEPENDS:texlive-babel-english = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-babelbib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-babelbib-20240311-6.el10.noarch.rpm;name=texlive-babelbib;unpack=0"
SRC_URI += "${URI_texlive-babelbib}"
SRC_URI[texlive-babelbib.sha256sum] = "0a0958788fcf260c8b82e8e2dbd3df4e399d27029107b91299a6a49e8c588597"
RDEPENDS:texlive-babelbib = " \
 texlive-kpathsea \
 texlive-babel \
 texlive-base \
"

URI_texlive-base = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-base-20240311-6.el10.noarch.rpm;name=texlive-base;unpack=0"
SRC_URI += "${URI_texlive-base}"
SRC_URI[texlive-base.sha256sum] = "1aa59f6fad1e2325a70f52351cf3e811077b7ff1159ed2ad0d0475f316c37e87"
RDEPENDS:texlive-base = " \
 coreutils \
 bash \
"

URI_texlive-beamer = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-beamer-20240311-6.el10.noarch.rpm;name=texlive-beamer;unpack=0"
SRC_URI += "${URI_texlive-beamer}"
SRC_URI[texlive-beamer.sha256sum] = "1051a30ece8f34b38b620f74a85a9e3758829d6f86737d3c394ef99e992373cc"
RDEPENDS:texlive-beamer = " \
 texlive-etoolbox \
 texlive-xcolor \
 texlive-pgf \
 texlive-geometry \
 texlive-graphics \
 texlive-amscls \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-hyperref \
 texlive-atbegshi \
 texlive-iftex \
 texlive-base \
 texlive-beamer \
 texlive-sansmathaccent \
 texlive-kpathsea \
 texlive-latex \
 texlive-tools \
 texlive-translator \
 texlive-ucs \
"

URI_texlive-bera = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-bera-20240311-6.el10.noarch.rpm;name=texlive-bera;unpack=0"
SRC_URI += "${URI_texlive-bera}"
SRC_URI[texlive-bera.sha256sum] = "0a2030890563cd7882e73787b17b36246248d48996bbf96e879f56510c3766f2"
RDEPENDS:texlive-bera = " \
 texlive-bera \
 texlive-graphics \
 texlive-kpathsea \
 texlive-latex \
 texlive-base \
"

URI_texlive-beton = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-beton-20240311-6.el10.noarch.rpm;name=texlive-beton;unpack=0"
SRC_URI += "${URI_texlive-beton}"
SRC_URI[texlive-beton.sha256sum] = "63464d6cf2863e1c8170e52302221f764955beaa9450baa12e38f3a4916be8be"
RDEPENDS:texlive-beton = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-bibtex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-bibtex-20240311-6.el10.x86_64_v2.rpm;name=texlive-bibtex;unpack=0"
SRC_URI += "${URI_texlive-bibtex}"
SRC_URI[texlive-bibtex.sha256sum] = "af79a25571bca88c93ced5ba97ac10c7672be1748f60a2c219cf80dd8bf331e9"
RDEPENDS:texlive-bibtex = " \
 glibc \
 texlive-lib \
 texlive-base \
 texlive-kpathsea \
"

URI_texlive-bibtopic = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-bibtopic-20240311-6.el10.noarch.rpm;name=texlive-bibtopic;unpack=0"
SRC_URI += "${URI_texlive-bibtopic}"
SRC_URI[texlive-bibtopic.sha256sum] = "d9ed124f905d848309f483a43ed0d2d85c0089953ad9a9bdbf655703723b8f7c"
RDEPENDS:texlive-bibtopic = " \
 texlive-kpathsea \
 texlive-latex \
 texlive-base \
"

URI_texlive-bidi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-bidi-20240311-6.el10.noarch.rpm;name=texlive-bidi;unpack=0"
SRC_URI += "${URI_texlive-bidi}"
SRC_URI[texlive-bidi.sha256sum] = "31b4ba01e61b8b176fa2234eb0ceb031b6b177a29b549c8bb067c3a782c6be36"
RDEPENDS:texlive-bidi = " \
 texlive-url \
 texlive-etoolbox \
 texlive-natbib \
 texlive-xcolor \
 texlive-fancyhdr \
 texlive-paralist \
 texlive-xifthen \
 texlive-zref \
 texlive-placeins \
 texlive-geometry \
 texlive-graphics \
 texlive-hopatch \
 texlive-hyperref \
 texlive-auxhook \
 texlive-iftex \
 texlive-ragged2e \
 texlive-base \
 texlive-bidi \
 texlive-sauerj \
 texlive-kpathsea \
 texlive-setspace \
 texlive-showexpl \
 texlive-latex \
 texlive-changepage \
 texlive-ltxcmds \
 texlive-titlesec \
 texlive-tools \
 texlive-marvosym \
"

URI_texlive-bigfoot = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-bigfoot-20240311-6.el10.noarch.rpm;name=texlive-bigfoot;unpack=0"
SRC_URI += "${URI_texlive-bigfoot}"
SRC_URI[texlive-bigfoot.sha256sum] = "1b17b239f8385a5e0827c08a04d1b9c25837971af0a8acb7133da7f61d64c063"
RDEPENDS:texlive-bigfoot = " \
 texlive-bigfoot \
 texlive-ncctools \
 texlive-kpathsea \
 texlive-base \
 texlive-etex-pkg \
"

URI_texlive-bigintcalc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-bigintcalc-20240311-6.el10.noarch.rpm;name=texlive-bigintcalc;unpack=0"
SRC_URI += "${URI_texlive-bigintcalc}"
SRC_URI[texlive-bigintcalc.sha256sum] = "b08aae1d238f8f5eca3e3218a7a6793e9f267bd586c55308c5a0d33304c5bd2b"
RDEPENDS:texlive-bigintcalc = " \
 texlive-kpathsea \
"

URI_texlive-bitset = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-bitset-20240311-6.el10.noarch.rpm;name=texlive-bitset;unpack=0"
SRC_URI += "${URI_texlive-bitset}"
SRC_URI[texlive-bitset.sha256sum] = "e71e3a3eba576cf8ed23938ad561e37edf3f744a97510d935bc6294f4855ec69"
RDEPENDS:texlive-bitset = " \
 texlive-kpathsea \
 texlive-bigintcalc \
"

URI_texlive-bookman = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-bookman-20240311-6.el10.noarch.rpm;name=texlive-bookman;unpack=0"
SRC_URI += "${URI_texlive-bookman}"
SRC_URI[texlive-bookman.sha256sum] = "168af1aacb5f0008e8abd26dc7e43911d3a628bb25970d66defba0c489d7aa51"
RDEPENDS:texlive-bookman = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-bookmark = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-bookmark-20240311-6.el10.noarch.rpm;name=texlive-bookmark;unpack=0"
SRC_URI += "${URI_texlive-bookmark}"
SRC_URI[texlive-bookmark.sha256sum] = "a45e7f0c4632a72904b58b1a193ee1668c61d558bdb908ff7b72dfc50d7a2916"
RDEPENDS:texlive-bookmark = " \
 texlive-kpathsea \
"

URI_texlive-booktabs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-booktabs-20240311-6.el10.noarch.rpm;name=texlive-booktabs;unpack=0"
SRC_URI += "${URI_texlive-booktabs}"
SRC_URI[texlive-booktabs.sha256sum] = "293b991f6b70f1e216a286ce1ed6a4087ea3feb0da215fccb83bda30f97ac062"
RDEPENDS:texlive-booktabs = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-breakurl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-breakurl-20240311-6.el10.noarch.rpm;name=texlive-breakurl;unpack=0"
SRC_URI += "${URI_texlive-breakurl}"
SRC_URI[texlive-breakurl.sha256sum] = "f26c94e13b509ebc43c69a9ad72c2fe3dfe2c9aca86ecf2244fca7789edd8cad"
RDEPENDS:texlive-breakurl = " \
 texlive-kpathsea \
 texlive-iftex \
 texlive-base \
 texlive-xkeyval \
"

URI_texlive-breqn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-breqn-20240311-6.el10.noarch.rpm;name=texlive-breqn;unpack=0"
SRC_URI += "${URI_texlive-breqn}"
SRC_URI[texlive-breqn.sha256sum] = "f5e45aa80fa94e558be01dd38e12ced9f47089e2d3625315b5a8ee1bfdd12688"
RDEPENDS:texlive-breqn = " \
 texlive-graphics \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-tools \
 texlive-base \
"

URI_texlive-capt-of = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-capt-of-20240311-6.el10.noarch.rpm;name=texlive-capt-of;unpack=0"
SRC_URI += "${URI_texlive-capt-of}"
SRC_URI[texlive-capt-of.sha256sum] = "6857ada40ecd81e0a499517759107be4760728339ecad42582b8a41c985344b7"
RDEPENDS:texlive-capt-of = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-caption = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-caption-20240311-6.el10.noarch.rpm;name=texlive-caption;unpack=0"
SRC_URI += "${URI_texlive-caption}"
SRC_URI[texlive-caption.sha256sum] = "3c6237e82ecad54e748def980011280f69caae152c33aafd4a297f0f27923e41"
RDEPENDS:texlive-caption = " \
 texlive-kpathsea \
 texlive-base \
 texlive-caption \
 texlive-graphics \
"

URI_texlive-carlisle = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-carlisle-20240311-6.el10.noarch.rpm;name=texlive-carlisle;unpack=0"
SRC_URI += "${URI_texlive-carlisle}"
SRC_URI[texlive-carlisle.sha256sum] = "b642c7f596102fdd03b25cdf05e427d1ba256d7fb73a709918b4e14e56c4498c"
RDEPENDS:texlive-carlisle = " \
 texlive-kpathsea \
 texlive-base \
 texlive-graphics \
 texlive-tools \
"

URI_texlive-catchfile = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-catchfile-20240311-6.el10.noarch.rpm;name=texlive-catchfile;unpack=0"
SRC_URI += "${URI_texlive-catchfile}"
SRC_URI[texlive-catchfile.sha256sum] = "c8fda800688aae42ad40848fe20aa2a267ff1e9702ca7743c6342e9c48f24956"
RDEPENDS:texlive-catchfile = " \
 texlive-ltxcmds \
 texlive-etexcmds \
 texlive-kpathsea \
 texlive-infwarerr \
"

URI_texlive-changebar = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-changebar-20240311-6.el10.noarch.rpm;name=texlive-changebar;unpack=0"
SRC_URI += "${URI_texlive-changebar}"
SRC_URI[texlive-changebar.sha256sum] = "c2502d7e0d46f72120dc9558cf3b377888948cb3325e12cc232c8f5a4f4767d2"
RDEPENDS:texlive-changebar = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-changepage = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-changepage-20240311-6.el10.noarch.rpm;name=texlive-changepage;unpack=0"
SRC_URI += "${URI_texlive-changepage}"
SRC_URI[texlive-changepage.sha256sum] = "02c5aa90cfd17f8de9f97b786cfd3b80b6e984354078c9ce57115dd88a8347be"
RDEPENDS:texlive-changepage = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-charter = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-charter-20240311-6.el10.noarch.rpm;name=texlive-charter;unpack=0"
SRC_URI += "${URI_texlive-charter}"
SRC_URI[texlive-charter.sha256sum] = "2919d5ed46b2128ee6f8e38970ed5a7b730933044d2ade141610a863e3b078d2"
RDEPENDS:texlive-charter = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-chngcntr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-chngcntr-20240311-6.el10.noarch.rpm;name=texlive-chngcntr;unpack=0"
SRC_URI += "${URI_texlive-chngcntr}"
SRC_URI[texlive-chngcntr.sha256sum] = "7cb75153984eb2615666706067f7e6e45f9e45eace3b2f00737a8a333f5a6510"
RDEPENDS:texlive-chngcntr = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-cite = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-cite-20240311-6.el10.noarch.rpm;name=texlive-cite;unpack=0"
SRC_URI += "${URI_texlive-cite}"
SRC_URI[texlive-cite.sha256sum] = "9ede9d057e6410224c291e856e8fb6a214b6261d43481f1dcd05822e34d47ff8"
RDEPENDS:texlive-cite = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-classpack = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-classpack-20240311-6.el10.noarch.rpm;name=texlive-classpack;unpack=0"
SRC_URI += "${URI_texlive-classpack}"
SRC_URI[texlive-classpack.sha256sum] = "ef89a3e544e664f18846b65f1684239bbffd8fa77ff8671061854e000ece03ff"
RDEPENDS:texlive-classpack = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-cm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-cm-20240311-6.el10.noarch.rpm;name=texlive-cm;unpack=0"
SRC_URI += "${URI_texlive-cm}"
SRC_URI[texlive-cm.sha256sum] = "b5a8db3342577f21f3c4f99db7da197bdb0e663b5a43c8cf5a8ed65c3699ac9f"
RDEPENDS:texlive-cm = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-cm-lgc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-cm-lgc-20240311-6.el10.noarch.rpm;name=texlive-cm-lgc;unpack=0"
SRC_URI += "${URI_texlive-cm-lgc}"
SRC_URI[texlive-cm-lgc.sha256sum] = "83d2ba83d31471852ee7329444c8ca57509409c9982e1cf37e24865970277dd9"
RDEPENDS:texlive-cm-lgc = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-cm-super = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-cm-super-20240311-6.el10.noarch.rpm;name=texlive-cm-super;unpack=0"
SRC_URI += "${URI_texlive-cm-super}"
SRC_URI[texlive-cm-super.sha256sum] = "873bd034eeb8ea275f189224b5d2d6a027e6f3155feb1782abfa30eb256c1231"
RDEPENDS:texlive-cm-super = " \
 texlive-kpathsea \
 texlive-latex \
 texlive-base \
"

URI_texlive-cmap = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-cmap-20240311-6.el10.noarch.rpm;name=texlive-cmap;unpack=0"
SRC_URI += "${URI_texlive-cmap}"
SRC_URI[texlive-cmap.sha256sum] = "1b12f6f7e5285e271c32d1635d4fa9410b1cd8ae753191cb213a1af1d55b882a"
RDEPENDS:texlive-cmap = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-cmextra = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-cmextra-20240311-6.el10.noarch.rpm;name=texlive-cmextra;unpack=0"
SRC_URI += "${URI_texlive-cmextra}"
SRC_URI[texlive-cmextra.sha256sum] = "9a26fa286a469354fa502dfd61289522f6b49c1c23b79c3295a722c9cb9b093a"
RDEPENDS:texlive-cmextra = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-cns = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-cns-20240311-6.el10.noarch.rpm;name=texlive-cns;unpack=0"
SRC_URI += "${URI_texlive-cns}"
SRC_URI[texlive-cns.sha256sum] = "4f9c693d5f90f7d7658e4e39f07f484a69fc6559ff87ea461a30fd06ad6e786a"
RDEPENDS:texlive-cns = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-collectbox = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-collectbox-20240311-6.el10.noarch.rpm;name=texlive-collectbox;unpack=0"
SRC_URI += "${URI_texlive-collectbox}"
SRC_URI[texlive-collectbox.sha256sum] = "76f3f6b1276df181543939b59de938da50555b32af3a56f0a22ef24fb26923fa"
RDEPENDS:texlive-collectbox = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-collection-basic = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-collection-basic-20240311-6.el10.noarch.rpm;name=texlive-collection-basic;unpack=0"
SRC_URI += "${URI_texlive-collection-basic}"
SRC_URI[texlive-collection-basic.sha256sum] = "7b80ad661df231f2362e58ea5a760dd442c28181cbb87c420b650c118f82c620"
RDEPENDS:texlive-collection-basic = " \
 texlive-modes \
 texlive-pdftex \
 texlive-plain \
 texlive-glyphlist \
 texlive-graphics-def \
 texlive-amsfonts \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-hyphenex \
 texlive-ifplatform \
 texlive-iftex \
 texlive-base \
 texlive-bibtex \
 texlive-knuth-lib \
 texlive-knuth-local \
 texlive-kpathsea \
 texlive-cm \
 texlive-tex \
 texlive-tex-ini-files \
 texlive-texlive-common-doc \
 texlive-texlive-en \
 texlive-lua-alt-getopt \
 texlive-texlive-msg-translations \
 texlive-colorprofiles \
 texlive-texlive.infra \
 texlive-luahbtex \
 texlive-texlive-scripts \
 texlive-luatex \
 texlive-makeindex \
 texlive-dvipdfmx \
 texlive-dvips \
 texlive-ec \
 texlive-enctex \
 texlive-metafont \
 texlive-mflogo \
 texlive-unicode-data \
 texlive-mfware \
 texlive-etex \
 texlive-etex-pkg \
"

URI_texlive-collection-fontsrecommended = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-collection-fontsrecommended-20240311-6.el10.noarch.rpm;name=texlive-collection-fontsrecommended;unpack=0"
SRC_URI += "${URI_texlive-collection-fontsrecommended}"
SRC_URI[texlive-collection-fontsrecommended.sha256sum] = "d6936a72fac979f0808c7c5744defcdaef9c3034d3360fcad266950a3aa9a42c"
RDEPENDS:texlive-collection-fontsrecommended = " \
 texlive-utopia \
 texlive-euro \
 texlive-wasy-type1 \
 texlive-eurosym \
 texlive-wasy \
 texlive-ncntrsbk \
 texlive-wasysym \
 texlive-palatino \
 texlive-zapfchan \
 texlive-zapfding \
 texlive-fpl \
 texlive-helvetic \
 texlive-avantgar \
 texlive-pxfonts \
 texlive-base \
 texlive-rsfs \
 texlive-bookman \
 texlive-charter \
 texlive-symbol \
 texlive-cm-super \
 texlive-cmextra \
 texlive-tex-gyre \
 texlive-lm \
 texlive-lm-math \
 texlive-collection-basic \
 texlive-tex-gyre-math \
 texlive-courier \
 texlive-times \
 texlive-tipa \
 texlive-manfnt-font \
 texlive-marvosym \
 texlive-mathpazo \
 texlive-txfonts \
 texlive-ec \
 texlive-mflogo-font \
"

URI_texlive-collection-htmlxml = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-collection-htmlxml-20240311-6.el10.noarch.rpm;name=texlive-collection-htmlxml;unpack=0"
SRC_URI += "${URI_texlive-collection-htmlxml}"
SRC_URI[texlive-collection-htmlxml.sha256sum] = "9f47bad0c100a3565e59984ddb504c4753555ae551866d368ab47a49effd6eb5"
RDEPENDS:texlive-collection-htmlxml = " \
 texlive-collection-latex \
 texlive-jadetex \
 texlive-tex-ini-files \
 texlive-tex4ht \
 texlive-classpack \
 texlive-passivetex \
 texlive-xmltex \
 texlive-base \
 texlive-collection-basic \
 texlive-collection-fontsrecommended \
"

URI_texlive-collection-latex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-collection-latex-20240311-6.el10.noarch.rpm;name=texlive-collection-latex;unpack=0"
SRC_URI += "${URI_texlive-collection-latex}"
SRC_URI[texlive-collection-latex.sha256sum] = "c66be8884ddd627328200bc765e4c13a94c250ad382974b995d09e6e5993393a"
RDEPENDS:texlive-collection-latex = " \
 texlive-etexcmds \
 texlive-url \
 texlive-mptopdf \
 texlive-natbib \
 texlive-fancyhdr \
 texlive-oberdiek \
 texlive-firstaid \
 texlive-fix2col \
 texlive-pdfescape \
 texlive-geometry \
 texlive-gettitlestring \
 texlive-graphics \
 texlive-graphics-cfg \
 texlive-pslatex \
 texlive-grfext \
 texlive-psnfss \
 texlive-ae \
 texlive-pspicture \
 texlive-amscls \
 texlive-amsmath \
 texlive-hycolor \
 texlive-hypcap \
 texlive-atbegshi \
 texlive-hyperref \
 texlive-atveryend \
 texlive-auxhook \
 texlive-babel \
 texlive-babel-english \
 texlive-babelbib \
 texlive-base \
 texlive-intcalc \
 texlive-refcount \
 texlive-rerunfilecheck \
 texlive-bitset \
 texlive-bookmark \
 texlive-kvoptions \
 texlive-kvdefinekeys \
 texlive-l3backend \
 texlive-kvsetkeys \
 texlive-l3kernel \
 texlive-carlisle \
 texlive-latex \
 texlive-latex-fonts \
 texlive-mfnfss \
 texlive-stringenc \
 texlive-latexconfig \
 texlive-letltxmacro \
 texlive-collection-basic \
 texlive-ltxcmds \
 texlive-ltxmisc \
 texlive-colortbl \
 texlive-tools \
 texlive-epstopdf-pkg \
 texlive-uniquecounter \
"

URI_texlive-collection-latexrecommended = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-collection-latexrecommended-20240311-6.el10.noarch.rpm;name=texlive-collection-latexrecommended;unpack=0"
SRC_URI += "${URI_texlive-collection-latexrecommended}"
SRC_URI[texlive-collection-latexrecommended.sha256sum] = "47028f87c999e2e45a46f178de683c2f6f2e3eb67d6d3464e3464a86c5295ebe"
RDEPENDS:texlive-collection-latexrecommended = " \
 texlive-etoolbox \
 texlive-euenc \
 texlive-euler \
 texlive-multitoc \
 texlive-everysel \
 texlive-everyshi \
 texlive-xcolor \
 texlive-extsizes \
 texlive-fancybox \
 texlive-fancyref \
 texlive-fancyvrb \
 texlive-newfloat \
 texlive-filehook \
 texlive-ntgclass \
 texlive-float \
 texlive-parskip \
 texlive-xfrac \
 texlive-xkeyval \
 texlive-pdfcolfoot \
 texlive-xltxtra \
 texlive-fontspec \
 texlive-pdflscape \
 texlive-pdfmanagement-testphase \
 texlive-pdfpages \
 texlive-footnotehyper \
 texlive-fp \
 texlive-xunicode \
 texlive-polyglossia \
 texlive-psfrag \
 texlive-grffile \
 texlive-hologo \
 texlive-anysize \
 texlive-attachfile2 \
 texlive-index \
 texlive-beamer \
 texlive-infwarerr \
 texlive-ragged2e \
 texlive-jknapltx \
 texlive-rcs \
 texlive-base \
 texlive-sansmath \
 texlive-koma-script \
 texlive-section \
 texlive-booktabs \
 texlive-seminar \
 texlive-breqn \
 texlive-l3experimental \
 texlive-caption \
 texlive-sepnum \
 texlive-setspace \
 texlive-latexbug \
 texlive-cite \
 texlive-subfig \
 texlive-cmap \
 texlive-lineno \
 texlive-listings \
 texlive-microtype \
 texlive-collection-fontsrecommended \
 texlive-collection-latex \
 texlive-textcase \
 texlive-count1to \
 texlive-crop \
 texlive-thumbpdf \
 texlive-ctable \
 texlive-lwarp \
 texlive-translator \
 texlive-mathspec \
 texlive-mathtools \
 texlive-mdwtools \
 texlive-memoir \
 texlive-typehtml \
 texlive-metalogo \
 texlive-ucharcat \
 texlive-underscore \
 texlive-unicode-math \
 texlive-eso-pic \
"

URI_texlive-collection-xetex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-collection-xetex-20240311-6.el10.noarch.rpm;name=texlive-collection-xetex;unpack=0"
SRC_URI += "${URI_texlive-collection-xetex}"
SRC_URI[texlive-collection-xetex.sha256sum] = "c7d0d5aa59eecf1c3e824e3fb5019c63256fe5fc03293dd93f671447fb5e05ea"
RDEPENDS:texlive-collection-xetex = " \
 texlive-xecolor \
 texlive-xecyr \
 texlive-xeindex \
 texlive-xesearch \
 texlive-xetex \
 texlive-xetex-itrans \
 texlive-xetex-pstricks \
 texlive-xetexconfig \
 texlive-fixlatvian \
 texlive-xetexfontinfo \
 texlive-fontbook \
 texlive-fontwrap \
 texlive-philokalia \
 texlive-awesomebox \
 texlive-ptext \
 texlive-base \
 texlive-realscripts \
 texlive-collection-basic \
 texlive-ucharclasses \
 texlive-unisugar \
"

URI_texlive-colorprofiles = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-colorprofiles-20240311-6.el10.noarch.rpm;name=texlive-colorprofiles;unpack=0"
SRC_URI += "${URI_texlive-colorprofiles}"
SRC_URI[texlive-colorprofiles.sha256sum] = "9f81ab3242480704b165bc0ed6da44b2a9f53b773b34449b9d94990c03af146e"
RDEPENDS:texlive-colorprofiles = " \
 texlive-kpathsea \
"

URI_texlive-colortbl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-colortbl-20240311-6.el10.noarch.rpm;name=texlive-colortbl;unpack=0"
SRC_URI += "${URI_texlive-colortbl}"
SRC_URI[texlive-colortbl.sha256sum] = "a2b8ce0ac4276ecb695eb21bdb9dc427541416c06fbefa00c8b5a2cdaf7f1db7"
RDEPENDS:texlive-colortbl = " \
 texlive-kpathsea \
 texlive-base \
 texlive-graphics \
 texlive-tools \
"

URI_texlive-context = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-context-20240311-6.el10.noarch.rpm;name=texlive-context;unpack=0"
SRC_URI += "${URI_texlive-context}"
SRC_URI[texlive-context.sha256sum] = "1efb0b3de50685ef4722ac01a07718c59ffd78323df5c0581471e92c3e86f3b5"
RDEPENDS:texlive-context = " \
 texlive-mptopdf \
 perl-libs \
 texlive-xetex \
 texlive-pdftex \
 texlive-amsfonts \
 texlive-pst-plot \
 texlive-pstricks \
 texlive-base \
 perl-Tk \
 texlive-kpathsea \
 texlive-stmaryrd \
 bash \
 texlive-lm \
 texlive-lm-math \
 perl-base \
 texlive-texlive-scripts \
 texlive-luatex \
 texlive-manfnt-font \
 texlive-metapost \
 coreutils \
 texlive-mflogo-font \
"

URI_texlive-count1to = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-count1to-20240311-6.el10.noarch.rpm;name=texlive-count1to;unpack=0"
SRC_URI += "${URI_texlive-count1to}"
SRC_URI[texlive-count1to.sha256sum] = "526347aef96c973c4c09e18ae8d9e4baf42425b05fe82788d66a67b870ddc7a7"
RDEPENDS:texlive-count1to = " \
 texlive-everyshi \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-courier = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-courier-20240311-6.el10.noarch.rpm;name=texlive-courier;unpack=0"
SRC_URI += "${URI_texlive-courier}"
SRC_URI[texlive-courier.sha256sum] = "3d94866d426971b3cb4f25ac8071e012313a5030e1cdeacb3af6c0add963ef24"
RDEPENDS:texlive-courier = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-crop = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-crop-20240311-6.el10.noarch.rpm;name=texlive-crop;unpack=0"
SRC_URI += "${URI_texlive-crop}"
SRC_URI[texlive-crop.sha256sum] = "33a474af6ce6444fa3d68fc2bc3d1c5b3f5947a63f67468e4b9fb67a18dda1ef"
RDEPENDS:texlive-crop = " \
 texlive-kpathsea \
 texlive-base \
 texlive-graphics \
"

URI_texlive-csquotes = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-csquotes-20240311-6.el10.noarch.rpm;name=texlive-csquotes;unpack=0"
SRC_URI += "${URI_texlive-csquotes}"
SRC_URI[texlive-csquotes.sha256sum] = "6bcb42246c76c203f9482ca78de4a6b921a9bd6bd3baf01dd7c8058dc3d7b6c4"
RDEPENDS:texlive-csquotes = " \
 texlive-kpathsea \
 texlive-etoolbox \
 texlive-base \
 texlive-graphics \
"

URI_texlive-ctable = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-ctable-20240311-6.el10.noarch.rpm;name=texlive-ctable;unpack=0"
SRC_URI += "${URI_texlive-ctable}"
SRC_URI[texlive-ctable.sha256sum] = "a6e9a5cd623ebe9fc5726f4f34c37d1dfa41ee5fb7a8e1a80c1271743241cc55"
RDEPENDS:texlive-ctable = " \
 texlive-etoolbox \
 texlive-graphics \
 texlive-kpathsea \
 texlive-booktabs \
 texlive-tools \
 bash \
 texlive-xkeyval \
 texlive-base \
"

URI_texlive-ctablestack = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-ctablestack-20240311-6.el10.noarch.rpm;name=texlive-ctablestack;unpack=0"
SRC_URI += "${URI_texlive-ctablestack}"
SRC_URI[texlive-ctablestack.sha256sum] = "c31864812a791c97fa88a9e1102481f1b7080b3316c5fef3e140c94b4be3ad31"
RDEPENDS:texlive-ctablestack = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-currfile = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-currfile-20240311-6.el10.noarch.rpm;name=texlive-currfile;unpack=0"
SRC_URI += "${URI_texlive-currfile}"
SRC_URI[texlive-currfile.sha256sum] = "7029609375105a05df5ee7a6509671c1e4f9779f4ad9137723759fc81ef6f6a2"
RDEPENDS:texlive-currfile = " \
 texlive-kpathsea \
 texlive-kvoptions \
 texlive-base \
 texlive-filehook \
"

URI_texlive-datetime = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-datetime-20240311-6.el10.noarch.rpm;name=texlive-datetime;unpack=0"
SRC_URI += "${URI_texlive-datetime}"
SRC_URI[texlive-datetime.sha256sum] = "07641c073b3d34087f912c885b8447e7a37b8461f19e656f1681dcd9e542f0a8"
RDEPENDS:texlive-datetime = " \
 texlive-kpathsea \
 texlive-latex \
 texlive-fmtcount \
 texlive-base \
"

URI_texlive-dehyph = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-dehyph-20240311-6.el10.noarch.rpm;name=texlive-dehyph;unpack=0"
SRC_URI += "${URI_texlive-dehyph}"
SRC_URI[texlive-dehyph.sha256sum] = "49b5195ff178ad52c298f2559bc019d13ab96f3e6c0addb4465d03bf280e2b6e"
RDEPENDS:texlive-dehyph = " \
 texlive-kpathsea \
"

URI_texlive-dvipdfmx = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-dvipdfmx-20240311-6.el10.x86_64_v2.rpm;name=texlive-dvipdfmx;unpack=0"
SRC_URI += "${URI_texlive-dvipdfmx}"
SRC_URI[texlive-dvipdfmx.sha256sum] = "fd6224ccddd8b46888ee170d23819058d7190c32506a85d52a7d39b504491a5e"
RDEPENDS:texlive-dvipdfmx = " \
 texlive-glyphlist \
 texlive-graphics-def \
 texlive-kpathsea \
 texlive-xetex \
 bash \
 texlive-base \
"

URI_texlive-dvipng = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-dvipng-20240311-6.el10.x86_64_v2.rpm;name=texlive-dvipng;unpack=0"
SRC_URI += "${URI_texlive-dvipng}"
SRC_URI[texlive-dvipng.sha256sum] = "982d2ffd2414f7ddb6cad3f1beff0ac4578297c6fe56b4ec854f70b890bf9919"
RDEPENDS:texlive-dvipng = " \
 gd \
 freetype \
 texlive-lib \
 texlive-kpathsea \
 info \
 glibc \
 texlive-base \
"

URI_texlive-dvips = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-dvips-20240311-6.el10.x86_64_v2.rpm;name=texlive-dvips;unpack=0"
SRC_URI += "${URI_texlive-dvips}"
SRC_URI[texlive-dvips.sha256sum] = "0c7de96648f10df7ab3223dbd117d5a47328ec626faf80048e617943ddcae29f"
RDEPENDS:texlive-dvips = " \
 texlive-lib \
 texlive-kpathsea \
 texlive-latex-fonts \
 info \
 glibc \
 texlive-base \
"

URI_texlive-dvisvgm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-dvisvgm-20240311-6.el10.x86_64_v2.rpm;name=texlive-dvisvgm;unpack=0"
SRC_URI += "${URI_texlive-dvisvgm}"
SRC_URI[texlive-dvisvgm.sha256sum] = "8a4fda06362e61a2063d0d45eadae2f18f224e3f55e586e4db245655051ab8bf"
RDEPENDS:texlive-dvisvgm = " \
 zlib-ng-compat \
 freetype \
 texlive-lib \
 texlive-kpathsea \
 libgcc \
 libstdc++ \
 libgs \
 glibc \
 potrace \
 texlive-base \
"

URI_texlive-ec = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-ec-20240311-6.el10.noarch.rpm;name=texlive-ec;unpack=0"
SRC_URI += "${URI_texlive-ec}"
SRC_URI[texlive-ec.sha256sum] = "ede4197ec1b9f2402b6808f308702b99496bb11b06328ebe5e9a447fa50987f4"
RDEPENDS:texlive-ec = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-eepic = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-eepic-20240311-6.el10.noarch.rpm;name=texlive-eepic;unpack=0"
SRC_URI += "${URI_texlive-eepic}"
SRC_URI[texlive-eepic.sha256sum] = "785cb2079afadc7ab58a10001051ae7fe8392842da2035ab58e76107828d0c41"
RDEPENDS:texlive-eepic = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-enctex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-enctex-20240311-6.el10.noarch.rpm;name=texlive-enctex;unpack=0"
SRC_URI += "${URI_texlive-enctex}"
SRC_URI[texlive-enctex.sha256sum] = "76258ed78db73a0d50064dfd03dca77119f4e6b3ea4ef5bf70bee6e6beb08dbb"
RDEPENDS:texlive-enctex = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-enumitem = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-enumitem-20240311-6.el10.noarch.rpm;name=texlive-enumitem;unpack=0"
SRC_URI += "${URI_texlive-enumitem}"
SRC_URI[texlive-enumitem.sha256sum] = "7f1d1b8f8bf81d09e3d34df45c4d773e875493c59b8c6c2b55f97555db2f3ce5"
RDEPENDS:texlive-enumitem = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-environ = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-environ-20240311-6.el10.noarch.rpm;name=texlive-environ;unpack=0"
SRC_URI += "${URI_texlive-environ}"
SRC_URI[texlive-environ.sha256sum] = "a3cf6db69efe126eb93397cc9a501b00f8acdeb8193f0e26776f857b4c719992"
RDEPENDS:texlive-environ = " \
 texlive-kpathsea \
 texlive-trimspaces \
 texlive-base \
"

URI_texlive-epsf = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-epsf-20240311-6.el10.noarch.rpm;name=texlive-epsf;unpack=0"
SRC_URI += "${URI_texlive-epsf}"
SRC_URI[texlive-epsf.sha256sum] = "a64561dff8b04d1dd7a2954952761f68b6f8dcf7f3565a64e26f797f452feda4"
RDEPENDS:texlive-epsf = " \
 texlive-kpathsea \
 bash \
 texlive-base \
"

URI_texlive-epstopdf = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-epstopdf-20240311-6.el10.noarch.rpm;name=texlive-epstopdf;unpack=0"
SRC_URI += "${URI_texlive-epstopdf}"
SRC_URI[texlive-epstopdf.sha256sum] = "53fd92707119f3ad95a93da4a257af98fd20e3ae2e82688965a4b078ece1f8d8"
RDEPENDS:texlive-epstopdf = " \
 perl-libs \
 texlive-kpathsea \
 perl-Getopt-Long \
 coreutils \
 texlive-base \
 perl-File-Temp \
"

URI_texlive-epstopdf-pkg = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-epstopdf-pkg-20240311-6.el10.noarch.rpm;name=texlive-epstopdf-pkg;unpack=0"
SRC_URI += "${URI_texlive-epstopdf-pkg}"
SRC_URI[texlive-epstopdf-pkg.sha256sum] = "08fd08cd29ca15c5b54bca1643db101209f6f06d21a4507e23bce1901e3c857d"
RDEPENDS:texlive-epstopdf-pkg = " \
 texlive-kpathsea \
"

URI_texlive-eqparbox = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-eqparbox-20240311-6.el10.noarch.rpm;name=texlive-eqparbox;unpack=0"
SRC_URI += "${URI_texlive-eqparbox}"
SRC_URI[texlive-eqparbox.sha256sum] = "093b7d7f754bf981fa521c6a325fca0c1639f990855648e8712e3fcf608617ad"
RDEPENDS:texlive-eqparbox = " \
 texlive-environ \
 texlive-kpathsea \
 texlive-base \
 texlive-tools \
"

URI_texlive-eso-pic = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-eso-pic-20240311-6.el10.noarch.rpm;name=texlive-eso-pic;unpack=0"
SRC_URI += "${URI_texlive-eso-pic}"
SRC_URI[texlive-eso-pic.sha256sum] = "c220264b03012a7da04362b5fde450f33204bbc762fe2c151795c0ccf67d7efc"
RDEPENDS:texlive-eso-pic = " \
 texlive-graphics \
 texlive-kpathsea \
 texlive-xcolor \
 texlive-atbegshi \
 texlive-base \
"

URI_texlive-etex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-etex-20240311-6.el10.noarch.rpm;name=texlive-etex;unpack=0"
SRC_URI += "${URI_texlive-etex}"
SRC_URI[texlive-etex.sha256sum] = "60b2cff3e1dc933c4f90a47492d5e5d9828d521bde97814f7c608a572b5a7d7d"
RDEPENDS:texlive-etex = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-etex-pkg = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-etex-pkg-20240311-6.el10.noarch.rpm;name=texlive-etex-pkg;unpack=0"
SRC_URI += "${URI_texlive-etex-pkg}"
SRC_URI[texlive-etex-pkg.sha256sum] = "ef2e95b92689c7ce5904e30e032244677129ac2eabf0de8ff46bf0726552bc11"
RDEPENDS:texlive-etex-pkg = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-etexcmds = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-etexcmds-20240311-6.el10.noarch.rpm;name=texlive-etexcmds;unpack=0"
SRC_URI += "${URI_texlive-etexcmds}"
SRC_URI[texlive-etexcmds.sha256sum] = "b19d9ae6ae5c82dd2f3c3e4fad85c9fa1a6ea560692d947bbe2ec9e4f6bb775e"
RDEPENDS:texlive-etexcmds = " \
 texlive-kpathsea \
"

URI_texlive-etoc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-etoc-20240311-6.el10.noarch.rpm;name=texlive-etoc;unpack=0"
SRC_URI += "${URI_texlive-etoc}"
SRC_URI[texlive-etoc.sha256sum] = "7b114be5bbd95084273b30e0980c006eb2c546105904146d57ee58f08db18e8e"
RDEPENDS:texlive-etoc = " \
 texlive-kpathsea \
 texlive-base \
 texlive-tools \
"

URI_texlive-etoolbox = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-etoolbox-20240311-6.el10.noarch.rpm;name=texlive-etoolbox;unpack=0"
SRC_URI += "${URI_texlive-etoolbox}"
SRC_URI[texlive-etoolbox.sha256sum] = "0f375cbcadc0756d45d3f452d5d5480a36fe7b873a08b29a0b23878a740ef708"
RDEPENDS:texlive-etoolbox = " \
 texlive-kpathsea \
 texlive-base \
 texlive-etex-pkg \
"

URI_texlive-euenc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-euenc-20240311-6.el10.noarch.rpm;name=texlive-euenc;unpack=0"
SRC_URI += "${URI_texlive-euenc}"
SRC_URI[texlive-euenc.sha256sum] = "5415d4482f7a0f108bb0fd85348437b331e7fa39783518267199aa76dd22318a"
RDEPENDS:texlive-euenc = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-euler = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-euler-20240311-6.el10.noarch.rpm;name=texlive-euler;unpack=0"
SRC_URI += "${URI_texlive-euler}"
SRC_URI[texlive-euler.sha256sum] = "bd4bd5f45e4d470bb5666e471a2818a5f54a755cd4d05fdc5a6e8fa77a81dcde"
RDEPENDS:texlive-euler = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-euro = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-euro-20240311-6.el10.noarch.rpm;name=texlive-euro;unpack=0"
SRC_URI += "${URI_texlive-euro}"
SRC_URI[texlive-euro.sha256sum] = "d710f38070428c81ef5a9dce39986620b3e3d1de05b236fa2d7ecc123380ff96"
RDEPENDS:texlive-euro = " \
 texlive-kpathsea \
 texlive-base \
 texlive-fp \
"

URI_texlive-eurosym = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-eurosym-20240311-6.el10.noarch.rpm;name=texlive-eurosym;unpack=0"
SRC_URI += "${URI_texlive-eurosym}"
SRC_URI[texlive-eurosym.sha256sum] = "d2a90dc4e55e942f1daeac197ee8583b4c66402775d2428b4bacee5aefb7b7fd"
RDEPENDS:texlive-eurosym = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-everysel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-everysel-20240311-6.el10.noarch.rpm;name=texlive-everysel;unpack=0"
SRC_URI += "${URI_texlive-everysel}"
SRC_URI[texlive-everysel.sha256sum] = "4b002fab710c49734afc999fcb5352b64b7b7a68c2b74fd488bdbbf57739b757"
RDEPENDS:texlive-everysel = " \
 texlive-kpathsea \
"

URI_texlive-everyshi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-everyshi-20240311-6.el10.noarch.rpm;name=texlive-everyshi;unpack=0"
SRC_URI += "${URI_texlive-everyshi}"
SRC_URI[texlive-everyshi.sha256sum] = "8ec04cb30b46746c7bccab63b121004c7c34a8819be020142f5c7f529eb724e4"
RDEPENDS:texlive-everyshi = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-extsizes = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-extsizes-20240311-6.el10.noarch.rpm;name=texlive-extsizes;unpack=0"
SRC_URI += "${URI_texlive-extsizes}"
SRC_URI[texlive-extsizes.sha256sum] = "1f7a72440a13808d61ba24cd3997b7140c60a85648e3a16afdab5b4c281a5935"
RDEPENDS:texlive-extsizes = " \
 texlive-kpathsea \
 texlive-latex \
 texlive-base \
"

URI_texlive-fancybox = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-fancybox-20240311-6.el10.noarch.rpm;name=texlive-fancybox;unpack=0"
SRC_URI += "${URI_texlive-fancybox}"
SRC_URI[texlive-fancybox.sha256sum] = "6397dc7e7f3c390f82e5d33f7d1cd87c87b3b5ef989acdf9c87020ff08a6aa89"
RDEPENDS:texlive-fancybox = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-fancyhdr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-fancyhdr-20240311-6.el10.noarch.rpm;name=texlive-fancyhdr;unpack=0"
SRC_URI += "${URI_texlive-fancyhdr}"
SRC_URI[texlive-fancyhdr.sha256sum] = "652231176eb36e94cde6ff52f5182322d8cd9f33290a7a6edd1be785318622ab"
RDEPENDS:texlive-fancyhdr = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-fancyref = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-fancyref-20240311-6.el10.noarch.rpm;name=texlive-fancyref;unpack=0"
SRC_URI += "${URI_texlive-fancyref}"
SRC_URI[texlive-fancyref.sha256sum] = "33b3090d2fef6f00346c5cc0657c79cc6bff00829a53f2e02be36be87a4d9fa2"
RDEPENDS:texlive-fancyref = " \
 texlive-kpathsea \
 texlive-base \
 texlive-tools \
"

URI_texlive-fancyvrb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-fancyvrb-20240311-6.el10.noarch.rpm;name=texlive-fancyvrb;unpack=0"
SRC_URI += "${URI_texlive-fancyvrb}"
SRC_URI[texlive-fancyvrb.sha256sum] = "a098780f3f5a5617ef20fe91f790628a3a213cb3d97b1a79d6869c043f2c4db2"
RDEPENDS:texlive-fancyvrb = " \
 texlive-graphics \
 texlive-kpathsea \
 texlive-fancyvrb \
 texlive-pstricks \
 texlive-base \
"

URI_texlive-filecontents = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-filecontents-20240311-6.el10.noarch.rpm;name=texlive-filecontents;unpack=0"
SRC_URI += "${URI_texlive-filecontents}"
SRC_URI[texlive-filecontents.sha256sum] = "22840e6a1292c358ae68e509abd406cada26d520500c2ed134bd370379ca58a8"
RDEPENDS:texlive-filecontents = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-filehook = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-filehook-20240311-6.el10.noarch.rpm;name=texlive-filehook;unpack=0"
SRC_URI += "${URI_texlive-filehook}"
SRC_URI[texlive-filehook.sha256sum] = "b1e251017051616a3cb85224f56ca6d43f29b46e523fa5ecc9c321de853940cb"
RDEPENDS:texlive-filehook = " \
 texlive-pgf \
 texlive-kpathsea \
 texlive-kvoptions \
 texlive-currfile \
 texlive-base \
"

URI_texlive-finstrut = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-finstrut-20240311-6.el10.noarch.rpm;name=texlive-finstrut;unpack=0"
SRC_URI += "${URI_texlive-finstrut}"
SRC_URI[texlive-finstrut.sha256sum] = "1e8f5ef6a8c90637f3ea0e5ee20206fd41a814b73f2b3fadb930f2eee8910ac5"
RDEPENDS:texlive-finstrut = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-firstaid = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-firstaid-20240311-6.el10.noarch.rpm;name=texlive-firstaid;unpack=0"
SRC_URI += "${URI_texlive-firstaid}"
SRC_URI[texlive-firstaid.sha256sum] = "31f5a95dbaec4daccb2268330e27553ac08776a3924b242fce10e5b8a21cf3c9"
RDEPENDS:texlive-firstaid = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-fix2col = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-fix2col-20240311-6.el10.noarch.rpm;name=texlive-fix2col;unpack=0"
SRC_URI += "${URI_texlive-fix2col}"
SRC_URI[texlive-fix2col.sha256sum] = "17f672f6ca8e64288ab873a3f803bba539b6ca8f952ec142c52a38eba026b472"
RDEPENDS:texlive-fix2col = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-fixlatvian = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-fixlatvian-20240311-6.el10.noarch.rpm;name=texlive-fixlatvian;unpack=0"
SRC_URI += "${URI_texlive-fixlatvian}"
SRC_URI[texlive-fixlatvian.sha256sum] = "5d2b3020de2ee33bcfc93158f1479c5750b7d422d7a928b9082ed86d7e2c5ac2"
RDEPENDS:texlive-fixlatvian = " \
 texlive-etoolbox \
 texlive-was \
 texlive-bigfoot \
 texlive-polyglossia \
 texlive-kpathsea \
 texlive-caption \
 texlive-tools \
 texlive-svn-prov \
 texlive-xstring \
 texlive-base \
"

URI_texlive-float = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-float-20240311-6.el10.noarch.rpm;name=texlive-float;unpack=0"
SRC_URI += "${URI_texlive-float}"
SRC_URI[texlive-float.sha256sum] = "1133a7eef34afe7859bf319a0bb8ead38befe04d08c51c9a738e3ab90c8c3096"
RDEPENDS:texlive-float = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-fmtcount = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-fmtcount-20240311-6.el10.noarch.rpm;name=texlive-fmtcount;unpack=0"
SRC_URI += "${URI_texlive-fmtcount}"
SRC_URI[texlive-fmtcount.sha256sum] = "2f2e486352cf8feddc038d834775aa09df6a8f263caf529c03425f35afceca97"
RDEPENDS:texlive-fmtcount = " \
 texlive-etoolbox \
 texlive-graphics \
 texlive-kpathsea \
 texlive-amsmath \
 texlive-latex \
 texlive-base \
"

URI_texlive-fncychap = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-fncychap-20240311-6.el10.noarch.rpm;name=texlive-fncychap;unpack=0"
SRC_URI += "${URI_texlive-fncychap}"
SRC_URI[texlive-fncychap.sha256sum] = "82b469184f8bd8b59d98d1ee798c93e204037961ef5bb50443824320a2c114bf"
RDEPENDS:texlive-fncychap = " \
 texlive-kpathsea \
 texlive-base \
 texlive-graphics \
"

URI_texlive-fontawesome = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-fontawesome-20240311-6.el10.noarch.rpm;name=texlive-fontawesome;unpack=0"
SRC_URI += "${URI_texlive-fontawesome}"
SRC_URI[texlive-fontawesome.sha256sum] = "09488d70ec1bbdb873c98a6acc4e8632f81553d221c5fe4e1d34a61ada34b387"
RDEPENDS:texlive-fontawesome = " \
 texlive-kpathsea \
 texlive-texlive-scripts \
 texlive-iftex \
 texlive-base \
"

URI_texlive-fontbook = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-fontbook-20240311-6.el10.noarch.rpm;name=texlive-fontbook;unpack=0"
SRC_URI += "${URI_texlive-fontbook}"
SRC_URI[texlive-fontbook.sha256sum] = "02b00ad11ef6a2b02d141b3a116b1e81f9dd62358227de44b5a09c7d5806513a"
RDEPENDS:texlive-fontbook = " \
 texlive-etoolbox \
 texlive-kpathsea \
 texlive-kvoptions \
 texlive-fontspec \
 texlive-xunicode \
 texlive-base \
"

URI_texlive-fonts-tlwg = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-fonts-tlwg-20240311-6.el10.noarch.rpm;name=texlive-fonts-tlwg;unpack=0"
SRC_URI += "${URI_texlive-fonts-tlwg}"
SRC_URI[texlive-fonts-tlwg.sha256sum] = "564d59f5dcb04b3a6926f83fb722ed06bec7405662a52699c499718cd739abc3"
RDEPENDS:texlive-fonts-tlwg = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-fontspec = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-fontspec-20240311-6.el10.noarch.rpm;name=texlive-fontspec;unpack=0"
SRC_URI += "${URI_texlive-fontspec}"
SRC_URI[texlive-fontspec.sha256sum] = "b7d0f670f1c40b6a0760cfc7f002edd30b526707a6dbb8c06d8076f1ff6ea431"
RDEPENDS:texlive-fontspec = " \
 texlive-kastrup \
 texlive-luaotfload \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-latex \
 texlive-xunicode \
 texlive-lm \
 texlive-base \
"

URI_texlive-fontware = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-fontware-20240311-6.el10.x86_64_v2.rpm;name=texlive-fontware;unpack=0"
SRC_URI += "${URI_texlive-fontware}"
SRC_URI[texlive-fontware.sha256sum] = "e539ee8233281fb5c1f537470f74767cd5c63b93f3caa917f2ea6205b451aad3"
RDEPENDS:texlive-fontware = " \
 glibc \
 texlive-lib \
 texlive-base \
 texlive-kpathsea \
"

URI_texlive-fontwrap = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-fontwrap-20240311-6.el10.noarch.rpm;name=texlive-fontwrap;unpack=0"
SRC_URI += "${URI_texlive-fontwrap}"
SRC_URI[texlive-fontwrap.sha256sum] = "813df9ca1a5b0aab70b2d719e9f011028704fa72cb6fbcf96bc09af31bb326ed"
RDEPENDS:texlive-fontwrap = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-footmisc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-footmisc-20240311-6.el10.noarch.rpm;name=texlive-footmisc;unpack=0"
SRC_URI += "${URI_texlive-footmisc}"
SRC_URI[texlive-footmisc.sha256sum] = "69dc1c7285850b0fef37b5848617dd8958e1759c5460ea9df7a18b48b1d384bc"
RDEPENDS:texlive-footmisc = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-footnotehyper = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-footnotehyper-20240311-6.el10.noarch.rpm;name=texlive-footnotehyper;unpack=0"
SRC_URI += "${URI_texlive-footnotehyper}"
SRC_URI[texlive-footnotehyper.sha256sum] = "cf25052d51f3805a8fb664d7ed1ff67df92baa590f0a1ee966f888d2ecfd6870"
RDEPENDS:texlive-footnotehyper = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-fp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-fp-20240311-6.el10.noarch.rpm;name=texlive-fp;unpack=0"
SRC_URI += "${URI_texlive-fp}"
SRC_URI[texlive-fp.sha256sum] = "d1682e024ea41e3b1f7eb2515a74b273e5c4b69861aed2ea51bb65c8320f9c24"
RDEPENDS:texlive-fp = " \
 texlive-kpathsea \
 texlive-base \
 texlive-fp \
"

URI_texlive-fpl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-fpl-20240311-6.el10.noarch.rpm;name=texlive-fpl;unpack=0"
SRC_URI += "${URI_texlive-fpl}"
SRC_URI[texlive-fpl.sha256sum] = "b4b2e15275dd75438534334d3fa2c98da2abd31e9cde35e136071b8cc060f86c"
RDEPENDS:texlive-fpl = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-framed = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-framed-20240311-6.el10.noarch.rpm;name=texlive-framed;unpack=0"
SRC_URI += "${URI_texlive-framed}"
SRC_URI[texlive-framed.sha256sum] = "68a73bdefd07ce2b893c7828dae84b92da4bf27456960f84b24d7f02e8302982"
RDEPENDS:texlive-framed = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-garuda-c90 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-garuda-c90-20240311-6.el10.noarch.rpm;name=texlive-garuda-c90;unpack=0"
SRC_URI += "${URI_texlive-garuda-c90}"
SRC_URI[texlive-garuda-c90.sha256sum] = "6fe6cb01ad8cfb3a8feab7257ceb1ea1df1b26f1de70d7cd246af82661135dd8"
RDEPENDS:texlive-garuda-c90 = " \
 texlive-kpathsea \
 texlive-fonts-tlwg \
 texlive-base \
"

URI_texlive-geometry = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-geometry-20240311-6.el10.noarch.rpm;name=texlive-geometry;unpack=0"
SRC_URI += "${URI_texlive-geometry}"
SRC_URI[texlive-geometry.sha256sum] = "410c1847a81daa380d1664e4f5a6a10d6aa1b356ef4a7190dea59687b1705867"
RDEPENDS:texlive-geometry = " \
 texlive-graphics \
 texlive-kpathsea \
 texlive-atbegshi \
 texlive-iftex \
 texlive-base \
"

URI_texlive-gettitlestring = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-gettitlestring-20240311-6.el10.noarch.rpm;name=texlive-gettitlestring;unpack=0"
SRC_URI += "${URI_texlive-gettitlestring}"
SRC_URI[texlive-gettitlestring.sha256sum] = "df1f5f31f9824dcff850bf62a31fac2d998a57b250fd59e0e37fff2bc37b2dd0"
RDEPENDS:texlive-gettitlestring = " \
 texlive-kpathsea \
"

URI_texlive-glyphlist = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-glyphlist-20240311-6.el10.noarch.rpm;name=texlive-glyphlist;unpack=0"
SRC_URI += "${URI_texlive-glyphlist}"
SRC_URI[texlive-glyphlist.sha256sum] = "0b61b5bf100cced075e6a312dd1bedbf8a671c36d74f79753ab1c016519654e9"
RDEPENDS:texlive-glyphlist = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-graphics = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-graphics-20240311-6.el10.noarch.rpm;name=texlive-graphics;unpack=0"
SRC_URI += "${URI_texlive-graphics}"
SRC_URI[texlive-graphics.sha256sum] = "ec4a5489684bac3768d808590b341cc46a2f60609ffd43ae072c7b83a22ee663"
RDEPENDS:texlive-graphics = " \
 texlive-kpathsea \
 texlive-base \
 texlive-graphics-cfg \
"

URI_texlive-graphics-cfg = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-graphics-cfg-20240311-6.el10.noarch.rpm;name=texlive-graphics-cfg;unpack=0"
SRC_URI += "${URI_texlive-graphics-cfg}"
SRC_URI[texlive-graphics-cfg.sha256sum] = "2ba8cbe6edce6a9c93164c9ab3a72aff63ccd66affab04958f9ebcc6ed4e08bd"
RDEPENDS:texlive-graphics-cfg = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-graphics-def = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-graphics-def-20240311-6.el10.noarch.rpm;name=texlive-graphics-def;unpack=0"
SRC_URI += "${URI_texlive-graphics-def}"
SRC_URI[texlive-graphics-def.sha256sum] = "345b5c43de3c77b20793fd9b313c42c4c3b9f77116348ce7aeb041e123f3e756"
RDEPENDS:texlive-graphics-def = " \
 texlive-kpathsea \
 texlive-epstopdf-pkg \
 texlive-base \
"

URI_texlive-grfext = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-grfext-20240311-6.el10.noarch.rpm;name=texlive-grfext;unpack=0"
SRC_URI += "${URI_texlive-grfext}"
SRC_URI[texlive-grfext.sha256sum] = "14e9d285e13c5f82186d681e4c862a2981bdba834222d0e85ccee5ab3738b546"
RDEPENDS:texlive-grfext = " \
 texlive-kpathsea \
"

URI_texlive-grffile = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-grffile-20240311-6.el10.noarch.rpm;name=texlive-grffile;unpack=0"
SRC_URI += "${URI_texlive-grffile}"
SRC_URI[texlive-grffile.sha256sum] = "930dbdc1dfbe2d8c469ade8e2531916b7737b97738a20ba55a6af6804d71463d"
RDEPENDS:texlive-grffile = " \
 texlive-kpathsea \
"

URI_texlive-gsftopk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-gsftopk-20240311-6.el10.x86_64_v2.rpm;name=texlive-gsftopk;unpack=0"
SRC_URI += "${URI_texlive-gsftopk}"
SRC_URI[texlive-gsftopk.sha256sum] = "2d8162896285a86dfca7b310e0b87fa0a2b58f3f0e5900fee0434457aadafb2f"
RDEPENDS:texlive-gsftopk = " \
 glibc \
 texlive-lib \
 texlive-base \
 texlive-kpathsea \
"

URI_texlive-hanging = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-hanging-20240311-6.el10.noarch.rpm;name=texlive-hanging;unpack=0"
SRC_URI += "${URI_texlive-hanging}"
SRC_URI[texlive-hanging.sha256sum] = "b1bfb6819626c5dfb35a10b1e9ee71cf1ef5adfffa3c64025bebb03f7657296d"
RDEPENDS:texlive-hanging = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-helvetic = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-helvetic-20240311-6.el10.noarch.rpm;name=texlive-helvetic;unpack=0"
SRC_URI += "${URI_texlive-helvetic}"
SRC_URI[texlive-helvetic.sha256sum] = "0b7968261c4f26af23318aec2dc93de89e499f57a1fdcd29815442ddd8767282"
RDEPENDS:texlive-helvetic = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-hobsub = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-hobsub-20240311-6.el10.noarch.rpm;name=texlive-hobsub;unpack=0"
SRC_URI += "${URI_texlive-hobsub}"
SRC_URI[texlive-hobsub.sha256sum] = "e0336e46093ce5e3329e46a74020069970c4e4f43ebaf63a9e4e4c0f5ea81112"
RDEPENDS:texlive-hobsub = " \
 texlive-kpathsea \
"

URI_texlive-hologo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-hologo-20240311-6.el10.noarch.rpm;name=texlive-hologo;unpack=0"
SRC_URI += "${URI_texlive-hologo}"
SRC_URI[texlive-hologo.sha256sum] = "93d047cf0dc0681c339e9814093c739e959ac3e513c70b9e7a3c6d5851b1ed83"
RDEPENDS:texlive-hologo = " \
 texlive-kpathsea \
"

URI_texlive-hopatch = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-hopatch-20240311-6.el10.noarch.rpm;name=texlive-hopatch;unpack=0"
SRC_URI += "${URI_texlive-hopatch}"
SRC_URI[texlive-hopatch.sha256sum] = "daf3becaa2d8da58b1fbf4c682a6358f592fed37eb29f004f7e1b9a324082028"
RDEPENDS:texlive-hopatch = " \
 texlive-ltxcmds \
 texlive-kpathsea \
"

URI_texlive-hycolor = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-hycolor-20240311-6.el10.noarch.rpm;name=texlive-hycolor;unpack=0"
SRC_URI += "${URI_texlive-hycolor}"
SRC_URI[texlive-hycolor.sha256sum] = "c330e74b21e4cd4f648ea43536d10c6e154d2fe9e324ea0fc767ed783456dfc9"
RDEPENDS:texlive-hycolor = " \
 texlive-kpathsea \
"

URI_texlive-hypcap = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-hypcap-20240311-6.el10.noarch.rpm;name=texlive-hypcap;unpack=0"
SRC_URI += "${URI_texlive-hypcap}"
SRC_URI[texlive-hypcap.sha256sum] = "8137e25d64285242f5758bbda2d319a8f69b60d827596d2d6186bb862b485cfa"
RDEPENDS:texlive-hypcap = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-hypdoc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-hypdoc-20240311-6.el10.noarch.rpm;name=texlive-hypdoc;unpack=0"
SRC_URI += "${URI_texlive-hypdoc}"
SRC_URI[texlive-hypdoc.sha256sum] = "c209a690a2c3b28af06f6f82dbaa3c2b2a83a87b44374ebb8329dd35094ae8d1"
RDEPENDS:texlive-hypdoc = " \
 texlive-kpathsea \
"

URI_texlive-hyperref = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-hyperref-20240311-6.el10.noarch.rpm;name=texlive-hyperref;unpack=0"
SRC_URI += "${URI_texlive-hyperref}"
SRC_URI[texlive-hyperref.sha256sum] = "6735a664b72db7c3298cd6ef15b0c19e0c51f2ea9cbdfc844cf3dc81c27eb190"
RDEPENDS:texlive-hyperref = " \
 texlive-url \
 texlive-etexcmds \
 texlive-pdfescape \
 texlive-zapfding \
 texlive-pdftexcmds \
 texlive-gettitlestring \
 texlive-graphics \
 texlive-hobsub \
 texlive-hycolor \
 texlive-atbegshi \
 texlive-auxhook \
 texlive-iftex \
 texlive-base \
 texlive-infwarerr \
 texlive-intcalc \
 texlive-refcount \
 texlive-rerunfilecheck \
 texlive-bitset \
 texlive-kpathsea \
 texlive-kvdefinekeys \
 texlive-kvoptions \
 texlive-kvsetkeys \
 texlive-stringenc \
 texlive-letltxmacro \
 texlive-ltxcmds \
 texlive-memoir \
"

URI_texlive-hyph-utf8 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-hyph-utf8-20240311-6.el10.noarch.rpm;name=texlive-hyph-utf8;unpack=0"
SRC_URI += "${URI_texlive-hyph-utf8}"
SRC_URI[texlive-hyph-utf8.sha256sum] = "9794a180018ec35022869b853f9cae21062c5bf4275c3a659c7ddaa83143d5db"
RDEPENDS:texlive-hyph-utf8 = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-hyphen-base = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-hyphen-base-20240311-6.el10.noarch.rpm;name=texlive-hyphen-base;unpack=0"
SRC_URI += "${URI_texlive-hyphen-base}"
SRC_URI[texlive-hyphen-base.sha256sum] = "b5a454a75041f5dcf148f982a47d80e61ece196e8c447bc0978ef178ef235457"
RDEPENDS:texlive-hyphen-base = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-hyphenat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-hyphenat-20240311-6.el10.noarch.rpm;name=texlive-hyphenat;unpack=0"
SRC_URI += "${URI_texlive-hyphenat}"
SRC_URI[texlive-hyphenat.sha256sum] = "a746206e0ff95b5af04df4c8d63194f183997e8c42edbc41cc516ba2a2654d11"
RDEPENDS:texlive-hyphenat = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-hyphenex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-hyphenex-20240311-6.el10.noarch.rpm;name=texlive-hyphenex;unpack=0"
SRC_URI += "${URI_texlive-hyphenex}"
SRC_URI[texlive-hyphenex.sha256sum] = "f0bfa96740fb55186e8531dda7574cfbf5fb452bd48c016f94a0dc98807925ce"
RDEPENDS:texlive-hyphenex = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-ifmtarg = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-ifmtarg-20240311-6.el10.noarch.rpm;name=texlive-ifmtarg;unpack=0"
SRC_URI += "${URI_texlive-ifmtarg}"
SRC_URI[texlive-ifmtarg.sha256sum] = "25fb8260d4591ede2ddd1004b1ce88b26f845567deb606d9a89d21af13dea7e1"
RDEPENDS:texlive-ifmtarg = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-ifoddpage = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-ifoddpage-20240311-6.el10.noarch.rpm;name=texlive-ifoddpage;unpack=0"
SRC_URI += "${URI_texlive-ifoddpage}"
SRC_URI[texlive-ifoddpage.sha256sum] = "3d9283f8bd9ad361b7fa599f335f33b312f78bd8191fd5699f464009031bf542"
RDEPENDS:texlive-ifoddpage = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-ifplatform = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-ifplatform-20240311-6.el10.noarch.rpm;name=texlive-ifplatform;unpack=0"
SRC_URI += "${URI_texlive-ifplatform}"
SRC_URI[texlive-ifplatform.sha256sum] = "28f733a8174665781981d85062669200cd3b8ea30a372f2e58fdcdfe62517542"
RDEPENDS:texlive-ifplatform = " \
 texlive-kpathsea \
 texlive-catchfile \
 texlive-iftex \
 texlive-base \
 texlive-pdftexcmds \
"

URI_texlive-iftex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-iftex-20240311-6.el10.noarch.rpm;name=texlive-iftex;unpack=0"
SRC_URI += "${URI_texlive-iftex}"
SRC_URI[texlive-iftex.sha256sum] = "7b6bb8f38a019559345afe8b21146f336defb6b3527fcf1af8c8dbd574920d67"
RDEPENDS:texlive-iftex = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-import = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-import-20240311-6.el10.noarch.rpm;name=texlive-import;unpack=0"
SRC_URI += "${URI_texlive-import}"
SRC_URI[texlive-import.sha256sum] = "35eedd23d1e8c157f40a5b3703165b347f3cb889bf6230dd674abe76d68eca8b"
RDEPENDS:texlive-import = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-index = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-index-20240311-6.el10.noarch.rpm;name=texlive-index;unpack=0"
SRC_URI += "${URI_texlive-index}"
SRC_URI[texlive-index.sha256sum] = "0de27ff6c09af51b1a1aac5bfe4456c6c3095d0f335cce1652cead6086015319"
RDEPENDS:texlive-index = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-infwarerr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-infwarerr-20240311-6.el10.noarch.rpm;name=texlive-infwarerr;unpack=0"
SRC_URI += "${URI_texlive-infwarerr}"
SRC_URI[texlive-infwarerr.sha256sum] = "c7995e906c968ba217a18cd527cc9525cd2c6373badd40eb49e21db4fe8c7569"
RDEPENDS:texlive-infwarerr = " \
 texlive-kpathsea \
"

URI_texlive-intcalc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-intcalc-20240311-6.el10.noarch.rpm;name=texlive-intcalc;unpack=0"
SRC_URI += "${URI_texlive-intcalc}"
SRC_URI[texlive-intcalc.sha256sum] = "70c9cf07a0386aaf0fe53469c9dc0729e721feda7661e76833aa892190b9a04e"
RDEPENDS:texlive-intcalc = " \
 texlive-kpathsea \
"

URI_texlive-jadetex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-jadetex-20240311-6.el10.noarch.rpm;name=texlive-jadetex;unpack=0"
SRC_URI += "${URI_texlive-jadetex}"
SRC_URI[texlive-jadetex.sha256sum] = "79149cafe1aea68a2d62eb99fe68a795b92bd5ab87328ebb0e6d5a12f01a186e"
RDEPENDS:texlive-jadetex = " \
 texlive-texlive-scripts \
 texlive-kpathsea \
 texlive-latex \
 texlive-passivetex \
 coreutils \
 texlive-tex \
 texlive-base \
 texlive-pdftex \
"

URI_texlive-jknapltx = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-jknapltx-20240311-6.el10.noarch.rpm;name=texlive-jknapltx;unpack=0"
SRC_URI += "${URI_texlive-jknapltx}"
SRC_URI[texlive-jknapltx.sha256sum] = "d3bf00b6d605ddd6f20141ae6bdf8b2c87e8a787582ebf4a048b2c13c9ca06cf"
RDEPENDS:texlive-jknapltx = " \
 texlive-kpathsea \
 texlive-latex \
 texlive-base \
 texlive-graphics \
"

URI_texlive-kastrup = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-kastrup-20240311-6.el10.noarch.rpm;name=texlive-kastrup;unpack=0"
SRC_URI += "${URI_texlive-kastrup}"
SRC_URI[texlive-kastrup.sha256sum] = "c934653c5573b70b8893d9d9a5cafd1e0550cdea135b63e1908132d42837a221"
RDEPENDS:texlive-kastrup = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-kerkis = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-kerkis-20240311-6.el10.noarch.rpm;name=texlive-kerkis;unpack=0"
SRC_URI += "${URI_texlive-kerkis}"
SRC_URI[texlive-kerkis.sha256sum] = "14fcf15d08fff01562c99ed73eea202086d35ac0bbebfdcafc38ec5df996dddb"
RDEPENDS:texlive-kerkis = " \
 texlive-kpathsea \
 texlive-txfonts \
 texlive-base \
"

URI_texlive-knuth-lib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-knuth-lib-20240311-6.el10.noarch.rpm;name=texlive-knuth-lib;unpack=0"
SRC_URI += "${URI_texlive-knuth-lib}"
SRC_URI[texlive-knuth-lib.sha256sum] = "802f92ece8e88b852b1e14ab3dbae5696420303122502c95bf85ab53e0918cf4"
RDEPENDS:texlive-knuth-lib = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-knuth-local = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-knuth-local-20240311-6.el10.noarch.rpm;name=texlive-knuth-local;unpack=0"
SRC_URI += "${URI_texlive-knuth-local}"
SRC_URI[texlive-knuth-local.sha256sum] = "fa5ae7b52e7dc20126ae4c2915f0bb483e4c6b7c302d35fde64767a2db082714"
RDEPENDS:texlive-knuth-local = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-koma-script = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-koma-script-20240311-6.el10.noarch.rpm;name=texlive-koma-script;unpack=0"
SRC_URI += "${URI_texlive-koma-script}"
SRC_URI[texlive-koma-script.sha256sum] = "ce096d7829992ed04bb4b6f745c1114810c96d02d9eadd776c0ca1c44e4326e6"
RDEPENDS:texlive-koma-script = " \
 texlive-mparhack \
 texlive-etoolbox \
 texlive-geometry \
 texlive-graphics \
 texlive-koma-script \
 texlive-kpathsea \
 texlive-xcolor \
 texlive-booktabs \
 texlive-bookmark \
 texlive-amsmath \
 texlive-tools \
 texlive-latex \
 texlive-marginnote \
 texlive-hyperref \
 texlive-listings \
 texlive-babelbib \
 texlive-base \
"

URI_texlive-kpathsea = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-kpathsea-20240311-6.el10.x86_64_v2.rpm;name=texlive-kpathsea;unpack=0"
SRC_URI += "${URI_texlive-kpathsea}"
SRC_URI[texlive-kpathsea.sha256sum] = "b89a7e82292488f93d539b8fbef0bc40833bd6981ed49d409c4b1a7e4ad11e70"
RDEPENDS:texlive-kpathsea = " \
 texlive-texlive-scripts \
 texlive-lib \
 grep \
 bash \
 glibc \
 coreutils \
 texlive-base \
"

URI_texlive-kvdefinekeys = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-kvdefinekeys-20240311-6.el10.noarch.rpm;name=texlive-kvdefinekeys;unpack=0"
SRC_URI += "${URI_texlive-kvdefinekeys}"
SRC_URI[texlive-kvdefinekeys.sha256sum] = "d11aee3f00acfdfe93357fbdaa83c13fa1d74053edc2393f759ac0ba1e57862f"
RDEPENDS:texlive-kvdefinekeys = " \
 texlive-kpathsea \
"

URI_texlive-kvoptions = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-kvoptions-20240311-6.el10.noarch.rpm;name=texlive-kvoptions;unpack=0"
SRC_URI += "${URI_texlive-kvoptions}"
SRC_URI[texlive-kvoptions.sha256sum] = "6d897439b5aedeaf1289186c082c67fb4eed0ea804e2fa23fe64c293c4c8f40e"
RDEPENDS:texlive-kvoptions = " \
 texlive-kpathsea \
"

URI_texlive-kvsetkeys = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-kvsetkeys-20240311-6.el10.noarch.rpm;name=texlive-kvsetkeys;unpack=0"
SRC_URI += "${URI_texlive-kvsetkeys}"
SRC_URI[texlive-kvsetkeys.sha256sum] = "f9e53e1c1c129e160b3e2f33dfc615a3109a52df64068f6d13e2f7049be4a22f"
RDEPENDS:texlive-kvsetkeys = " \
 texlive-kpathsea \
"

URI_texlive-l3backend = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-l3backend-20240311-6.el10.noarch.rpm;name=texlive-l3backend;unpack=0"
SRC_URI += "${URI_texlive-l3backend}"
SRC_URI[texlive-l3backend.sha256sum] = "c80a4b490da01a6c086be0d02bddabbe9a44f4de8e10fccf8c0f707f60022521"
RDEPENDS:texlive-l3backend = " \
 texlive-kpathsea \
"

URI_texlive-l3experimental = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-l3experimental-20240311-6.el10.noarch.rpm;name=texlive-l3experimental;unpack=0"
SRC_URI += "${URI_texlive-l3experimental}"
SRC_URI[texlive-l3experimental.sha256sum] = "a408a27aadf3dba403cf8bd8520a8aa7abdaeb3fcc26406d45999599f28c111d"
RDEPENDS:texlive-l3experimental = " \
 texlive-kpathsea \
 texlive-base \
 texlive-l3kernel \
 texlive-l3packages \
"

URI_texlive-l3kernel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-l3kernel-20240311-6.el10.noarch.rpm;name=texlive-l3kernel;unpack=0"
SRC_URI += "${URI_texlive-l3kernel}"
SRC_URI[texlive-l3kernel.sha256sum] = "429c8afda0240d1c16cd8fa4f0b8cb66c659cb7b22966ecda2ad0be17af8c725"
RDEPENDS:texlive-l3kernel = " \
 texlive-fancyvrb \
 texlive-graphics \
 texlive-psnfss \
 texlive-alphalph \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-hologo \
 texlive-hypdoc \
 texlive-base \
 texlive-kpathsea \
 texlive-booktabs \
 texlive-l3backend \
 texlive-latex \
 texlive-lm \
 texlive-colortbl \
 texlive-csquotes \
 texlive-tools \
 texlive-enumitem \
 texlive-underscore \
"

URI_texlive-l3packages = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-l3packages-20240311-6.el10.noarch.rpm;name=texlive-l3packages;unpack=0"
SRC_URI += "${URI_texlive-l3packages}"
SRC_URI[texlive-l3packages.sha256sum] = "bb91ffc69d003542afdf0395752eb5e4bb40582f123ee20f1b9be891ad17abbe"
RDEPENDS:texlive-l3packages = " \
 texlive-graphics \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-amsmath \
 texlive-base \
"

URI_texlive-lastpage = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-lastpage-20240311-6.el10.noarch.rpm;name=texlive-lastpage;unpack=0"
SRC_URI += "${URI_texlive-lastpage}"
SRC_URI[texlive-lastpage.sha256sum] = "fd1b8f3fd8d386783689bb444385291e43b2a8f6d2eb48e7b81960d3f6acac55"
RDEPENDS:texlive-lastpage = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-latex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-latex-20240311-6.el10.noarch.rpm;name=texlive-latex;unpack=0"
SRC_URI += "${URI_texlive-latex}"
SRC_URI[texlive-latex.sha256sum] = "a463504942d7afe874247573cae24c4a9500d099b4c3fe34b2f422ca646dad4c"
RDEPENDS:texlive-latex = " \
 texlive-url \
 texlive-cm-super \
 texlive-luatex \
 texlive-psnfss \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-tools \
 texlive-latex-fonts \
 texlive-hypdoc \
 texlive-hyperref \
 texlive-latexconfig \
 coreutils \
 texlive-base \
 texlive-pdftex \
"

URI_texlive-latex-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-latex-fonts-20240311-6.el10.noarch.rpm;name=texlive-latex-fonts;unpack=0"
SRC_URI += "${URI_texlive-latex-fonts}"
SRC_URI[texlive-latex-fonts.sha256sum] = "c956e5756398df793f5a761f27ae25bccd109a28a0d4dc1c9e8b5831e350281f"
RDEPENDS:texlive-latex-fonts = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-latex2man = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-latex2man-20240311-6.el10.noarch.rpm;name=texlive-latex2man;unpack=0"
SRC_URI += "${URI_texlive-latex2man}"
SRC_URI[texlive-latex2man.sha256sum] = "0eb0ab627050c0f44dd8abdf5ace4eca1236eeaf2bd03c7459e36b00f5c46e94"
RDEPENDS:texlive-latex2man = " \
 perl-libs \
 texlive-kpathsea \
 texlive-fancyhdr \
 perl-File-Basename \
 perl-Getopt-Std \
 info \
 coreutils \
 texlive-base \
"

URI_texlive-latexbug = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-latexbug-20240311-6.el10.noarch.rpm;name=texlive-latexbug;unpack=0"
SRC_URI += "${URI_texlive-latexbug}"
SRC_URI[texlive-latexbug.sha256sum] = "27c00c69f68270e70cb447e096996eeacedb1d49834e5c5c5ccdd9bfc3ab9522"
RDEPENDS:texlive-latexbug = " \
 texlive-kpathsea \
"

URI_texlive-latexconfig = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-latexconfig-20240311-6.el10.noarch.rpm;name=texlive-latexconfig;unpack=0"
SRC_URI += "${URI_texlive-latexconfig}"
SRC_URI[texlive-latexconfig.sha256sum] = "d3088136fd669c7162a9ef3a3e54842d607bd424d7eb7b39c06af2e6071f4edb"
RDEPENDS:texlive-latexconfig = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-letltxmacro = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-letltxmacro-20240311-6.el10.noarch.rpm;name=texlive-letltxmacro;unpack=0"
SRC_URI += "${URI_texlive-letltxmacro}"
SRC_URI[texlive-letltxmacro.sha256sum] = "08d50f4fb413fb8a6d4ba2d8807cdb704f947d50f8df52badfaab6ddbf219b40"
RDEPENDS:texlive-letltxmacro = " \
 texlive-kpathsea \
"

URI_texlive-lettrine = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-lettrine-20240311-6.el10.noarch.rpm;name=texlive-lettrine;unpack=0"
SRC_URI += "${URI_texlive-lettrine}"
SRC_URI[texlive-lettrine.sha256sum] = "fbc5a9bcb4401363b227d12f53c34e48caa97d9c83b4bf2a2e90acc37e5bf4cd"
RDEPENDS:texlive-lettrine = " \
 texlive-kpathsea \
 texlive-base \
 texlive-graphics \
"

URI_texlive-lib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-lib-20240311-6.el10.x86_64_v2.rpm;name=texlive-lib;unpack=0"
SRC_URI += "${URI_texlive-lib}"
SRC_URI[texlive-lib.sha256sum] = "ded3855db19b4f26dc964f1a3936b06925701fa16fe776ca7d636dbf3cb95c06"
RDEPENDS:texlive-lib = " \
 glibc \
 zlib-ng-compat \
"

URI_texlive-linegoal = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-linegoal-20240311-6.el10.noarch.rpm;name=texlive-linegoal;unpack=0"
SRC_URI += "${URI_texlive-linegoal}"
SRC_URI[texlive-linegoal.sha256sum] = "ff0fa91cf992fab9cb765687ab0e8ea1a8100b40e73d365521ad626d52aa24a5"
RDEPENDS:texlive-linegoal = " \
 texlive-kpathsea \
 texlive-zref \
 texlive-base \
 texlive-etex-pkg \
"

URI_texlive-lineno = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-lineno-20240311-6.el10.noarch.rpm;name=texlive-lineno;unpack=0"
SRC_URI += "${URI_texlive-lineno}"
SRC_URI[texlive-lineno.sha256sum] = "847b1214306bf9a12376816fb6f1087b24bde8013be20120e1a4d9af987cab5c"
RDEPENDS:texlive-lineno = " \
 texlive-kpathsea \
 texlive-tools \
 texlive-finstrut \
 texlive-base \
 texlive-ltabptch \
"

URI_texlive-listings = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-listings-20240311-6.el10.noarch.rpm;name=texlive-listings;unpack=0"
SRC_URI += "${URI_texlive-listings}"
SRC_URI[texlive-listings.sha256sum] = "5db64f123427d23848ea6c4cf69724f5efa8ecf729758c9c69e72ede20838482"
RDEPENDS:texlive-listings = " \
 texlive-url \
 texlive-graphics \
 texlive-kpathsea \
 texlive-algorithms \
 texlive-fancyvrb \
 texlive-latex \
 texlive-hyperref \
 texlive-base \
"

URI_texlive-listofitems = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-listofitems-20240311-6.el10.noarch.rpm;name=texlive-listofitems;unpack=0"
SRC_URI += "${URI_texlive-listofitems}"
SRC_URI[texlive-listofitems.sha256sum] = "74d9224b08b2a3d57c621b0c76ceb6218721a83fb2bf47c1136cf52ff9b81be2"
RDEPENDS:texlive-listofitems = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-lm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-lm-20240311-6.el10.noarch.rpm;name=texlive-lm;unpack=0"
SRC_URI += "${URI_texlive-lm}"
SRC_URI[texlive-lm.sha256sum] = "870d37c634dabb82020062dedec56bff418ba0ff304982c5533ea1adc6539fa7"
RDEPENDS:texlive-lm = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-lm-math = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-lm-math-20240311-6.el10.noarch.rpm;name=texlive-lm-math;unpack=0"
SRC_URI += "${URI_texlive-lm-math}"
SRC_URI[texlive-lm-math.sha256sum] = "9a6836fc0d1398a3c83f08f0f94dcaa270c47bb6611ae5f6f71214018fe464c8"
RDEPENDS:texlive-lm-math = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-ltabptch = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-ltabptch-20240311-6.el10.noarch.rpm;name=texlive-ltabptch;unpack=0"
SRC_URI += "${URI_texlive-ltabptch}"
SRC_URI[texlive-ltabptch.sha256sum] = "18757d34b6eba9f14e4ef2030149bce36a87f34f28968ddc7ddab4f51e5f619f"
RDEPENDS:texlive-ltabptch = " \
 texlive-kpathsea \
 texlive-base \
 texlive-tools \
"

URI_texlive-ltxcmds = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-ltxcmds-20240311-6.el10.noarch.rpm;name=texlive-ltxcmds;unpack=0"
SRC_URI += "${URI_texlive-ltxcmds}"
SRC_URI[texlive-ltxcmds.sha256sum] = "d89ae7253ef2157870421edd5315876a305fb81e4b9b30eedaa579be7898f800"
RDEPENDS:texlive-ltxcmds = " \
 texlive-kpathsea \
"

URI_texlive-ltxmisc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-ltxmisc-20240311-6.el10.noarch.rpm;name=texlive-ltxmisc;unpack=0"
SRC_URI += "${URI_texlive-ltxmisc}"
SRC_URI[texlive-ltxmisc.sha256sum] = "044f16dad4052a6d07b5b42e71c2435302809f2575a352c721db938c072cf84c"
RDEPENDS:texlive-ltxmisc = " \
 texlive-beton \
 texlive-euler \
 texlive-graphics \
 texlive-natbib \
 texlive-kpathsea \
 texlive-psnfss \
 texlive-tools \
 texlive-latex \
 texlive-base \
 texlive-minitoc \
"

URI_texlive-lua-alt-getopt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-lua-alt-getopt-20240311-6.el10.noarch.rpm;name=texlive-lua-alt-getopt;unpack=0"
SRC_URI += "${URI_texlive-lua-alt-getopt}"
SRC_URI[texlive-lua-alt-getopt.sha256sum] = "4fb6f1101924010b4808f86f5c9b47f89ec8d9d7c2ff9bf2ab0504afa8cafe10"
RDEPENDS:texlive-lua-alt-getopt = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-lua-uni-algos = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-lua-uni-algos-20240311-6.el10.noarch.rpm;name=texlive-lua-uni-algos;unpack=0"
SRC_URI += "${URI_texlive-lua-uni-algos}"
SRC_URI[texlive-lua-uni-algos.sha256sum] = "f259f0841946fb4b935603e711f15ad8c1e179105cdd3aaa9aa2ebf407a544d0"
RDEPENDS:texlive-lua-uni-algos = " \
 texlive-luatex \
 texlive-unicode-data \
 texlive-kpathsea \
"

URI_texlive-luahbtex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-luahbtex-20240311-6.el10.x86_64_v2.rpm;name=texlive-luahbtex;unpack=0"
SRC_URI += "${URI_texlive-luahbtex}"
SRC_URI[texlive-luahbtex.sha256sum] = "4a9841618f3e6261b148ee4877c4dee8179da15c4ec2b9e5c067450757f6d572"
RDEPENDS:texlive-luahbtex = " \
 zlib-ng-compat \
 texlive-lib \
 libpng \
 texlive-plain \
 texlive-knuth-lib \
 texlive-luatex \
 texlive-kpathsea \
 harfbuzz \
 libgcc \
 zziplib \
 texlive-etex \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-cm \
 glibc \
 texlive-unicode-data \
 texlive-base \
 texlive-tex-ini-files \
"

URI_texlive-lualatex-math = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-lualatex-math-20240311-6.el10.noarch.rpm;name=texlive-lualatex-math;unpack=0"
SRC_URI += "${URI_texlive-lualatex-math}"
SRC_URI[texlive-lualatex-math.sha256sum] = "d83022e6241054eafd5ee02f340a4957da15937101784ea473af65f9ea4399c8"
RDEPENDS:texlive-lualatex-math = " \
 texlive-etoolbox \
 texlive-kpathsea \
 texlive-luatexbase \
 texlive-l3kernel \
 texlive-filehook \
 texlive-base \
"

URI_texlive-lualibs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-lualibs-20240311-6.el10.noarch.rpm;name=texlive-lualibs;unpack=0"
SRC_URI += "${URI_texlive-lualibs}"
SRC_URI[texlive-lualibs.sha256sum] = "e2a2d5708f33880c34d692510a6e86929a4e57fbdd6b12f570af486f858daea4"
RDEPENDS:texlive-lualibs = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-luaotfload = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-luaotfload-20240311-6.el10.noarch.rpm;name=texlive-luaotfload;unpack=0"
SRC_URI += "${URI_texlive-luaotfload}"
SRC_URI[texlive-luaotfload.sha256sum] = "37a85f96ca94f90cb74c216b3b767d21c567ced9ff05bc24501f2fd39fcebc9f"
RDEPENDS:texlive-luaotfload = " \
 texlive-lua-alt-getopt \
 texlive-lua-uni-algos \
 texlive-lualibs \
 texlive-kpathsea \
 texlive-luatexbase \
 coreutils \
 texlive-base \
"

URI_texlive-luatex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-luatex-20240311-6.el10.x86_64_v2.rpm;name=texlive-luatex;unpack=0"
SRC_URI += "${URI_texlive-luatex}"
SRC_URI[texlive-luatex.sha256sum] = "b57acfca26c08afb3cee3879121cb84b643d9fafd42e79b7958fd48ee1411bf0"
RDEPENDS:texlive-luatex = " \
 zlib-ng-compat \
 texlive-lib \
 libpng \
 texlive-texlive-scripts \
 texlive-plain \
 texlive-knuth-lib \
 texlive-graphics-def \
 texlive-kpathsea \
 zziplib \
 texlive-etex \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-cm \
 glibc \
 coreutils \
 texlive-unicode-data \
 texlive-base \
 texlive-tex-ini-files \
"

URI_texlive-luatex85 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-luatex85-20240311-6.el10.noarch.rpm;name=texlive-luatex85;unpack=0"
SRC_URI += "${URI_texlive-luatex85}"
SRC_URI[texlive-luatex85.sha256sum] = "ebdc1cd8e63eeef456cefeaa6c9a4f8398ae98237eba37010c65f72736c40b4d"
RDEPENDS:texlive-luatex85 = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-luatexbase = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-luatexbase-20240311-6.el10.noarch.rpm;name=texlive-luatexbase;unpack=0"
SRC_URI += "${URI_texlive-luatexbase}"
SRC_URI[texlive-luatexbase.sha256sum] = "7e7a20a1335817cffdc69f91f9023fa74bd9c238d94ef3d87fec0e68b119e944"
RDEPENDS:texlive-luatexbase = " \
 texlive-kpathsea \
 texlive-luatexbase \
 texlive-iftex \
 texlive-base \
 texlive-etex-pkg \
"

URI_texlive-lwarp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-lwarp-20240311-6.el10.noarch.rpm;name=texlive-lwarp;unpack=0"
SRC_URI += "${URI_texlive-lwarp}"
SRC_URI[texlive-lwarp.sha256sum] = "c035115151353c752431808c16d6800242f84b177f0d966cac217b6062a3f4ec"
RDEPENDS:texlive-lwarp = " \
 texlive-kpathsea \
 coreutils \
 texlive-base \
"

URI_texlive-makecmds = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-makecmds-20240311-6.el10.noarch.rpm;name=texlive-makecmds;unpack=0"
SRC_URI += "${URI_texlive-makecmds}"
SRC_URI[texlive-makecmds.sha256sum] = "491d07fda42ca73f24dde21d4b12f34e1ecce134fca26329d00ec27ca3acefeb"
RDEPENDS:texlive-makecmds = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-makeindex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-makeindex-20240311-6.el10.x86_64_v2.rpm;name=texlive-makeindex;unpack=0"
SRC_URI += "${URI_texlive-makeindex}"
SRC_URI[texlive-makeindex.sha256sum] = "c62f2c9015f4c69566083b0a98c89ddd309cbb59d3c728a03a9c7828aef0b2d0"
RDEPENDS:texlive-makeindex = " \
 texlive-lib \
 texlive-kpathsea \
 bash \
 glibc \
 texlive-base \
"

URI_texlive-manfnt-font = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-manfnt-font-20240311-6.el10.noarch.rpm;name=texlive-manfnt-font;unpack=0"
SRC_URI += "${URI_texlive-manfnt-font}"
SRC_URI[texlive-manfnt-font.sha256sum] = "9cec5bcb7cf06278a2eb0d3c1ada61f7b78292a7da1c5f6ad5e3f28958bdc547"
RDEPENDS:texlive-manfnt-font = " \
 texlive-kpathsea \
 texlive-texlive-scripts \
 texlive-base \
"

URI_texlive-marginnote = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-marginnote-20240311-6.el10.noarch.rpm;name=texlive-marginnote;unpack=0"
SRC_URI += "${URI_texlive-marginnote}"
SRC_URI[texlive-marginnote.sha256sum] = "c4fdd82885a218939ac1a95fa711e61749d907362f191220a9c151f44e724b2b"
RDEPENDS:texlive-marginnote = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-marvosym = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-marvosym-20240311-6.el10.noarch.rpm;name=texlive-marvosym;unpack=0"
SRC_URI += "${URI_texlive-marvosym}"
SRC_URI[texlive-marvosym.sha256sum] = "078bc7b64a9a3b0b87edcdd3638e8c5ed452fadaa0f845cd5624ac696f8d33d7"
RDEPENDS:texlive-marvosym = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-mathpazo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-mathpazo-20240311-6.el10.noarch.rpm;name=texlive-mathpazo;unpack=0"
SRC_URI += "${URI_texlive-mathpazo}"
SRC_URI[texlive-mathpazo.sha256sum] = "115b2120f6f4fdd4c2a018c123848b67031eaa782388e8d5d27efe3979293175"
RDEPENDS:texlive-mathpazo = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-mathspec = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-mathspec-20240311-6.el10.noarch.rpm;name=texlive-mathspec;unpack=0"
SRC_URI += "${URI_texlive-mathspec}"
SRC_URI[texlive-mathspec.sha256sum] = "d12563ef1f8be490df25d75a553be08bec71a88d794daf71914cb5ed2331d64f"
RDEPENDS:texlive-mathspec = " \
 texlive-etoolbox \
 texlive-kpathsea \
 texlive-amsmath \
 texlive-xkeyval \
 texlive-fontspec \
 texlive-iftex \
 texlive-base \
 texlive-mnsymbol \
"

URI_texlive-mathtools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-mathtools-20240311-6.el10.noarch.rpm;name=texlive-mathtools;unpack=0"
SRC_URI += "${URI_texlive-mathtools}"
SRC_URI[texlive-mathtools.sha256sum] = "4be2776d66c339ee7d1198ee8b9ef71ac0a10c85c2d4e3f1704cae3df7851b8c"
RDEPENDS:texlive-mathtools = " \
 texlive-graphics \
 texlive-kpathsea \
 texlive-amsmath \
 texlive-tools \
 texlive-mathtools \
 texlive-base \
"

URI_texlive-mdwtools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-mdwtools-20240311-6.el10.noarch.rpm;name=texlive-mdwtools;unpack=0"
SRC_URI += "${URI_texlive-mdwtools}"
SRC_URI[texlive-mdwtools.sha256sum] = "28d8a857e825c8ea7031a9cf641752a80ee323b3f7cc681b4cd7c64d76a7699a"
RDEPENDS:texlive-mdwtools = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-memoir = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-memoir-20240311-6.el10.noarch.rpm;name=texlive-memoir;unpack=0"
SRC_URI += "${URI_texlive-memoir}"
SRC_URI[texlive-memoir.sha256sum] = "15223364fe278176dd67ec9ff604e6a0ea060e7c424a70be6e2a2ac9f0427e88"
RDEPENDS:texlive-memoir = " \
 texlive-kpathsea \
 texlive-iftex \
 texlive-base \
 texlive-etex-pkg \
"

URI_texlive-metafont = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-metafont-20240311-6.el10.x86_64_v2.rpm;name=texlive-metafont;unpack=0"
SRC_URI += "${URI_texlive-metafont}"
SRC_URI[texlive-metafont.sha256sum] = "9fed63b33ba52eaf8ea90f273e8630102c6ca56203e2d7d81b7e66ffc8d39796"
RDEPENDS:texlive-metafont = " \
 texlive-lib \
 texlive-texlive-scripts \
 texlive-kpathsea \
 libX11 \
 glibc \
 coreutils \
 texlive-base \
"

URI_texlive-metalogo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-metalogo-20240311-6.el10.noarch.rpm;name=texlive-metalogo;unpack=0"
SRC_URI += "${URI_texlive-metalogo}"
SRC_URI[texlive-metalogo.sha256sum] = "8efc7ea8af63eafaf11f691ffe06ffb8a005a3d4a19f50a0f2ea70e9ee4d40af"
RDEPENDS:texlive-metalogo = " \
 texlive-graphics \
 texlive-kpathsea \
 texlive-fontspec \
 texlive-iftex \
 texlive-base \
"

URI_texlive-metapost = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-metapost-20240311-6.el10.x86_64_v2.rpm;name=texlive-metapost;unpack=0"
SRC_URI += "${URI_texlive-metapost}"
SRC_URI[texlive-metapost.sha256sum] = "e7a931edeccff6b47cb61d7a042c35c320d01364119ae5727c0e6d8e1dec412d"
RDEPENDS:texlive-metapost = " \
 gmp \
 zlib-ng-compat \
 texlive-lib \
 libpng \
 mpfr \
 texlive-texlive-scripts \
 texlive-kpathsea \
 cairo \
 glibc \
 texlive-base \
 pixman \
"

URI_texlive-mflogo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-mflogo-20240311-6.el10.noarch.rpm;name=texlive-mflogo;unpack=0"
SRC_URI += "${URI_texlive-mflogo}"
SRC_URI[texlive-mflogo.sha256sum] = "cbdfd878c8f3b3ef4b63548114ba0a862a9dc1842f018d548223ca900dbe6e11"
RDEPENDS:texlive-mflogo = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-mflogo-font = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-mflogo-font-20240311-6.el10.noarch.rpm;name=texlive-mflogo-font;unpack=0"
SRC_URI += "${URI_texlive-mflogo-font}"
SRC_URI[texlive-mflogo-font.sha256sum] = "b9e1d6f6a34897ef76094a79201bf6c5eddfcb71e0caae54e23a177b2615b9ea"
RDEPENDS:texlive-mflogo-font = " \
 texlive-kpathsea \
 texlive-texlive-scripts \
 texlive-base \
"

URI_texlive-mfnfss = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-mfnfss-20240311-6.el10.noarch.rpm;name=texlive-mfnfss;unpack=0"
SRC_URI += "${URI_texlive-mfnfss}"
SRC_URI[texlive-mfnfss.sha256sum] = "130c4044a96ef88759dcb4e5e2323682120852f82e25dc4a888fb40272010d92"
RDEPENDS:texlive-mfnfss = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-mfware = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-mfware-20240311-6.el10.x86_64_v2.rpm;name=texlive-mfware;unpack=0"
SRC_URI += "${URI_texlive-mfware}"
SRC_URI[texlive-mfware.sha256sum] = "7f6a0c2227d1b35cf3f44b75a708be1fed4a98591c8684a5da9d34f8ded2d02a"
RDEPENDS:texlive-mfware = " \
 texlive-lib \
 texlive-kpathsea \
 glibc \
 texlive-mfware \
 texlive-base \
"

URI_texlive-microtype = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-microtype-20240311-6.el10.noarch.rpm;name=texlive-microtype;unpack=0"
SRC_URI += "${URI_texlive-microtype}"
SRC_URI[texlive-microtype.sha256sum] = "8031a0a3568539b1c8aba69b68cd1089a5c37c51a8acaa8d688ba898a6770c62"
RDEPENDS:texlive-microtype = " \
 texlive-kpathsea \
 texlive-base \
 texlive-graphics \
"

URI_texlive-minitoc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-minitoc-20240311-6.el10.noarch.rpm;name=texlive-minitoc;unpack=0"
SRC_URI += "${URI_texlive-minitoc}"
SRC_URI[texlive-minitoc.sha256sum] = "f5043f59eb717d72c7af353180c2a94dfa363d4baf087293b6ba940842e112cc"
RDEPENDS:texlive-minitoc = " \
 texlive-placeins \
 texlive-kpathsea \
 texlive-notoccite \
 texlive-latex \
 texlive-base \
 texlive-minitoc \
"

URI_texlive-mnsymbol = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-mnsymbol-20240311-6.el10.noarch.rpm;name=texlive-mnsymbol;unpack=0"
SRC_URI += "${URI_texlive-mnsymbol}"
SRC_URI[texlive-mnsymbol.sha256sum] = "b14f13a8b7e9c1c7ae8de31d0b6c677ed9bfd4d91d55b8dda4bdbedf4769f683"
RDEPENDS:texlive-mnsymbol = " \
 texlive-kpathsea \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-latex \
 texlive-base \
"

URI_texlive-modes = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-modes-20240311-6.el10.noarch.rpm;name=texlive-modes;unpack=0"
SRC_URI += "${URI_texlive-modes}"
SRC_URI[texlive-modes.sha256sum] = "4418dc9e04558a355851cf1ec52d2a30a165ddedf6967caf2fb1c2ac195c746d"
RDEPENDS:texlive-modes = " \
 texlive-kpathsea \
 bash \
"

URI_texlive-mparhack = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-mparhack-20240311-6.el10.noarch.rpm;name=texlive-mparhack;unpack=0"
SRC_URI += "${URI_texlive-mparhack}"
SRC_URI[texlive-mparhack.sha256sum] = "7b9a819c9119ea302dfc44cf9e839e062ff121015f6e1b269abcead4868da4aa"
RDEPENDS:texlive-mparhack = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-mptopdf = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-mptopdf-20240311-6.el10.noarch.rpm;name=texlive-mptopdf;unpack=0"
SRC_URI += "${URI_texlive-mptopdf}"
SRC_URI[texlive-mptopdf.sha256sum] = "ec7accf5f4f4d36ddd23a313656bd5b8af31fb199afd5cc50c89d82236b872d7"
RDEPENDS:texlive-mptopdf = " \
 texlive-texlive-scripts \
 perl-libs \
 texlive-kpathsea \
 perl-Getopt-Long \
 perl-File-Basename \
 coreutils \
 perl-interpreter \
 texlive-base \
"

URI_texlive-multido = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-multido-20240311-6.el10.noarch.rpm;name=texlive-multido;unpack=0"
SRC_URI += "${URI_texlive-multido}"
SRC_URI[texlive-multido.sha256sum] = "a3e14ac997a1d378ef977d99667bf9542934056b581e449865f431f05c1a3d67"
RDEPENDS:texlive-multido = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-multirow = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-multirow-20240311-6.el10.noarch.rpm;name=texlive-multirow;unpack=0"
SRC_URI += "${URI_texlive-multirow}"
SRC_URI[texlive-multirow.sha256sum] = "f7273ef1874d2ad0658339d7770b8ef91b1dbfbbb5191a4b2f9955a5d690a01f"
RDEPENDS:texlive-multirow = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-multitoc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-multitoc-20240311-6.el10.noarch.rpm;name=texlive-multitoc;unpack=0"
SRC_URI += "${URI_texlive-multitoc}"
SRC_URI[texlive-multitoc.sha256sum] = "f47ffd1665ec47b2b6c218cf851b4c85dc720d3df52fcc03a53e7aff1944a588"
RDEPENDS:texlive-multitoc = " \
 texlive-kpathsea \
 texlive-latex \
 texlive-base \
 texlive-tools \
"

URI_texlive-natbib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-natbib-20240311-6.el10.noarch.rpm;name=texlive-natbib;unpack=0"
SRC_URI += "${URI_texlive-natbib}"
SRC_URI[texlive-natbib.sha256sum] = "da51fcbc61ad8871d446522661b2647df0ca2b93b5d4512981e79be906291051"
RDEPENDS:texlive-natbib = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-ncctools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-ncctools-20240311-6.el10.noarch.rpm;name=texlive-ncctools;unpack=0"
SRC_URI += "${URI_texlive-ncctools}"
SRC_URI[texlive-ncctools.sha256sum] = "1f860592d1796afcc34bee0e3c4e7c9cd7fbd5dad83d53266df08de312cdc908"
RDEPENDS:texlive-ncctools = " \
 texlive-bigfoot \
 texlive-graphics \
 texlive-kpathsea \
 texlive-amsmath \
 texlive-base \
"

URI_texlive-ncntrsbk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-ncntrsbk-20240311-6.el10.noarch.rpm;name=texlive-ncntrsbk;unpack=0"
SRC_URI += "${URI_texlive-ncntrsbk}"
SRC_URI[texlive-ncntrsbk.sha256sum] = "6251576f9368a7563aad9da161e5f1d6389cc0d974e9cbc9d05cc4af24f77e62"
RDEPENDS:texlive-ncntrsbk = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-needspace = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-needspace-20240311-6.el10.noarch.rpm;name=texlive-needspace;unpack=0"
SRC_URI += "${URI_texlive-needspace}"
SRC_URI[texlive-needspace.sha256sum] = "a4682c25896fcbb371c56c78365ccd8aa280e79effd5323883eb91a4e651f912"
RDEPENDS:texlive-needspace = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-newfloat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-newfloat-20240311-6.el10.noarch.rpm;name=texlive-newfloat;unpack=0"
SRC_URI += "${URI_texlive-newfloat}"
SRC_URI[texlive-newfloat.sha256sum] = "1504537a82467927678ced0c0e859a699d712a95b4600dfb7afde1d0af7bbbb1"
RDEPENDS:texlive-newfloat = " \
 texlive-kpathsea \
"

URI_texlive-newunicodechar = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-newunicodechar-20240311-6.el10.noarch.rpm;name=texlive-newunicodechar;unpack=0"
SRC_URI += "${URI_texlive-newunicodechar}"
SRC_URI[texlive-newunicodechar.sha256sum] = "cf1949ec476bf8f2934c5ed6db14ee7010c53a5d12bd22a87b97ba6a0e94e637"
RDEPENDS:texlive-newunicodechar = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-norasi-c90 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-norasi-c90-20240311-6.el10.noarch.rpm;name=texlive-norasi-c90;unpack=0"
SRC_URI += "${URI_texlive-norasi-c90}"
SRC_URI[texlive-norasi-c90.sha256sum] = "8f058965dce5a913d3ac36d25b3344233d5acf9ce26efe7e56ed5fac199c51c3"
RDEPENDS:texlive-norasi-c90 = " \
 texlive-kpathsea \
 texlive-fonts-tlwg \
 texlive-base \
"

URI_texlive-notoccite = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-notoccite-20240311-6.el10.noarch.rpm;name=texlive-notoccite;unpack=0"
SRC_URI += "${URI_texlive-notoccite}"
SRC_URI[texlive-notoccite.sha256sum] = "3ae343008dc1ac2de9742625cbd8635d62f557ea6cd58ee63e1a59b2712c9480"
RDEPENDS:texlive-notoccite = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-ntgclass = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-ntgclass-20240311-6.el10.noarch.rpm;name=texlive-ntgclass;unpack=0"
SRC_URI += "${URI_texlive-ntgclass}"
SRC_URI[texlive-ntgclass.sha256sum] = "dcd8de656d6be698858bb1d92f9933a3e6590fd09059efa9eb016b02fb43e912"
RDEPENDS:texlive-ntgclass = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-oberdiek = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-oberdiek-20240311-6.el10.noarch.rpm;name=texlive-oberdiek;unpack=0"
SRC_URI += "${URI_texlive-oberdiek}"
SRC_URI[texlive-oberdiek.sha256sum] = "4669c32a90e8515ca3a55685bdfd87e7bc3688392b0b2a22de8e25ece6cd2d07"
RDEPENDS:texlive-oberdiek = " \
 texlive-etexcmds \
 texlive-parallel \
 texlive-pdfcol \
 texlive-fontspec \
 texlive-pdfescape \
 texlive-fp \
 texlive-pdftexcmds \
 texlive-zref \
 texlive-graphics \
 texlive-grfext \
 texlive-grffile \
 texlive-amsmath \
 texlive-hologo \
 texlive-hypcap \
 texlive-hypdoc \
 texlive-hyperref \
 texlive-atveryend \
 texlive-auxhook \
 texlive-iftex \
 texlive-index \
 texlive-infwarerr \
 texlive-intcalc \
 texlive-base \
 texlive-bigintcalc \
 texlive-sauerj \
 texlive-kpathsea \
 texlive-kvoptions \
 texlive-kvsetkeys \
 texlive-carlisle \
 texlive-letltxmacro \
 texlive-ltxcmds \
 texlive-tools \
 texlive-unicode-math \
 texlive-uniquecounter \
"

URI_texlive-overpic = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-overpic-20240311-6.el10.noarch.rpm;name=texlive-overpic;unpack=0"
SRC_URI += "${URI_texlive-overpic}"
SRC_URI[texlive-overpic.sha256sum] = "6afc155d6b0569a71c8cf047dca6f999b818142e72f9772681e99dcdf3a54795"
RDEPENDS:texlive-overpic = " \
 texlive-kpathsea \
 texlive-base \
 texlive-eepic \
 texlive-graphics \
"

URI_texlive-palatino = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-palatino-20240311-6.el10.noarch.rpm;name=texlive-palatino;unpack=0"
SRC_URI += "${URI_texlive-palatino}"
SRC_URI[texlive-palatino.sha256sum] = "1043000116fd5af45278b7204eba7f6b4e3e44d96e7fc80e198c16c790e2920a"
RDEPENDS:texlive-palatino = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-paralist = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-paralist-20240311-6.el10.noarch.rpm;name=texlive-paralist;unpack=0"
SRC_URI += "${URI_texlive-paralist}"
SRC_URI[texlive-paralist.sha256sum] = "3ae6ca32c4c581d3ea2adb0f3b429244c20a509798b25fd676daf638f04858e3"
RDEPENDS:texlive-paralist = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-parallel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-parallel-20240311-6.el10.noarch.rpm;name=texlive-parallel;unpack=0"
SRC_URI += "${URI_texlive-parallel}"
SRC_URI[texlive-parallel.sha256sum] = "3ad9eef2fa82fcf12e51f4a7dc3e2c1b75f7b8007c67fb8e429929a6477ed5e1"
RDEPENDS:texlive-parallel = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-parskip = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-parskip-20240311-6.el10.noarch.rpm;name=texlive-parskip;unpack=0"
SRC_URI += "${URI_texlive-parskip}"
SRC_URI[texlive-parskip.sha256sum] = "ad057883cf28ca7f334690bc3e91a16f7964c3ce7915b4687fa9c44ca854580f"
RDEPENDS:texlive-parskip = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-passivetex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-passivetex-20240311-6.el10.noarch.rpm;name=texlive-passivetex;unpack=0"
SRC_URI += "${URI_texlive-passivetex}"
SRC_URI[texlive-passivetex.sha256sum] = "1068ea61ed7e8a7317e5c100a6016261cd0df91bdcd7858365497b3ac534e031"
RDEPENDS:texlive-passivetex = " \
 texlive-url \
 texlive-graphics \
 texlive-kpathsea \
 texlive-psnfss \
 texlive-tipa \
 texlive-amsfonts \
 texlive-tools \
 texlive-amsmath \
 texlive-latex \
 texlive-marvosym \
 texlive-hyperref \
 texlive-passivetex \
 texlive-ulem \
 texlive-base \
"

URI_texlive-pdfcol = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pdfcol-20240311-6.el10.noarch.rpm;name=texlive-pdfcol;unpack=0"
SRC_URI += "${URI_texlive-pdfcol}"
SRC_URI[texlive-pdfcol.sha256sum] = "dfe4c5b0c3e5bb182e6b0e4d4e0e7d40afc36bccab13bebcfe178712c3b8a8fc"
RDEPENDS:texlive-pdfcol = " \
 texlive-kpathsea \
"

URI_texlive-pdfcolfoot = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pdfcolfoot-20240311-6.el10.noarch.rpm;name=texlive-pdfcolfoot;unpack=0"
SRC_URI += "${URI_texlive-pdfcolfoot}"
SRC_URI[texlive-pdfcolfoot.sha256sum] = "3971f8a891fbc91735b54c7ea44ffd86d09bd663ef5370bec233bd96dee1ee2a"
RDEPENDS:texlive-pdfcolfoot = " \
 texlive-kpathsea \
"

URI_texlive-pdfcolmk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pdfcolmk-20240311-6.el10.noarch.rpm;name=texlive-pdfcolmk;unpack=0"
SRC_URI += "${URI_texlive-pdfcolmk}"
SRC_URI[texlive-pdfcolmk.sha256sum] = "ee6a4d241edf9555b09b0b602f261416720e4964d565cbb33f18581e7bbb9eff"
RDEPENDS:texlive-pdfcolmk = " \
 texlive-kpathsea \
"

URI_texlive-pdfescape = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pdfescape-20240311-6.el10.noarch.rpm;name=texlive-pdfescape;unpack=0"
SRC_URI += "${URI_texlive-pdfescape}"
SRC_URI[texlive-pdfescape.sha256sum] = "55688d02facaa9cf6f4c07092a6fd427715e1b77ba4e3eba26aa5b7c65cd0a9b"
RDEPENDS:texlive-pdfescape = " \
 texlive-kpathsea \
"

URI_texlive-pdflscape = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pdflscape-20240311-6.el10.noarch.rpm;name=texlive-pdflscape;unpack=0"
SRC_URI += "${URI_texlive-pdflscape}"
SRC_URI[texlive-pdflscape.sha256sum] = "315c87a8df3eae1482b4b82068bb08c758ee759dfe3a4f5065be96abdd656b71"
RDEPENDS:texlive-pdflscape = " \
 texlive-kpathsea \
"

URI_texlive-pdfmanagement-testphase = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pdfmanagement-testphase-20240311-6.el10.noarch.rpm;name=texlive-pdfmanagement-testphase;unpack=0"
SRC_URI += "${URI_texlive-pdfmanagement-testphase}"
SRC_URI[texlive-pdfmanagement-testphase.sha256sum] = "7422f1121ada16fcc037680b844f22bce7d5a74fce0f467a8894e4a262e7bd62"
RDEPENDS:texlive-pdfmanagement-testphase = " \
 texlive-kpathsea \
 texlive-graphics \
"

URI_texlive-pdfpages = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pdfpages-20240311-6.el10.noarch.rpm;name=texlive-pdfpages;unpack=0"
SRC_URI += "${URI_texlive-pdfpages}"
SRC_URI[texlive-pdfpages.sha256sum] = "24b64b1776f43c1d30789e120d3737b66793c498641aabf744ab49d2650914db"
RDEPENDS:texlive-pdfpages = " \
 texlive-graphics \
 texlive-count1to \
 texlive-kpathsea \
 texlive-tools \
 texlive-latex \
 texlive-pdflscape \
 texlive-eso-pic \
 texlive-base \
"

URI_texlive-pdftex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pdftex-20240311-6.el10.x86_64_v2.rpm;name=texlive-pdftex;unpack=0"
SRC_URI += "${URI_texlive-pdftex}"
SRC_URI[texlive-pdftex.sha256sum] = "9f152198e150e6c3dcafa5e0f22cc56d4e18e10f166ba3481f907de2524e0a83"
RDEPENDS:texlive-pdftex = " \
 perl-libs \
 libpng \
 texlive-plain \
 texlive-graphics-def \
 libstdc++ \
 texlive-hyphen-base \
 texlive-base \
 zlib-ng-compat \
 texlive-knuth-lib \
 texlive-kpathsea \
 libgcc \
 bash \
 texlive-cm \
 texlive-lib \
 texlive-tex-ini-files \
 texlive-texlive-scripts \
 glibc \
 coreutils \
 texlive-etex \
"

URI_texlive-pdftexcmds = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pdftexcmds-20240311-6.el10.noarch.rpm;name=texlive-pdftexcmds;unpack=0"
SRC_URI += "${URI_texlive-pdftexcmds}"
SRC_URI[texlive-pdftexcmds.sha256sum] = "b108e09f93ae42aa27eef17110ed236d420d5e71bfe025d7688608c45408ce59"
RDEPENDS:texlive-pdftexcmds = " \
 texlive-kpathsea \
"

URI_texlive-pgf = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pgf-20240311-6.el10.noarch.rpm;name=texlive-pgf;unpack=0"
SRC_URI += "${URI_texlive-pgf}"
SRC_URI[texlive-pgf.sha256sum] = "2a963c70cf2e1648e43ab37068847a9b43aff66e0b3dd82041fd14e254bd6ed7"
RDEPENDS:texlive-pgf = " \
 texlive-pgf \
 texlive-graphics \
 texlive-kpathsea \
 texlive-xcolor \
 texlive-xkeyval \
 texlive-base \
"

URI_texlive-philokalia = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-philokalia-20240311-6.el10.noarch.rpm;name=texlive-philokalia;unpack=0"
SRC_URI += "${URI_texlive-philokalia}"
SRC_URI[texlive-philokalia.sha256sum] = "a12b0cfb225676af7b7adb96c0dd6af3eca33c1f0bfdd70837cd343b878a0981"
RDEPENDS:texlive-philokalia = " \
 texlive-xltxtra \
 texlive-kpathsea \
 texlive-lettrine \
 texlive-fontspec \
 texlive-xunicode \
 texlive-base \
"

URI_texlive-placeins = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-placeins-20240311-6.el10.noarch.rpm;name=texlive-placeins;unpack=0"
SRC_URI += "${URI_texlive-placeins}"
SRC_URI[texlive-placeins.sha256sum] = "c88da1b2d7e321d13f7822085a25098f29c50a384792489ca0ae4475691d2ab4"
RDEPENDS:texlive-placeins = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-plain = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-plain-20240311-6.el10.noarch.rpm;name=texlive-plain;unpack=0"
SRC_URI += "${URI_texlive-plain}"
SRC_URI[texlive-plain.sha256sum] = "17d99b9e0821f701556b2d62642624ec50e3dee44e8b543767c33c8e1d437362"
RDEPENDS:texlive-plain = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-polyglossia = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-polyglossia-20240311-6.el10.noarch.rpm;name=texlive-polyglossia;unpack=0"
SRC_URI += "${URI_texlive-polyglossia}"
SRC_URI[texlive-polyglossia.sha256sum] = "878086d830fd66800eb70e738048a823cb4e2458ac1abb6048a527d967503233"
RDEPENDS:texlive-polyglossia = " \
 texlive-etoolbox \
 texlive-bidi \
 texlive-polyglossia \
 texlive-kpathsea \
 texlive-makecmds \
 texlive-tools \
 texlive-xkeyval \
 texlive-fontspec \
 texlive-base \
"

URI_texlive-powerdot = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-powerdot-20240311-6.el10.noarch.rpm;name=texlive-powerdot;unpack=0"
SRC_URI += "${URI_texlive-powerdot}"
SRC_URI[texlive-powerdot.sha256sum] = "59eaf25da2702bce4dcb734daa815c346c0dde474cdcd74b219ee340917ee530"
RDEPENDS:texlive-powerdot = " \
 texlive-geometry \
 texlive-graphics \
 texlive-kpathsea \
 texlive-xcolor \
 texlive-psnfss \
 texlive-pst-blur \
 texlive-amsfonts \
 texlive-tools \
 texlive-pst-grad \
 texlive-type1cm \
 texlive-hyperref \
 texlive-pst-slpe \
 texlive-xkeyval \
 texlive-enumitem \
 texlive-pst-text \
 texlive-pstricks \
 texlive-iftex \
 texlive-base \
"

URI_texlive-preprint = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-preprint-20240311-6.el10.noarch.rpm;name=texlive-preprint;unpack=0"
SRC_URI += "${URI_texlive-preprint}"
SRC_URI[texlive-preprint.sha256sum] = "e0f8c1eb0b595683dbf3776218850ff3c83b7ac44511d6d446c922b89f184fb8"
RDEPENDS:texlive-preprint = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-psfrag = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-psfrag-20240311-6.el10.noarch.rpm;name=texlive-psfrag;unpack=0"
SRC_URI += "${URI_texlive-psfrag}"
SRC_URI[texlive-psfrag.sha256sum] = "d1ea2a7d96f5db9b13cebc06c2cce52545d0dacdab574d9255844b27d0c53671"
RDEPENDS:texlive-psfrag = " \
 texlive-kpathsea \
 texlive-base \
 texlive-graphics \
"

URI_texlive-pslatex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pslatex-20240311-6.el10.noarch.rpm;name=texlive-pslatex;unpack=0"
SRC_URI += "${URI_texlive-pslatex}"
SRC_URI[texlive-pslatex.sha256sum] = "142f19aa4bb22f2e7e1f3cc35e5c450a1ea99d2f2db7edd4596bc432ad52d670"
RDEPENDS:texlive-pslatex = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-psnfss = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-psnfss-20240311-6.el10.noarch.rpm;name=texlive-psnfss;unpack=0"
SRC_URI += "${URI_texlive-psnfss}"
SRC_URI[texlive-psnfss.sha256sum] = "d10837e1e574330699b490438a37bf2b4df781cb75a4a5a58361f5155025c8c7"
RDEPENDS:texlive-psnfss = " \
 texlive-graphics \
 texlive-zapfding \
 texlive-kpathsea \
 texlive-symbol \
 texlive-base \
"

URI_texlive-pspicture = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pspicture-20240311-6.el10.noarch.rpm;name=texlive-pspicture;unpack=0"
SRC_URI += "${URI_texlive-pspicture}"
SRC_URI[texlive-pspicture.sha256sum] = "8ab4d439b459e252ac9a70d1c9d87591ec2f53129789f5c3cbe8d216b0e7ecbe"
RDEPENDS:texlive-pspicture = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-pst-3d = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pst-3d-20240311-6.el10.noarch.rpm;name=texlive-pst-3d;unpack=0"
SRC_URI += "${URI_texlive-pst-3d}"
SRC_URI[texlive-pst-3d.sha256sum] = "efac7c1f4911f82cfcaf8af5f9d0cf93115ae8130d511b3c9f263bda2e0df622"
RDEPENDS:texlive-pst-3d = " \
 texlive-kpathsea \
 texlive-pstricks \
 texlive-base \
"

URI_texlive-pst-arrow = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pst-arrow-20240311-6.el10.noarch.rpm;name=texlive-pst-arrow;unpack=0"
SRC_URI += "${URI_texlive-pst-arrow}"
SRC_URI[texlive-pst-arrow.sha256sum] = "1c985bfbfbe7a73b0edd94ea84fc7c19cb16164478a8f32e2dead0db3421b663"
RDEPENDS:texlive-pst-arrow = " \
 texlive-kpathsea \
"

URI_texlive-pst-blur = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pst-blur-20240311-6.el10.noarch.rpm;name=texlive-pst-blur;unpack=0"
SRC_URI += "${URI_texlive-pst-blur}"
SRC_URI[texlive-pst-blur.sha256sum] = "f36bf6ecb5689270d916536171b260f73de9b1a1d427c27c23cc6923caf4a7bc"
RDEPENDS:texlive-pst-blur = " \
 texlive-kpathsea \
 texlive-pstricks \
 texlive-base \
"

URI_texlive-pst-coil = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pst-coil-20240311-6.el10.noarch.rpm;name=texlive-pst-coil;unpack=0"
SRC_URI += "${URI_texlive-pst-coil}"
SRC_URI[texlive-pst-coil.sha256sum] = "267015b1412f6662a96000ce6385e57cbdb1012ea16247bb3d872fd1c4dafd90"
RDEPENDS:texlive-pst-coil = " \
 texlive-kpathsea \
 texlive-pstricks \
 texlive-base \
"

URI_texlive-pst-eps = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pst-eps-20240311-6.el10.noarch.rpm;name=texlive-pst-eps;unpack=0"
SRC_URI += "${URI_texlive-pst-eps}"
SRC_URI[texlive-pst-eps.sha256sum] = "8a830840ff11690118dd4524fbcb7b9b073b344f3bf471bae2be1d8807996c16"
RDEPENDS:texlive-pst-eps = " \
 texlive-kpathsea \
 texlive-pstricks \
 texlive-base \
"

URI_texlive-pst-fill = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pst-fill-20240311-6.el10.noarch.rpm;name=texlive-pst-fill;unpack=0"
SRC_URI += "${URI_texlive-pst-fill}"
SRC_URI[texlive-pst-fill.sha256sum] = "96dc7a756e8834a6afbc1d8a7918c1fdc73a7ac46e20be1ab62687ad66d4fc40"
RDEPENDS:texlive-pst-fill = " \
 texlive-kpathsea \
 texlive-pstricks \
 texlive-base \
"

URI_texlive-pst-grad = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pst-grad-20240311-6.el10.noarch.rpm;name=texlive-pst-grad;unpack=0"
SRC_URI += "${URI_texlive-pst-grad}"
SRC_URI[texlive-pst-grad.sha256sum] = "c1e4ac5c00244a7339ede6b3af0b0b0e1631f0961bc3fb7b65fbe7ff9704d534"
RDEPENDS:texlive-pst-grad = " \
 texlive-kpathsea \
 texlive-pstricks \
 texlive-base \
"

URI_texlive-pst-math = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pst-math-20240311-6.el10.noarch.rpm;name=texlive-pst-math;unpack=0"
SRC_URI += "${URI_texlive-pst-math}"
SRC_URI[texlive-pst-math.sha256sum] = "9c173ec926580063a1d78c81de3add5baee30f2f304a4fed6abd485c4710be1c"
RDEPENDS:texlive-pst-math = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-pst-node = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pst-node-20240311-6.el10.noarch.rpm;name=texlive-pst-node;unpack=0"
SRC_URI += "${URI_texlive-pst-node}"
SRC_URI[texlive-pst-node.sha256sum] = "119ab3c28982638c47db4c70816cdfc6fbe1e5ed940f475a2cf6320d772894d2"
RDEPENDS:texlive-pst-node = " \
 texlive-kpathsea \
 texlive-pstricks \
 texlive-base \
"

URI_texlive-pst-plot = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pst-plot-20240311-6.el10.noarch.rpm;name=texlive-pst-plot;unpack=0"
SRC_URI += "${URI_texlive-pst-plot}"
SRC_URI[texlive-pst-plot.sha256sum] = "20e09a14e2fa2fcb8db313f471f2218ee2ae97151509dc66a2945e6ddcdb0451"
RDEPENDS:texlive-pst-plot = " \
 texlive-multido \
 texlive-kpathsea \
 texlive-xkeyval \
 texlive-pstricks \
 texlive-base \
"

URI_texlive-pst-slpe = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pst-slpe-20240311-6.el10.noarch.rpm;name=texlive-pst-slpe;unpack=0"
SRC_URI += "${URI_texlive-pst-slpe}"
SRC_URI[texlive-pst-slpe.sha256sum] = "ba682149cee935ffd676df9e6f086123f4c4e4e6d7744181017ab9215b9dd599"
RDEPENDS:texlive-pst-slpe = " \
 texlive-kpathsea \
 texlive-pstricks \
 texlive-base \
"

URI_texlive-pst-text = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pst-text-20240311-6.el10.noarch.rpm;name=texlive-pst-text;unpack=0"
SRC_URI += "${URI_texlive-pst-text}"
SRC_URI[texlive-pst-text.sha256sum] = "a0f4f0432d09b53275329216fdfeb6534216eb496183ca8891ff23520a85d4a1"
RDEPENDS:texlive-pst-text = " \
 texlive-kpathsea \
 texlive-pstricks \
 texlive-base \
"

URI_texlive-pst-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pst-tools-20240311-6.el10.noarch.rpm;name=texlive-pst-tools;unpack=0"
SRC_URI += "${URI_texlive-pst-tools}"
SRC_URI[texlive-pst-tools.sha256sum] = "9f80e4a8587530ad6471bd2c0de7614bd3bf4f8a83a36917abfe5026ae2cdfe4"
RDEPENDS:texlive-pst-tools = " \
 texlive-kpathsea \
 texlive-pstricks \
 texlive-base \
"

URI_texlive-pst-tree = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pst-tree-20240311-6.el10.noarch.rpm;name=texlive-pst-tree;unpack=0"
SRC_URI += "${URI_texlive-pst-tree}"
SRC_URI[texlive-pst-tree.sha256sum] = "dfbf53f0a3d5550210e014aa3c5883f9828ef28db880db1caf7892e316fed449"
RDEPENDS:texlive-pst-tree = " \
 texlive-kpathsea \
 texlive-pstricks \
 texlive-base \
"

URI_texlive-pstricks = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pstricks-20240311-6.el10.noarch.rpm;name=texlive-pstricks;unpack=0"
SRC_URI += "${URI_texlive-pstricks}"
SRC_URI[texlive-pstricks.sha256sum] = "aff55ebb65afd55ab64c606063ea5e7b565a8b21ed189300651d4969ec308710"
RDEPENDS:texlive-pstricks = " \
 texlive-multido \
 texlive-xcolor \
 texlive-fancyvrb \
 texlive-filecontents \
 texlive-paralist \
 texlive-xkeyval \
 texlive-footmisc \
 texlive-graphics \
 texlive-pst-3d \
 texlive-pst-arrow \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-pst-coil \
 texlive-pst-grad \
 texlive-pst-eps \
 texlive-pst-node \
 texlive-hyperref \
 texlive-pst-plot \
 texlive-pst-fill \
 texlive-pst-tools \
 texlive-pst-text \
 texlive-pst-tree \
 texlive-pstricks-add \
 texlive-babel \
 texlive-iftex \
 texlive-ragged2e \
 texlive-base \
 texlive-bera \
 texlive-koma-script \
 texlive-kpathsea \
 texlive-booktabs \
 texlive-breakurl \
 texlive-setspace \
 texlive-caption \
 texlive-showexpl \
 texlive-latex \
 texlive-chngcntr \
 texlive-subfig \
 texlive-tools \
 texlive-eso-pic \
"

URI_texlive-pstricks-add = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pstricks-add-20240311-6.el10.noarch.rpm;name=texlive-pstricks-add;unpack=0"
SRC_URI += "${URI_texlive-pstricks-add}"
SRC_URI[texlive-pstricks-add.sha256sum] = "8527c2d3188501330928d5799714a9fa7bd6665a7ced118c87b4c9066e42db74"
RDEPENDS:texlive-pstricks-add = " \
 texlive-multido \
 texlive-kpathsea \
 texlive-pst-3d \
 texlive-pst-math \
 texlive-pst-node \
 texlive-pst-plot \
 texlive-pstricks \
 texlive-base \
"

URI_texlive-ptext = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-ptext-20240311-6.el10.noarch.rpm;name=texlive-ptext;unpack=0"
SRC_URI += "${URI_texlive-ptext}"
SRC_URI[texlive-ptext.sha256sum] = "03ec72f59f89c83b86ac9ce286c7465445499c554a2b1df4bf5156fffe41075a"
RDEPENDS:texlive-ptext = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-pxfonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-pxfonts-20240311-6.el10.noarch.rpm;name=texlive-pxfonts;unpack=0"
SRC_URI += "${URI_texlive-pxfonts}"
SRC_URI[texlive-pxfonts.sha256sum] = "28bdd60ee035061e6a882a1ad823bae4cab70b71f9495519164c5c7dee0c97cc"
RDEPENDS:texlive-pxfonts = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-qstest = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-qstest-20240311-6.el10.noarch.rpm;name=texlive-qstest;unpack=0"
SRC_URI += "${URI_texlive-qstest}"
SRC_URI[texlive-qstest.sha256sum] = "3661c41e9750061c30e533ac706811b00d62d7c08394be1108886e29437cc242"
RDEPENDS:texlive-qstest = " \
 texlive-kpathsea \
 texlive-base \
 texlive-tools \
"

URI_texlive-ragged2e = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-ragged2e-20240311-6.el10.noarch.rpm;name=texlive-ragged2e;unpack=0"
SRC_URI += "${URI_texlive-ragged2e}"
SRC_URI[texlive-ragged2e.sha256sum] = "da2688c1a2f78d3294b568c97ca79ee7fba93101f44cfbeef09d8cda6984f2a3"
RDEPENDS:texlive-ragged2e = " \
 texlive-kpathsea \
"

URI_texlive-rcs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-rcs-20240311-6.el10.noarch.rpm;name=texlive-rcs;unpack=0"
SRC_URI += "${URI_texlive-rcs}"
SRC_URI[texlive-rcs.sha256sum] = "0845c9d6c9a7090f7a7cfe973c6b49119446ffa6b347ff29028060399c545ae3"
RDEPENDS:texlive-rcs = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-realscripts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-realscripts-20240311-6.el10.noarch.rpm;name=texlive-realscripts;unpack=0"
SRC_URI += "${URI_texlive-realscripts}"
SRC_URI[texlive-realscripts.sha256sum] = "87d1c1b60f3af3f48b7a1f1df032c1bff91b66c7fe90357242e20f3625651ccf"
RDEPENDS:texlive-realscripts = " \
 texlive-kpathsea \
 texlive-fontspec \
 texlive-base \
"

URI_texlive-refcount = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-refcount-20240311-6.el10.noarch.rpm;name=texlive-refcount;unpack=0"
SRC_URI += "${URI_texlive-refcount}"
SRC_URI[texlive-refcount.sha256sum] = "a3b5bd7aefe5870e20d056d705ca139550f25902caf22160c02227a9c651fb70"
RDEPENDS:texlive-refcount = " \
 texlive-kpathsea \
"

URI_texlive-relsize = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-relsize-20240311-6.el10.noarch.rpm;name=texlive-relsize;unpack=0"
SRC_URI += "${URI_texlive-relsize}"
SRC_URI[texlive-relsize.sha256sum] = "6ce2ac2f7dc69e2f6223d1975b9b2e6c5eb840eb7387a937af946b5186fa7aec"
RDEPENDS:texlive-relsize = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-rerunfilecheck = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-rerunfilecheck-20240311-6.el10.noarch.rpm;name=texlive-rerunfilecheck;unpack=0"
SRC_URI += "${URI_texlive-rerunfilecheck}"
SRC_URI[texlive-rerunfilecheck.sha256sum] = "1a939772aa802ca2fc79fe6c18d46d80885f4a3ccea35c22e899f2253adbb995"
RDEPENDS:texlive-rerunfilecheck = " \
 texlive-kpathsea \
 texlive-uniquecounter \
 texlive-atveryend \
"

URI_texlive-rsfs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-rsfs-20240311-6.el10.noarch.rpm;name=texlive-rsfs;unpack=0"
SRC_URI += "${URI_texlive-rsfs}"
SRC_URI[texlive-rsfs.sha256sum] = "534fffff5e5cba0a0b09fbaebc48bc01b373ef33cfe425519f0183721131f3d0"
RDEPENDS:texlive-rsfs = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-sansmath = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-sansmath-20240311-6.el10.noarch.rpm;name=texlive-sansmath;unpack=0"
SRC_URI += "${URI_texlive-sansmath}"
SRC_URI[texlive-sansmath.sha256sum] = "08283f85a678d569796d52cfb96f860170de03b80cc86e6a28eb57f9a9b87932"
RDEPENDS:texlive-sansmath = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-sansmathaccent = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-sansmathaccent-20240311-6.el10.noarch.rpm;name=texlive-sansmathaccent;unpack=0"
SRC_URI += "${URI_texlive-sansmathaccent}"
SRC_URI[texlive-sansmathaccent.sha256sum] = "2c309ff48d5b6c331418f999bb947b18ecd3a1b95f8b0af617de7e548b07cdd2"
RDEPENDS:texlive-sansmathaccent = " \
 texlive-kpathsea \
 texlive-base \
 texlive-filehook \
"

URI_texlive-sauerj = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-sauerj-20240311-6.el10.noarch.rpm;name=texlive-sauerj;unpack=0"
SRC_URI += "${URI_texlive-sauerj}"
SRC_URI[texlive-sauerj.sha256sum] = "0dee151aa4648617cee1c986a6a7856088e8763ed7cb1a2504ed1c240083ea71"
RDEPENDS:texlive-sauerj = " \
 texlive-kpathsea \
 texlive-base \
 texlive-graphics \
"

URI_texlive-scheme-basic = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-scheme-basic-20240311-6.el10.noarch.rpm;name=texlive-scheme-basic;unpack=0"
SRC_URI += "${URI_texlive-scheme-basic}"
SRC_URI[texlive-scheme-basic.sha256sum] = "7cb43973ec7e17e2f4fd1f5a5df221ed23c23f1d43be68ddce34e9f69eb4862e"
RDEPENDS:texlive-scheme-basic = " \
 coreutils \
 texlive-base \
 texlive-collection-latex \
 texlive-collection-basic \
"

URI_texlive-section = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-section-20240311-6.el10.noarch.rpm;name=texlive-section;unpack=0"
SRC_URI += "${URI_texlive-section}"
SRC_URI[texlive-section.sha256sum] = "00f1e314b0060c903f28ff80f69eadbaf755c23a9df51e562f70a06492f17da8"
RDEPENDS:texlive-section = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-sectsty = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-sectsty-20240311-6.el10.noarch.rpm;name=texlive-sectsty;unpack=0"
SRC_URI += "${URI_texlive-sectsty}"
SRC_URI[texlive-sectsty.sha256sum] = "4892147c37adbb06efebae4776844a74b2c2738b526a4bd1dc6c0b6db28719eb"
RDEPENDS:texlive-sectsty = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-seminar = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-seminar-20240311-6.el10.noarch.rpm;name=texlive-seminar;unpack=0"
SRC_URI += "${URI_texlive-seminar}"
SRC_URI[texlive-seminar.sha256sum] = "4184740d93d1a8f017d66e12b2ab4783dd70b87302dcbaf2183cb8bd9c29eb8d"
RDEPENDS:texlive-seminar = " \
 texlive-kpathsea \
 texlive-pstricks \
 bash \
 texlive-base \
"

URI_texlive-sepnum = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-sepnum-20240311-6.el10.noarch.rpm;name=texlive-sepnum;unpack=0"
SRC_URI += "${URI_texlive-sepnum}"
SRC_URI[texlive-sepnum.sha256sum] = "8ae7b27a310e943c4e32b3ed51148af1217b263c97b9e3e127e52ad8e23e92cf"
RDEPENDS:texlive-sepnum = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-setspace = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-setspace-20240311-6.el10.noarch.rpm;name=texlive-setspace;unpack=0"
SRC_URI += "${URI_texlive-setspace}"
SRC_URI[texlive-setspace.sha256sum] = "3c10e16e21bed84a7803ee46a79b80617a743a19a7c202e08af8b299ef5f702a"
RDEPENDS:texlive-setspace = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-sfmath = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-sfmath-20240311-6.el10.noarch.rpm;name=texlive-sfmath;unpack=0"
SRC_URI += "${URI_texlive-sfmath}"
SRC_URI[texlive-sfmath.sha256sum] = "6553311a2eee5f21127f40e52feca5da18e394515771e7741a993efc63110093"
RDEPENDS:texlive-sfmath = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-showexpl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-showexpl-20240311-6.el10.noarch.rpm;name=texlive-showexpl;unpack=0"
SRC_URI += "${URI_texlive-showexpl}"
SRC_URI[texlive-showexpl.sha256sum] = "491c1866d4b0ef9c0aca2943d0afdb1ca24dde8257a31858b3b31fe84264518e"
RDEPENDS:texlive-showexpl = " \
 texlive-varwidth \
 texlive-graphics \
 texlive-kpathsea \
 texlive-tools \
 texlive-latex \
 texlive-attachfile \
 texlive-listings \
 texlive-base \
"

URI_texlive-soul = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-soul-20240311-6.el10.noarch.rpm;name=texlive-soul;unpack=0"
SRC_URI += "${URI_texlive-soul}"
SRC_URI[texlive-soul.sha256sum] = "47d703c5a949adabcabd0dc1e3ff6fef61c9a4b6ff7293d94c7e181ad799eec5"
RDEPENDS:texlive-soul = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-stackengine = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-stackengine-20240311-6.el10.noarch.rpm;name=texlive-stackengine;unpack=0"
SRC_URI += "${URI_texlive-stackengine}"
SRC_URI[texlive-stackengine.sha256sum] = "c23ea31b76538f456d5abab1c818e3881493af0e96c0af5ee92111dde67811a0"
RDEPENDS:texlive-stackengine = " \
 texlive-kpathsea \
 texlive-etoolbox \
 texlive-listofitems \
 texlive-base \
"

URI_texlive-stmaryrd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-stmaryrd-20240311-6.el10.noarch.rpm;name=texlive-stmaryrd;unpack=0"
SRC_URI += "${URI_texlive-stmaryrd}"
SRC_URI[texlive-stmaryrd.sha256sum] = "ccfed540249465ffa89699bd24cb4368d4c531313767279ee28ae1930653784e"
RDEPENDS:texlive-stmaryrd = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-stringenc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-stringenc-20240311-6.el10.noarch.rpm;name=texlive-stringenc;unpack=0"
SRC_URI += "${URI_texlive-stringenc}"
SRC_URI[texlive-stringenc.sha256sum] = "f7af7fc98f76993aad383347652050912b8b7f7c701ef1e0d5106ed0899dadff"
RDEPENDS:texlive-stringenc = " \
 texlive-kpathsea \
"

URI_texlive-subfig = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-subfig-20240311-6.el10.noarch.rpm;name=texlive-subfig;unpack=0"
SRC_URI += "${URI_texlive-subfig}"
SRC_URI[texlive-subfig.sha256sum] = "6a92670a22d86a4ae0d58696d55b12eba88fadb7d770ba1de554745d07b9183f"
RDEPENDS:texlive-subfig = " \
 texlive-kpathsea \
 texlive-base \
 texlive-caption \
 texlive-graphics \
"

URI_texlive-subfigure = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-subfigure-20240311-6.el10.noarch.rpm;name=texlive-subfigure;unpack=0"
SRC_URI += "${URI_texlive-subfigure}"
SRC_URI[texlive-subfigure.sha256sum] = "9ba539b29bffb9e076f52f838cb88a876def656eeb065cca46d32a064aaa385e"
RDEPENDS:texlive-subfigure = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-svn-prov = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-svn-prov-20240311-6.el10.noarch.rpm;name=texlive-svn-prov;unpack=0"
SRC_URI += "${URI_texlive-svn-prov}"
SRC_URI[texlive-svn-prov.sha256sum] = "fbf4c8f8c751e9382507180807e9136fb600bd5473eeda22c2a396f001772db1"
RDEPENDS:texlive-svn-prov = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-symbol = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-symbol-20240311-6.el10.noarch.rpm;name=texlive-symbol;unpack=0"
SRC_URI += "${URI_texlive-symbol}"
SRC_URI[texlive-symbol.sha256sum] = "462cdcfa00e4399cff2c39179124a1ea13aebbe6bf2b0116223d9a98ea6ab213"
RDEPENDS:texlive-symbol = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-t2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-t2-20240311-6.el10.noarch.rpm;name=texlive-t2;unpack=0"
SRC_URI += "${URI_texlive-t2}"
SRC_URI[texlive-t2.sha256sum] = "bbfd737544f9067434ef308f6de40ec28f6c797848debee03c2ea06b08289f6a"
RDEPENDS:texlive-t2 = " \
 texlive-kpathsea \
 texlive-base \
 texlive-amsfonts \
 texlive-tools \
"

URI_texlive-tabu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-tabu-20240311-6.el10.noarch.rpm;name=texlive-tabu;unpack=0"
SRC_URI += "${URI_texlive-tabu}"
SRC_URI[texlive-tabu.sha256sum] = "5c2f6cebbfad62c218feac42937f4a9ced2214d34b20ff1cb6742596896784aa"
RDEPENDS:texlive-tabu = " \
 texlive-varwidth \
 texlive-kpathsea \
 texlive-tools \
 texlive-linegoal \
 texlive-base \
"

URI_texlive-tabulary = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-tabulary-20240311-6.el10.noarch.rpm;name=texlive-tabulary;unpack=0"
SRC_URI += "${URI_texlive-tabulary}"
SRC_URI[texlive-tabulary.sha256sum] = "a3b8c25b09b443338d08c97e243a489aca02b198698018ba0607db739b228fb7"
RDEPENDS:texlive-tabulary = " \
 texlive-kpathsea \
 texlive-base \
 texlive-tools \
"

URI_texlive-tex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-tex-20240311-6.el10.x86_64_v2.rpm;name=texlive-tex;unpack=0"
SRC_URI += "${URI_texlive-tex}"
SRC_URI[texlive-tex.sha256sum] = "dd658306d7b0f32d58226297081ca4217c02b9cb63a87fa6b36662d0a6c3eb35"
RDEPENDS:texlive-tex = " \
 texlive-lib \
 texlive-texlive-scripts \
 texlive-plain \
 texlive-knuth-lib \
 texlive-kpathsea \
 texlive-hyphen-base \
 texlive-cm \
 glibc \
 coreutils \
 texlive-base \
"

URI_texlive-tex-gyre = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-tex-gyre-20240311-6.el10.noarch.rpm;name=texlive-tex-gyre;unpack=0"
SRC_URI += "${URI_texlive-tex-gyre}"
SRC_URI[texlive-tex-gyre.sha256sum] = "9477722053646030e21371854dd81dd891d8ef2d8d325d71d187c9349526d00b"
RDEPENDS:texlive-tex-gyre = " \
 texlive-kpathsea \
 texlive-kvoptions \
 texlive-tex-gyre \
 texlive-base \
"

URI_texlive-tex-gyre-math = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-tex-gyre-math-20240311-6.el10.noarch.rpm;name=texlive-tex-gyre-math;unpack=0"
SRC_URI += "${URI_texlive-tex-gyre-math}"
SRC_URI[texlive-tex-gyre-math.sha256sum] = "5ec8584e24053305e5e5e119dfd396765de5526c7df024cb302b8e9f6b20c013"
RDEPENDS:texlive-tex-gyre-math = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-tex-ini-files = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-tex-ini-files-20240311-6.el10.noarch.rpm;name=texlive-tex-ini-files;unpack=0"
SRC_URI += "${URI_texlive-tex-ini-files}"
SRC_URI[texlive-tex-ini-files.sha256sum] = "fe197c833a773a1e52ca6c625999238d2583f6faa3f0b0f6bbe24c8bde1fdab1"
RDEPENDS:texlive-tex-ini-files = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-tex4ht = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-tex4ht-20240311-6.el10.x86_64_v2.rpm;name=texlive-tex4ht;unpack=0"
SRC_URI += "${URI_texlive-tex4ht}"
SRC_URI[texlive-tex4ht.sha256sum] = "8c9a8c307f1fedab420038e2d8bbe37e904850b872c8a8064730ae590b81c2c7"
RDEPENDS:texlive-tex4ht = " \
 texlive-lib \
 perl-libs \
 texlive-kpathsea \
 bash \
 glibc \
 coreutils \
 texlive-base \
"

URI_texlive-texlive-common-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-texlive-common-doc-20240311-6.el10.noarch.rpm;name=texlive-texlive-common-doc;unpack=0"
SRC_URI += "${URI_texlive-texlive-common-doc}"
SRC_URI[texlive-texlive-common-doc.sha256sum] = "8f5594caf4b732b24fd825b851ad960270ad45c411f29f10963a9e1de93b7123"
RDEPENDS:texlive-texlive-common-doc = ""

URI_texlive-texlive-en = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-texlive-en-20240311-6.el10.noarch.rpm;name=texlive-texlive-en;unpack=0"
SRC_URI += "${URI_texlive-texlive-en}"
SRC_URI[texlive-texlive-en.sha256sum] = "2c1881bbe5c7ddcabe7dfa4108c18e143cd4229c4d9cd4da20529ea2eab6ea82"
RDEPENDS:texlive-texlive-en = " \
 texlive-kpathsea \
 info \
 texlive-base \
 bash \
"

URI_texlive-texlive-msg-translations = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-texlive-msg-translations-20240311-6.el10.noarch.rpm;name=texlive-texlive-msg-translations;unpack=0"
SRC_URI += "${URI_texlive-texlive-msg-translations}"
SRC_URI[texlive-texlive-msg-translations.sha256sum] = "69f01cfb30a9c0bb51967c3beb2e6e119d97ee4036be17f46774d1b385127e90"
RDEPENDS:texlive-texlive-msg-translations = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-texlive-scripts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-texlive-scripts-20240311-6.el10.noarch.rpm;name=texlive-texlive-scripts;unpack=0"
SRC_URI += "${URI_texlive-texlive-scripts}"
SRC_URI[texlive-texlive-scripts.sha256sum] = "47008a42465488d481cf440e5518cc0763de2a788ce58a2e05e5ab5bc7d17b8d"
RDEPENDS:texlive-texlive-scripts = " \
 perl-libs \
 texlive-texlive.infra \
 texlive-kpathsea \
 perl-Getopt-Long \
 perl-File-Basename \
 perl-PathTools \
 bash \
 perl-File-Find \
 coreutils \
 texlive-base \
 perl-Pod-Usage \
"

URI_texlive-texlive-scripts-extra = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-texlive-scripts-extra-20240311-6.el10.noarch.rpm;name=texlive-texlive-scripts-extra;unpack=0"
SRC_URI += "${URI_texlive-texlive-scripts-extra}"
SRC_URI[texlive-texlive-scripts-extra.sha256sum] = "4c4a42eaa607c8a3eee96ae6abd9f482d0ea80502a4366279c45f10528cd5b8e"
RDEPENDS:texlive-texlive-scripts-extra = " \
 texlive-texlive.infra \
 texlive-kpathsea \
 bash \
 coreutils \
 texlive-base \
"

URI_texlive-texlive.infra = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-texlive.infra-20240311-6.el10.noarch.rpm;name=texlive-texlive.infra;unpack=0"
SRC_URI += "${URI_texlive-texlive.infra}"
SRC_URI[texlive-texlive.infra.sha256sum] = "d2d0ad3d87954fb35aa4136d2d5f02c59416e414b1d760273ef4901659b48092"
RDEPENDS:texlive-texlive.infra = " \
 perl-constant \
 perl-libs \
 perl-vars \
 perl-FileHandle \
 texlive-kpathsea \
 perl-Digest-MD5 \
 perl-Getopt-Long \
 perl-Text-Unidecode \
 perl-XML-Parser \
 bash \
 perl-PathTools \
 perl-XML-XPath \
 perl-File-Find \
 coreutils \
 perl-Exporter \
 texlive-base \
 perl-File-Temp \
 perl-Pod-Usage \
"

URI_texlive-textcase = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-textcase-20240311-6.el10.noarch.rpm;name=texlive-textcase;unpack=0"
SRC_URI += "${URI_texlive-textcase}"
SRC_URI[texlive-textcase.sha256sum] = "a8589fc5649923dc42f488cc0a12d8420a98dfc9abd82790076453951de0f107"
RDEPENDS:texlive-textcase = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-textpos = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-textpos-20240311-6.el10.noarch.rpm;name=texlive-textpos;unpack=0"
SRC_URI += "${URI_texlive-textpos}"
SRC_URI[texlive-textpos.sha256sum] = "6ed267cb379e611a9315d4b05f26d3e84a597d4c880743ac6d0708f09bc425f4"
RDEPENDS:texlive-textpos = " \
 texlive-everyshi \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-threeparttable = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-threeparttable-20240311-6.el10.noarch.rpm;name=texlive-threeparttable;unpack=0"
SRC_URI += "${URI_texlive-threeparttable}"
SRC_URI[texlive-threeparttable.sha256sum] = "79ccb1fc7ea156e0aae04aa824674f4f0320aa93d5d1ba3afa360c36f93f286a"
RDEPENDS:texlive-threeparttable = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-thumbpdf = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-thumbpdf-20240311-6.el10.noarch.rpm;name=texlive-thumbpdf;unpack=0"
SRC_URI += "${URI_texlive-thumbpdf}"
SRC_URI[texlive-thumbpdf.sha256sum] = "8f5322e45629481367f5f077e4d8ad6f1924b6e35f07b9d02a5782c0fa3579d4"
RDEPENDS:texlive-thumbpdf = " \
 perl-libs \
 texlive-kpathsea \
 perl-Getopt-Long \
 perl-interpreter \
 texlive-iftex \
 ghostscript \
 texlive-base \
"

URI_texlive-times = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-times-20240311-6.el10.noarch.rpm;name=texlive-times;unpack=0"
SRC_URI += "${URI_texlive-times}"
SRC_URI[texlive-times.sha256sum] = "c998d0d28a39aded84916dd0abd11ebf8bc5df57333e8479675036fae5ce9b83"
RDEPENDS:texlive-times = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-tipa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-tipa-20240311-6.el10.noarch.rpm;name=texlive-tipa;unpack=0"
SRC_URI += "${URI_texlive-tipa}"
SRC_URI[texlive-tipa.sha256sum] = "0d398e0eefb856a633b90b48c1e68f5fd1267307ecef521c6d0455f56473f920"
RDEPENDS:texlive-tipa = " \
 texlive-kpathsea \
 texlive-latex \
 texlive-tipa \
 texlive-base \
"

URI_texlive-titlesec = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-titlesec-20240311-6.el10.noarch.rpm;name=texlive-titlesec;unpack=0"
SRC_URI += "${URI_texlive-titlesec}"
SRC_URI[texlive-titlesec.sha256sum] = "da6573fffc12935cd74b9cf465dd422bd8925a42ab608f2f71147565839c447e"
RDEPENDS:texlive-titlesec = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-titling = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-titling-20240311-6.el10.noarch.rpm;name=texlive-titling;unpack=0"
SRC_URI += "${URI_texlive-titling}"
SRC_URI[texlive-titling.sha256sum] = "498abc15ad57f1a50c00498ca25b93ccb8ff053d60671688d3d3246a2965a6d9"
RDEPENDS:texlive-titling = " \
 texlive-kpathsea \
 coreutils \
 texlive-base \
"

URI_texlive-tocloft = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-tocloft-20240311-6.el10.noarch.rpm;name=texlive-tocloft;unpack=0"
SRC_URI += "${URI_texlive-tocloft}"
SRC_URI[texlive-tocloft.sha256sum] = "f40b4b64e9cf47717b5fa616bae8f745a7a369dbfb1f51ad47f16c02b4bde4b0"
RDEPENDS:texlive-tocloft = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-tools-20240311-6.el10.noarch.rpm;name=texlive-tools;unpack=0"
SRC_URI += "${URI_texlive-tools}"
SRC_URI[texlive-tools.sha256sum] = "c7c2eea487d65fdfc1fbb3a8e7ad3f97a1a34d79f6380438cdfba055d2e3c475"
RDEPENDS:texlive-tools = " \
 texlive-kpathsea \
 texlive-base \
 texlive-graphics \
"

URI_texlive-translator = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-translator-20240311-6.el10.noarch.rpm;name=texlive-translator;unpack=0"
SRC_URI += "${URI_texlive-translator}"
SRC_URI[texlive-translator.sha256sum] = "feb68bcc9cddc9becde221920762c0986f863a034812d433a192148773dc42ff"
RDEPENDS:texlive-translator = " \
 texlive-kpathsea \
 texlive-graphics \
"

URI_texlive-trimspaces = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-trimspaces-20240311-6.el10.noarch.rpm;name=texlive-trimspaces;unpack=0"
SRC_URI += "${URI_texlive-trimspaces}"
SRC_URI[texlive-trimspaces.sha256sum] = "ec0e6bd400e5d7c6d3542440984756c7bab669cf41633ae30346af7f4370d697"
RDEPENDS:texlive-trimspaces = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-txfonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-txfonts-20240311-6.el10.noarch.rpm;name=texlive-txfonts;unpack=0"
SRC_URI += "${URI_texlive-txfonts}"
SRC_URI[texlive-txfonts.sha256sum] = "b8a28f5fec69945f6ec15b8d399e7d8b47e15dc3cbc9cc96daa2a8b0eb234d7c"
RDEPENDS:texlive-txfonts = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-type1cm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-type1cm-20240311-6.el10.noarch.rpm;name=texlive-type1cm;unpack=0"
SRC_URI += "${URI_texlive-type1cm}"
SRC_URI[texlive-type1cm.sha256sum] = "96773f276fb1e7285382ea36fcc4e88a82b0b8f81c8a7f84d57e84749e56e237"
RDEPENDS:texlive-type1cm = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-typehtml = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-typehtml-20240311-6.el10.noarch.rpm;name=texlive-typehtml;unpack=0"
SRC_URI += "${URI_texlive-typehtml}"
SRC_URI[texlive-typehtml.sha256sum] = "aa4949317fdf900360ac175d7c649999dd2f623db3be23a637f3659f352feab3"
RDEPENDS:texlive-typehtml = " \
 texlive-kpathsea \
 texlive-latex \
 texlive-base \
"

URI_texlive-ucharcat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-ucharcat-20240311-6.el10.noarch.rpm;name=texlive-ucharcat;unpack=0"
SRC_URI += "${URI_texlive-ucharcat}"
SRC_URI[texlive-ucharcat.sha256sum] = "ad54b94fa23b0f7966542e072466e219a6aef74b9fc95afc5aa4aef558227a19"
RDEPENDS:texlive-ucharcat = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-ucharclasses = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-ucharclasses-20240311-6.el10.noarch.rpm;name=texlive-ucharclasses;unpack=0"
SRC_URI += "${URI_texlive-ucharclasses}"
SRC_URI[texlive-ucharclasses.sha256sum] = "cb272b35fa21ec04d1c095695fb916da9fc05f30e4598bb541e1e257a2a1a2d0"
RDEPENDS:texlive-ucharclasses = " \
 texlive-kpathsea \
 texlive-iftex \
 texlive-base \
"

URI_texlive-ucs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-ucs-20240311-6.el10.noarch.rpm;name=texlive-ucs;unpack=0"
SRC_URI += "${URI_texlive-ucs}"
SRC_URI[texlive-ucs.sha256sum] = "686387a5d6d63add465b955117818f9be23ba022329ec3686aac17410ea7c8ac"
RDEPENDS:texlive-ucs = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-IO \
 texlive-graphics \
 texlive-kpathsea \
 perl-Getopt-Long \
 texlive-latex \
 texlive-hyperref \
 perl-interpreter \
 perl-Data-Dumper \
 texlive-base \
"

URI_texlive-uhc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-uhc-20240311-6.el10.noarch.rpm;name=texlive-uhc;unpack=0"
SRC_URI += "${URI_texlive-uhc}"
SRC_URI[texlive-uhc.sha256sum] = "907aa8902573f451790e48f29e3a8f4992900c7e738260e12a8511a963602b9f"
RDEPENDS:texlive-uhc = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-ulem = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-ulem-20240311-6.el10.noarch.rpm;name=texlive-ulem;unpack=0"
SRC_URI += "${URI_texlive-ulem}"
SRC_URI[texlive-ulem.sha256sum] = "09dc20f3c6a9b6fe167ddb9070a212717e7bf0afc3af5cd7d38827586c1c69b5"
RDEPENDS:texlive-ulem = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-underscore = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-underscore-20240311-6.el10.noarch.rpm;name=texlive-underscore;unpack=0"
SRC_URI += "${URI_texlive-underscore}"
SRC_URI[texlive-underscore.sha256sum] = "92c90bafe1a5d5122db0085c70de880f9f742b98955b0d1380edb544e07eace1"
RDEPENDS:texlive-underscore = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-unicode-data = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-unicode-data-20240311-6.el10.noarch.rpm;name=texlive-unicode-data;unpack=0"
SRC_URI += "${URI_texlive-unicode-data}"
SRC_URI[texlive-unicode-data.sha256sum] = "2f4cfe0404f81cd34acbbecf80f1c439acf9ce03de7ddd76fc9a1db55004d2df"
RDEPENDS:texlive-unicode-data = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-unicode-math = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-unicode-math-20240311-6.el10.noarch.rpm;name=texlive-unicode-math;unpack=0"
SRC_URI += "${URI_texlive-unicode-math}"
SRC_URI[texlive-unicode-math.sha256sum] = "a97f3acefcf20e55432ebecaaf075ff55f68d7da21c0c995bafc53fba65ca246"
RDEPENDS:texlive-unicode-math = " \
 texlive-lualatex-math \
 texlive-luaotfload \
 texlive-kpathsea \
 texlive-luatexbase \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-filehook \
 texlive-catchfile \
 texlive-latex \
 texlive-fontspec \
 texlive-base \
"

URI_texlive-uniquecounter = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-uniquecounter-20240311-6.el10.noarch.rpm;name=texlive-uniquecounter;unpack=0"
SRC_URI += "${URI_texlive-uniquecounter}"
SRC_URI[texlive-uniquecounter.sha256sum] = "25ac8cc440a5218370f12526cd8d9aaf48d0417c5afd1466c410aef7dc1c231e"
RDEPENDS:texlive-uniquecounter = " \
 texlive-kpathsea \
"

URI_texlive-unisugar = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-unisugar-20240311-6.el10.noarch.rpm;name=texlive-unisugar;unpack=0"
SRC_URI += "${URI_texlive-unisugar}"
SRC_URI[texlive-unisugar.sha256sum] = "c36473c164a16069b4b3531d706dcc4ff2f42317e485c2ea34b68b77c82d752e"
RDEPENDS:texlive-unisugar = " \
 texlive-kpathsea \
 texlive-iftex \
 texlive-base \
"

URI_texlive-upquote = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-upquote-20240311-6.el10.noarch.rpm;name=texlive-upquote;unpack=0"
SRC_URI += "${URI_texlive-upquote}"
SRC_URI[texlive-upquote.sha256sum] = "e961a1f925ee1175b557d4a87666a2e04dfbb5e3d9d99540cd003cc675d0d595"
RDEPENDS:texlive-upquote = " \
 texlive-kpathsea \
 texlive-latex \
 texlive-base \
"

URI_texlive-url = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-url-20240311-6.el10.noarch.rpm;name=texlive-url;unpack=0"
SRC_URI += "${URI_texlive-url}"
SRC_URI[texlive-url.sha256sum] = "76479c34e7c405bb03960719dc4cafb1cc53f1a9363a33155fe9f57e6142eb98"
RDEPENDS:texlive-url = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-utopia = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-utopia-20240311-6.el10.noarch.rpm;name=texlive-utopia;unpack=0"
SRC_URI += "${URI_texlive-utopia}"
SRC_URI[texlive-utopia.sha256sum] = "72d41fec45217ab1cba71552298ec4fa7a05d4ed9d37e6240d12bad0e8dbbf04"
RDEPENDS:texlive-utopia = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-varwidth = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-varwidth-20240311-6.el10.noarch.rpm;name=texlive-varwidth;unpack=0"
SRC_URI += "${URI_texlive-varwidth}"
SRC_URI[texlive-varwidth.sha256sum] = "b61e56625b11644a0bd9b41d4b3cdd86703e298e88070b7af8a73dba14689df6"
RDEPENDS:texlive-varwidth = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-wadalab = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-wadalab-20240311-6.el10.noarch.rpm;name=texlive-wadalab;unpack=0"
SRC_URI += "${URI_texlive-wadalab}"
SRC_URI[texlive-wadalab.sha256sum] = "d3f648dbd83842ba9a09fdc5ab34060d75984a2ab5c870745d730a7ff288b76e"
RDEPENDS:texlive-wadalab = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-was = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-was-20240311-6.el10.noarch.rpm;name=texlive-was;unpack=0"
SRC_URI += "${URI_texlive-was}"
SRC_URI[texlive-was.sha256sum] = "28765f7b1eb4eea284a484d641c4c61ebfd6b6bc42b30d5158821ec6ee592810"
RDEPENDS:texlive-was = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-wasy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-wasy-20240311-6.el10.noarch.rpm;name=texlive-wasy;unpack=0"
SRC_URI += "${URI_texlive-wasy}"
SRC_URI[texlive-wasy.sha256sum] = "e5cf1fc9c604cad9cc33e3f21c5eddd479419c383c61efc8b5f7d35d2a5f1767"
RDEPENDS:texlive-wasy = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-wasy-type1 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-wasy-type1-20240311-6.el10.noarch.rpm;name=texlive-wasy-type1;unpack=0"
SRC_URI += "${URI_texlive-wasy-type1}"
SRC_URI[texlive-wasy-type1.sha256sum] = "18333b06115981355ba90798814e8c61b3b065ec6b1684452be78ba03a429e15"
RDEPENDS:texlive-wasy-type1 = " \
 texlive-kpathsea \
 texlive-wasy \
"

URI_texlive-wasysym = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-wasysym-20240311-6.el10.noarch.rpm;name=texlive-wasysym;unpack=0"
SRC_URI += "${URI_texlive-wasysym}"
SRC_URI[texlive-wasysym.sha256sum] = "f616fdb95d8376a384679e126a77074e04cd0cd5b1faa52ead32057c54d714e2"
RDEPENDS:texlive-wasysym = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-wrapfig = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-wrapfig-20240311-6.el10.noarch.rpm;name=texlive-wrapfig;unpack=0"
SRC_URI += "${URI_texlive-wrapfig}"
SRC_URI[texlive-wrapfig.sha256sum] = "d44f2bb170f03794bbb78bb98d2e51acfb2a2ba41afe352b120caa0e6c813d56"
RDEPENDS:texlive-wrapfig = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-xcolor = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-xcolor-20240311-6.el10.noarch.rpm;name=texlive-xcolor;unpack=0"
SRC_URI += "${URI_texlive-xcolor}"
SRC_URI[texlive-xcolor.sha256sum] = "0716c198a759790a84bab8e1ed32a9248fe1d09244d84c848ffda6d7944f347b"
RDEPENDS:texlive-xcolor = " \
 texlive-kpathsea \
 texlive-pdfcolmk \
 texlive-colortbl \
 texlive-base \
"

URI_texlive-xecolor = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-xecolor-20240311-6.el10.noarch.rpm;name=texlive-xecolor;unpack=0"
SRC_URI += "${URI_texlive-xecolor}"
SRC_URI[texlive-xecolor.sha256sum] = "00fc9cf59105133861f60c3891ab810966c93164712e603de20809aff8345cd5"
RDEPENDS:texlive-xecolor = " \
 texlive-kpathsea \
 texlive-fontspec \
 texlive-iftex \
 texlive-base \
"

URI_texlive-xecyr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-xecyr-20240311-6.el10.noarch.rpm;name=texlive-xecyr;unpack=0"
SRC_URI += "${URI_texlive-xecyr}"
SRC_URI[texlive-xecyr.sha256sum] = "2ddabc8e6d4964fcb3bb201cf8d6f80554c5753f31fb174ea171815aa5456aa6"
RDEPENDS:texlive-xecyr = " \
 texlive-kpathsea \
 texlive-xltxtra \
 texlive-t2 \
 texlive-xunicode \
 texlive-base \
"

URI_texlive-xeindex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-xeindex-20240311-6.el10.noarch.rpm;name=texlive-xeindex;unpack=0"
SRC_URI += "${URI_texlive-xeindex}"
SRC_URI[texlive-xeindex.sha256sum] = "303ec55d1cf0672db7ff54c701b88f01bb67ded32b397117bd6aaf4717260ceb"
RDEPENDS:texlive-xeindex = " \
 texlive-kpathsea \
 texlive-latex \
 texlive-base \
 texlive-xesearch \
"

URI_texlive-xepersian = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-xepersian-20240311-6.el10.noarch.rpm;name=texlive-xepersian;unpack=0"
SRC_URI += "${URI_texlive-xepersian}"
SRC_URI[texlive-xepersian.sha256sum] = "371e1e3c8196f820c4af39b512f9191195cbdc3edf26aba55e7a2a6ece5019c2"
RDEPENDS:texlive-xepersian = " \
 texlive-multido \
 texlive-fancybox \
 texlive-fancyhdr \
 texlive-fontspec \
 texlive-geometry \
 texlive-preprint \
 texlive-psnfss \
 texlive-hyphenat \
 texlive-iftex \
 texlive-ragged2e \
 texlive-base \
 texlive-bidi \
 texlive-kpathsea \
 texlive-setspace \
 texlive-lastpage \
 texlive-latex \
 python-unversioned-command \
 texlive-textpos \
 texlive-datetime \
 texlive-tools \
"

URI_texlive-xesearch = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-xesearch-20240311-6.el10.noarch.rpm;name=texlive-xesearch;unpack=0"
SRC_URI += "${URI_texlive-xesearch}"
SRC_URI[texlive-xesearch.sha256sum] = "d5ffcd5fa1bcc9ee12cf34126d99ddbbb5394a732a28a937f8642241cf65e1c7"
RDEPENDS:texlive-xesearch = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-xetex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-xetex-20240311-6.el10.x86_64_v2.rpm;name=texlive-xetex;unpack=0"
SRC_URI += "${URI_texlive-xetex}"
SRC_URI[texlive-xetex.sha256sum] = "c28314e4ef07b14354a4aaf7af00868c2e1822ad5cdccc8dd86ef65691bc24b9"
RDEPENDS:texlive-xetex = " \
 libpng \
 fontconfig \
 texlive-xetexconfig \
 texlive-plain \
 teckit \
 texlive-graphics-def \
 libpaper \
 libstdc++ \
 texlive-hyphen-base \
 texlive-babel \
 texlive-base \
 zlib-ng-compat \
 texlive-kpathsea \
 libgcc \
 graphite2 \
 texlive-l3kernel \
 texlive-latex \
 texlive-latex-fonts \
 texlive-cm \
 texlive-lib \
 libicu \
 texlive-lm \
 texlive-tex-ini-files \
 freetype \
 harfbuzz \
 texlive-dvipdfmx \
 glibc \
 coreutils \
 texlive-unicode-data \
 texlive-etex \
"

URI_texlive-xetex-itrans = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-xetex-itrans-20240311-6.el10.noarch.rpm;name=texlive-xetex-itrans;unpack=0"
SRC_URI += "${URI_texlive-xetex-itrans}"
SRC_URI[texlive-xetex-itrans.sha256sum] = "68f82005c91c958d9bbf006643c66e0d91c42d8f63d9e32c97709fed745f550d"
RDEPENDS:texlive-xetex-itrans = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-xetex-pstricks = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-xetex-pstricks-20240311-6.el10.noarch.rpm;name=texlive-xetex-pstricks;unpack=0"
SRC_URI += "${URI_texlive-xetex-pstricks}"
SRC_URI[texlive-xetex-pstricks.sha256sum] = "822b13c650e0d6303ddda5ddefb5f9dd4d125bcb57fd8627c826dce9bdaa7dea"
RDEPENDS:texlive-xetex-pstricks = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-xetexconfig = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-xetexconfig-20240311-6.el10.noarch.rpm;name=texlive-xetexconfig;unpack=0"
SRC_URI += "${URI_texlive-xetexconfig}"
SRC_URI[texlive-xetexconfig.sha256sum] = "072d0b4ce773f44d9c2e7397ff9d99fb50282c5b2fcfbe5b2af078326c416c8d"
RDEPENDS:texlive-xetexconfig = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-xetexfontinfo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-xetexfontinfo-20240311-6.el10.noarch.rpm;name=texlive-xetexfontinfo;unpack=0"
SRC_URI += "${URI_texlive-xetexfontinfo}"
SRC_URI[texlive-xetexfontinfo.sha256sum] = "d4d9afd56325bd54225b7980bb2cfb64cf98f841f2eac57df3302d016978c07f"
RDEPENDS:texlive-xetexfontinfo = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-xfrac = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-xfrac-20240311-6.el10.noarch.rpm;name=texlive-xfrac;unpack=0"
SRC_URI += "${URI_texlive-xfrac}"
SRC_URI[texlive-xfrac.sha256sum] = "c8740829e27a5120ec556092fd8ba0ede523c6188b1ebc190fbddc75382533f9"
RDEPENDS:texlive-xfrac = " \
 texlive-kpathsea \
"

URI_texlive-xifthen = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-xifthen-20240311-6.el10.noarch.rpm;name=texlive-xifthen;unpack=0"
SRC_URI += "${URI_texlive-xifthen}"
SRC_URI[texlive-xifthen.sha256sum] = "724d6b18154cbf0bdce87647e49748aeac271b47d541f3a4327fe5b1c082a64c"
RDEPENDS:texlive-xifthen = " \
 texlive-kpathsea \
 texlive-tools \
 texlive-latex \
 texlive-ifmtarg \
 texlive-base \
 texlive-etex-pkg \
"

URI_texlive-xkeyval = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-xkeyval-20240311-6.el10.noarch.rpm;name=texlive-xkeyval;unpack=0"
SRC_URI += "${URI_texlive-xkeyval}"
SRC_URI[texlive-xkeyval.sha256sum] = "2204fe2dcfe8aad8b790ca4a7456bb01a582436108b5d4f9dce101a7b7ae6e29"
RDEPENDS:texlive-xkeyval = " \
 texlive-kpathsea \
 texlive-base \
 texlive-tools \
"

URI_texlive-xltxtra = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-xltxtra-20240311-6.el10.noarch.rpm;name=texlive-xltxtra;unpack=0"
SRC_URI += "${URI_texlive-xltxtra}"
SRC_URI[texlive-xltxtra.sha256sum] = "64e484df7726e2d779515f67e6b0cc45c41ca0971125fa755de4dbc6edae168d"
RDEPENDS:texlive-xltxtra = " \
 texlive-realscripts \
 texlive-kpathsea \
 texlive-metalogo \
 texlive-fontspec \
 texlive-iftex \
 texlive-base \
"

URI_texlive-xmltex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-xmltex-20240311-6.el10.noarch.rpm;name=texlive-xmltex;unpack=0"
SRC_URI += "${URI_texlive-xmltex}"
SRC_URI[texlive-xmltex.sha256sum] = "ef3b9c3649ec7abfcf46096876e068ea45da17f2b8c9476f8c54f062bbef5e01"
RDEPENDS:texlive-xmltex = " \
 texlive-pdftex \
 texlive-kpathsea \
 texlive-l3backend \
 texlive-babel \
 texlive-l3kernel \
 texlive-dehyph \
 texlive-l3packages \
 texlive-latex \
 texlive-latex-fonts \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-cm \
 texlive-latexconfig \
 texlive-tex \
 texlive-unicode-data \
 texlive-base \
 texlive-tex-ini-files \
"

URI_texlive-xpatch = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-xpatch-20240311-6.el10.noarch.rpm;name=texlive-xpatch;unpack=0"
SRC_URI += "${URI_texlive-xpatch}"
SRC_URI[texlive-xpatch.sha256sum] = "9b24932987901a82c54659ff050a46036e3a89d6a0f435ce19dc66187449b419"
RDEPENDS:texlive-xpatch = " \
 texlive-etoolbox \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-base \
"

URI_texlive-xstring = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-xstring-20240311-6.el10.noarch.rpm;name=texlive-xstring;unpack=0"
SRC_URI += "${URI_texlive-xstring}"
SRC_URI[texlive-xstring.sha256sum] = "154f936a07b8cdeecb554e099b96b0f3cdf11230d8443c48fd41d9c58e4cf091"
RDEPENDS:texlive-xstring = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-xtab = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-xtab-20240311-6.el10.noarch.rpm;name=texlive-xtab;unpack=0"
SRC_URI += "${URI_texlive-xtab}"
SRC_URI[texlive-xtab.sha256sum] = "dfccf1d73357635f3673328adda2e9a11bb656ee446a36ef3f2d34d7e602637b"
RDEPENDS:texlive-xtab = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-xunicode = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-xunicode-20240311-6.el10.noarch.rpm;name=texlive-xunicode;unpack=0"
SRC_URI += "${URI_texlive-xunicode}"
SRC_URI[texlive-xunicode.sha256sum] = "e8175e59ac471ec808a62f8474516741ae23519a4840b13338d3c86cafe3b90e"
RDEPENDS:texlive-xunicode = " \
 texlive-kpathsea \
 texlive-tipa \
 texlive-base \
 texlive-graphics \
"

URI_texlive-zapfchan = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-zapfchan-20240311-6.el10.noarch.rpm;name=texlive-zapfchan;unpack=0"
SRC_URI += "${URI_texlive-zapfchan}"
SRC_URI[texlive-zapfchan.sha256sum] = "9c87a4ff8c1a2f0c15f2db323f5c5f019b504625f226f56d6a697a4b610b3293"
RDEPENDS:texlive-zapfchan = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-zapfding = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-zapfding-20240311-6.el10.noarch.rpm;name=texlive-zapfding;unpack=0"
SRC_URI += "${URI_texlive-zapfding}"
SRC_URI[texlive-zapfding.sha256sum] = "3dfbeef3adb0ad11633cf41b9c2f1f017f4aeb12fbf51c5b1ead585f6f664747"
RDEPENDS:texlive-zapfding = " \
 texlive-kpathsea \
 texlive-base \
"

URI_texlive-zref = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/texlive-zref-20240311-6.el10.noarch.rpm;name=texlive-zref;unpack=0"
SRC_URI += "${URI_texlive-zref}"
SRC_URI[texlive-zref.sha256sum] = "895ec361386b9d93411a3df565dd4efbfeb8f33a0c7b668e7647d7fb2d572c8e"
RDEPENDS:texlive-zref = " \
 texlive-kpathsea \
"

URI_texlive-gnu-freefont = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/texlive-gnu-freefont-20240311-6.el10.noarch.rpm;name=texlive-gnu-freefont;unpack=0"
SRC_URI += "${URI_texlive-gnu-freefont}"
SRC_URI[texlive-gnu-freefont.sha256sum] = "86a5b55e20a5eff47edcc6cf05fecf475e0f2aa9acfea123724054f96c07071c"
RDEPENDS:texlive-gnu-freefont = " \
 texlive-kpathsea \
 bash \
 python-unversioned-command \
 coreutils \
 perl-interpreter \
 texlive-base \
 fontforge \
"

URI_texlive-lib-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/texlive-lib-devel-20240311-6.el10.x86_64_v2.rpm;name=texlive-lib-devel;unpack=0"
SRC_URI += "${URI_texlive-lib-devel}"
SRC_URI[texlive-lib-devel.sha256sum] = "75ea4b8bb96bc0fb9422d4e8550deb5607c3ee944affd8e8a12a60a3c8654e96"
RDEPENDS:texlive-lib-devel = " \
 texlive-lib \
 zlib-ng-compat-devel \
 texlive-lib-devel \
 pkgconf-pkg-config \
"
