# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gsound"
PE = "0"
PV = "1.0.3"
PR = "10.el10"
PACKAGES = "gsound gsound-devel"
PROVIDES = "rpm/gsound rpm/gsound-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gsound-1.0.3-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9e9558b1e9a6d692f4614d7b482ed18465ba7082c9357af51e3125fa62125c5"

URI_gsound = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gsound-1.0.3-10.el10.x86_64_v2.rpm;name=gsound;unpack=0"
SRC_URI += "${URI_gsound}"
SRC_URI[gsound.sha256sum] = "41b3aa4f46b3266b5b2bfa410696d3173653cfdfa033375e2d2cc800c4502b57"
RDEPENDS:gsound = " \
 glibc \
 glib2 \
 libcanberra \
"

URI_gsound-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gsound-devel-1.0.3-10.el10.x86_64_v2.rpm;name=gsound-devel;unpack=0"
SRC_URI += "${URI_gsound-devel}"
SRC_URI[gsound-devel.sha256sum] = "7bdde4a29cc6f68a4d2d6ee7991258ac56774ae010ebee4dd77fd07f729be753"
RDEPENDS:gsound-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 gsound \
 libcanberra-devel \
"
