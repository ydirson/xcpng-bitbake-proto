# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-si"
PE = "0"
PV = "0.2.1"
PR = "34.el10"
PACKAGES = "hunspell-si"
PROVIDES = "rpm/hunspell-si"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-si-0.2.1-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f3da04312b189879647a29f78c137c3e229f01d13c487d551e7c7d5fad57b11"

URI_hunspell-si = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-si-0.2.1-34.el10.noarch.rpm;name=hunspell-si;unpack=0"
SRC_URI += "${URI_hunspell-si}"
SRC_URI[hunspell-si.sha256sum] = "12504e57114de7018fff775deccece53d5158227310339e00c47d41e5e7b035e"
RDEPENDS:hunspell-si = " \
 hunspell \
"
