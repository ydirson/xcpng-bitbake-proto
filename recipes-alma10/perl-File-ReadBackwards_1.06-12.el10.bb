# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-File-ReadBackwards"
PE = "0"
PV = "1.06"
PR = "12.el10"
PACKAGES = "perl-File-ReadBackwards perl-File-ReadBackwards-tests"
PROVIDES = "rpm/perl-File-ReadBackwards rpm/perl-File-ReadBackwards-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-File-ReadBackwards-1.06-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f70e62c93eed8509f5ff5842815c617ad60b0e62581427232c582086d16125d8"

URI_perl-File-ReadBackwards = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-File-ReadBackwards-1.06-12.el10.noarch.rpm;name=perl-File-ReadBackwards;unpack=0"
SRC_URI += "${URI_perl-File-ReadBackwards}"
SRC_URI[perl-File-ReadBackwards.sha256sum] = "0a13a3a46122fd23530f16f59669ad9b4c77cbf5ca5d676aecf588d4202ac336"
RDEPENDS:perl-File-ReadBackwards = " \
 perl-Fcntl \
 perl-Symbol \
 perl-libs \
 perl-Carp \
"

URI_perl-File-ReadBackwards-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-File-ReadBackwards-tests-1.06-12.el10.noarch.rpm;name=perl-File-ReadBackwards-tests;unpack=0"
SRC_URI += "${URI_perl-File-ReadBackwards-tests}"
SRC_URI[perl-File-ReadBackwards-tests.sha256sum] = "3f01826f22f73dc3d873d5a97a198a540d1a2a0418400b069daa02f4886e6654"
RDEPENDS:perl-File-ReadBackwards-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-Fcntl \
 bash \
 perl-interpreter \
 perl-File-ReadBackwards \
 perl-File-Temp \
"
