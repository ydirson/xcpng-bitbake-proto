# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ibus-anthy"
PE = "0"
PV = "1.5.16"
PR = "22.el10"
PACKAGES = "ibus-anthy ibus-anthy-python ibus-anthy-devel ibus-anthy-tests"
PROVIDES = "rpm/ibus-anthy rpm/ibus-anthy-python rpm/ibus-anthy-devel rpm/ibus-anthy-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ibus-anthy-1.5.16-22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4cfb008dc6fb246a51b284ae73e4a82460b88370698d97379005f5da6b5191d7"

URI_ibus-anthy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ibus-anthy-1.5.16-22.el10.x86_64_v2.rpm;name=ibus-anthy;unpack=0"
SRC_URI += "${URI_ibus-anthy}"
SRC_URI[ibus-anthy.sha256sum] = "12e130284f1ec42cd108136bb15fbdf933edc5e129d48ebb2910e5b1068666c0"
RDEPENDS:ibus-anthy = " \
 kasumi-unicode \
 ibus \
 ibus-anthy-python \
 glib2 \
 glibc \
 anthy-unicode \
"

URI_ibus-anthy-python = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ibus-anthy-python-1.5.16-22.el10.noarch.rpm;name=ibus-anthy-python;unpack=0"
SRC_URI += "${URI_ibus-anthy-python}"
SRC_URI[ibus-anthy-python.sha256sum] = "0d807ff35fd7ebe92a9a724e0fe197992ea5cc3567d8a9b41496a9514a0c4ef3"
RDEPENDS:ibus-anthy-python = " \
 python3-gobject \
 python3-cairo \
 ibus-anthy \
 bash \
 gtk3 \
"

URI_ibus-anthy-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ibus-anthy-devel-1.5.16-22.el10.x86_64_v2.rpm;name=ibus-anthy-devel;unpack=0"
SRC_URI += "${URI_ibus-anthy-devel}"
SRC_URI[ibus-anthy-devel.sha256sum] = "3384a857891ea6c1f8fd081945d4f08055da1c9b036b2f4b5f93bc8ebf5992ab"
RDEPENDS:ibus-anthy-devel = " \
 ibus-anthy \
 glib2-devel \
 anthy-unicode-devel \
"

URI_ibus-anthy-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ibus-anthy-tests-1.5.16-22.el10.x86_64_v2.rpm;name=ibus-anthy-tests;unpack=0"
SRC_URI += "${URI_ibus-anthy-tests}"
SRC_URI[ibus-anthy-tests.sha256sum] = "a6a3a3f6c9e56badf693b45122685d02ecb495060d6d1e3503af92274bc0cccd"
RDEPENDS:ibus-anthy-tests = " \
 python3 \
 ibus-anthy \
 python3-pycotap \
"
