# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "fio"
PE = "0"
PV = "3.36"
PR = "5.el10"
PACKAGES = "fio fio-engine-http fio-engine-libaio fio-engine-nbd fio-engine-rados fio-engine-rbd fio-engine-rdma"
PROVIDES = "rpm/fio rpm/fio-engine-http rpm/fio-engine-libaio rpm/fio-engine-nbd rpm/fio-engine-rados rpm/fio-engine-rbd rpm/fio-engine-rdma"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/fio-3.36-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce08049dfabf0e9423e7b38389bf0af86f37e5e89fb31e7448a6b47e22b6fc99"

URI_fio = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fio-3.36-5.el10.x86_64_v2.rpm;name=fio;unpack=0"
SRC_URI += "${URI_fio}"
SRC_URI[fio.sha256sum] = "b95ffd2e3cbb07817b9c086af786276740170847743a230188e733fd565709a5"
RDEPENDS:fio = " \
 python3 \
 zlib-ng-compat \
 numactl-libs \
 bash \
 glibc \
"

URI_fio-engine-http = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fio-engine-http-3.36-5.el10.x86_64_v2.rpm;name=fio-engine-http;unpack=0"
SRC_URI += "${URI_fio-engine-http}"
SRC_URI[fio-engine-http.sha256sum] = "9d52a4f07d1ea35078fa6adec6d113ca33bd579438c6307563eb497432316fe9"
RDEPENDS:fio-engine-http = " \
 glibc \
 fio \
 openssl-libs \
 libcurl \
"

URI_fio-engine-libaio = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fio-engine-libaio-3.36-5.el10.x86_64_v2.rpm;name=fio-engine-libaio;unpack=0"
SRC_URI += "${URI_fio-engine-libaio}"
SRC_URI[fio-engine-libaio.sha256sum] = "c865a356fc320a30632e6c2d9c7cee12869b29587c8ef803442eb30b438f985f"
RDEPENDS:fio-engine-libaio = " \
 glibc \
 fio \
 libaio \
"

URI_fio-engine-nbd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fio-engine-nbd-3.36-5.el10.x86_64_v2.rpm;name=fio-engine-nbd;unpack=0"
SRC_URI += "${URI_fio-engine-nbd}"
SRC_URI[fio-engine-nbd.sha256sum] = "d0fb6b1e9f89f075b25080dfb098414088863953a4bdd15a4679500e46c5b45a"
RDEPENDS:fio-engine-nbd = " \
 glibc \
 fio \
 libnbd \
"

URI_fio-engine-rados = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fio-engine-rados-3.36-5.el10.x86_64_v2.rpm;name=fio-engine-rados;unpack=0"
SRC_URI += "${URI_fio-engine-rados}"
SRC_URI[fio-engine-rados.sha256sum] = "f46ab64442273a73cc17ae4988eec5fc16482c1b9e0abf488cdc6494430237a8"
RDEPENDS:fio-engine-rados = " \
 glibc \
 fio \
 librados2 \
"

URI_fio-engine-rbd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fio-engine-rbd-3.36-5.el10.x86_64_v2.rpm;name=fio-engine-rbd;unpack=0"
SRC_URI += "${URI_fio-engine-rbd}"
SRC_URI[fio-engine-rbd.sha256sum] = "aa4ecbcab11f45657ab4bdae60b2df2c91ec6f194bbda0fe4114be56ad313722"
RDEPENDS:fio-engine-rbd = " \
 glibc \
 fio \
 librados2 \
 librbd1 \
"

URI_fio-engine-rdma = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fio-engine-rdma-3.36-5.el10.x86_64_v2.rpm;name=fio-engine-rdma;unpack=0"
SRC_URI += "${URI_fio-engine-rdma}"
SRC_URI[fio-engine-rdma.sha256sum] = "3fe14254ee41294bf93210fba002976cdcf1805374ddce7b76db8d10646b3b58"
RDEPENDS:fio-engine-rdma = " \
 glibc \
 fio \
 libibverbs \
 librdmacm \
"
