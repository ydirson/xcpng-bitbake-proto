# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-tpm2-pytss"
PE = "0"
PV = "2.3.0"
PR = "2.el10"
PACKAGES = "python3-tpm2-pytss"
PROVIDES = "rpm/python3-tpm2-pytss"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-tpm2-pytss-2.3.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "079927ed46a85d4736fdec11fab9516d82e8d188cfb6265eb04ff46357ec89b2"

URI_python3-tpm2-pytss = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-tpm2-pytss-2.3.0-2.el10.x86_64_v2.rpm;name=python3-tpm2-pytss;unpack=0"
SRC_URI += "${URI_python3-tpm2-pytss}"
SRC_URI[python3-tpm2-pytss.sha256sum] = "8ce17eaa7d4e9fa3631d6b7e136bfa18646a6171632574011550f9659ac3668e"
RDEPENDS:python3-tpm2-pytss = " \
 python3 \
 python3-pyyaml \
 python3-cffi \
 python3-cryptography \
 tpm2-tss \
 glibc \
 python3-packaging \
 python3-asn1crypto \
 tpm2-tss-fapi \
"
