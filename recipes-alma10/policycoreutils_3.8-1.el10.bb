# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "policycoreutils"
PE = "0"
PV = "3.8"
PR = "1.el10"
PACKAGES = "policycoreutils policycoreutils-newrole policycoreutils-restorecond policycoreutils-dbus policycoreutils-devel policycoreutils-gui policycoreutils-python-utils policycoreutils-sandbox python3-policycoreutils"
PROVIDES = "rpm/policycoreutils rpm/policycoreutils-newrole rpm/policycoreutils-restorecond rpm/policycoreutils-dbus rpm/policycoreutils-devel rpm/policycoreutils-gui rpm/policycoreutils-python-utils rpm/policycoreutils-sandbox rpm/python3-policycoreutils"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/policycoreutils-3.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2152ee99700e607041d48ec9d72d92ab1e6ca84062e061b726cb3965b22c8655"

URI_policycoreutils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/policycoreutils-3.8-1.el10.x86_64_v2.rpm;name=policycoreutils;unpack=0"
SRC_URI += "${URI_policycoreutils}"
SRC_URI[policycoreutils.sha256sum] = "8c878688a575e3de24c8dee9c8d64e37ea8572ac62d1abd6388de113f99ed347"
RDEPENDS:policycoreutils = " \
 util-linux \
 audit-libs \
 gawk \
 diffutils \
 grep \
 libselinux-utils \
 libselinux \
 bash \
 glibc \
 coreutils \
 sed \
 rpm \
 libsemanage \
 libsepol \
"

URI_policycoreutils-newrole = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/policycoreutils-newrole-3.8-1.el10.x86_64_v2.rpm;name=policycoreutils-newrole;unpack=0"
SRC_URI += "${URI_policycoreutils-newrole}"
SRC_URI[policycoreutils-newrole.sha256sum] = "4e49e1d89c7115ffdd96388da2ab14967e828bb5af8e4c17301c8b12f7dd1353"
RDEPENDS:policycoreutils-newrole = " \
 audit-libs \
 libcap-ng \
 pam-libs \
 policycoreutils \
 glibc \
 libselinux \
"

URI_policycoreutils-restorecond = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/policycoreutils-restorecond-3.8-1.el10.x86_64_v2.rpm;name=policycoreutils-restorecond;unpack=0"
SRC_URI += "${URI_policycoreutils-restorecond}"
SRC_URI[policycoreutils-restorecond.sha256sum] = "89cc0553081211cdb921306a152d902edd6136cda016f80c2e6c57df23a0e057"
RDEPENDS:policycoreutils-restorecond = " \
 glibc \
 libselinux \
 bash \
 glib2 \
"

URI_policycoreutils-dbus = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/policycoreutils-dbus-3.8-1.el10.noarch.rpm;name=policycoreutils-dbus;unpack=0"
SRC_URI += "${URI_policycoreutils-dbus}"
SRC_URI[policycoreutils-dbus.sha256sum] = "6c83f8ca4ab8bf4ef64882ce2728dd4745d6636f8f5a57db28ca7c3663047888"
RDEPENDS:policycoreutils-dbus = " \
 python3 \
 polkit \
 python3-gobject-base \
 python3-policycoreutils \
"

URI_policycoreutils-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/policycoreutils-devel-3.8-1.el10.x86_64_v2.rpm;name=policycoreutils-devel;unpack=0"
SRC_URI += "${URI_policycoreutils-devel}"
SRC_URI[policycoreutils-devel.sha256sum] = "13f121572f2444805c05249fb8b0cd4dce5663c7212dd8c498d716fc4a2504a4"
RDEPENDS:policycoreutils-devel = " \
 python3 \
 selinux-policy-devel \
 policycoreutils-python-utils \
 make \
 python3-dnf \
 glibc \
 libselinux \
"

URI_policycoreutils-gui = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/policycoreutils-gui-3.8-1.el10.noarch.rpm;name=policycoreutils-gui;unpack=0"
SRC_URI += "${URI_policycoreutils-gui}"
SRC_URI[policycoreutils-gui.sha256sum] = "9368d2e458907de14501898c8c06dc9e6eb2834075b4c8abd61369a27e1236ba"
RDEPENDS:policycoreutils-gui = " \
 python3 \
 python3-policycoreutils \
 python3-gobject \
 policycoreutils-dbus \
 policycoreutils-devel \
 bash \
 gtk3 \
"

URI_policycoreutils-python-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/policycoreutils-python-utils-3.8-1.el10.noarch.rpm;name=policycoreutils-python-utils;unpack=0"
SRC_URI += "${URI_policycoreutils-python-utils}"
SRC_URI[policycoreutils-python-utils.sha256sum] = "e1dc6d7fae25024f068a9f0989bfb16b13093f5820640be8b1e4b542fad7b0ba"
RDEPENDS:policycoreutils-python-utils = " \
 python3 \
 python3-policycoreutils \
"

URI_policycoreutils-sandbox = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/policycoreutils-sandbox-3.8-1.el10.x86_64_v2.rpm;name=policycoreutils-sandbox;unpack=0"
SRC_URI += "${URI_policycoreutils-sandbox}"
SRC_URI[policycoreutils-sandbox.sha256sum] = "20848fa972e6af8588d6de2be611c8e0e82fe94777f63b0b629f161163ca74b3"
RDEPENDS:policycoreutils-sandbox = " \
 python3 \
 python3-policycoreutils \
 rsync \
 libcap-ng \
 bash \
 glibc \
 libselinux \
"

URI_python3-policycoreutils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-policycoreutils-3.8-1.el10.noarch.rpm;name=python3-policycoreutils;unpack=0"
SRC_URI += "${URI_python3-policycoreutils}"
SRC_URI[python3-policycoreutils.sha256sum] = "edaec2ae8d1cdf15aec40f1f3f1132e1390e6e61de969b8329c29301d584be8d"
RDEPENDS:python3-policycoreutils = " \
 python3 \
 checkpolicy \
 python3-libselinux \
 policycoreutils \
 python3-libsemanage \
 python3-setools \
 python3-distro \
 python3-audit \
"
