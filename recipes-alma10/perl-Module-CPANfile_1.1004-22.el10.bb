# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Module-CPANfile"
PE = "0"
PV = "1.1004"
PR = "22.el10"
PACKAGES = "perl-Module-CPANfile perl-Module-CPANfile-tests"
PROVIDES = "rpm/perl-Module-CPANfile rpm/perl-Module-CPANfile-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Module-CPANfile-1.1004-22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e275f64950ea63efa4f28b672c34fb13933192680cac17752c5734c034f092d"

URI_perl-Module-CPANfile = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Module-CPANfile-1.1004-22.el10.noarch.rpm;name=perl-Module-CPANfile;unpack=0"
SRC_URI += "${URI_perl-Module-CPANfile}"
SRC_URI[perl-Module-CPANfile.sha256sum] = "3fbacc6ffc35c094cc0cdade121f312aa3d0d3fec398b98eb6ba33b77e8c905f"
RDEPENDS:perl-Module-CPANfile = " \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Requirements \
 perl-libs \
 perl-Carp \
 perl-Module-CPANfile \
 perl-Getopt-Long \
 perl-PathTools \
 perl-interpreter \
 perl-Data-Dumper \
 perl-Pod-Usage \
"

URI_perl-Module-CPANfile-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Module-CPANfile-tests-1.1004-22.el10.noarch.rpm;name=perl-Module-CPANfile-tests;unpack=0"
SRC_URI += "${URI_perl-Module-CPANfile-tests}"
SRC_URI[perl-Module-CPANfile-tests.sha256sum] = "7703e23570ccd45bf9e97979664336871328d19aa0ae38055c63a29f3344f0ca"
RDEPENDS:perl-Module-CPANfile-tests = " \
 perl-File-pushd \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Module-CPANfile \
 perl-POSIX \
 bash \
 perl-base \
 perl-interpreter \
 perl-Exporter \
 perl-lib \
"
