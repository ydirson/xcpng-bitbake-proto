# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "passim"
PE = "0"
PV = "0.1.8"
PR = "2.el10"
PACKAGES = "passim passim-devel passim-libs"
PROVIDES = "rpm/passim rpm/passim-devel rpm/passim-libs"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/passim-0.1.8-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81b6b280ee4ac712fca0c5f41e435fbf09cd8f24e326e27ba18c9661111cfe94"

URI_passim = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/passim-0.1.8-2.el10.x86_64_v2.rpm;name=passim;unpack=0"
SRC_URI += "${URI_passim}"
SRC_URI[passim.sha256sum] = "cd79d07bab6b9d02016a5eb10ad1f22db70cb8cb66611ed35cf5433da59741c4"
RDEPENDS:passim = " \
 libsoup3 \
 gnutls \
 libgcc \
 bash \
 glib2 \
 passim-libs \
 glibc \
"

URI_passim-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/passim-devel-0.1.8-2.el10.x86_64_v2.rpm;name=passim-devel;unpack=0"
SRC_URI += "${URI_passim-devel}"
SRC_URI[passim-devel.sha256sum] = "8ee773ac0796e78b022127a4402597e36ccae6a7313072601c44484022c48230"
RDEPENDS:passim-devel = " \
 passim \
 passim-libs \
 glib2-devel \
 pkgconf-pkg-config \
"

URI_passim-libs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/passim-libs-0.1.8-2.el10.x86_64_v2.rpm;name=passim-libs;unpack=0"
SRC_URI += "${URI_passim-libs}"
SRC_URI[passim-libs.sha256sum] = "d7ebfea2cd074ff4a53ab2fd3e12cc8ec5579a9cf2e3c38045765a0ff3ad49c6"
RDEPENDS:passim-libs = " \
 glibc \
 libgcc \
 glib2 \
"
