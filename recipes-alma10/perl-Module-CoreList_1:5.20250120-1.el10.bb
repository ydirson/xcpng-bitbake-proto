# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Module-CoreList"
PE = "1"
PV = "5.20250120"
PR = "1.el10"
PACKAGES = "perl-Module-CoreList perl-Module-CoreList-tools perl-Module-CoreList-tests"
PROVIDES = "rpm/perl-Module-CoreList rpm/perl-Module-CoreList-tools rpm/perl-Module-CoreList-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Module-CoreList-5.20250120-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "552865106e9c211d44db6df7ecb055fac4c5da192c0069f1bd61e78bfbbb7988"

URI_perl-Module-CoreList = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Module-CoreList-5.20250120-1.el10.noarch.rpm;name=perl-Module-CoreList;unpack=0"
SRC_URI += "${URI_perl-Module-CoreList}"
SRC_URI[perl-Module-CoreList.sha256sum] = "7c61ed21d3071321c70148f3e539e7955d59f6ba1b7349d9cac2064710c21697"
RDEPENDS:perl-Module-CoreList = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Module-CoreList \
 perl-version \
"

URI_perl-Module-CoreList-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Module-CoreList-tools-5.20250120-1.el10.noarch.rpm;name=perl-Module-CoreList-tools;unpack=0"
SRC_URI += "${URI_perl-Module-CoreList-tools}"
SRC_URI[perl-Module-CoreList-tools.sha256sum] = "b5da03f1ec597fd282899217bc8db0246842c796c00f3423859152b1c5937f0d"
RDEPENDS:perl-Module-CoreList-tools = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-version \
 perl-Module-CoreList \
 perl-Getopt-Long \
 perl-interpreter \
 perl-Pod-Usage \
"

URI_perl-Module-CoreList-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Module-CoreList-tests-5.20250120-1.el10.noarch.rpm;name=perl-Module-CoreList-tests;unpack=0"
SRC_URI += "${URI_perl-Module-CoreList-tests}"
SRC_URI[perl-Module-CoreList-tests.sha256sum] = "c947e8a69cc135250e7ff65c224da15dbb1c1f588d3c8634cc553dde7f604417"
RDEPENDS:perl-Module-CoreList-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Module-CoreList \
 perl-Module-CoreList-tools \
 bash \
 perl-interpreter \
"
