# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "java-21-openjdk"
PE = "1"
PV = "21.0.9.0.10"
PR = "1.el10.alma.1"
PACKAGES = "java-21-openjdk java-21-openjdk-demo java-21-openjdk-devel java-21-openjdk-headless java-21-openjdk-javadoc java-21-openjdk-javadoc-zip java-21-openjdk-jmods java-21-openjdk-src java-21-openjdk-static-libs java-21-openjdk-demo-fastdebug java-21-openjdk-demo-slowdebug java-21-openjdk-devel-fastdebug java-21-openjdk-devel-slowdebug java-21-openjdk-fastdebug java-21-openjdk-headless-fastdebug java-21-openjdk-headless-slowdebug java-21-openjdk-jmods-fastdebug java-21-openjdk-jmods-slowdebug java-21-openjdk-slowdebug java-21-openjdk-src-fastdebug java-21-openjdk-src-slowdebug java-21-openjdk-static-libs-fastdebug java-21-openjdk-static-libs-slowdebug"
PROVIDES = "rpm/java-21-openjdk rpm/java-21-openjdk-demo rpm/java-21-openjdk-devel rpm/java-21-openjdk-headless rpm/java-21-openjdk-javadoc rpm/java-21-openjdk-javadoc-zip rpm/java-21-openjdk-jmods rpm/java-21-openjdk-src rpm/java-21-openjdk-static-libs rpm/java-21-openjdk-demo-fastdebug rpm/java-21-openjdk-demo-slowdebug rpm/java-21-openjdk-devel-fastdebug rpm/java-21-openjdk-devel-slowdebug rpm/java-21-openjdk-fastdebug rpm/java-21-openjdk-headless-fastdebug rpm/java-21-openjdk-headless-slowdebug rpm/java-21-openjdk-jmods-fastdebug rpm/java-21-openjdk-jmods-slowdebug rpm/java-21-openjdk-slowdebug rpm/java-21-openjdk-src-fastdebug rpm/java-21-openjdk-src-slowdebug rpm/java-21-openjdk-static-libs-fastdebug rpm/java-21-openjdk-static-libs-slowdebug"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/java-21-openjdk-21.0.9.0.10-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d63b5ba4c2e7f522b2db7ece3d71844519da13b9e0a5a17908b132039de1b6ff"

URI_java-21-openjdk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/java-21-openjdk-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=java-21-openjdk;unpack=0"
SRC_URI += "${URI_java-21-openjdk}"
SRC_URI[java-21-openjdk.sha256sum] = "623928904c8bc9f3c86b8bd968b239c1c6e9b6c56b1f8de8b586400df8729c53"
RDEPENDS:java-21-openjdk = " \
 libXi \
 libXcomposite \
 fontconfig \
 xorg-x11-fonts-Type1 \
 libX11 \
 libXrender \
 bash \
 libXtst \
 java-21-openjdk-headless \
 glibc \
 libXext \
"

URI_java-21-openjdk-demo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/java-21-openjdk-demo-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=java-21-openjdk-demo;unpack=0"
SRC_URI += "${URI_java-21-openjdk-demo}"
SRC_URI[java-21-openjdk-demo.sha256sum] = "8b0aeca1a5555cf489f7c7cb20fddb676c388978b7c1db04d80e956668b4245a"
RDEPENDS:java-21-openjdk-demo = " \
 java-21-openjdk \
"

URI_java-21-openjdk-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/java-21-openjdk-devel-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=java-21-openjdk-devel;unpack=0"
SRC_URI += "${URI_java-21-openjdk-devel}"
SRC_URI[java-21-openjdk-devel.sha256sum] = "37175f82b762464273b891daf7d37955e7d352d7810c4ea75c35fb72c7313a2b"
RDEPENDS:java-21-openjdk-devel = " \
 glibc \
 alternatives \
 java-21-openjdk \
 bash \
"

URI_java-21-openjdk-headless = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/java-21-openjdk-headless-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=java-21-openjdk-headless;unpack=0"
SRC_URI += "${URI_java-21-openjdk-headless}"
SRC_URI[java-21-openjdk-headless.sha256sum] = "c3921c4b88c623d5e4b5701eb9e1063471f69405577afc0054dc222fe93391d0"
RDEPENDS:java-21-openjdk-headless = " \
 alsa-lib \
 nss \
 crypto-policies \
 javapackages-filesystem \
 ca-certificates \
 cups-libs \
 tzdata-java \
 bash \
 glibc \
 alternatives \
 lksctp-tools \
"

URI_java-21-openjdk-javadoc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/java-21-openjdk-javadoc-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=java-21-openjdk-javadoc;unpack=0"
SRC_URI += "${URI_java-21-openjdk-javadoc}"
SRC_URI[java-21-openjdk-javadoc.sha256sum] = "666eb3ac3594c838f9c60078a08c5e27d0536d5a03976d22e669240cdb40b7b7"
RDEPENDS:java-21-openjdk-javadoc = " \
 alternatives \
 bash \
 javapackages-filesystem \
 java-21-openjdk-headless \
"

URI_java-21-openjdk-javadoc-zip = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/java-21-openjdk-javadoc-zip-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=java-21-openjdk-javadoc-zip;unpack=0"
SRC_URI += "${URI_java-21-openjdk-javadoc-zip}"
SRC_URI[java-21-openjdk-javadoc-zip.sha256sum] = "5497f388bebbb7acfb95ca730e80d6e19cb50ad375a3d9a8b20f848a693ed0f0"
RDEPENDS:java-21-openjdk-javadoc-zip = " \
 alternatives \
 bash \
 javapackages-filesystem \
 java-21-openjdk-headless \
"

URI_java-21-openjdk-jmods = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/java-21-openjdk-jmods-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=java-21-openjdk-jmods;unpack=0"
SRC_URI += "${URI_java-21-openjdk-jmods}"
SRC_URI[java-21-openjdk-jmods.sha256sum] = "4a00789cc1b13b5fe6885e6398dee5454d937f58242dabc87d5042d09d613fbb"
RDEPENDS:java-21-openjdk-jmods = " \
 java-21-openjdk-devel \
"

URI_java-21-openjdk-src = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/java-21-openjdk-src-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=java-21-openjdk-src;unpack=0"
SRC_URI += "${URI_java-21-openjdk-src}"
SRC_URI[java-21-openjdk-src.sha256sum] = "0783301d84d6409ef63e5853222bdd0078215bd3127533a82ba265eecb8e22d1"
RDEPENDS:java-21-openjdk-src = " \
 java-21-openjdk-headless \
"

URI_java-21-openjdk-static-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/java-21-openjdk-static-libs-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=java-21-openjdk-static-libs;unpack=0"
SRC_URI += "${URI_java-21-openjdk-static-libs}"
SRC_URI[java-21-openjdk-static-libs.sha256sum] = "73db3b9ad8f9c960bed0b6accd9360735c006e3ef84a3f61be8404bed670b04f"
RDEPENDS:java-21-openjdk-static-libs = " \
 java-21-openjdk-devel \
"

URI_java-21-openjdk-demo-fastdebug = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/java-21-openjdk-demo-fastdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=java-21-openjdk-demo-fastdebug;unpack=0"
SRC_URI += "${URI_java-21-openjdk-demo-fastdebug}"
SRC_URI[java-21-openjdk-demo-fastdebug.sha256sum] = "d1a0493823991693dcded3271656dbda83ba8f8017dbe5fed47704e8f8a131cd"
RDEPENDS:java-21-openjdk-demo-fastdebug = " \
 java-21-openjdk-fastdebug \
"

URI_java-21-openjdk-demo-slowdebug = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/java-21-openjdk-demo-slowdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=java-21-openjdk-demo-slowdebug;unpack=0"
SRC_URI += "${URI_java-21-openjdk-demo-slowdebug}"
SRC_URI[java-21-openjdk-demo-slowdebug.sha256sum] = "1fed05eefa2021bbbd0a21aef01bfe74e19678b9ecf3f870db6e8743726294f5"
RDEPENDS:java-21-openjdk-demo-slowdebug = " \
 java-21-openjdk-slowdebug \
"

URI_java-21-openjdk-devel-fastdebug = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/java-21-openjdk-devel-fastdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=java-21-openjdk-devel-fastdebug;unpack=0"
SRC_URI += "${URI_java-21-openjdk-devel-fastdebug}"
SRC_URI[java-21-openjdk-devel-fastdebug.sha256sum] = "867a4fc2e04fd1842565dd98804cb82db585b16373dccb3176ce2ae6b09fb4a5"
RDEPENDS:java-21-openjdk-devel-fastdebug = " \
 alternatives \
 java-21-openjdk-fastdebug \
 bash \
"

URI_java-21-openjdk-devel-slowdebug = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/java-21-openjdk-devel-slowdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=java-21-openjdk-devel-slowdebug;unpack=0"
SRC_URI += "${URI_java-21-openjdk-devel-slowdebug}"
SRC_URI[java-21-openjdk-devel-slowdebug.sha256sum] = "7b25b345609fd2e366117b85e80f62e05312d09a9a068ee5eb93da66fb98fe89"
RDEPENDS:java-21-openjdk-devel-slowdebug = " \
 alternatives \
 java-21-openjdk-slowdebug \
 bash \
"

URI_java-21-openjdk-fastdebug = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/java-21-openjdk-fastdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=java-21-openjdk-fastdebug;unpack=0"
SRC_URI += "${URI_java-21-openjdk-fastdebug}"
SRC_URI[java-21-openjdk-fastdebug.sha256sum] = "9e43ab0893e1948fbcad140692b70a98b03cf38f2c67189c1ec2b3b918875311"
RDEPENDS:java-21-openjdk-fastdebug = " \
 java-21-openjdk-headless-fastdebug \
 xorg-x11-fonts-Type1 \
 fontconfig \
 bash \
 libXcomposite \
"

URI_java-21-openjdk-headless-fastdebug = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/java-21-openjdk-headless-fastdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=java-21-openjdk-headless-fastdebug;unpack=0"
SRC_URI += "${URI_java-21-openjdk-headless-fastdebug}"
SRC_URI[java-21-openjdk-headless-fastdebug.sha256sum] = "f7ac15308ceed68eed2e3e5064960a539a0ee809c12cd7bdc19c3a748c2046cf"
RDEPENDS:java-21-openjdk-headless-fastdebug = " \
 nss \
 crypto-policies \
 javapackages-filesystem \
 ca-certificates \
 cups-libs \
 tzdata-java \
 bash \
 alternatives \
 lksctp-tools \
"

URI_java-21-openjdk-headless-slowdebug = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/java-21-openjdk-headless-slowdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=java-21-openjdk-headless-slowdebug;unpack=0"
SRC_URI += "${URI_java-21-openjdk-headless-slowdebug}"
SRC_URI[java-21-openjdk-headless-slowdebug.sha256sum] = "6ea8eeea8585cd37e304701cbd78b9665e63706732f0817df56f77e7df63c3ec"
RDEPENDS:java-21-openjdk-headless-slowdebug = " \
 nss \
 crypto-policies \
 javapackages-filesystem \
 ca-certificates \
 cups-libs \
 tzdata-java \
 bash \
 alternatives \
 lksctp-tools \
"

URI_java-21-openjdk-jmods-fastdebug = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/java-21-openjdk-jmods-fastdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=java-21-openjdk-jmods-fastdebug;unpack=0"
SRC_URI += "${URI_java-21-openjdk-jmods-fastdebug}"
SRC_URI[java-21-openjdk-jmods-fastdebug.sha256sum] = "8f842754d9714c50276355cf396b80b3d4b26dd34a15d08e3e1ede786c4d6d8e"
RDEPENDS:java-21-openjdk-jmods-fastdebug = " \
 java-21-openjdk-devel-fastdebug \
"

URI_java-21-openjdk-jmods-slowdebug = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/java-21-openjdk-jmods-slowdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=java-21-openjdk-jmods-slowdebug;unpack=0"
SRC_URI += "${URI_java-21-openjdk-jmods-slowdebug}"
SRC_URI[java-21-openjdk-jmods-slowdebug.sha256sum] = "6899c048607bfc7ac9b652462040b5d427fadeca925adc8ab9a7780b73791897"
RDEPENDS:java-21-openjdk-jmods-slowdebug = " \
 java-21-openjdk-devel-slowdebug \
"

URI_java-21-openjdk-slowdebug = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/java-21-openjdk-slowdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=java-21-openjdk-slowdebug;unpack=0"
SRC_URI += "${URI_java-21-openjdk-slowdebug}"
SRC_URI[java-21-openjdk-slowdebug.sha256sum] = "7d0e65af269b3507c0106d6973077dd95b2adedb06a46df0b723b835adaf0d96"
RDEPENDS:java-21-openjdk-slowdebug = " \
 java-21-openjdk-headless-slowdebug \
 xorg-x11-fonts-Type1 \
 fontconfig \
 bash \
 libXcomposite \
"

URI_java-21-openjdk-src-fastdebug = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/java-21-openjdk-src-fastdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=java-21-openjdk-src-fastdebug;unpack=0"
SRC_URI += "${URI_java-21-openjdk-src-fastdebug}"
SRC_URI[java-21-openjdk-src-fastdebug.sha256sum] = "2275eb712280421be62487c5eda01dbcc17697c06ae98c718484e0bc9c1b31ed"
RDEPENDS:java-21-openjdk-src-fastdebug = " \
 java-21-openjdk-headless-fastdebug \
"

URI_java-21-openjdk-src-slowdebug = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/java-21-openjdk-src-slowdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=java-21-openjdk-src-slowdebug;unpack=0"
SRC_URI += "${URI_java-21-openjdk-src-slowdebug}"
SRC_URI[java-21-openjdk-src-slowdebug.sha256sum] = "6f5d1b46da2ea46eee5a8c3f59d76b4fae32b4d7a3e8385dcb281e09f285008f"
RDEPENDS:java-21-openjdk-src-slowdebug = " \
 java-21-openjdk-headless-slowdebug \
"

URI_java-21-openjdk-static-libs-fastdebug = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/java-21-openjdk-static-libs-fastdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=java-21-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI += "${URI_java-21-openjdk-static-libs-fastdebug}"
SRC_URI[java-21-openjdk-static-libs-fastdebug.sha256sum] = "f28ea855209e0d15cd3a98cec60c8e718f4b55282433d1093a153dd332d81459"
RDEPENDS:java-21-openjdk-static-libs-fastdebug = " \
 java-21-openjdk-devel-fastdebug \
"

URI_java-21-openjdk-static-libs-slowdebug = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/java-21-openjdk-static-libs-slowdebug-21.0.9.0.10-1.el10.alma.1.x86_64_v2.rpm;name=java-21-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI += "${URI_java-21-openjdk-static-libs-slowdebug}"
SRC_URI[java-21-openjdk-static-libs-slowdebug.sha256sum] = "d633076d830824002779eb67f0aa683a05331b494cb2774296aa02440c760996"
RDEPENDS:java-21-openjdk-static-libs-slowdebug = " \
 java-21-openjdk-devel-slowdebug \
"
