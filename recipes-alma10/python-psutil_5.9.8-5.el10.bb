# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-psutil"
PE = "0"
PV = "5.9.8"
PR = "5.el10"
PACKAGES = "python3-psutil python3-psutil-tests"
PROVIDES = "rpm/python3-psutil rpm/python3-psutil-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-psutil-5.9.8-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d32b3d152577315098405151350102333231caeb04713cc89cdd136aa69c89f"

URI_python3-psutil = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-psutil-5.9.8-5.el10.x86_64_v2.rpm;name=python3-psutil;unpack=0"
SRC_URI += "${URI_python3-psutil}"
SRC_URI[python3-psutil.sha256sum] = "ebc708ebd1f00dadf2d234c29bf566882418006847152e9d7a6e1b7d547923ac"
RDEPENDS:python3-psutil = " \
 glibc \
 python3 \
"

URI_python3-psutil-tests = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-psutil-tests-5.9.8-5.el10.x86_64_v2.rpm;name=python3-psutil-tests;unpack=0"
SRC_URI += "${URI_python3-psutil-tests}"
SRC_URI[python3-psutil-tests.sha256sum] = "d75ceaf7037e36a793115efdd8ec02f50544e7ced0aff82fc8ddcfb283552fd2"
RDEPENDS:python3-psutil-tests = " \
 python3 \
 python3-psutil \
"
