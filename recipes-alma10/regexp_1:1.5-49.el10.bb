# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "regexp"
PE = "1"
PV = "1.5"
PR = "49.el10"
PACKAGES = "regexp regexp-javadoc"
PROVIDES = "rpm/regexp rpm/regexp-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/regexp-1.5-49.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "698788518c08e11cfe19dbec28224e4dcae455c84c42be4633fb02e32f3cac98"

URI_regexp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/regexp-1.5-49.el10.noarch.rpm;name=regexp;unpack=0"
SRC_URI += "${URI_regexp}"
SRC_URI[regexp.sha256sum] = "8b17bd833ef4d11f26f7270f7c610bd859223e4fe0d018ec7d3bca89d3ec7209"
RDEPENDS:regexp = " \
 javapackages-filesystem \
"

URI_regexp-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/regexp-javadoc-1.5-49.el10.noarch.rpm;name=regexp-javadoc;unpack=0"
SRC_URI += "${URI_regexp-javadoc}"
SRC_URI[regexp-javadoc.sha256sum] = "59b37bfcdb37796038b21aae9c9266daa0cb79c98cf07e0c36482a9fa41e19f3"
RDEPENDS:regexp-javadoc = " \
 javapackages-filesystem \
"
