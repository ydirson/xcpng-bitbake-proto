# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libqmi"
PE = "0"
PV = "1.34.0"
PR = "8.el10"
PACKAGES = "libqmi libqmi-utils libqmi-devel"
PROVIDES = "rpm/libqmi rpm/libqmi-utils rpm/libqmi-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libqmi-1.34.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9578a5b55a4e128acf5067966b3b5b80ef382c3df4e121a13f5e1fa499368a2"

URI_libqmi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libqmi-1.34.0-8.el10.x86_64_v2.rpm;name=libqmi;unpack=0"
SRC_URI += "${URI_libqmi}"
SRC_URI[libqmi.sha256sum] = "105adc0d2ab00c722d3e35f545e8f97d7cad9f689fcb55792b62690bfda18c63"
RDEPENDS:libqmi = " \
 libmbim \
 libgcc \
 libqrtr-glib \
 glib2 \
 glibc \
"

URI_libqmi-utils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libqmi-utils-1.34.0-8.el10.x86_64_v2.rpm;name=libqmi-utils;unpack=0"
SRC_URI += "${URI_libqmi-utils}"
SRC_URI[libqmi-utils.sha256sum] = "e0a76d98504ef76bfb422071701637b729681cec130752878b293dede9e89eda"
RDEPENDS:libqmi-utils = " \
 libmbim \
 libqmi \
 libgcc \
 libqrtr-glib \
 libgudev \
 bash \
 glib2 \
 glibc \
"

URI_libqmi-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libqmi-devel-1.34.0-8.el10.x86_64_v2.rpm;name=libqmi-devel;unpack=0"
SRC_URI += "${URI_libqmi-devel}"
SRC_URI[libqmi-devel.sha256sum] = "9512ee40b471ce3ab2c297d07072bf2fd98d91633ddcce1c93a2a8f2d81a4913"
RDEPENDS:libqmi-devel = " \
 glib2-devel \
 libmbim-devel \
 libqmi \
 pkgconf-pkg-config \
 libqrtr-glib-devel \
"
