# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-CPAN-DistnameInfo"
PE = "0"
PV = "0.12"
PR = "32.el10"
PACKAGES = "perl-CPAN-DistnameInfo perl-CPAN-DistnameInfo-tests"
PROVIDES = "rpm/perl-CPAN-DistnameInfo rpm/perl-CPAN-DistnameInfo-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-CPAN-DistnameInfo-0.12-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "230e01fcbb82390c81d53dbb53bbf29bbd080dc2e307497c53e26129a34e06e0"

URI_perl-CPAN-DistnameInfo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-CPAN-DistnameInfo-0.12-32.el10.noarch.rpm;name=perl-CPAN-DistnameInfo;unpack=0"
SRC_URI += "${URI_perl-CPAN-DistnameInfo}"
SRC_URI[perl-CPAN-DistnameInfo.sha256sum] = "1493c0e5b3fd60ff14881976927cb8f4e6299886f1c6bb748591c357d49fcdf9"
RDEPENDS:perl-CPAN-DistnameInfo = " \
 perl-libs \
"

URI_perl-CPAN-DistnameInfo-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-CPAN-DistnameInfo-tests-0.12-32.el10.noarch.rpm;name=perl-CPAN-DistnameInfo-tests;unpack=0"
SRC_URI += "${URI_perl-CPAN-DistnameInfo-tests}"
SRC_URI[perl-CPAN-DistnameInfo-tests.sha256sum] = "476e3a15c5bc244713ef04927df9dcfb55b5b64fb1fe94ca19b7dfbc13f3dc81"
RDEPENDS:perl-CPAN-DistnameInfo-tests = " \
 perl-Test-Harness \
 perl-Test-Simple \
 bash \
 perl-interpreter \
 perl-Data-Dumper \
 perl-CPAN-DistnameInfo \
"
