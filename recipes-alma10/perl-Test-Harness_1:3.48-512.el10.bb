# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Test-Harness"
PE = "1"
PV = "3.48"
PR = "512.el10"
PACKAGES = "perl-Test-Harness perl-Test-Harness-tests"
PROVIDES = "rpm/perl-Test-Harness rpm/perl-Test-Harness-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Test-Harness-3.48-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "346be9b2d1c68f06cc9a59d82bbb1c0f95c2bf6272a0de8537ac6c0302db2fac"

URI_perl-Test-Harness = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Test-Harness-3.48-512.el10.noarch.rpm;name=perl-Test-Harness;unpack=0"
SRC_URI += "${URI_perl-Test-Harness}"
SRC_URI[perl-Test-Harness.sha256sum] = "4f95d7364a0d07a80da4d923104c661dee34ac09ec600bd4ce092569a36049fd"
RDEPENDS:perl-Test-Harness = " \
 perl-Benchmark \
 perl-constant \
 perl-Test-Harness \
 perl-libs \
 perl-Carp \
 perl-interpreter \
 perl-IO \
 perl-Text-ParseWords \
 perl-Getopt-Long \
 perl-POSIX \
 perl-File-Basename \
 perl-Errno \
 perl-PathTools \
 perl-File-Find \
 perl-Exporter \
 perl-File-Path \
 perl-base \
"

URI_perl-Test-Harness-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Test-Harness-tests-3.48-512.el10.noarch.rpm;name=perl-Test-Harness-tests;unpack=0"
SRC_URI += "${URI_perl-Test-Harness-tests}"
SRC_URI[perl-Test-Harness-tests.sha256sum] = "31e32f675e642144ab2e9712ce5fd9a4263dd79ef319bfe3dd45cb08bc409ea6"
RDEPENDS:perl-Test-Harness-tests = " \
 perl-constant \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-IO \
 perl-Text-ParseWords \
 perl-Getopt-Long \
 perl-POSIX \
 perl-Symbol \
 bash \
 perl-PathTools \
 perl-interpreter \
 perl-File-Path \
 perl-Data-Dumper \
 perl-base \
 perl-lib \
"
