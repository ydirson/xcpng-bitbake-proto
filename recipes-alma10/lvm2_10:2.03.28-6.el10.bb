# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lvm2"
PE = "10"
PV = "2.03.28"
PR = "6.el10"
PACKAGES = "device-mapper device-mapper-event device-mapper-event-libs device-mapper-libs lvm2 lvm2-libs lvm2-dbusd lvm2-lockd device-mapper-devel device-mapper-event-devel lvm2-devel lvm2-testsuite"
PROVIDES = "rpm/device-mapper rpm/device-mapper-event rpm/device-mapper-event-libs rpm/device-mapper-libs rpm/lvm2 rpm/lvm2-libs rpm/lvm2-dbusd rpm/lvm2-lockd rpm/device-mapper-devel rpm/device-mapper-event-devel rpm/lvm2-devel rpm/lvm2-testsuite"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/lvm2-2.03.28-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af26655d0201f2458b565bf9f3c330ff91decd1d09454fb2f1da71fce00656e8"

URI_device-mapper = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/device-mapper-1.02.202-6.el10.x86_64_v2.rpm;name=device-mapper;unpack=0"
SRC_URI += "${URI_device-mapper}"
SRC_URI[device-mapper.sha256sum] = "94c7a1d3a48b1a586ce680427c63f9293e0fd9314866b9b28f2485a0aeb4dfb2"
RDEPENDS:device-mapper = " \
 device-mapper-libs \
 systemd \
 util-linux-core \
 bash \
 glibc \
"

URI_device-mapper-event = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/device-mapper-event-1.02.202-6.el10.x86_64_v2.rpm;name=device-mapper-event;unpack=0"
SRC_URI += "${URI_device-mapper-event}"
SRC_URI[device-mapper-event.sha256sum] = "f3e312206077397de321f85f75ed8afa33e5067170cac2624a6b4de55b918fe7"
RDEPENDS:device-mapper-event = " \
 device-mapper \
 device-mapper-event-libs \
 systemd \
 device-mapper-libs \
 libgcc \
 bash \
 glibc \
"

URI_device-mapper-event-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/device-mapper-event-libs-1.02.202-6.el10.x86_64_v2.rpm;name=device-mapper-event-libs;unpack=0"
SRC_URI += "${URI_device-mapper-event-libs}"
SRC_URI[device-mapper-event-libs.sha256sum] = "20a0c49156e9431c0fefe03d82bc9839d299680391f910829febf671f468b539"
RDEPENDS:device-mapper-event-libs = " \
 glibc \
 device-mapper-libs \
"

URI_device-mapper-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/device-mapper-libs-1.02.202-6.el10.x86_64_v2.rpm;name=device-mapper-libs;unpack=0"
SRC_URI += "${URI_device-mapper-libs}"
SRC_URI[device-mapper-libs.sha256sum] = "891770d113c9615e8dbb2d2cbf4939eea242c49be32108f4949e73745a0a1f50"
RDEPENDS:device-mapper-libs = " \
 glibc \
 libselinux \
 systemd-libs \
 device-mapper \
"

URI_lvm2 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/lvm2-2.03.28-6.el10.x86_64_v2.rpm;name=lvm2;unpack=0"
SRC_URI += "${URI_lvm2}"
SRC_URI[lvm2.sha256sum] = "ffbc422ee9591183c00f24f61dfb09041d4ef831eb6df97b2b8d460d421e1d42"
RDEPENDS:lvm2 = " \
 device-mapper-event-libs \
 systemd \
 libaio \
 systemd-libs \
 lvm2-libs \
 device-mapper-persistent-data \
 kmod \
 libblkid \
 bash \
 glibc \
 libselinux \
 libnvme \
 libedit \
"

URI_lvm2-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/lvm2-libs-2.03.28-6.el10.x86_64_v2.rpm;name=lvm2-libs;unpack=0"
SRC_URI += "${URI_lvm2-libs}"
SRC_URI[lvm2-libs.sha256sum] = "69b39d88992b93bf8ef2ede24a58d7b9bf10cf18506b1b525e6262610190a527"
RDEPENDS:lvm2-libs = " \
 device-mapper-event \
 device-mapper-event-libs \
 device-mapper-libs \
 libaio \
 systemd-libs \
 libblkid \
 glibc \
 libselinux \
 libnvme \
"

URI_lvm2-dbusd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lvm2-dbusd-2.03.28-6.el10.noarch.rpm;name=lvm2-dbusd;unpack=0"
SRC_URI += "${URI_lvm2-dbusd}"
SRC_URI[lvm2-dbusd.sha256sum] = "5661ba27c120fefb31b7e350b99861cb51b1bb9e1512c5507f92f35a87c298b7"
RDEPENDS:lvm2-dbusd = " \
 python3 \
 python3-pyudev \
 systemd \
 lvm2 \
 python3-dbus \
 bash \
 dbus \
 python3-gobject-base \
"

URI_lvm2-lockd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lvm2-lockd-2.03.28-6.el10.x86_64_v2.rpm;name=lvm2-lockd;unpack=0"
SRC_URI += "${URI_lvm2-lockd}"
SRC_URI[lvm2-lockd.sha256sum] = "46e5067accaf07c7d817999c45e7d6514c95417cd127a22d783538631f920d03"
RDEPENDS:lvm2-lockd = " \
 systemd \
 systemd-libs \
 sanlock-lib \
 lvm2 \
 bash \
 glibc \
 libselinux \
"

URI_device-mapper-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/device-mapper-devel-1.02.202-6.el10.x86_64_v2.rpm;name=device-mapper-devel;unpack=0"
SRC_URI += "${URI_device-mapper-devel}"
SRC_URI[device-mapper-devel.sha256sum] = "80efde797f603bcab8dadba0813c0bf279b1df3645a9728fc3a2b40a3f235ae2"
RDEPENDS:device-mapper-devel = " \
 device-mapper \
 device-mapper-libs \
 systemd-devel \
 pkgconf-pkg-config \
 libselinux-devel \
"

URI_device-mapper-event-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/device-mapper-event-devel-1.02.202-6.el10.x86_64_v2.rpm;name=device-mapper-event-devel;unpack=0"
SRC_URI += "${URI_device-mapper-event-devel}"
SRC_URI[device-mapper-event-devel.sha256sum] = "b6bc019d7dbce55d9da520b12ecf6d5ba8362f8c29c7460a983d108743d96bbe"
RDEPENDS:device-mapper-event-devel = " \
 device-mapper-event \
 device-mapper-event-libs \
 pkgconf-pkg-config \
"

URI_lvm2-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/lvm2-devel-2.03.28-6.el10.x86_64_v2.rpm;name=lvm2-devel;unpack=0"
SRC_URI += "${URI_lvm2-devel}"
SRC_URI[lvm2-devel.sha256sum] = "8edf8fabffbcb7b979c665704a0dae499b0b4a465c2cd113683d9b1f51cd93aa"
RDEPENDS:lvm2-devel = " \
 lvm2 \
 lvm2-libs \
 pkgconf-pkg-config \
 device-mapper-devel \
 device-mapper-event-devel \
"

URI_lvm2-testsuite = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/lvm2-testsuite-2.03.28-6.el10.x86_64_v2.rpm;name=lvm2-testsuite;unpack=0"
SRC_URI += "${URI_lvm2-testsuite}"
SRC_URI[lvm2-testsuite.sha256sum] = "a9cdcd519f49693f6639eb5908f2c941a0ae0d6e678b41371c8d865184283b84"
RDEPENDS:lvm2-testsuite = " \
 python3 \
 libaio \
 device-mapper-libs \
 systemd-libs \
 libgcc \
 libstdc++ \
 bash \
 glibc \
 libselinux \
"
