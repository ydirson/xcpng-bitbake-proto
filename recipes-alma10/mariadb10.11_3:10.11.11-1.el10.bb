# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mariadb10.11"
PE = "3"
PV = "10.11.11"
PR = "1.el10"
PACKAGES = "mariadb mariadb-backup mariadb-client-utils mariadb-common mariadb-devel mariadb-embedded mariadb-embedded-devel mariadb-errmsg mariadb-gssapi-server mariadb-oqgraph-engine mariadb-pam mariadb-server mariadb-server-galera mariadb-server-utils mariadb-test"
PROVIDES = "rpm/mariadb rpm/mariadb-backup rpm/mariadb-client-utils rpm/mariadb-common rpm/mariadb-devel rpm/mariadb-embedded rpm/mariadb-embedded-devel rpm/mariadb-errmsg rpm/mariadb-gssapi-server rpm/mariadb-oqgraph-engine rpm/mariadb-pam rpm/mariadb-server rpm/mariadb-server-galera rpm/mariadb-server-utils rpm/mariadb-test"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mariadb10.11-10.11.11-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16d21eabe74531783a2a9060d785dadf4fda65d54616e57f07272a00d3c8e7f3"

URI_mariadb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mariadb-10.11.11-1.el10.x86_64_v2.rpm;name=mariadb;unpack=0"
SRC_URI += "${URI_mariadb}"
SRC_URI[mariadb.sha256sum] = "5ba2aaa46b0735929c15ef705ecb1f8735cb0d69e6bfc555ff18af887d7ee9ce"
RDEPENDS:mariadb = " \
 zlib-ng-compat \
 mariadb-common \
 libgcc \
 openssl-libs \
 grep \
 libstdc++ \
 bash \
 ncurses-libs \
 mariadb-connector-c \
 glibc \
 coreutils \
 libedit \
"

URI_mariadb-backup = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mariadb-backup-10.11.11-1.el10.x86_64_v2.rpm;name=mariadb-backup;unpack=0"
SRC_URI += "${URI_mariadb-backup}"
SRC_URI[mariadb-backup.sha256sum] = "c64307eec300f65d2a8fe055f288bee4382f5816b2cc4ce264041a0587bc2a14"
RDEPENDS:mariadb-backup = " \
 zlib-ng-compat \
 libaio \
 systemd-libs \
 libxcrypt \
 openssl-libs \
 libgcc \
 mariadb-server \
 libstdc++ \
 pcre2 \
 glibc \
"

URI_mariadb-client-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mariadb-client-utils-10.11.11-1.el10.x86_64_v2.rpm;name=mariadb-client-utils;unpack=0"
SRC_URI += "${URI_mariadb-client-utils}"
SRC_URI[mariadb-client-utils.sha256sum] = "87540d0e1a19e1e099d7309685e4a75d943dd2d11de25cd2fb4b84dd3497cfe3"
RDEPENDS:mariadb-client-utils = " \
 mariadb \
 perl-interpreter \
 perl-Fcntl \
 perl-Getopt-Long \
 perl-IPC-Open3 \
 perl-Sys-Hostname \
 perl-DBI \
 perl-Exporter \
 perl-File-Temp \
"

URI_mariadb-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mariadb-common-10.11.11-1.el10.noarch.rpm;name=mariadb-common;unpack=0"
SRC_URI += "${URI_mariadb-common}"
SRC_URI[mariadb-common.sha256sum] = "69e0392d522c2b33b7da5499e7c61b1ab03b92dcea900757f672a747b4673226"
RDEPENDS:mariadb-common = " \
 mariadb-connector-c-config \
"

URI_mariadb-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mariadb-devel-10.11.11-1.el10.x86_64_v2.rpm;name=mariadb-devel;unpack=0"
SRC_URI += "${URI_mariadb-devel}"
SRC_URI[mariadb-devel.sha256sum] = "5c1cf20daf8ff750059297f11e41a85edccbe54a41ee968f7b40a5193e50d7a5"
RDEPENDS:mariadb-devel = " \
 mariadb-connector-c-devel \
 openssl-devel \
 pkgconf-pkg-config \
"

URI_mariadb-embedded = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mariadb-embedded-10.11.11-1.el10.x86_64_v2.rpm;name=mariadb-embedded;unpack=0"
SRC_URI += "${URI_mariadb-embedded}"
SRC_URI[mariadb-embedded.sha256sum] = "524fd0b786cbd444679404cda55229d97feafc4bb98261bdcdd9aab4f7074bf0"
RDEPENDS:mariadb-embedded = " \
 zlib-ng-compat \
 libaio \
 mariadb-common \
 libxcrypt \
 openssl-libs \
 libgcc \
 mariadb-errmsg \
 libstdc++ \
 pcre2 \
 glibc \
"

URI_mariadb-embedded-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mariadb-embedded-devel-10.11.11-1.el10.x86_64_v2.rpm;name=mariadb-embedded-devel;unpack=0"
SRC_URI += "${URI_mariadb-embedded-devel}"
SRC_URI[mariadb-embedded-devel.sha256sum] = "1c690458966d94348e8983a65a5b199c76239d26511fd30086af041672844cb2"
RDEPENDS:mariadb-embedded-devel = " \
 mariadb-devel \
 mariadb-embedded \
 libaio-devel \
"

URI_mariadb-errmsg = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mariadb-errmsg-10.11.11-1.el10.noarch.rpm;name=mariadb-errmsg;unpack=0"
SRC_URI += "${URI_mariadb-errmsg}"
SRC_URI[mariadb-errmsg.sha256sum] = "b4b6ab8cd76b6667bb2b68ea114f91c3776f0779347dc2d904d8faf0212e48f0"
RDEPENDS:mariadb-errmsg = " \
 mariadb-common \
"

URI_mariadb-gssapi-server = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mariadb-gssapi-server-10.11.11-1.el10.x86_64_v2.rpm;name=mariadb-gssapi-server;unpack=0"
SRC_URI += "${URI_mariadb-gssapi-server}"
SRC_URI[mariadb-gssapi-server.sha256sum] = "a573f4da81f822fc4d25a1521a02d46e3dc0a4e293cb23750d2c08b4597af63e"
RDEPENDS:mariadb-gssapi-server = " \
 glibc \
 krb5-libs \
 mariadb-server \
"

URI_mariadb-oqgraph-engine = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mariadb-oqgraph-engine-10.11.11-1.el10.x86_64_v2.rpm;name=mariadb-oqgraph-engine;unpack=0"
SRC_URI += "${URI_mariadb-oqgraph-engine}"
SRC_URI[mariadb-oqgraph-engine.sha256sum] = "3782167076ed33be59c8b3bf3cc5997bd0e6a2c3fb32b841e494574d8848051e"
RDEPENDS:mariadb-oqgraph-engine = " \
 libgcc \
 mariadb-server \
 libstdc++ \
 glibc \
 Judy \
"

URI_mariadb-pam = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mariadb-pam-10.11.11-1.el10.x86_64_v2.rpm;name=mariadb-pam;unpack=0"
SRC_URI += "${URI_mariadb-pam}"
SRC_URI[mariadb-pam.sha256sum] = "28b397615dc36a8efdd93b6d9cc14614984dec3c0a3a876f9db2998cee20a1c4"
RDEPENDS:mariadb-pam = " \
 glibc \
 mariadb-server \
 pam-libs \
"

URI_mariadb-server = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mariadb-server-10.11.11-1.el10.x86_64_v2.rpm;name=mariadb-server;unpack=0"
SRC_URI += "${URI_mariadb-server}"
SRC_URI[mariadb-server.sha256sum] = "7af58d35e43b128196dd9b97e289fe6089435c32bcfd38468ad2259d0274aab7"
RDEPENDS:mariadb-server = " \
 systemd \
 systemd-libs \
 iproute \
 mysql-selinux \
 libaio \
 mariadb \
 mariadb-common \
 mariadb-errmsg \
 libstdc++ \
 shadow-utils \
 zlib-ng-compat \
 libxcrypt \
 libgcc \
 openssl-libs \
 snappy \
 bash \
 pcre2 \
 bzip2-libs \
 lz4-libs \
 lzo \
 mariadb-connector-c-config \
 glibc \
 coreutils \
"

URI_mariadb-server-galera = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mariadb-server-galera-10.11.11-1.el10.x86_64_v2.rpm;name=mariadb-server-galera;unpack=0"
SRC_URI += "${URI_mariadb-server-galera}"
SRC_URI[mariadb-server-galera.sha256sum] = "17f27d9eb72a731ae05527d2a8637c0d1eb84800dedc335e961befafb1582080"
RDEPENDS:mariadb-server-galera = " \
 rsync \
 lsof \
 mariadb-common \
 policycoreutils-python-utils \
 policycoreutils \
 mariadb-server \
 bash \
 galera \
 libselinux-utils \
"

URI_mariadb-server-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mariadb-server-utils-10.11.11-1.el10.x86_64_v2.rpm;name=mariadb-server-utils;unpack=0"
SRC_URI += "${URI_mariadb-server-utils}"
SRC_URI[mariadb-server-utils.sha256sum] = "b8331cf76ba08f7d5c5aefa8778e809fabc23a4cecee74f980f7f21ede008671"
RDEPENDS:mariadb-server-utils = " \
 perl-libs \
 perl-vars \
 perl-Getopt-Long \
 perl-POSIX \
 perl-File-Basename \
 perl-DBI \
 perl-File-Copy \
 perl-DBD-MariaDB \
 perl-Sys-Hostname \
 mariadb-server \
 glibc \
 perl-interpreter \
 perl-File-Path \
 perl-Data-Dumper \
 perl-File-Temp \
"

URI_mariadb-test = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mariadb-test-10.11.11-1.el10.x86_64_v2.rpm;name=mariadb-test;unpack=0"
SRC_URI += "${URI_mariadb-test}"
SRC_URI[mariadb-test.sha256sum] = "04adc774c32c53706f75357222e6397593c7c71c55c47f101d15a03ee646ece2"
RDEPENDS:mariadb-test = " \
 perl-libs \
 perl-Socket \
 perl-Storable \
 perl-Getopt-Long \
 perl-overload \
 perl-Symbol \
 perl-File-Find \
 perl-Sys-Hostname \
 perl-Term-ANSIColor \
 perl-threads \
 perl-threads-shared \
 libaio \
 perl-Carp \
 patch \
 perl-Test-Simple \
 perl-IO \
 mariadb-common \
 mariadb \
 perl-Text-Tabs+Wrap \
 perl-File-Temp \
 libstdc++ \
 perl-IPC-Open3 \
 mariadb-server \
 perl-Data-Dumper \
 perl-Time \
 perl-Time-HiRes \
 zlib-ng-compat \
 perl-Memoize \
 libxcrypt \
 libgcc \
 openssl-libs \
 pam-libs \
 bash \
 pcre2 \
 perl-English \
 perl-Env \
 perl-Exporter \
 perl-base \
 perl-constant \
 perl-Fcntl \
 perl-POSIX \
 perl-File-Basename \
 perl-File-Copy \
 perl-PathTools \
 perl-if \
 glibc \
 perl-interpreter \
 perl-File-Path \
 perl-lib \
"
