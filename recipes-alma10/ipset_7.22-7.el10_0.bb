# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ipset"
PE = "0"
PV = "7.22"
PR = "7.el10_0"
PACKAGES = "ipset ipset-libs ipset-service ipset-devel"
PROVIDES = "rpm/ipset rpm/ipset-libs rpm/ipset-service rpm/ipset-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/ipset-7.22-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3455bf1f909c1f8c2452cbd0d153fbe5db1b7b694ccc4fff712181ffbfa97b1"

URI_ipset = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/ipset-7.22-7.el10_0.x86_64_v2.rpm;name=ipset;unpack=0"
SRC_URI += "${URI_ipset}"
SRC_URI[ipset.sha256sum] = "ca48af4eb285c897dab514f692aee76d9b0d093cf4284db51494fa5ae9ec5a8e"
RDEPENDS:ipset = " \
 ipset-libs \
 kernel-modules-extra \
 bash \
 glibc \
 kernel-debug-modules-extra \
"

URI_ipset-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/ipset-libs-7.22-7.el10_0.x86_64_v2.rpm;name=ipset-libs;unpack=0"
SRC_URI += "${URI_ipset-libs}"
SRC_URI[ipset-libs.sha256sum] = "ed6bdca66f44ea2af6a37a83a634f634291bacc0aac36c3c97494a14fbc1c8d2"
RDEPENDS:ipset-libs = " \
 glibc \
 libmnl \
"

URI_ipset-service = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ipset-service-7.22-7.el10_0.noarch.rpm;name=ipset-service;unpack=0"
SRC_URI += "${URI_ipset-service}"
SRC_URI[ipset-service.sha256sum] = "6ea6be083eda363053ffa2e884272af2410e9021f7890a228d550a7da88ffe39"
RDEPENDS:ipset-service = " \
 ipset \
 systemd \
 bash \
 iptables-nft-services \
"

URI_ipset-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ipset-devel-7.22-7.el10_0.x86_64_v2.rpm;name=ipset-devel;unpack=0"
SRC_URI += "${URI_ipset-devel}"
SRC_URI[ipset-devel.sha256sum] = "45783c8f8f28a8174c46a0a2b28f51d136205c010474f798d75b540f2361503c"
RDEPENDS:ipset-devel = " \
 ipset-libs \
 kernel-headers \
 pkgconf-pkg-config \
 libmnl-devel \
"
