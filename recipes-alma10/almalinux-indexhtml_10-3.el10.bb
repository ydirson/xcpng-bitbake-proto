# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "almalinux-indexhtml"
PE = "0"
PV = "10"
PR = "3.el10"
PACKAGES = "almalinux-indexhtml"
PROVIDES = "rpm/almalinux-indexhtml"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/almalinux-indexhtml-10-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b20d6ac00d83fab4da935196cc3e87569439ca47270d159ca2b518b7740fcfd5"

URI_almalinux-indexhtml = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/almalinux-indexhtml-10-3.el10.noarch.rpm;name=almalinux-indexhtml;unpack=0"
SRC_URI += "${URI_almalinux-indexhtml}"
SRC_URI[almalinux-indexhtml.sha256sum] = "f978e9332a5fe1edace0a386be271b5d3621774430f68c7edad714cebdf7d071"
RDEPENDS:almalinux-indexhtml = ""
