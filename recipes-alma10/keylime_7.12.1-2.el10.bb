# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "keylime"
PE = "0"
PV = "7.12.1"
PR = "2.el10"
PACKAGES = "keylime keylime-base keylime-registrar keylime-selinux keylime-tenant keylime-tools keylime-verifier python3-keylime"
PROVIDES = "rpm/keylime rpm/keylime-base rpm/keylime-registrar rpm/keylime-selinux rpm/keylime-tenant rpm/keylime-tools rpm/keylime-verifier rpm/python3-keylime"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/keylime-7.12.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ace03484c740abdc4d0992083aa91fe29ee2c8194fd6fc05f5505c97eb61c5d7"

URI_keylime = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/keylime-7.12.1-2.el10.x86_64_v2.rpm;name=keylime;unpack=0"
SRC_URI += "${URI_keylime}"
SRC_URI[keylime.sha256sum] = "32be177d5d4811f4328f1a040e489d864ee84c70a22f6ad7a60f87840fed827b"
RDEPENDS:keylime = " \
 keylime-agent-rust \
 keylime-base \
 keylime-registrar \
 keylime-tenant \
 keylime-tools \
 keylime-verifier \
 python3-keylime \
"

URI_keylime-base = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/keylime-base-7.12.1-2.el10.x86_64_v2.rpm;name=keylime-base;unpack=0"
SRC_URI += "${URI_keylime-base}"
SRC_URI[keylime-base.sha256sum] = "ef9026ef9f82dbc2269113073dd435e48e44cb0d6fef19916216ff3da73c0012"
RDEPENDS:keylime-base = " \
 python3 \
 shadow-utils \
 efivar-libs \
 openssl \
 python3-jinja2 \
 bash \
 tpm2-tss \
 procps-ng \
"

URI_keylime-registrar = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/keylime-registrar-7.12.1-2.el10.x86_64_v2.rpm;name=keylime-registrar;unpack=0"
SRC_URI += "${URI_keylime-registrar}"
SRC_URI[keylime-registrar.sha256sum] = "6e90c7f34bb7a304ced608f11f9eb8f732f4a878fb26952838618b5886eb7cff"
RDEPENDS:keylime-registrar = " \
 python3 \
 python3-keylime \
 bash \
 keylime-base \
"

URI_keylime-selinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/keylime-selinux-7.12.1-2.el10.noarch.rpm;name=keylime-selinux;unpack=0"
SRC_URI += "${URI_keylime-selinux}"
SRC_URI[keylime-selinux.sha256sum] = "fa72358fa34e614f561e9b1f6e1cb488625bb0ac8ac8fde438338199aeacec55"
RDEPENDS:keylime-selinux = " \
 policycoreutils-python-utils \
 policycoreutils \
 bash \
 selinux-policy \
 libselinux-utils \
 selinux-policy-targeted \
"

URI_keylime-tenant = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/keylime-tenant-7.12.1-2.el10.x86_64_v2.rpm;name=keylime-tenant;unpack=0"
SRC_URI += "${URI_keylime-tenant}"
SRC_URI[keylime-tenant.sha256sum] = "9fefac826fc2bf1f2ce6a4a867caa8efcb0b7c984ff77b41207ad8b5ef8d0680"
RDEPENDS:keylime-tenant = " \
 python3 \
 python3-keylime \
 bash \
 keylime-base \
"

URI_keylime-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/keylime-tools-7.12.1-2.el10.x86_64_v2.rpm;name=keylime-tools;unpack=0"
SRC_URI += "${URI_keylime-tools}"
SRC_URI[keylime-tools.sha256sum] = "4793d8df8107e86cae1cfe5b8d729c97ae165acc6e77a43de2af0509312e1cfc"
RDEPENDS:keylime-tools = " \
 python3 \
 python3-keylime \
 keylime-base \
"

URI_keylime-verifier = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/keylime-verifier-7.12.1-2.el10.x86_64_v2.rpm;name=keylime-verifier;unpack=0"
SRC_URI += "${URI_keylime-verifier}"
SRC_URI[keylime-verifier.sha256sum] = "de30da60beec0b7a879b71b72a7c3552f144987a3537abe561a04c7177562803"
RDEPENDS:keylime-verifier = " \
 python3 \
 python3-keylime \
 bash \
 keylime-base \
"

URI_python3-keylime = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-keylime-7.12.1-2.el10.x86_64_v2.rpm;name=python3-keylime;unpack=0"
SRC_URI += "${URI_python3-keylime}"
SRC_URI[python3-keylime.sha256sum] = "3226b64b88ea40265e5e326c10063e6650d5d27233297663d03fd18f7c72dc2d"
RDEPENDS:python3-keylime = " \
 python3 \
 python3-pyyaml \
 python3-requests \
 python3-psutil \
 python3-cryptography \
 python3-pyasn1 \
 python3-pyasn1-modules \
 python3-lark \
 python3-sqlalchemy \
 python3-tornado \
 keylime-base \
 python3-gpg \
 tpm2-tools \
 python3-alembic \
 python3-packaging \
 python3-jsonschema \
 python3-typing-extensions \
"
