# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rrdtool"
PE = "0"
PV = "1.8.0"
PR = "20.el10"
PACKAGES = "rrdtool rrdtool-perl python3-rrdtool rrdtool-devel rrdtool-doc rrdtool-lua rrdtool-ruby rrdtool-tcl"
PROVIDES = "rpm/rrdtool rpm/rrdtool-perl rpm/python3-rrdtool rpm/rrdtool-devel rpm/rrdtool-doc rpm/rrdtool-lua rpm/rrdtool-ruby rpm/rrdtool-tcl"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/rrdtool-1.8.0-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d60705ce1e2ac267626e58c8f5f4d0b120eb0a83aa77ec6f282770bd6d8df15f"

URI_rrdtool = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rrdtool-1.8.0-20.el10.x86_64_v2.rpm;name=rrdtool;unpack=0"
SRC_URI += "${URI_rrdtool}"
SRC_URI[rrdtool.sha256sum] = "36bbf31fb821c7a93bda1be8ff34bd4040f7e2e5fe96c5da1e181df3682d97e0"
RDEPENDS:rrdtool = " \
 systemd \
 libpng \
 harfbuzz \
 libxml2 \
 pango \
 bash \
 glib2 \
 cairo \
 glibc \
 dejavu-sans-mono-fonts \
"

URI_rrdtool-perl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rrdtool-perl-1.8.0-20.el10.x86_64_v2.rpm;name=rrdtool-perl;unpack=0"
SRC_URI += "${URI_rrdtool-perl}"
SRC_URI[rrdtool-perl.sha256sum] = "2d765863b1ae9fa7de51a64d4011af622d61164a01825374b064620be883c891"
RDEPENDS:rrdtool-perl = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-IO \
 perl-Fcntl \
 perl-DynaLoader \
 perl-IPC-Open3 \
 glibc \
 rrdtool \
"

URI_python3-rrdtool = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-rrdtool-1.8.0-20.el10.x86_64_v2.rpm;name=python3-rrdtool;unpack=0"
SRC_URI += "${URI_python3-rrdtool}"
SRC_URI[python3-rrdtool.sha256sum] = "7cdeba3e5c5af5b71f2c2f49d6b1d84e69e2f5c13198769cbceeb1073759a94a"
RDEPENDS:python3-rrdtool = " \
 glibc \
 rrdtool \
 python3 \
"

URI_rrdtool-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/rrdtool-devel-1.8.0-20.el10.x86_64_v2.rpm;name=rrdtool-devel;unpack=0"
SRC_URI += "${URI_rrdtool-devel}"
SRC_URI[rrdtool-devel.sha256sum] = "1541b2324b82a682de72d182414a18e0460e2eeb0ebea6a5f0ffc2c6493ce64a"
RDEPENDS:rrdtool-devel = " \
 rrdtool \
 pkgconf-pkg-config \
"

URI_rrdtool-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/rrdtool-doc-1.8.0-20.el10.x86_64_v2.rpm;name=rrdtool-doc;unpack=0"
SRC_URI += "${URI_rrdtool-doc}"
SRC_URI[rrdtool-doc.sha256sum] = "afc3ad22c37cfb4ee750c9a7f51f4027f473132c64299a9771c942ca95c1971c"
RDEPENDS:rrdtool-doc = ""

URI_rrdtool-lua = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/rrdtool-lua-1.8.0-20.el10.x86_64_v2.rpm;name=rrdtool-lua;unpack=0"
SRC_URI += "${URI_rrdtool-lua}"
SRC_URI[rrdtool-lua.sha256sum] = "bc8e50151e3390a177283b07ec11b5fdf67f668553db530e8cb6136c73460688"
RDEPENDS:rrdtool-lua = " \
 libpng \
 lua-libs \
 harfbuzz \
 libxml2 \
 pango \
 cairo \
 glib2 \
 glibc \
 rrdtool \
"

URI_rrdtool-ruby = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/rrdtool-ruby-1.8.0-20.el10.x86_64_v2.rpm;name=rrdtool-ruby;unpack=0"
SRC_URI += "${URI_rrdtool-ruby}"
SRC_URI[rrdtool-ruby.sha256sum] = "82939ac5af99f6a0f87bf6a64ea0c6f8ade9fb03cfb85ab28cf24b340efe9756"
RDEPENDS:rrdtool-ruby = " \
 glibc \
 rrdtool \
 ruby-libs \
"

URI_rrdtool-tcl = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/rrdtool-tcl-1.8.0-20.el10.x86_64_v2.rpm;name=rrdtool-tcl;unpack=0"
SRC_URI += "${URI_rrdtool-tcl}"
SRC_URI[rrdtool-tcl.sha256sum] = "325a3de1417911e07686a3e2f0b777e6a6f2853e6f1ba1ea48f44864bdbb9fdb"
RDEPENDS:rrdtool-tcl = " \
 glibc \
 rrdtool \
 tcl \
"
