# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gperf"
PE = "0"
PV = "3.1"
PR = "21.el10"
PACKAGES = "gperf"
PROVIDES = "rpm/gperf"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gperf-3.1-21.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78f1c874cdce1c469640a195daf77d9d85d2760fe7b378b939036e80378e3443"

URI_gperf = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gperf-3.1-21.el10.x86_64_v2.rpm;name=gperf;unpack=0"
SRC_URI += "${URI_gperf}"
SRC_URI[gperf.sha256sum] = "cd682fcf83bc330c265f9aae45fd2e97f7a16aa7c3bd5ba5e06ece3ff5e92ed3"
RDEPENDS:gperf = " \
 glibc \
 libgcc \
 libstdc++ \
"
