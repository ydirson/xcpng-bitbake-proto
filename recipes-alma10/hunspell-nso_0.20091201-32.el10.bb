# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-nso"
PE = "0"
PV = "0.20091201"
PR = "32.el10"
PACKAGES = "hunspell-nso"
PROVIDES = "rpm/hunspell-nso"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-nso-0.20091201-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7ee84cd9621a881f6fb203f227c8d57a18a13035cba2af80c0158288017a6b1"

URI_hunspell-nso = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-nso-0.20091201-32.el10.noarch.rpm;name=hunspell-nso;unpack=0"
SRC_URI += "${URI_hunspell-nso}"
SRC_URI[hunspell-nso.sha256sum] = "e95e3ef493b4054da5102d14b7ee17a3e43414efc91e409c1b5fad3c0d9a2bda"
RDEPENDS:hunspell-nso = " \
 hunspell \
"
