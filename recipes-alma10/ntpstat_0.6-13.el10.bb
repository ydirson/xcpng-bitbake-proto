# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ntpstat"
PE = "0"
PV = "0.6"
PR = "13.el10"
PACKAGES = "ntpstat"
PROVIDES = "rpm/ntpstat"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ntpstat-0.6-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51858dffa179be2c1a7e92502028ee4ebd2d1493da5edfc36101be3616d4e9e5"

URI_ntpstat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ntpstat-0.6-13.el10.noarch.rpm;name=ntpstat;unpack=0"
SRC_URI += "${URI_ntpstat}"
SRC_URI[ntpstat.sha256sum] = "cecac2840352d8be1349db7e2f77ba0a9466ba4f1c3de5d4b07d8a1d5bdf657c"
RDEPENDS:ntpstat = " \
 chrony \
 bash \
"
