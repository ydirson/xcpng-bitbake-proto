# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libvma"
PE = "0"
PV = "9.8.60"
PR = "3.el10"
PACKAGES = "libvma libvma-utils libvma-devel"
PROVIDES = "rpm/libvma rpm/libvma-utils rpm/libvma-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libvma-9.8.60-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7bfbc2b18f637491bbe49adbf95f1450b69e06c1a7724f2f12f978f24448cb19"

URI_libvma = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvma-9.8.60-3.el10.x86_64_v2.rpm;name=libvma;unpack=0"
SRC_URI += "${URI_libvma}"
SRC_URI[libvma.sha256sum] = "528c27b4af3752ae5bc2c4521385c32232a0ca2a1d1752fc74a3e2409f84f8f9"
RDEPENDS:libvma = " \
 libgcc \
 libnl3 \
 librdmacm \
 libstdc++ \
 bash \
 libibverbs \
 glibc \
"

URI_libvma-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvma-utils-9.8.60-3.el10.x86_64_v2.rpm;name=libvma-utils;unpack=0"
SRC_URI += "${URI_libvma-utils}"
SRC_URI[libvma-utils.sha256sum] = "2b00ff9d2a309795b8000505f65b2939a12fdf218bb6292bd80f8675158ee193"
RDEPENDS:libvma-utils = " \
 glibc \
 libvma \
 libgcc \
 libstdc++ \
"

URI_libvma-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libvma-devel-9.8.60-3.el10.x86_64_v2.rpm;name=libvma-devel;unpack=0"
SRC_URI += "${URI_libvma-devel}"
SRC_URI[libvma-devel.sha256sum] = "c2e3321a894cea0de71e333f02dbdb97998b7aef78ff7c910347ce6f56487dc3"
RDEPENDS:libvma-devel = " \
 libvma \
"
