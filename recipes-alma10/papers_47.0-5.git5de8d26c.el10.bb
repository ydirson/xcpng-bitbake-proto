# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "papers"
PE = "0"
PV = "47.0"
PR = "5.git5de8d26c.el10"
PACKAGES = "papers papers-libs papers-nautilus papers-previewer papers-thumbnailer papers-devel"
PROVIDES = "rpm/papers rpm/papers-libs rpm/papers-nautilus rpm/papers-previewer rpm/papers-thumbnailer rpm/papers-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/papers-47.0-5.git5de8d26c.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d65565acf1dc5e2284d7eddf8e1afad2227b08ccdb4bb9807aea0b3f4e1a01ec"

URI_papers = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/papers-47.0-5.git5de8d26c.el10.x86_64_v2.rpm;name=papers;unpack=0"
SRC_URI += "${URI_papers}"
SRC_URI[papers.sha256sum] = "0ec2c462e72bf6112ce8fec34f694402617e90fb05042e5ff530e4267eda40b3"
RDEPENDS:papers = " \
 libgcc \
 pango \
 gdk-pixbuf2 \
 papers-libs \
 papers-previewer \
 glib2 \
 graphene \
 papers-thumbnailer \
 glibc \
 gtk4 \
 hicolor-icon-theme \
 libadwaita \
"

URI_papers-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/papers-libs-47.0-5.git5de8d26c.el10.x86_64_v2.rpm;name=papers-libs;unpack=0"
SRC_URI += "${URI_papers-libs}"
SRC_URI[papers-libs.sha256sum] = "0a77b742f8a0a7aa015794d7f25d66eea28474599c91894d82b5f6130e573cd9"
RDEPENDS:papers-libs = " \
 libarchive \
 libspelling \
 libgcc \
 pango \
 gdk-pixbuf2 \
 exempi \
 poppler-glib \
 cairo \
 glib2 \
 graphene \
 glibc \
 gtk4 \
 libadwaita \
 gtksourceview5 \
 libtiff \
"

URI_papers-nautilus = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/papers-nautilus-47.0-5.git5de8d26c.el10.x86_64_v2.rpm;name=papers-nautilus;unpack=0"
SRC_URI += "${URI_papers-nautilus}"
SRC_URI[papers-nautilus.sha256sum] = "eecc71f849767c0587f2c6365157202892483dc4e6b8e1f2c4a3d35350fb540b"
RDEPENDS:papers-nautilus = " \
 libgcc \
 papers-libs \
 glib2 \
 glibc \
 nautilus \
 nautilus-extensions \
"

URI_papers-previewer = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/papers-previewer-47.0-5.git5de8d26c.el10.x86_64_v2.rpm;name=papers-previewer;unpack=0"
SRC_URI += "${URI_papers-previewer}"
SRC_URI[papers-previewer.sha256sum] = "3e3723e44cb223ff229395c0612af672fb5604d1aa37d2272e12e9f477b2c669"
RDEPENDS:papers-previewer = " \
 libgcc \
 papers-libs \
 glib2 \
 glibc \
 gtk4 \
 libadwaita \
"

URI_papers-thumbnailer = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/papers-thumbnailer-47.0-5.git5de8d26c.el10.x86_64_v2.rpm;name=papers-thumbnailer;unpack=0"
SRC_URI += "${URI_papers-thumbnailer}"
SRC_URI[papers-thumbnailer.sha256sum] = "cce20ebb331399646a8ca650a93f4bd0145d7d9661117121e302d14142efa16b"
RDEPENDS:papers-thumbnailer = " \
 libgcc \
 gdk-pixbuf2 \
 papers-libs \
 glib2 \
 glibc \
"

URI_papers-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/papers-devel-47.0-5.git5de8d26c.el10.x86_64_v2.rpm;name=papers-devel;unpack=0"
SRC_URI += "${URI_papers-devel}"
SRC_URI[papers-devel.sha256sum] = "f579df1d1c0ec2b84e5970a3cc8970f12da059fceeeac477d36cc1cdc84b608c"
RDEPENDS:papers-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 papers-libs \
 libadwaita-devel \
 gtk4-devel \
"
