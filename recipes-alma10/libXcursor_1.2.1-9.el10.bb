# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libXcursor"
PE = "0"
PV = "1.2.1"
PR = "9.el10"
PACKAGES = "libXcursor libXcursor-devel"
PROVIDES = "rpm/libXcursor rpm/libXcursor-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libXcursor-1.2.1-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "540ffbaed103d14e5f06f2fe5d1d2c55209a0214b171986cfdacae04ea00a253"

URI_libXcursor = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXcursor-1.2.1-9.el10.x86_64_v2.rpm;name=libXcursor;unpack=0"
SRC_URI += "${URI_libXcursor}"
SRC_URI[libXcursor.sha256sum] = "f32cbd3132ef75aa9946e6defb42e98f3340a6b13a23b4811b57550f6714c642"
RDEPENDS:libXcursor = " \
 glibc \
 libXfixes \
 libX11 \
 libXrender \
"

URI_libXcursor-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXcursor-devel-1.2.1-9.el10.x86_64_v2.rpm;name=libXcursor-devel;unpack=0"
SRC_URI += "${URI_libXcursor-devel}"
SRC_URI[libXcursor-devel.sha256sum] = "a930d37d300cec27a174ba12a8b3682ae22523d5c9b6ea6192c7a5549843cb02"
RDEPENDS:libXcursor-devel = " \
 libXfixes-devel \
 pkgconf-pkg-config \
 libXrender-devel \
 xorg-x11-proto-devel \
 libX11-devel \
 libXcursor \
"
