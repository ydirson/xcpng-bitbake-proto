# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libabigail"
PE = "0"
PV = "2.6"
PR = "1.el10"
PACKAGES = "libabigail libabigail-devel libabigail-doc"
PROVIDES = "rpm/libabigail rpm/libabigail-devel rpm/libabigail-doc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/libabigail-2.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "655c8c9f593ecca67e64af551699709325bb4751d7b64d23e789b08f945fbe16"

URI_libabigail = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libabigail-2.6-1.el10.x86_64_v2.rpm;name=libabigail;unpack=0"
SRC_URI += "${URI_libabigail}"
SRC_URI[libabigail.sha256sum] = "6e9aa3ba0014b7cfda232fea5a577388afb23c45aed109a3187755df36da54bd"
RDEPENDS:libabigail = " \
 libgcc \
 libbpf \
 libxml2 \
 elfutils-libelf \
 elfutils-libs \
 libstdc++ \
 binutils \
 glibc \
"

URI_libabigail-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libabigail-devel-2.6-1.el10.x86_64_v2.rpm;name=libabigail-devel;unpack=0"
SRC_URI += "${URI_libabigail-devel}"
SRC_URI[libabigail-devel.sha256sum] = "22817210b7e289102dd9ba757102d3368be7dce0192efa555867b23d8566a987"
RDEPENDS:libabigail-devel = " \
 libxml2-devel \
 libabigail \
 pkgconf-pkg-config \
"

URI_libabigail-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libabigail-doc-2.6-1.el10.x86_64_v2.rpm;name=libabigail-doc;unpack=0"
SRC_URI += "${URI_libabigail-doc}"
SRC_URI[libabigail-doc.sha256sum] = "ccd6df182ebb6302cf91e1a03e8e836d5efacf55763fc78cc28b42022a265e4b"
RDEPENDS:libabigail-doc = ""
