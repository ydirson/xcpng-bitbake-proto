# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libgpg-error"
PE = "0"
PV = "1.50"
PR = "2.el10"
PACKAGES = "libgpg-error libgpg-error-devel"
PROVIDES = "rpm/libgpg-error rpm/libgpg-error-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libgpg-error-1.50-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7cc5f23c201b10cf285d2137ddc3f8fe3f29bae6767662c3d4452482a9f8d2c"

URI_libgpg-error = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libgpg-error-1.50-2.el10.x86_64_v2.rpm;name=libgpg-error;unpack=0"
SRC_URI += "${URI_libgpg-error}"
SRC_URI[libgpg-error.sha256sum] = "776c0fb2b4275a9aea6a8c561ff10ec325340e8282ccba9a7fffd7f2df3d8870"
RDEPENDS:libgpg-error = " \
 glibc \
"

URI_libgpg-error-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libgpg-error-devel-1.50-2.el10.x86_64_v2.rpm;name=libgpg-error-devel;unpack=0"
SRC_URI += "${URI_libgpg-error-devel}"
SRC_URI[libgpg-error-devel.sha256sum] = "9b5e86b58aac13798931fab088a5e774d9b9ada02b55a10161953e0fc09c9c0e"
RDEPENDS:libgpg-error-devel = " \
 glibc \
 bash \
 pkgconf-pkg-config \
 libgpg-error \
"
