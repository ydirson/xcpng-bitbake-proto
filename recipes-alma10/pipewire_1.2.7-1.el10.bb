# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pipewire"
PE = "0"
PV = "1.2.7"
PR = "1.el10"
PACKAGES = "pipewire pipewire-alsa pipewire-devel pipewire-gstreamer pipewire-jack-audio-connection-kit pipewire-jack-audio-connection-kit-devel pipewire-jack-audio-connection-kit-libs pipewire-libs pipewire-module-x11 pipewire-plugin-libcamera pipewire-pulseaudio pipewire-utils pipewire-doc pipewire-plugin-vulkan pipewire-v4l2"
PROVIDES = "rpm/pipewire rpm/pipewire-alsa rpm/pipewire-devel rpm/pipewire-gstreamer rpm/pipewire-jack-audio-connection-kit rpm/pipewire-jack-audio-connection-kit-devel rpm/pipewire-jack-audio-connection-kit-libs rpm/pipewire-libs rpm/pipewire-module-x11 rpm/pipewire-plugin-libcamera rpm/pipewire-pulseaudio rpm/pipewire-utils rpm/pipewire-doc rpm/pipewire-plugin-vulkan rpm/pipewire-v4l2"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/pipewire-1.2.7-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "130a8a5b69d0edf823424879c982e0fdcbb330620a9956cbbb40ba48823f6c1e"

URI_pipewire = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pipewire-1.2.7-1.el10.x86_64_v2.rpm;name=pipewire;unpack=0"
SRC_URI += "${URI_pipewire}"
SRC_URI[pipewire.sha256sum] = "377d107614f6e058e8cc3417e157055356e551af63f811531c94d90a35d585da"
RDEPENDS:pipewire = " \
 shadow-utils \
 systemd \
 wireplumber \
 bash \
 rtkit \
 glibc \
 pipewire-libs \
"

URI_pipewire-alsa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pipewire-alsa-1.2.7-1.el10.x86_64_v2.rpm;name=pipewire-alsa;unpack=0"
SRC_URI += "${URI_pipewire-alsa}"
SRC_URI[pipewire-alsa.sha256sum] = "6b40eb51ae69c926e1dda48c6fda61c34edd1b12ff83b7935eaab0fcffc6d65e"
RDEPENDS:pipewire-alsa = " \
 glibc \
 pipewire-libs \
 alsa-lib \
"

URI_pipewire-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pipewire-devel-1.2.7-1.el10.x86_64_v2.rpm;name=pipewire-devel;unpack=0"
SRC_URI += "${URI_pipewire-devel}"
SRC_URI[pipewire-devel.sha256sum] = "18f09516865091717582d124e4b745f85d36d46e3104ed84d0c4d1fcaab027ad"
RDEPENDS:pipewire-devel = " \
 pipewire-libs \
 pipewire-devel \
 pkgconf-pkg-config \
"

URI_pipewire-gstreamer = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pipewire-gstreamer-1.2.7-1.el10.x86_64_v2.rpm;name=pipewire-gstreamer;unpack=0"
SRC_URI += "${URI_pipewire-gstreamer}"
SRC_URI[pipewire-gstreamer.sha256sum] = "0fda051db8f781c45896583a9ab510079cb9d6e949cb812a5e0b97ccc3be7e5d"
RDEPENDS:pipewire-gstreamer = " \
 gstreamer1 \
 libgcc \
 gstreamer1-plugins-base \
 glib2 \
 glibc \
 pipewire-libs \
"

URI_pipewire-jack-audio-connection-kit = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pipewire-jack-audio-connection-kit-1.2.7-1.el10.x86_64_v2.rpm;name=pipewire-jack-audio-connection-kit;unpack=0"
SRC_URI += "${URI_pipewire-jack-audio-connection-kit}"
SRC_URI[pipewire-jack-audio-connection-kit.sha256sum] = "7cd1e89514714fda14518ac42dbce56d00bd55b4b75dc6ee67bf0ae902edf93f"
RDEPENDS:pipewire-jack-audio-connection-kit = " \
 pipewire-jack-audio-connection-kit-libs \
"

URI_pipewire-jack-audio-connection-kit-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pipewire-jack-audio-connection-kit-devel-1.2.7-1.el10.x86_64_v2.rpm;name=pipewire-jack-audio-connection-kit-devel;unpack=0"
SRC_URI += "${URI_pipewire-jack-audio-connection-kit-devel}"
SRC_URI[pipewire-jack-audio-connection-kit-devel.sha256sum] = "dee76509a72b516f9853412570f6f2c09b2eb40715a82e6e16ad394008d94aa8"
RDEPENDS:pipewire-jack-audio-connection-kit-devel = " \
 pipewire-jack-audio-connection-kit-libs \
 pkgconf-pkg-config \
"

URI_pipewire-jack-audio-connection-kit-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pipewire-jack-audio-connection-kit-libs-1.2.7-1.el10.x86_64_v2.rpm;name=pipewire-jack-audio-connection-kit-libs;unpack=0"
SRC_URI += "${URI_pipewire-jack-audio-connection-kit-libs}"
SRC_URI[pipewire-jack-audio-connection-kit-libs.sha256sum] = "4fe0776dd435c9ed36bc7f4acc2fe3ef48919f6c7d2383768005120e9721d3ce"
RDEPENDS:pipewire-jack-audio-connection-kit-libs = " \
 glibc \
 pipewire-libs \
 bash \
 pipewire-jack-audio-connection-kit \
"

URI_pipewire-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pipewire-libs-1.2.7-1.el10.x86_64_v2.rpm;name=pipewire-libs;unpack=0"
SRC_URI += "${URI_pipewire-libs}"
SRC_URI[pipewire-libs.sha256sum] = "7426fa50a7de168fa7819a7d4a7712c2122da39754392becd7f7aa5e95f92ee1"
RDEPENDS:pipewire-libs = " \
 liblc3 \
 libldac \
 systemd-libs \
 dbus-libs \
 libselinux \
 libstdc++ \
 fdk-aac-free \
 libusb1 \
 alsa-lib \
 pulseaudio-libs \
 openssl-libs \
 libgcc \
 libsbc \
 avahi-libs \
 bluez-libs \
 opus \
 libsndfile \
 webrtc-audio-processing \
 glib2 \
 glibc \
"

URI_pipewire-module-x11 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pipewire-module-x11-1.2.7-1.el10.x86_64_v2.rpm;name=pipewire-module-x11;unpack=0"
SRC_URI += "${URI_pipewire-module-x11}"
SRC_URI[pipewire-module-x11.sha256sum] = "de03712f4a8239225bbce2675dabb06d8895f5b39f57d0a79f51b152e12999ad"
RDEPENDS:pipewire-module-x11 = " \
 libXfixes \
 libcanberra \
 libX11 \
 glibc \
 pipewire-libs \
"

URI_pipewire-plugin-libcamera = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pipewire-plugin-libcamera-1.2.7-1.el10.x86_64_v2.rpm;name=pipewire-plugin-libcamera;unpack=0"
SRC_URI += "${URI_pipewire-plugin-libcamera}"
SRC_URI[pipewire-plugin-libcamera.sha256sum] = "24eecbb2122edf22c4beaa3c96ec8af8400f9bba04936a1acfcca180d2306343"
RDEPENDS:pipewire-plugin-libcamera = " \
 libcamera \
 libgcc \
 libstdc++ \
 glibc \
 pipewire-libs \
 libdrm \
"

URI_pipewire-pulseaudio = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pipewire-pulseaudio-1.2.7-1.el10.x86_64_v2.rpm;name=pipewire-pulseaudio;unpack=0"
SRC_URI += "${URI_pipewire-pulseaudio}"
SRC_URI[pipewire-pulseaudio.sha256sum] = "09dae8cab7a36865dcd6ffd922b275f97e04ac2ad1b547bc7516294059d4de4a"
RDEPENDS:pipewire-pulseaudio = " \
 systemd-libs \
 libgcc \
 avahi-libs \
 bash \
 glib2 \
 glibc \
 pipewire-libs \
 dbus-libs \
"

URI_pipewire-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pipewire-utils-1.2.7-1.el10.x86_64_v2.rpm;name=pipewire-utils;unpack=0"
SRC_URI += "${URI_pipewire-utils}"
SRC_URI[pipewire-utils.sha256sum] = "d46467e7779c3c493653a3f79ebfffdfa60a70c41081630a287ffea3a9d15f8b"
RDEPENDS:pipewire-utils = " \
 alsa-lib \
 libgcc \
 readline \
 pipewire \
 ncurses-libs \
 glibc \
 pipewire-libs \
 dbus-libs \
 libsndfile \
"

URI_pipewire-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/pipewire-doc-1.2.7-1.el10.x86_64_v2.rpm;name=pipewire-doc;unpack=0"
SRC_URI += "${URI_pipewire-doc}"
SRC_URI[pipewire-doc.sha256sum] = "651ca2cb16be72aa461bef0f220c4c71fd1615ec2fab5c7d7bd9761e28dbf6da"
RDEPENDS:pipewire-doc = ""

URI_pipewire-plugin-vulkan = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/pipewire-plugin-vulkan-1.2.7-1.el10.x86_64_v2.rpm;name=pipewire-plugin-vulkan;unpack=0"
SRC_URI += "${URI_pipewire-plugin-vulkan}"
SRC_URI[pipewire-plugin-vulkan.sha256sum] = "99d95b19d5a9953c943590115f15e68f3b364936d184b21ec166af2f85ae16a8"
RDEPENDS:pipewire-plugin-vulkan = " \
 glibc \
 pipewire-libs \
 vulkan-loader \
 libdrm \
"

URI_pipewire-v4l2 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/pipewire-v4l2-1.2.7-1.el10.x86_64_v2.rpm;name=pipewire-v4l2;unpack=0"
SRC_URI += "${URI_pipewire-v4l2}"
SRC_URI[pipewire-v4l2.sha256sum] = "037646f00bac2aadb0135940b959ce65cc0716cd56a59ad20aa9918db975df51"
RDEPENDS:pipewire-v4l2 = " \
 glibc \
 pipewire-libs \
 bash \
"
