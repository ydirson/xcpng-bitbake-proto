# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "conmon"
PE = "3"
PV = "2.1.12"
PR = "4.el10"
PACKAGES = "conmon"
PROVIDES = "rpm/conmon"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/conmon-2.1.12-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2fee73959c5b7cc29a603a72d8c5bfdb04b4b0445c7ed2283709ba549e77c7aa"

URI_conmon = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/conmon-2.1.12-4.el10.x86_64_v2.rpm;name=conmon;unpack=0"
SRC_URI += "${URI_conmon}"
SRC_URI[conmon.sha256sum] = "177cf1848b3ce1c18a4e18d8db537a15496693fa08d2856c6f77136ee8dc92ae"
RDEPENDS:conmon = " \
 systemd-libs \
 libgcc \
 glib2 \
 libseccomp \
 glibc \
"
