# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "phodav"
PE = "0"
PV = "3.0"
PR = "6.el10"
PACKAGES = "libphodav libphodav-devel spice-webdavd chezdav"
PROVIDES = "rpm/libphodav rpm/libphodav-devel rpm/spice-webdavd rpm/chezdav"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/phodav-3.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c7c352b5b2781e1cb34f7d413372a4d88064ba13929b0a6c19feffb06d7c21d"

URI_libphodav = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libphodav-3.0-6.el10.x86_64_v2.rpm;name=libphodav;unpack=0"
SRC_URI += "${URI_libphodav}"
SRC_URI[libphodav.sha256sum] = "d89d159fa8a5631b872ad8b0ef144fd321c498869a157bda71f82e8ded45764b"
RDEPENDS:libphodav = " \
 glibc \
 libxml2 \
 libsoup3 \
 glib2 \
"

URI_libphodav-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libphodav-devel-3.0-6.el10.x86_64_v2.rpm;name=libphodav-devel;unpack=0"
SRC_URI += "${URI_libphodav-devel}"
SRC_URI[libphodav-devel.sha256sum] = "3f160d7ac522d2ca6469ed9622b400cdac6362c8b3d08d1e554e30e7698064ad"
RDEPENDS:libphodav-devel = " \
 libxml2-devel \
 glib2-devel \
 libsoup3-devel \
 pkgconf-pkg-config \
 libphodav \
"

URI_spice-webdavd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/spice-webdavd-3.0-6.el10.x86_64_v2.rpm;name=spice-webdavd;unpack=0"
SRC_URI += "${URI_spice-webdavd}"
SRC_URI[spice-webdavd.sha256sum] = "a558ffa00895ebae58df8c68953ca58aca7d622293082d72dff02255ce454002"
RDEPENDS:spice-webdavd = " \
 systemd \
 avahi-gobject \
 avahi \
 bash \
 glib2 \
 glibc \
"

URI_chezdav = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/chezdav-3.0-6.el10.x86_64_v2.rpm;name=chezdav;unpack=0"
SRC_URI += "${URI_chezdav}"
SRC_URI[chezdav.sha256sum] = "8728a487873062584c19716d40abf0f730febf1904697de038395d2880c019b7"
RDEPENDS:chezdav = " \
 libsoup3 \
 avahi-gobject \
 libphodav \
 glib2 \
 glibc \
"
