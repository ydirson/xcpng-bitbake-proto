# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xterm"
PE = "0"
PV = "389"
PR = "4.el10"
PACKAGES = "xterm xterm-resize"
PROVIDES = "rpm/xterm rpm/xterm-resize"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xterm-389-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce37622a12a778e0f7745a3d1398b61d2f017a580e6c29010d7c7858f0bbc423"

URI_xterm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xterm-389-4.el10.x86_64_v2.rpm;name=xterm;unpack=0"
SRC_URI += "${URI_xterm}"
SRC_URI[xterm.sha256sum] = "0133f9ddb1cc7558c011d6a0382e29efb7efcd1e81fd380d8730f08831150b9e"
RDEPENDS:xterm = " \
 libutempter \
 freetype \
 libXft \
 libXmu \
 libICE \
 libXpm \
 fontconfig \
 libX11 \
 libXt \
 ncurses-libs \
 bash \
 libXaw \
 pcre2 \
 glibc \
 libXext \
"

URI_xterm-resize = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xterm-resize-389-4.el10.x86_64_v2.rpm;name=xterm-resize;unpack=0"
SRC_URI += "${URI_xterm-resize}"
SRC_URI[xterm-resize.sha256sum] = "5f90ae7bc7b712cea30d1dd4151f6c4d54a558a6a64b418fe472c1b2cfe8d822"
RDEPENDS:xterm-resize = " \
 glibc \
 ncurses-libs \
"
