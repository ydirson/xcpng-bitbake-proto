# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "usbredir"
PE = "0"
PV = "0.13.0"
PR = "6.el10"
PACKAGES = "usbredir usbredir-devel usbredir-tools"
PROVIDES = "rpm/usbredir rpm/usbredir-devel rpm/usbredir-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/usbredir-0.13.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b3cd63a3540fd8f305cc8ddb2bd6f91d72f2fab56f34380e7bc7640d062111f"

URI_usbredir = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/usbredir-0.13.0-6.el10.x86_64_v2.rpm;name=usbredir;unpack=0"
SRC_URI += "${URI_usbredir}"
SRC_URI[usbredir.sha256sum] = "a27c978a7bc82e2d16aedf4d938d7e5fec253600e3d0f87831fabb718fdcfa72"
RDEPENDS:usbredir = " \
 glibc \
 libusb1 \
"

URI_usbredir-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/usbredir-devel-0.13.0-6.el10.x86_64_v2.rpm;name=usbredir-devel;unpack=0"
SRC_URI += "${URI_usbredir-devel}"
SRC_URI[usbredir-devel.sha256sum] = "ad7bd0b2420a878deb3452ac231bc16e7a6f6db0173b32a5374e8d4257e01526"
RDEPENDS:usbredir-devel = " \
 libusb1-devel \
 usbredir \
 usbredir-devel \
 pkgconf-pkg-config \
"

URI_usbredir-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/usbredir-tools-0.13.0-6.el10.x86_64_v2.rpm;name=usbredir-tools;unpack=0"
SRC_URI += "${URI_usbredir-tools}"
SRC_URI[usbredir-tools.sha256sum] = "7e22c484b0a20c56ca290d8160292c70c9f865b448027e6b6981fb7fe19888f2"
RDEPENDS:usbredir-tools = " \
 glibc \
 usbredir \
 glib2 \
 libusb1 \
"
