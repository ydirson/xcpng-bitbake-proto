# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "certmonger"
PE = "0"
PV = "0.79.20"
PR = "3.el10"
PACKAGES = "certmonger"
PROVIDES = "rpm/certmonger"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/certmonger-0.79.20-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffefa96de39e8a96cf166f7a25f7c244330aa02a9b432cf1b1da30b25254763a"

URI_certmonger = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/certmonger-0.79.20-3.el10.x86_64_v2.rpm;name=certmonger;unpack=0"
SRC_URI += "${URI_certmonger}"
SRC_URI[certmonger.sha256sum] = "6a1e9d4bcee0799158be2fbc96325fc40d2fc8cb3f2c4596dda2a9d046826ef1"
RDEPENDS:certmonger = " \
 systemd \
 nss \
 krb5-libs \
 nss-util \
 dbus \
 dbus-libs \
 dbus-tools \
 jansson \
 libcom_err \
 libtalloc \
 libcurl \
 sed \
 libtevent \
 openldap \
 libuuid \
 openssl-libs \
 libxml2 \
 bash \
 libidn2 \
 popt \
 glibc \
 nspr \
"
