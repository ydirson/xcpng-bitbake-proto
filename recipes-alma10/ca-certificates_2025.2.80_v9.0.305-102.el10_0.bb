# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ca-certificates"
PE = "0"
PV = "2025.2.80_v9.0.305"
PR = "102.el10_0"
PACKAGES = "ca-certificates"
PROVIDES = "rpm/ca-certificates"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/ca-certificates-2025.2.80_v9.0.305-102.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "713335f5511fbfd6f2adc09a384692fcf5db8320e63830b5161e377eb925c71e"

URI_ca-certificates = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/ca-certificates-2025.2.80_v9.0.305-102.el10_0.noarch.rpm;name=ca-certificates;unpack=0"
SRC_URI += "${URI_ca-certificates}"
SRC_URI[ca-certificates.sha256sum] = "fb19ca670a213eb70690c70824b3791057abb9773124c5f9f1bb93f7181bc623"
RDEPENDS:ca-certificates = " \
 libffi \
 grep \
 p11-kit-trust \
 bash \
 sed \
 coreutils \
 findutils \
"
