# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "buildah"
PE = "2"
PV = "1.39.4"
PR = "2.el10_0"
PACKAGES = "buildah buildah-tests"
PROVIDES = "rpm/buildah rpm/buildah-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/buildah-1.39.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae9a1a0e2837f5511e2582129fb9bde23badf36e47408334bec51588752fb2df"

URI_buildah = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/buildah-1.39.4-2.el10_0.x86_64_v2.rpm;name=buildah;unpack=0"
SRC_URI += "${URI_buildah}"
SRC_URI[buildah.sha256sum] = "26d5354fd20ad4094fb0421e65c8ce7ef76f0019819c7560523d7785664f6a79"
RDEPENDS:buildah = " \
 containers-common-extra \
 shadow-utils-subid \
 gpgme \
 libseccomp \
 glibc \
"

URI_buildah-tests = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/buildah-tests-1.39.4-2.el10_0.x86_64_v2.rpm;name=buildah-tests;unpack=0"
SRC_URI += "${URI_buildah-tests}"
SRC_URI[buildah-tests.sha256sum] = "1f8197ac52ff6cef88d493d0b83f7401d48ed412f5f54d21d86354c8484ec17d"
RDEPENDS:buildah-tests = " \
 nmap-ncat \
 bzip2 \
 shadow-utils-subid \
 openssl \
 buildah \
 gpgme \
 jq \
 httpd-tools \
 git-daemon \
 bash \
 libseccomp \
 glibc \
 golang \
 podman \
"
