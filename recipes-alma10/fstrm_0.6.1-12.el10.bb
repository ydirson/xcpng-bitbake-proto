# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "fstrm"
PE = "0"
PV = "0.6.1"
PR = "12.el10"
PACKAGES = "fstrm fstrm-devel fstrm-utils fstrm-doc"
PROVIDES = "rpm/fstrm rpm/fstrm-devel rpm/fstrm-utils rpm/fstrm-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/fstrm-0.6.1-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7875f7736ba79d576f8b0e3865ae0fd6dd7355f83cf95b5a42c45a1436368b43"

URI_fstrm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fstrm-0.6.1-12.el10.x86_64_v2.rpm;name=fstrm;unpack=0"
SRC_URI += "${URI_fstrm}"
SRC_URI[fstrm.sha256sum] = "b9af1dd3d0f2547214a84e6c5cf57b435968a30e1111b396fcb08ed67241e9f8"
RDEPENDS:fstrm = " \
 glibc \
"

URI_fstrm-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/fstrm-devel-0.6.1-12.el10.x86_64_v2.rpm;name=fstrm-devel;unpack=0"
SRC_URI += "${URI_fstrm-devel}"
SRC_URI[fstrm-devel.sha256sum] = "0644683fed00c810257907a873f587f4b4962b673f2e534d2c1dce85a6638cf0"
RDEPENDS:fstrm-devel = " \
 pkgconf-pkg-config \
 fstrm \
"

URI_fstrm-utils = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/fstrm-utils-0.6.1-12.el10.x86_64_v2.rpm;name=fstrm-utils;unpack=0"
SRC_URI += "${URI_fstrm-utils}"
SRC_URI[fstrm-utils.sha256sum] = "9271da13f44643897df554f93e97d232baf55eb09843c6a17cde7b694b70a7c1"
RDEPENDS:fstrm-utils = " \
 glibc \
 libevent \
 fstrm \
"

URI_fstrm-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/fstrm-doc-0.6.1-12.el10.noarch.rpm;name=fstrm-doc;unpack=0"
SRC_URI += "${URI_fstrm-doc}"
SRC_URI[fstrm-doc.sha256sum] = "b8187ac14e0b03e478523933828736db19b4e22e564337ad655797155e70269f"
RDEPENDS:fstrm-doc = " \
 fstrm \
"
