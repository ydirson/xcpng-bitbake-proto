# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ocaml-srpm-macros"
PE = "0"
PV = "10"
PR = "4.el10"
PACKAGES = "ocaml-srpm-macros"
PROVIDES = "rpm/ocaml-srpm-macros"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ocaml-srpm-macros-10-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c9449e4760a1bf8cae6a0c96eb15865ecd03179cdb456b996dafb4e2733f412"

URI_ocaml-srpm-macros = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ocaml-srpm-macros-10-4.el10.noarch.rpm;name=ocaml-srpm-macros;unpack=0"
SRC_URI += "${URI_ocaml-srpm-macros}"
SRC_URI[ocaml-srpm-macros.sha256sum] = "f9ee48e40c5bc2dcdd87cb85a3d69088527801cf5c309f565753f834df097cb7"
RDEPENDS:ocaml-srpm-macros = ""
