# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rust-sequoia-sqv"
PE = "0"
PV = "1.3.0"
PR = "2.el10_0"
PACKAGES = "sequoia-sqv"
PROVIDES = "rpm/sequoia-sqv"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/rust-sequoia-sqv-1.3.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac2f2ee3f4410b14ae7eb9ccf7ae11ef429420286c7c6f396be1313829e6942d"

URI_sequoia-sqv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sequoia-sqv-1.3.0-2.el10_0.x86_64_v2.rpm;name=sequoia-sqv;unpack=0"
SRC_URI += "${URI_sequoia-sqv}"
SRC_URI[sequoia-sqv.sha256sum] = "58307e8bec4c0dfc621fafa0c45549b4f7c689a1158f358dbe98d271f5a4baba"
RDEPENDS:sequoia-sqv = " \
 glibc \
 openssl-libs \
 libgcc \
"
