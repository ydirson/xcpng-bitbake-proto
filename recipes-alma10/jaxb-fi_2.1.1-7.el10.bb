# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jaxb-fi"
PE = "0"
PV = "2.1.1"
PR = "7.el10"
PACKAGES = "jaxb-fi jaxb-fi-javadoc jaxb-fi-tests"
PROVIDES = "rpm/jaxb-fi rpm/jaxb-fi-javadoc rpm/jaxb-fi-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/jaxb-fi-2.1.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6e7016d8e2f94bf01de1f8c546ad133b90fee28a7a84c4babc997ece2ed3104"

URI_jaxb-fi = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jaxb-fi-2.1.1-7.el10.noarch.rpm;name=jaxb-fi;unpack=0"
SRC_URI += "${URI_jaxb-fi}"
SRC_URI[jaxb-fi.sha256sum] = "ccf130fd76ac21a55e431e8a048281998bac912b8a9dab033bdf061f5e5abddc"
RDEPENDS:jaxb-fi = " \
 javapackages-filesystem \
"

URI_jaxb-fi-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jaxb-fi-javadoc-2.1.1-7.el10.noarch.rpm;name=jaxb-fi-javadoc;unpack=0"
SRC_URI += "${URI_jaxb-fi-javadoc}"
SRC_URI[jaxb-fi-javadoc.sha256sum] = "fd685854d1124927050fbcc1c3009e49f19ec0164a65eff5f7a390afc096496f"
RDEPENDS:jaxb-fi-javadoc = " \
 javapackages-filesystem \
"

URI_jaxb-fi-tests = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jaxb-fi-tests-2.1.1-7.el10.noarch.rpm;name=jaxb-fi-tests;unpack=0"
SRC_URI += "${URI_jaxb-fi-tests}"
SRC_URI[jaxb-fi-tests.sha256sum] = "4068e5011d3c91661150dc9b85c1422f22e47e7779c54af2fb66b1e0bdc01968"
RDEPENDS:jaxb-fi-tests = " \
 jaxb-fi \
 javapackages-filesystem \
"
