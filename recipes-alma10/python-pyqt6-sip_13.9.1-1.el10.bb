# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-pyqt6-sip"
PE = "0"
PV = "13.9.1"
PR = "1.el10"
PACKAGES = "python3-pyqt6-sip"
PROVIDES = "rpm/python3-pyqt6-sip"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-pyqt6-sip-13.9.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e63f76a3b4a9e4df5b00bb82ebcf39409fdf424d17ddc9a8b1b1809524e4d83"

URI_python3-pyqt6-sip = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-pyqt6-sip-13.9.1-1.el10.x86_64_v2.rpm;name=python3-pyqt6-sip;unpack=0"
SRC_URI += "${URI_python3-pyqt6-sip}"
SRC_URI[python3-pyqt6-sip.sha256sum] = "521c15afac782b07fb779a2d9e84627cc2930eca46ea12bcbec974b3d0377996"
RDEPENDS:python3-pyqt6-sip = " \
 glibc \
 python3 \
"
