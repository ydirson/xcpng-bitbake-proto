# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "unbound"
PE = "0"
PV = "1.20.0"
PR = "12.el10_0"
PACKAGES = "python3-unbound unbound unbound-anchor unbound-dracut unbound-libs unbound-devel unbound-utils"
PROVIDES = "rpm/python3-unbound rpm/unbound rpm/unbound-anchor rpm/unbound-dracut rpm/unbound-libs rpm/unbound-devel rpm/unbound-utils"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/unbound-1.20.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5be7d92307cbb6d270710d471a5066419d3d0b1081a5841c43ae3f39adab478"

URI_python3-unbound = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-unbound-1.20.0-12.el10_0.x86_64_v2.rpm;name=python3-unbound;unpack=0"
SRC_URI += "${URI_python3-unbound}"
SRC_URI[python3-unbound.sha256sum] = "38b90126920a57d2a71227390c4e9f2561dc3aaccc97a85d732f7c53ff203893"
RDEPENDS:python3-unbound = " \
 python3 \
 systemd-libs \
 libevent \
 openssl-libs \
 python3-libs \
 unbound-libs \
 libnghttp2 \
 glibc \
 protobuf-c \
"

URI_unbound = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/unbound-1.20.0-12.el10_0.x86_64_v2.rpm;name=unbound;unpack=0"
SRC_URI += "${URI_unbound}"
SRC_URI[unbound.sha256sum] = "84163a6246c0da8dee4eff01d43a365754eecb3d0b518072222d3818433e5ae4"
RDEPENDS:unbound = " \
 systemd-libs \
 libevent \
 openssl \
 unbound-anchor \
 openssl-libs \
 python3-libs \
 unbound-libs \
 bash \
 libnghttp2 \
 glibc \
 protobuf-c \
"

URI_unbound-anchor = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/unbound-anchor-1.20.0-12.el10_0.x86_64_v2.rpm;name=unbound-anchor;unpack=0"
SRC_URI += "${URI_unbound-anchor}"
SRC_URI[unbound-anchor.sha256sum] = "1e521c132e73c832a6e28455c4142317190f1638be4ca3ccc3ac60bca9eeea51"
RDEPENDS:unbound-anchor = " \
 openssl-libs \
 unbound-libs \
 bash \
 expat \
 glibc \
"

URI_unbound-dracut = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/unbound-dracut-1.20.0-12.el10_0.x86_64_v2.rpm;name=unbound-dracut;unpack=0"
SRC_URI += "${URI_unbound-dracut}"
SRC_URI[unbound-dracut.sha256sum] = "27322d8b464c6d48eae382095223ed5924ccf91dae63f2a9a4272076fb60e18c"
RDEPENDS:unbound-dracut = " \
 bash \
 dracut \
 unbound \
"

URI_unbound-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/unbound-libs-1.20.0-12.el10_0.x86_64_v2.rpm;name=unbound-libs;unpack=0"
SRC_URI += "${URI_unbound-libs}"
SRC_URI[unbound-libs.sha256sum] = "4b598b64baf2c1d434c5e47c9ca4cbe516601f1b64dda071b26478dbfe45b288"
RDEPENDS:unbound-libs = " \
 shadow-utils \
 systemd-libs \
 libevent \
 openssl-libs \
 python3-libs \
 bash \
 libnghttp2 \
 glibc \
 protobuf-c \
"

URI_unbound-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/unbound-devel-1.20.0-12.el10_0.x86_64_v2.rpm;name=unbound-devel;unpack=0"
SRC_URI += "${URI_unbound-devel}"
SRC_URI[unbound-devel.sha256sum] = "28bc5bda4d1bf4aef216126ad5a8205fdb029ec5913c18431f3691d8aa6c408b"
RDEPENDS:unbound-devel = " \
 pkgconf-pkg-config \
 unbound-libs \
 openssl-devel \
 libevent-devel \
 python3-devel \
"

URI_unbound-utils = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/unbound-utils-1.20.0-12.el10_0.x86_64_v2.rpm;name=unbound-utils;unpack=0"
SRC_URI += "${URI_unbound-utils}"
SRC_URI[unbound-utils.sha256sum] = "c7901935ccc38052151219b106955b9dae92d8ac6a19db52c0a2aa162b97b990"
RDEPENDS:unbound-utils = " \
 libevent \
 openssl-libs \
 python3-libs \
 unbound-libs \
 libnghttp2 \
 glibc \
"
