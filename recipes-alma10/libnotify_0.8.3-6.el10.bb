# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libnotify"
PE = "0"
PV = "0.8.3"
PR = "6.el10"
PACKAGES = "libnotify libnotify-devel"
PROVIDES = "rpm/libnotify rpm/libnotify-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libnotify-0.8.3-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2da670eb275b73cf008e553996ff09fe3e044ba4a58af49819207d5c0fe6fade"

URI_libnotify = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libnotify-0.8.3-6.el10.x86_64_v2.rpm;name=libnotify;unpack=0"
SRC_URI += "${URI_libnotify}"
SRC_URI[libnotify.sha256sum] = "a955d4f63e809b63e2bb2553afd6e929f25f549b212df0bcb8c5867f9220ebfb"
RDEPENDS:libnotify = " \
 glibc \
 glib2 \
 gdk-pixbuf2 \
"

URI_libnotify-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libnotify-devel-0.8.3-6.el10.x86_64_v2.rpm;name=libnotify-devel;unpack=0"
SRC_URI += "${URI_libnotify-devel}"
SRC_URI[libnotify-devel.sha256sum] = "dc213d6e207324cbc7be40fb371873483f0ef04ca0476cf47b349496db8eebe1"
RDEPENDS:libnotify-devel = " \
 gdk-pixbuf2-devel \
 glib2-devel \
 pkgconf-pkg-config \
 libnotify \
"
