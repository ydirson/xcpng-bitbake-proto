# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "udica"
PE = "0"
PV = "0.2.8"
PR = "6.el10"
PACKAGES = "udica"
PROVIDES = "rpm/udica"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/udica-0.2.8-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74aa179ec7801674850b1e7ec23a883226a95f7cffafe6cce31b7ddb36872054"

URI_udica = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/udica-0.2.8-6.el10.noarch.rpm;name=udica;unpack=0"
SRC_URI += "${URI_udica}"
SRC_URI[udica.sha256sum] = "fc0a6aeea00094c293c85f54cb1bf6fae148c402680eca5c3364d78e149ad72d"
RDEPENDS:udica = " \
 python3 \
 container-selinux \
 python3-libselinux \
 python3-libsemanage \
"
