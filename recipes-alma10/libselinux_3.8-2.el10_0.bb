# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libselinux"
PE = "0"
PV = "3.8"
PR = "2.el10_0"
PACKAGES = "libselinux libselinux-utils libselinux-devel libselinux-ruby python3-libselinux libselinux-static"
PROVIDES = "rpm/libselinux rpm/libselinux-utils rpm/libselinux-devel rpm/libselinux-ruby rpm/python3-libselinux rpm/libselinux-static"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libselinux-3.8-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1f4c0b55efbf029104d7217e568dc582a81d1f3f2cc4f2cd2649932baea919c"

URI_libselinux = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libselinux-3.8-2.el10_0.x86_64_v2.rpm;name=libselinux;unpack=0"
SRC_URI += "${URI_libselinux}"
SRC_URI[libselinux.sha256sum] = "f6fa5062497c4385a0974581d8adfc9cb368e06e04fa547ff9bccf707a81a322"
RDEPENDS:libselinux = " \
 glibc \
 pcre2 \
 libsepol \
"

URI_libselinux-utils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libselinux-utils-3.8-2.el10_0.x86_64_v2.rpm;name=libselinux-utils;unpack=0"
SRC_URI += "${URI_libselinux-utils}"
SRC_URI[libselinux-utils.sha256sum] = "925b0e4a2ea0997dcc2666d6f3bc8a2b370ad6f44a36b5fea07917cfe862e750"
RDEPENDS:libselinux-utils = " \
 glibc \
 libselinux \
 pcre2 \
 libsepol \
"

URI_libselinux-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libselinux-devel-3.8-2.el10_0.x86_64_v2.rpm;name=libselinux-devel;unpack=0"
SRC_URI += "${URI_libselinux-devel}"
SRC_URI[libselinux-devel.sha256sum] = "d0caebe72f4d8c9a492b935c682f3321d077d26ca6c48c1238fbcc5262a10e35"
RDEPENDS:libselinux-devel = " \
 libselinux \
 libsepol-devel \
 pkgconf-pkg-config \
 pcre2-devel \
"

URI_libselinux-ruby = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libselinux-ruby-3.8-2.el10_0.x86_64_v2.rpm;name=libselinux-ruby;unpack=0"
SRC_URI += "${URI_libselinux-ruby}"
SRC_URI[libselinux-ruby.sha256sum] = "76ead062374fdeef789e89426a96a8149e74653ca911765ff1e7afbcae126489"
RDEPENDS:libselinux-ruby = " \
 glibc \
 libselinux \
 ruby-libs \
"

URI_python3-libselinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-libselinux-3.8-2.el10_0.x86_64_v2.rpm;name=python3-libselinux;unpack=0"
SRC_URI += "${URI_python3-libselinux}"
SRC_URI[python3-libselinux.sha256sum] = "203f4e974f99e8dc2d7b382a41ec075327b25bbd00075729b39c3bafbc6ed6d5"
RDEPENDS:python3-libselinux = " \
 glibc \
 libselinux \
 python3 \
"

URI_libselinux-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libselinux-static-3.8-2.el10_0.x86_64_v2.rpm;name=libselinux-static;unpack=0"
SRC_URI += "${URI_libselinux-static}"
SRC_URI[libselinux-static.sha256sum] = "4e909128e2e5e6cbcd7561fb8196d2fd68f23e849cabacc6bed0e6bbc8952945"
RDEPENDS:libselinux-static = " \
 libselinux-devel \
"
