# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hexedit"
PE = "0"
PV = "1.6"
PR = "8.el10"
PACKAGES = "hexedit"
PROVIDES = "rpm/hexedit"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hexedit-1.6-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edfcd81b0c8c85953c55fa48c26a96ea294a781a33196636f250e0cde01bb6d6"

URI_hexedit = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hexedit-1.6-8.el10.x86_64_v2.rpm;name=hexedit;unpack=0"
SRC_URI += "${URI_hexedit}"
SRC_URI[hexedit.sha256sum] = "37d72cee740cb7f92cbed605bea5f0010b3d1f3d3d74e6057b48d99e15e789e6"
RDEPENDS:hexedit = " \
 glibc \
 ncurses-libs \
"
