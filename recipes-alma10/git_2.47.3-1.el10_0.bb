# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "git"
PE = "0"
PV = "2.47.3"
PR = "1.el10_0"
PACKAGES = "git git-all git-core git-core-doc git-credential-libsecret git-daemon git-email git-gui git-instaweb git-subtree git-svn gitk gitweb perl-Git perl-Git-SVN"
PROVIDES = "rpm/git rpm/git-all rpm/git-core rpm/git-core-doc rpm/git-credential-libsecret rpm/git-daemon rpm/git-email rpm/git-gui rpm/git-instaweb rpm/git-subtree rpm/git-svn rpm/gitk rpm/gitweb rpm/perl-Git rpm/perl-Git-SVN"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/git-2.47.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edd4aa82bf84ea4df11700abc7cd0345678773cc7c81166166485f31324bd94c"

URI_git = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/git-2.47.3-1.el10_0.x86_64_v2.rpm;name=git;unpack=0"
SRC_URI += "${URI_git}"
SRC_URI[git.sha256sum] = "be3360cfafbe8899efe5121b660421c3f6f62d5658c0a99e4a5bb0f430bfa660"
RDEPENDS:git = " \
 perl-TermReadKey \
 perl-libs \
 git-core \
 git-core-doc \
 perl-Getopt-Long \
 perl-File-Basename \
 perl-Git \
 perl-IPC-Open3 \
 perl-PathTools \
 bash \
 perl-File-Find \
 perl-interpreter \
 perl-lib \
"

URI_git-all = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/git-all-2.47.3-1.el10_0.noarch.rpm;name=git-all;unpack=0"
SRC_URI += "${URI_git-all}"
SRC_URI[git-all.sha256sum] = "d18356a77f1c0ea93db48cc41c978d11b621759efb33568d42448ef856940306"
RDEPENDS:git-all = " \
 perl-TermReadKey \
 git \
 git-credential-libsecret \
 git-daemon \
 git-email \
 perl-Git \
 git-gui \
 git-instaweb \
 git-subtree \
 git-svn \
 gitk \
"

URI_git-core = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/git-core-2.47.3-1.el10_0.x86_64_v2.rpm;name=git-core;unpack=0"
SRC_URI += "${URI_git-core}"
SRC_URI[git-core.sha256sum] = "d39f90d1f07abe1b04067332c7edc9f43316ef084afdd605dbadc50e5558f978"
RDEPENDS:git-core = " \
 less \
 zlib-ng-compat \
 openssh-clients \
 openssl-libs \
 bash \
 pcre2 \
 libcurl \
 glibc \
 expat \
"

URI_git-core-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/git-core-doc-2.47.3-1.el10_0.noarch.rpm;name=git-core-doc;unpack=0"
SRC_URI += "${URI_git-core-doc}"
SRC_URI[git-core-doc.sha256sum] = "74ec60b957467d9c227b9503693515cf269aeecc5ccd030e1e02e5913c4e2949"
RDEPENDS:git-core-doc = " \
 git-core \
"

URI_git-credential-libsecret = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/git-credential-libsecret-2.47.3-1.el10_0.x86_64_v2.rpm;name=git-credential-libsecret;unpack=0"
SRC_URI += "${URI_git-credential-libsecret}"
SRC_URI[git-credential-libsecret.sha256sum] = "f820d4df6b2915129acecc82ea49e63ca648e5e1b8cffb9701b848ea507026f8"
RDEPENDS:git-credential-libsecret = " \
 glibc \
 libsecret \
 git \
 glib2 \
"

URI_git-daemon = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/git-daemon-2.47.3-1.el10_0.x86_64_v2.rpm;name=git-daemon;unpack=0"
SRC_URI += "${URI_git-daemon}"
SRC_URI[git-daemon.sha256sum] = "53a1b2b43d3a5f342f7afd69393c5543587ea12e9d208de673f316babde74f20"
RDEPENDS:git-daemon = " \
 systemd \
 zlib-ng-compat \
 git-core \
 bash \
 pcre2 \
 glibc \
"

URI_git-email = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/git-email-2.47.3-1.el10_0.noarch.rpm;name=git-email;unpack=0"
SRC_URI += "${URI_git-email}"
SRC_URI[git-email.sha256sum] = "8c6984e7dc61795c0870984cc9f56616b5ea2e74d31d9f795df350e7465cce7f"
RDEPENDS:git-email = " \
 perl-libnet \
 perl-libs \
 perl-Getopt-Long \
 perl-Git \
 perl-Authen-SASL \
 perl-Sys-Hostname \
 perl-Term-ANSIColor \
 perl-Term-ReadLine \
 perl-Text-ParseWords \
 perl-IO-Socket-SSL \
 perl-lib \
 perl-MIME-Base64 \
 perl-MailTools \
 perl-Error \
 perl-Net-SMTP-SSL \
 git \
 perl-POSIX \
 perl-PathTools \
 perl-interpreter \
 perl-File-Temp \
"

URI_git-gui = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/git-gui-2.47.3-1.el10_0.noarch.rpm;name=git-gui;unpack=0"
SRC_URI += "${URI_git-gui}"
SRC_URI[git-gui.sha256sum] = "1ddc3746ab181b75687c192d57a522284b6042b46727713358699f2ed009f147"
RDEPENDS:git-gui = " \
 gitk \
 bash \
 tk \
"

URI_git-instaweb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/git-instaweb-2.47.3-1.el10_0.noarch.rpm;name=git-instaweb;unpack=0"
SRC_URI += "${URI_git-instaweb}"
SRC_URI[git-instaweb.sha256sum] = "9336710adff149893d5fb11465f959a725fb9a2d4c88e9911f579a3ebad5c4ce"
RDEPENDS:git-instaweb = " \
 git \
 bash \
 httpd \
 gitweb \
"

URI_git-subtree = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/git-subtree-2.47.3-1.el10_0.noarch.rpm;name=git-subtree;unpack=0"
SRC_URI += "${URI_git-subtree}"
SRC_URI[git-subtree.sha256sum] = "d5cc2602c6b1745bb0817accb8a6f3adf42cd1df35802ccd94f74176f2a92bc4"
RDEPENDS:git-subtree = " \
 git-core \
 bash \
"

URI_git-svn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/git-svn-2.47.3-1.el10_0.noarch.rpm;name=git-svn;unpack=0"
SRC_URI += "${URI_git-svn}"
SRC_URI[git-svn.sha256sum] = "d3c0fcf8f98a83aab5ebed395f26b8fedc8742621c9a9c058c90921514c627bb"
RDEPENDS:git-svn = " \
 perl-TermReadKey \
 git \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-Memoize \
 perl-Digest-MD5 \
 perl-Getopt-Long \
 perl-File-Basename \
 subversion \
 perl-Git \
 perl-PathTools \
 perl-Git-SVN \
 perl-interpreter \
 perl-File-Path \
 perl-lib \
"

URI_gitk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gitk-2.47.3-1.el10_0.noarch.rpm;name=gitk;unpack=0"
SRC_URI += "${URI_gitk}"
SRC_URI[gitk.sha256sum] = "45b3df6f789bdd8577a3cda2cabfe33d9d436b67ef01025b46453d25439e4bd1"
RDEPENDS:gitk = " \
 git-gui \
 git \
 bash \
 tk \
"

URI_gitweb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gitweb-2.47.3-1.el10_0.noarch.rpm;name=gitweb;unpack=0"
SRC_URI += "${URI_gitweb}"
SRC_URI[gitweb.sha256sum] = "23d2b1db94ddd27d46c82479a53f3df13c755aac952eb0817e96b4a39b09dc24"
RDEPENDS:gitweb = " \
 perl-constant \
 git \
 perl-libs \
 perl-Digest-MD5 \
 perl-Fcntl \
 perl-File-Basename \
 perl-Encode \
 perl-filetest \
 perl-File-Find \
 perl-interpreter \
 perl-CGI \
 perl-Time-HiRes \
"

URI_perl-Git = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Git-2.47.3-1.el10_0.noarch.rpm;name=perl-Git;unpack=0"
SRC_URI += "${URI_perl-Git}"
SRC_URI[perl-Git.sha256sum] = "934646f94c5315391d63ca73fefc0531bff234037a9006f559229915493a9f09"
RDEPENDS:perl-Git = " \
 perl-constant \
 git \
 perl-libs \
 perl-Git \
 perl-Error \
 perl-Exporter \
"

URI_perl-Git-SVN = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Git-SVN-2.47.3-1.el10_0.noarch.rpm;name=perl-Git-SVN;unpack=0"
SRC_URI += "${URI_perl-Git-SVN}"
SRC_URI[perl-Git-SVN.sha256sum] = "21b6dc7fbfc8c031a7a3b2b04927bbfcbdcbd090ccc316f89472284e816bda72"
RDEPENDS:perl-Git-SVN = " \
 perl-constant \
 git \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-Memoize \
 perl-Fcntl \
 perl-Storable \
 perl-POSIX \
 perl-File-Basename \
 perl-Git \
 perl-IPC-Open3 \
 subversion-perl \
 perl-YAML \
 perl-Exporter \
 perl-File-Path \
 perl-base \
 perl-Time-Local \
"
