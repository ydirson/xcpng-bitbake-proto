# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rubygem-nokogiri"
PE = "0"
PV = "1.16.4"
PR = "3.el10"
PACKAGES = "rubygem-nokogiri rubygem-nokogiri-doc"
PROVIDES = "rpm/rubygem-nokogiri rpm/rubygem-nokogiri-doc"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/rubygem-nokogiri-1.16.4-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f34e18e282043cf25ff1910cc78e2b19a34fad00662508f4e61fb80023d50318"

URI_rubygem-nokogiri = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-nokogiri-1.16.4-3.el10.x86_64_v2.rpm;name=rubygem-nokogiri;unpack=0"
SRC_URI += "${URI_rubygem-nokogiri}"
SRC_URI[rubygem-nokogiri.sha256sum] = "0fc8710809670f0ffd0fce1c22ec283a9f105cfadd9e42a1c98fde71e370560d"
RDEPENDS:rubygem-nokogiri = " \
 libxslt \
 rubygem-racc \
 ruby \
 libxml2 \
 rubygems \
 ruby-libs \
 glibc \
 coreutils \
"

URI_rubygem-nokogiri-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-nokogiri-doc-1.16.4-3.el10.x86_64_v2.rpm;name=rubygem-nokogiri-doc;unpack=0"
SRC_URI += "${URI_rubygem-nokogiri-doc}"
SRC_URI[rubygem-nokogiri-doc.sha256sum] = "0893a11ccb6a6a275e898be57ad29f5570a3fc8219aeff6d138d85146e50ab53"
RDEPENDS:rubygem-nokogiri-doc = " \
 rubygem-nokogiri \
"
