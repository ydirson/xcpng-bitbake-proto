# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rapidjson"
PE = "0"
PV = "1.1.0"
PR = "29.el10"
PACKAGES = "rapidjson-devel rapidjson-doc"
PROVIDES = "rpm/rapidjson-devel rpm/rapidjson-doc"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/rapidjson-1.1.0-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b451be40bb6fe4b7be48bf97e9ad0d710ce9b99d81bfd211a806fc5ce0e8956c"

URI_rapidjson-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rapidjson-devel-1.1.0-29.el10.x86_64_v2.rpm;name=rapidjson-devel;unpack=0"
SRC_URI += "${URI_rapidjson-devel}"
SRC_URI[rapidjson-devel.sha256sum] = "eafeac577966edb086de7cb505301f924502ae93e35fb477af58104a53f25ec3"
RDEPENDS:rapidjson-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
"

URI_rapidjson-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rapidjson-doc-1.1.0-29.el10.noarch.rpm;name=rapidjson-doc;unpack=0"
SRC_URI += "${URI_rapidjson-doc}"
SRC_URI[rapidjson-doc.sha256sum] = "faff6348bfac414e8eaa0d2152214f0e588dc5bdc760f79f3b0503c736191046"
RDEPENDS:rapidjson-doc = ""
