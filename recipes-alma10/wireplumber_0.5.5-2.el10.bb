# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "wireplumber"
PE = "0"
PV = "0.5.5"
PR = "2.el10"
PACKAGES = "wireplumber wireplumber-libs wireplumber-devel wireplumber-doc"
PROVIDES = "rpm/wireplumber rpm/wireplumber-libs rpm/wireplumber-devel rpm/wireplumber-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/wireplumber-0.5.5-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f3a12f570644393fa94f40c9fe73c9bb4394267a2abe0941b2b1805860a626a"

URI_wireplumber = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/wireplumber-0.5.5-2.el10.x86_64_v2.rpm;name=wireplumber;unpack=0"
SRC_URI += "${URI_wireplumber}"
SRC_URI[wireplumber.sha256sum] = "0783aedea24b9b416d5a0c498e14c7d92270e249fd1e1655c837da80ff282b1d"
RDEPENDS:wireplumber = " \
 libgcc \
 wireplumber-libs \
 bash \
 glib2 \
 glibc \
 pipewire-libs \
"

URI_wireplumber-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/wireplumber-libs-0.5.5-2.el10.x86_64_v2.rpm;name=wireplumber-libs;unpack=0"
SRC_URI += "${URI_wireplumber-libs}"
SRC_URI[wireplumber-libs.sha256sum] = "a252340bd0c057f550f6e14e704da5a9defa32a5f74f22e0b0a59edc44d4f233"
RDEPENDS:wireplumber-libs = " \
 systemd-libs \
 lua-libs \
 libgcc \
 glib2 \
 glibc \
 pipewire-libs \
"

URI_wireplumber-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/wireplumber-devel-0.5.5-2.el10.x86_64_v2.rpm;name=wireplumber-devel;unpack=0"
SRC_URI += "${URI_wireplumber-devel}"
SRC_URI[wireplumber-devel.sha256sum] = "e8ef5547f428ed9bb49178d8afa394b15ba3ccc3acdd7396a72bf160bf4ca1fc"
RDEPENDS:wireplumber-devel = " \
 glib2-devel \
 wireplumber \
 wireplumber-libs \
 pkgconf-pkg-config \
 pipewire-devel \
"

URI_wireplumber-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/wireplumber-doc-0.5.5-2.el10.x86_64_v2.rpm;name=wireplumber-doc;unpack=0"
SRC_URI += "${URI_wireplumber-doc}"
SRC_URI[wireplumber-doc.sha256sum] = "8d9c578c71e316928eddfe1703b56c07627daacc6d43960741de4c9879dcbeca"
RDEPENDS:wireplumber-doc = ""
