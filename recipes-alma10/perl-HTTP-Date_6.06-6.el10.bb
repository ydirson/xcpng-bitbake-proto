# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-HTTP-Date"
PE = "0"
PV = "6.06"
PR = "6.el10"
PACKAGES = "perl-HTTP-Date perl-HTTP-Date-tests"
PROVIDES = "rpm/perl-HTTP-Date rpm/perl-HTTP-Date-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-HTTP-Date-6.06-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58fa3e1dfcf155092e213f91188a8a022e830b8e0213cac96e8dc114a725bdac"

URI_perl-HTTP-Date = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-HTTP-Date-6.06-6.el10.noarch.rpm;name=perl-HTTP-Date;unpack=0"
SRC_URI += "${URI_perl-HTTP-Date}"
SRC_URI[perl-HTTP-Date.sha256sum] = "0cc9443c4ee49bb73d67a5f4d083c1cd7be05f87844db954343c2d2b51f9972b"
RDEPENDS:perl-HTTP-Date = " \
 perl-Exporter \
 perl-libs \
 perl-TimeDate \
 perl-Time-Local \
"

URI_perl-HTTP-Date-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-HTTP-Date-tests-6.06-6.el10.noarch.rpm;name=perl-HTTP-Date-tests;unpack=0"
SRC_URI += "${URI_perl-HTTP-Date-tests}"
SRC_URI[perl-HTTP-Date-tests.sha256sum] = "4c7a0d1003bcadd75d0a99fce73f64a89f73187e1fd0f346120412cddf6a402c"
RDEPENDS:perl-HTTP-Date-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 bash \
 perl-HTTP-Date \
 perl-interpreter \
"
