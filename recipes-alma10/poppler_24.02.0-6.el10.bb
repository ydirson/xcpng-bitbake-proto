# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "poppler"
PE = "0"
PV = "24.02.0"
PR = "6.el10"
PACKAGES = "poppler poppler-cpp poppler-glib poppler-qt6 poppler-utils poppler-cpp-devel poppler-devel poppler-glib-devel poppler-glib-doc poppler-qt6-devel"
PROVIDES = "rpm/poppler rpm/poppler-cpp rpm/poppler-glib rpm/poppler-qt6 rpm/poppler-utils rpm/poppler-cpp-devel rpm/poppler-devel rpm/poppler-glib-devel rpm/poppler-glib-doc rpm/poppler-qt6-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/poppler-24.02.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c48323fb56270b83fceef24ef8debd3c6459c7b4a062b4c0a4aeb3d28bfead78"

URI_poppler = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/poppler-24.02.0-6.el10.x86_64_v2.rpm;name=poppler;unpack=0"
SRC_URI += "${URI_poppler}"
SRC_URI[poppler.sha256sum] = "8a1e3b6598abdc0ddac9afc51a95ee3d8eed9030590627feb23b7ffa5ca17c7e"
RDEPENDS:poppler = " \
 zlib-ng-compat \
 nss \
 freetype \
 libpng \
 lcms2 \
 openjpeg2 \
 libgcc \
 gpgmepp \
 fontconfig \
 poppler-data \
 libstdc++ \
 libcurl \
 glibc \
 libtiff \
 libjpeg-turbo \
 nspr \
"

URI_poppler-cpp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/poppler-cpp-24.02.0-6.el10.x86_64_v2.rpm;name=poppler-cpp;unpack=0"
SRC_URI += "${URI_poppler-cpp}"
SRC_URI[poppler-cpp.sha256sum] = "29a6b27444f7ad9492a0bc9c5601f4712255d507a55c71305708aefbd4e2ddd4"
RDEPENDS:poppler-cpp = " \
 glibc \
 libgcc \
 libstdc++ \
 poppler \
"

URI_poppler-glib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/poppler-glib-24.02.0-6.el10.x86_64_v2.rpm;name=poppler-glib;unpack=0"
SRC_URI += "${URI_poppler-glib}"
SRC_URI[poppler-glib.sha256sum] = "f130d370bf624de844690c32c5dc5649417eebfa0455c49d715dfa1c9f79e2d0"
RDEPENDS:poppler-glib = " \
 freetype \
 libgcc \
 poppler \
 libstdc++ \
 cairo \
 glib2 \
 glibc \
"

URI_poppler-qt6 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/poppler-qt6-24.02.0-6.el10.x86_64_v2.rpm;name=poppler-qt6;unpack=0"
SRC_URI += "${URI_poppler-qt6}"
SRC_URI[poppler-qt6.sha256sum] = "326c32bb98fb08273d188963e9326fae53a811e3dcdc0f643d57d00147ab0d5c"
RDEPENDS:poppler-qt6 = " \
 freetype \
 lcms2 \
 libgcc \
 qt6-qtbase \
 poppler \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_poppler-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/poppler-utils-24.02.0-6.el10.x86_64_v2.rpm;name=poppler-utils;unpack=0"
SRC_URI += "${URI_poppler-utils}"
SRC_URI[poppler-utils.sha256sum] = "9de91101f9cf7d489929ad6bfebacd90a429167a1e8a70e7c4f6f731a814ddf8"
RDEPENDS:poppler-utils = " \
 freetype \
 lcms2 \
 libgcc \
 poppler \
 libstdc++ \
 cairo \
 glibc \
"

URI_poppler-cpp-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/poppler-cpp-devel-24.02.0-6.el10.x86_64_v2.rpm;name=poppler-cpp-devel;unpack=0"
SRC_URI += "${URI_poppler-cpp-devel}"
SRC_URI[poppler-cpp-devel.sha256sum] = "d01366b70af9bfa45b429be55936cb2bb5a15c9edc36f40798ce0d789e789ba1"
RDEPENDS:poppler-cpp-devel = " \
 poppler-devel \
 pkgconf-pkg-config \
 poppler-cpp \
"

URI_poppler-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/poppler-devel-24.02.0-6.el10.x86_64_v2.rpm;name=poppler-devel;unpack=0"
SRC_URI += "${URI_poppler-devel}"
SRC_URI[poppler-devel.sha256sum] = "d1e1383d1f5eddcde297b488e9f958b5f02eb52ddafe4a0d2c7f0c2a626f8c86"
RDEPENDS:poppler-devel = " \
 pkgconf-pkg-config \
 poppler \
"

URI_poppler-glib-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/poppler-glib-devel-24.02.0-6.el10.x86_64_v2.rpm;name=poppler-glib-devel;unpack=0"
SRC_URI += "${URI_poppler-glib-devel}"
SRC_URI[poppler-glib-devel.sha256sum] = "d09a3e36d6e4505d2a0d2c14ed3d26c66abaea5eb14e8f4f7a9e5ac13c02c85f"
RDEPENDS:poppler-glib-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 poppler-glib \
 poppler-devel \
 cairo-devel \
"

URI_poppler-glib-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/poppler-glib-doc-24.02.0-6.el10.noarch.rpm;name=poppler-glib-doc;unpack=0"
SRC_URI += "${URI_poppler-glib-doc}"
SRC_URI[poppler-glib-doc.sha256sum] = "0a3179808da40b578432439ecc36ad82ae1f8e12209d49cbb9e85b44b65b29a8"
RDEPENDS:poppler-glib-doc = ""

URI_poppler-qt6-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/poppler-qt6-devel-24.02.0-6.el10.x86_64_v2.rpm;name=poppler-qt6-devel;unpack=0"
SRC_URI += "${URI_poppler-qt6-devel}"
SRC_URI[poppler-qt6-devel.sha256sum] = "5f7fa7b26c1cacc94a96c82f1370f74afb72cbb30bd928f0035f061a1d8772ba"
RDEPENDS:poppler-qt6-devel = " \
 poppler-qt6 \
 poppler-devel \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
"
