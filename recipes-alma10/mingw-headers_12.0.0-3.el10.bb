# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mingw-headers"
PE = "0"
PV = "12.0.0"
PR = "3.el10"
PACKAGES = "mingw32-headers mingw64-headers ucrt64-headers"
PROVIDES = "rpm/mingw32-headers rpm/mingw64-headers rpm/ucrt64-headers"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/mingw-headers-12.0.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30b832613d5c27f31cd89f97343d8c633840fbb2f57d0648f32a39f984f06c00"

URI_mingw32-headers = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw32-headers-12.0.0-3.el10.noarch.rpm;name=mingw32-headers;unpack=0"
SRC_URI += "${URI_mingw32-headers}"
SRC_URI[mingw32-headers.sha256sum] = "11334936ad9aa2881d02871ed1819b3fbe5d5d0e8451ca85cf154c3a6d69f6d7"
RDEPENDS:mingw32-headers = " \
 mingw32-filesystem \
 mingw32-winpthreads \
"

URI_mingw64-headers = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw64-headers-12.0.0-3.el10.noarch.rpm;name=mingw64-headers;unpack=0"
SRC_URI += "${URI_mingw64-headers}"
SRC_URI[mingw64-headers.sha256sum] = "9d9e968d44f4325f96c7c3a4d9c7cfb0350ca649702c7fff1e0864bda90d067f"
RDEPENDS:mingw64-headers = " \
 mingw64-filesystem \
 mingw64-winpthreads \
"

URI_ucrt64-headers = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ucrt64-headers-12.0.0-3.el10.noarch.rpm;name=ucrt64-headers;unpack=0"
SRC_URI += "${URI_ucrt64-headers}"
SRC_URI[ucrt64-headers.sha256sum] = "611af32a1c82963de732b2a82b3bce481e7fb1200b8f8968812ecbb74ca1337b"
RDEPENDS:ucrt64-headers = " \
 ucrt64-filesystem \
 ucrt64-winpthreads \
"
