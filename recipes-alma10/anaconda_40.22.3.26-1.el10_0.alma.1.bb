# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "anaconda"
PE = "0"
PV = "40.22.3.26"
PR = "1.el10_0.alma.1"
PACKAGES = "anaconda anaconda-core anaconda-dracut anaconda-gui anaconda-install-env-deps anaconda-install-img-deps anaconda-tui anaconda-widgets anaconda-widgets-devel anaconda-live"
PROVIDES = "rpm/anaconda rpm/anaconda-core rpm/anaconda-dracut rpm/anaconda-gui rpm/anaconda-install-env-deps rpm/anaconda-install-img-deps rpm/anaconda-tui rpm/anaconda-widgets rpm/anaconda-widgets-devel rpm/anaconda-live"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/anaconda-40.22.3.26-1.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "93a029a362cadcb7bccc046d74b6d5892944eb2669b03a4a6ecea61a635cd910"

URI_anaconda = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/anaconda-40.22.3.26-1.el10_0.alma.1.x86_64_v2.rpm;name=anaconda;unpack=0"
SRC_URI += "${URI_anaconda}"
SRC_URI[anaconda.sha256sum] = "9f691e4c0b27d864d62a4af275071023a6f719157676656582abab12d8903991"
RDEPENDS:anaconda = " \
 anaconda-gui \
 anaconda-tui \
"

URI_anaconda-core = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/anaconda-core-40.22.3.26-1.el10_0.alma.1.x86_64_v2.rpm;name=anaconda-core;unpack=0"
SRC_URI += "${URI_anaconda-core}"
SRC_URI[anaconda-core.sha256sum] = "4e271a00182025350c158579d0546cea0f5b2ba6270742712cc0bc67dac47dff"
RDEPENDS:anaconda-core = " \
 python3 \
 flatpak-libs \
 systemd \
 crypto-policies \
 crypto-policies-scripts \
 NetworkManager \
 python3-dnf \
 python3-gobject-base \
 NetworkManager-libnm \
 python3-kickstart \
 python3-langtable \
 util-linux \
 python3-requests-ftp \
 python3-libselinux \
 python3-libs \
 kbd \
 glibc-langpack-en \
 dbus-daemon \
 python3-meh \
 python3-requests \
 python3-rpm \
 bash \
 python3-systemd \
 anaconda-tui \
 python3-pid \
 python3-productmd \
 python3-blivet \
 python3-blockdev \
 python3-pwquality \
 chrony \
 python3-pyparted \
 python3-dasbus \
 python3-requests-file \
 coreutils \
 cracklib-dicts \
"

URI_anaconda-dracut = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/anaconda-dracut-40.22.3.26-1.el10_0.alma.1.x86_64_v2.rpm;name=anaconda-dracut;unpack=0"
SRC_URI += "${URI_anaconda-dracut}"
SRC_URI[anaconda-dracut.sha256sum] = "462163ec13209895a8ee53cfd074a20b14f253ae84fc8ece32b5b1febdda02fa"
RDEPENDS:anaconda-dracut = " \
 python3 \
 libarchive \
 dnsconfd \
 dnsconfd-dracut \
 dracut-live \
 iputils \
 python3-kickstart \
 bash \
 dracut \
 xz \
 glibc \
 rpm-libs \
 dracut-network \
"

URI_anaconda-gui = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/anaconda-gui-40.22.3.26-1.el10_0.alma.1.x86_64_v2.rpm;name=anaconda-gui;unpack=0"
SRC_URI += "${URI_anaconda-gui}"
SRC_URI[anaconda-gui.sha256sum] = "52c711bb79c311add14c905d1b843f6c02ac92fa0bb0b9d02d12c3af75a5ad8c"
RDEPENDS:anaconda-gui = " \
 python3 \
 nm-connection-editor \
 tecla \
 NetworkManager-wifi \
 adwaita-icon-theme \
 python3-iso639 \
 anaconda-core \
 anaconda-widgets \
 almalinux-logos \
 python3-meh-gui \
 python3-xkbregistry \
"

URI_anaconda-install-env-deps = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/anaconda-install-env-deps-40.22.3.26-1.el10_0.alma.1.x86_64_v2.rpm;name=anaconda-install-env-deps;unpack=0"
SRC_URI += "${URI_anaconda-install-env-deps}"
SRC_URI[anaconda-install-env-deps.sha256sum] = "ac5da01ec784dcdea7804edcb07c892ae0135f3e4848657b85c97255279c0705"
RDEPENDS:anaconda-install-env-deps = " \
 isomd5sum \
 e2fsprogs \
 rsync \
 gdb \
 kexec-tools \
 realmd \
 libblockdev-plugins-all \
 dosfstools \
 tmux \
 xfsprogs \
 udisks2-iscsi \
"

URI_anaconda-install-img-deps = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/anaconda-install-img-deps-40.22.3.26-1.el10_0.alma.1.x86_64_v2.rpm;name=anaconda-install-img-deps;unpack=0"
SRC_URI += "${URI_anaconda-install-img-deps}"
SRC_URI[anaconda-install-img-deps.sha256sum] = "19ef0011af893d4782a31cb3f7226047f28790fc55a8a1dffd79edc0009f5e9e"
RDEPENDS:anaconda-install-img-deps = " \
 dnsconfd \
 dnsconfd-dracut \
 createrepo_c \
 brltty \
 device-mapper-multipath \
 nvme-cli \
 skopeo \
 gnome-kiosk \
 gnome-remote-desktop \
 python3-pam \
 mesa-dri-drivers \
 openssl \
 librsvg2 \
 kdump-anaconda-addon \
 zram-generator \
 rpm-ostree \
 anaconda-install-env-deps \
 fcoe-utils \
 nm-connection-editor \
 gsettings-desktop-schemas \
 ostree \
"

URI_anaconda-tui = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/anaconda-tui-40.22.3.26-1.el10_0.alma.1.x86_64_v2.rpm;name=anaconda-tui;unpack=0"
SRC_URI += "${URI_anaconda-tui}"
SRC_URI[anaconda-tui.sha256sum] = "f9481d3d12d5af1c468b05618d4e36c8e8968a139af7c9ab60b38a95e02afb20"
RDEPENDS:anaconda-tui = " \
 python3 \
 python3-simpleline \
 anaconda-core \
"

URI_anaconda-widgets = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/anaconda-widgets-40.22.3.26-1.el10_0.alma.1.x86_64_v2.rpm;name=anaconda-widgets;unpack=0"
SRC_URI += "${URI_anaconda-widgets}"
SRC_URI[anaconda-widgets.sha256sum] = "7f02061d433775c53a335e573fb0a2a7894cb20506a23776426961c354107b1e"
RDEPENDS:anaconda-widgets = " \
 python3 \
 atk \
 cairo-gobject \
 libgcc \
 harfbuzz \
 pango \
 gdk-pixbuf2 \
 cairo \
 glib2 \
 gtk3 \
 glibc \
"

URI_anaconda-widgets-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/anaconda-widgets-devel-40.22.3.26-1.el10_0.alma.1.x86_64_v2.rpm;name=anaconda-widgets-devel;unpack=0"
SRC_URI += "${URI_anaconda-widgets-devel}"
SRC_URI[anaconda-widgets-devel.sha256sum] = "5723b8ec378ff1ec193e32df3969ea1f865edd78098a50fdd32dc3f6c27ba414"
RDEPENDS:anaconda-widgets-devel = " \
 anaconda-widgets \
"

URI_anaconda-live = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/anaconda-live-40.22.3.26-1.el10_0.alma.1.noarch.rpm;name=anaconda-live;unpack=0"
SRC_URI += "${URI_anaconda-live}"
SRC_URI[anaconda-live.sha256sum] = "aa91a91639afb7fcbe4bd5d9caec2fb3e202414be4f209d0b5523d0670783dd4"
RDEPENDS:anaconda-live = " \
 anaconda-gui \
 zenity \
 bash \
 usermode \
"
