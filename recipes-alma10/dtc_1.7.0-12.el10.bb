# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dtc"
PE = "0"
PV = "1.7.0"
PR = "12.el10"
PACKAGES = "dtc libfdt libfdt-devel libfdt-static python3-libfdt"
PROVIDES = "rpm/dtc rpm/libfdt rpm/libfdt-devel rpm/libfdt-static rpm/python3-libfdt"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/dtc-1.7.0-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66843944e01bd0d55015592f719838165cb2e3ee77ab0d2d484b33cb6b9776ec"

URI_dtc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dtc-1.7.0-12.el10.x86_64_v2.rpm;name=dtc;unpack=0"
SRC_URI += "${URI_dtc}"
SRC_URI[dtc.sha256sum] = "2ec668c7959ab63f2de1146bb415a3b48221479ffdec57b604230fabd5ecc488"
RDEPENDS:dtc = " \
 glibc \
 libfdt \
 bash \
"

URI_libfdt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libfdt-1.7.0-12.el10.x86_64_v2.rpm;name=libfdt;unpack=0"
SRC_URI += "${URI_libfdt}"
SRC_URI[libfdt.sha256sum] = "f0d42dae6b8949e2197e36de267a4e1c8909c00d29f72ed7b2a4099ff2a467fe"
RDEPENDS:libfdt = " \
 glibc \
"

URI_libfdt-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libfdt-devel-1.7.0-12.el10.x86_64_v2.rpm;name=libfdt-devel;unpack=0"
SRC_URI += "${URI_libfdt-devel}"
SRC_URI[libfdt-devel.sha256sum] = "709fe5262b416d8414cd01681aca58dee4bcc5718d3f3a4c17c867bcaec65253"
RDEPENDS:libfdt-devel = " \
 libfdt \
"

URI_libfdt-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libfdt-static-1.7.0-12.el10.x86_64_v2.rpm;name=libfdt-static;unpack=0"
SRC_URI += "${URI_libfdt-static}"
SRC_URI[libfdt-static.sha256sum] = "be9b8c0ec5b1d269bcb35689e4757f0179ea5eb21b7edd49d0c5ebef2d93388b"
RDEPENDS:libfdt-static = " \
 libfdt-devel \
"

URI_python3-libfdt = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-libfdt-1.7.0-12.el10.x86_64_v2.rpm;name=python3-libfdt;unpack=0"
SRC_URI += "${URI_python3-libfdt}"
SRC_URI[python3-libfdt.sha256sum] = "296b6b399e7bffb19a1b06db269c08c10f3e4db9342b81fe7dd6c534003ced02"
RDEPENDS:python3-libfdt = " \
 glibc \
 dtc \
 python3 \
"
