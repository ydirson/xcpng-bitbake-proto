# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "targetcli"
PE = "0"
PV = "2.1.58"
PR = "3.el10"
PACKAGES = "targetcli"
PROVIDES = "rpm/targetcli"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/targetcli-2.1.58-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc29c438db0f68b559539011ed097841d8d7b936e29231466c1153575882b7af"

URI_targetcli = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/targetcli-2.1.58-3.el10.noarch.rpm;name=targetcli;unpack=0"
SRC_URI += "${URI_targetcli}"
SRC_URI[targetcli.sha256sum] = "a150aafa6e8256d088d2a7d38e5c8a32261f7a8c7603c768adf047f70a69ecc6"
RDEPENDS:targetcli = " \
 python3 \
 python3-configshell \
 python3-dbus \
 python3-six \
 python3-gobject-base \
 target-restore \
 python3-rtslib \
"
