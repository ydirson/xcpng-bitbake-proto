# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "yajl"
PE = "0"
PV = "2.1.0"
PR = "24.el10"
PACKAGES = "yajl yajl-devel"
PROVIDES = "rpm/yajl rpm/yajl-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/yajl-2.1.0-24.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97e5abdb06f7168c2c4d6c2aa8f19c62c4ddc66c5e588a004e8826874ea18042"

URI_yajl = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/yajl-2.1.0-24.el10.x86_64_v2.rpm;name=yajl;unpack=0"
SRC_URI += "${URI_yajl}"
SRC_URI[yajl.sha256sum] = "b987d051a71f81fa8f9c9a7779da10141378bcbc210dbccba87bc827aceb656f"
RDEPENDS:yajl = " \
 glibc \
"

URI_yajl-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/yajl-devel-2.1.0-24.el10.x86_64_v2.rpm;name=yajl-devel;unpack=0"
SRC_URI += "${URI_yajl-devel}"
SRC_URI[yajl-devel.sha256sum] = "e92badbb93afd3a57d90076a6e35d2932fd09987b8f48eeeb0ffa013a11cff21"
RDEPENDS:yajl-devel = " \
 yajl \
 pkgconf-pkg-config \
"
