# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-PerlIO-utf8_strict"
PE = "0"
PV = "0.010"
PR = "10.el10"
PACKAGES = "perl-PerlIO-utf8_strict perl-PerlIO-utf8_strict-tests"
PROVIDES = "rpm/perl-PerlIO-utf8_strict rpm/perl-PerlIO-utf8_strict-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-PerlIO-utf8_strict-0.010-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae40f34ad1641bef92769c9113d95517cec1a2d8f9c013c194c8d9952feaed7c"

URI_perl-PerlIO-utf8_strict = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-PerlIO-utf8_strict-0.010-10.el10.x86_64_v2.rpm;name=perl-PerlIO-utf8_strict;unpack=0"
SRC_URI += "${URI_perl-PerlIO-utf8_strict}"
SRC_URI[perl-PerlIO-utf8_strict.sha256sum] = "e20bfcc5f1b14bb1b51dd6760063cd3eaeabf283d76390dc2241744a4c15f04d"
RDEPENDS:perl-PerlIO-utf8_strict = " \
 glibc \
 perl-libs \
"

URI_perl-PerlIO-utf8_strict-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-PerlIO-utf8_strict-tests-0.010-10.el10.x86_64_v2.rpm;name=perl-PerlIO-utf8_strict-tests;unpack=0"
SRC_URI += "${URI_perl-PerlIO-utf8_strict-tests}"
SRC_URI[perl-PerlIO-utf8_strict-tests.sha256sum] = "18c8611cd90f51b2ad6b86c76fc5692107006800b85f17b92fe5f1afd393830c"
RDEPENDS:perl-PerlIO-utf8_strict-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Carp \
 perl-Test-Simple \
 perl-IO \
 perl-PerlIO-utf8_strict \
 bash \
 perl-PathTools \
 perl-interpreter \
 perl-Test-Exception \
 perl-lib \
"
