# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "snphost"
PE = "0"
PV = "0.5.0"
PR = "1.el10"
PACKAGES = "snphost"
PROVIDES = "rpm/snphost"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/snphost-0.5.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ad5600f039e82cbae5f3e9dabdbba10c79ec8732baf8dd0e77238f93e2996fb"

URI_snphost = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/snphost-0.5.0-1.el10.x86_64_v2.rpm;name=snphost;unpack=0"
SRC_URI += "${URI_snphost}"
SRC_URI[snphost.sha256sum] = "9dfbea5584e909d747bcbe049802599881285733c7967b8f8bb4a1749d81866d"
RDEPENDS:snphost = " \
 glibc \
 openssl-libs \
 libgcc \
"
