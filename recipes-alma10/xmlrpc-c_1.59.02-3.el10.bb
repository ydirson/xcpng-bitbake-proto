# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xmlrpc-c"
PE = "0"
PV = "1.59.02"
PR = "3.el10"
PACKAGES = "xmlrpc-c xmlrpc-c-apps xmlrpc-c-c++ xmlrpc-c-client++ xmlrpc-c-client xmlrpc-c-devel"
PROVIDES = "rpm/xmlrpc-c rpm/xmlrpc-c-apps rpm/xmlrpc-c-c++ rpm/xmlrpc-c-client++ rpm/xmlrpc-c-client rpm/xmlrpc-c-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/xmlrpc-c-1.59.02-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "062bd9de0458ed2f8bafee685a96f67feddf38506aced68c9e20959b73dcfa33"

URI_xmlrpc-c = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/xmlrpc-c-1.59.02-3.el10.x86_64_v2.rpm;name=xmlrpc-c;unpack=0"
SRC_URI += "${URI_xmlrpc-c}"
SRC_URI[xmlrpc-c.sha256sum] = "044654369786a3a95ef1932684e4f369709ad7c77818973d2383330051801cd5"
RDEPENDS:xmlrpc-c = " \
 glibc \
 openssl-libs \
 libgcc \
"

URI_xmlrpc-c-apps = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/xmlrpc-c-apps-1.59.02-3.el10.x86_64_v2.rpm;name=xmlrpc-c-apps;unpack=0"
SRC_URI += "${URI_xmlrpc-c-apps}"
SRC_URI[xmlrpc-c-apps.sha256sum] = "70542ec0c11de898444fe3c1ae93a04f17a2c96df1349a7c01ce945b04ee9567"
RDEPENDS:xmlrpc-c-apps = " \
 xmlrpc-c \
 xmlrpc-c-c++ \
 xmlrpc-c-client++ \
 xmlrpc-c-client \
 libgcc \
 readline \
 libstdc++ \
 glibc \
 perl-interpreter \
"

URI_xmlrpc-c-c++ = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/xmlrpc-c-c++-1.59.02-3.el10.x86_64_v2.rpm;name=xmlrpc-c-c++;unpack=0"
SRC_URI += "${URI_xmlrpc-c-c++}"
SRC_URI[xmlrpc-c-c++.sha256sum] = "1d7b1bd020e1cd8ed268be06e759a9444b4e6a7c8af1c7ac55544295060294dd"
RDEPENDS:xmlrpc-c-c++ = " \
 glibc \
 xmlrpc-c \
 libgcc \
 libstdc++ \
"

URI_xmlrpc-c-client++ = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/xmlrpc-c-client++-1.59.02-3.el10.x86_64_v2.rpm;name=xmlrpc-c-client++;unpack=0"
SRC_URI += "${URI_xmlrpc-c-client++}"
SRC_URI[xmlrpc-c-client++.sha256sum] = "78692ad696c51f13b6b3a7af691e7a12815ebd57c050306a0ccdd353b9414668"
RDEPENDS:xmlrpc-c-client++ = " \
 xmlrpc-c \
 xmlrpc-c-c++ \
 xmlrpc-c-client \
 libgcc \
 libstdc++ \
 glibc \
"

URI_xmlrpc-c-client = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/xmlrpc-c-client-1.59.02-3.el10.x86_64_v2.rpm;name=xmlrpc-c-client;unpack=0"
SRC_URI += "${URI_xmlrpc-c-client}"
SRC_URI[xmlrpc-c-client.sha256sum] = "6ffecc536828a6424158be299c97376b6c0cc011220608bfd5d2ef93c4d75c57"
RDEPENDS:xmlrpc-c-client = " \
 glibc \
 xmlrpc-c \
 libcurl \
"

URI_xmlrpc-c-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/xmlrpc-c-devel-1.59.02-3.el10.x86_64_v2.rpm;name=xmlrpc-c-devel;unpack=0"
SRC_URI += "${URI_xmlrpc-c-devel}"
SRC_URI[xmlrpc-c-devel.sha256sum] = "0052eb04219a6d13b9997bd65d37f5650e85a217d4d13a4433ba9e0b43919cc2"
RDEPENDS:xmlrpc-c-devel = " \
 xmlrpc-c \
 xmlrpc-c-c++ \
 xmlrpc-c-client++ \
 xmlrpc-c-client \
 xmlrpc-c-devel \
 pkgconf-pkg-config \
 bash \
"
