# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "package-notes"
PE = "0"
PV = "0.5"
PR = "13.el10"
PACKAGES = "package-notes-srpm-macros"
PROVIDES = "rpm/package-notes-srpm-macros"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/package-notes-0.5-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8afd1377c0cf89a5cf02ff14a34e8508ce2fac1b99fb19a4b63474686897622f"

URI_package-notes-srpm-macros = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/package-notes-srpm-macros-0.5-13.el10.noarch.rpm;name=package-notes-srpm-macros;unpack=0"
SRC_URI += "${URI_package-notes-srpm-macros}"
SRC_URI[package-notes-srpm-macros.sha256sum] = "a0f267a35fa2d5fb57a4310cffac67849794e005e40b4d2a24e83e71647ce0cf"
RDEPENDS:package-notes-srpm-macros = ""
