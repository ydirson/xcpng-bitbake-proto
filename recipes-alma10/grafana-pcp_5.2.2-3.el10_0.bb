# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "grafana-pcp"
PE = "0"
PV = "5.2.2"
PR = "3.el10_0"
PACKAGES = "grafana-pcp"
PROVIDES = "rpm/grafana-pcp"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/grafana-pcp-5.2.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ad8fd29d47b99043fe662cceba95c080a0340285f6c3fb6998f08779e36176b"

URI_grafana-pcp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/grafana-pcp-5.2.2-3.el10_0.x86_64_v2.rpm;name=grafana-pcp;unpack=0"
SRC_URI += "${URI_grafana-pcp}"
SRC_URI[grafana-pcp.sha256sum] = "fa4c1ed7ba2906c223fc707be9a09776510b094cf09dad0aeb0ab5bd0cc078df"
RDEPENDS:grafana-pcp = " \
 glibc \
 grafana \
 systemd \
 bash \
"
