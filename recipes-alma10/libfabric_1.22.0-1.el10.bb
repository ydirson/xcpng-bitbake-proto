# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libfabric"
PE = "0"
PV = "1.22.0"
PR = "1.el10"
PACKAGES = "libfabric libfabric-devel"
PROVIDES = "rpm/libfabric rpm/libfabric-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libfabric-1.22.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09f7ce7ba4d6e9fa64a7578f8decc20280fb8235b5cc35cbe96a3aeac4f19143"

URI_libfabric = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libfabric-1.22.0-1.el10.x86_64_v2.rpm;name=libfabric;unpack=0"
SRC_URI += "${URI_libfabric}"
SRC_URI[libfabric.sha256sum] = "e5fab8574eae8e42c0aa4e7e994ecfc8be1893ea501a5831fa5555f5afab84b9"
RDEPENDS:libfabric = " \
 glibc \
 libnl3 \
 libibverbs \
 librdmacm \
"

URI_libfabric-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libfabric-devel-1.22.0-1.el10.x86_64_v2.rpm;name=libfabric-devel;unpack=0"
SRC_URI += "${URI_libfabric-devel}"
SRC_URI[libfabric-devel.sha256sum] = "a441b71031cb4b709d26c34d19315ecd742ab6e7ba3d1d1280bf2c9c053c18b5"
RDEPENDS:libfabric-devel = " \
 libfabric \
 pkgconf-pkg-config \
"
