# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "chkconfig"
PE = "0"
PV = "1.30"
PR = "2.el10"
PACKAGES = "alternatives chkconfig ntsysv"
PROVIDES = "rpm/alternatives rpm/chkconfig rpm/ntsysv"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/chkconfig-1.30-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6738a6bc28c8f6f3f30a7fedd72e1cdaf78738168a2032e5b8fab9f704c6691b"

URI_alternatives = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/alternatives-1.30-2.el10.x86_64_v2.rpm;name=alternatives;unpack=0"
SRC_URI += "${URI_alternatives}"
SRC_URI[alternatives.sha256sum] = "598c955ec1ce6285ea0ac448d0145313f6fad770334945faf82abfd580af2ce6"
RDEPENDS:alternatives = " \
 glibc \
"

URI_chkconfig = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/chkconfig-1.30-2.el10.x86_64_v2.rpm;name=chkconfig;unpack=0"
SRC_URI += "${URI_chkconfig}"
SRC_URI[chkconfig.sha256sum] = "452c0b0baea9fa1e804a70bcb3c02bdcc3b176efd5d811cb4d535e4cd007a674"
RDEPENDS:chkconfig = " \
 glibc \
 libselinux \
 popt \
"

URI_ntsysv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ntsysv-1.30-2.el10.x86_64_v2.rpm;name=ntsysv;unpack=0"
SRC_URI += "${URI_ntsysv}"
SRC_URI[ntsysv.sha256sum] = "b6c4a0204c1a9a5f7b16ab7115b5c4d9ff73f0ffccd4814c6117b07fcb85581c"
RDEPENDS:ntsysv = " \
 newt \
 chkconfig \
 popt \
 glibc \
 libselinux \
"
