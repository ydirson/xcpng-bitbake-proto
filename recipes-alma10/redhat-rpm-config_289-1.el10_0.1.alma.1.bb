# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "redhat-rpm-config"
PE = "0"
PV = "289"
PR = "1.el10_0.1.alma.1"
PACKAGES = "redhat-rpm-config"
PROVIDES = "rpm/redhat-rpm-config"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/redhat-rpm-config-289-1.el10_0.1.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87c036ab4438e2964b9328ce4c01a647ded42e3629d8bcd64bc979ca6b8dd3e2"

URI_redhat-rpm-config = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/redhat-rpm-config-289-1.el10_0.1.alma.1.noarch.rpm;name=redhat-rpm-config;unpack=0"
SRC_URI += "${URI_redhat-rpm-config}"
SRC_URI[redhat-rpm-config.sha256sum] = "19c6030fe76c83d7fbdecdcdce28f14dc9f22dc40fc83b082f82565a357ca300"
RDEPENDS:redhat-rpm-config = " \
 package-notes-srpm-macros \
 dwz \
 fonts-srpm-macros \
 forge-srpm-macros \
 efi-srpm-macros \
 lua-srpm-macros \
 perl-srpm-macros \
 ocaml-srpm-macros \
 qt6-srpm-macros \
 sed \
 gcc-plugin-annobin \
 openblas-srpm-macros \
 zip \
 rust-toolset-srpm-macros \
 grep \
 pyproject-srpm-macros \
 kernel-srpm-macros \
 python-srpm-macros \
 bash \
 file \
 findutils \
 annobin-plugin-gcc \
 gawk \
 go-srpm-macros \
 llvm \
 coreutils \
 rpm \
"
