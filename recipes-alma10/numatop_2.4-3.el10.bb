# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "numatop"
PE = "0"
PV = "2.4"
PR = "3.el10"
PACKAGES = "numatop"
PROVIDES = "rpm/numatop"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/numatop-2.4-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7a0533209cdc30348211f23d4ce1744ddccc25ad3fab2c3d23fd5189417a3d2"

URI_numatop = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/numatop-2.4-3.el10.x86_64_v2.rpm;name=numatop;unpack=0"
SRC_URI += "${URI_numatop}"
SRC_URI[numatop.sha256sum] = "dd11b92098d19fd8fa5e970d83cec276c44ef09dd305714bce060af6bf16dfe7"
RDEPENDS:numatop = " \
 glibc \
 ncurses-libs \
 numactl-libs \
"
