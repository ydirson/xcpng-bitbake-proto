# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ethtool"
PE = "2"
PV = "6.11"
PR = "5.el10_0"
PACKAGES = "ethtool"
PROVIDES = "rpm/ethtool"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/ethtool-6.11-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e5d0310f6e4ee4e3db70df260e837918815a3d177b753b36aceca5a5b02fa4d"

URI_ethtool = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/ethtool-6.11-5.el10_0.x86_64_v2.rpm;name=ethtool;unpack=0"
SRC_URI += "${URI_ethtool}"
SRC_URI[ethtool.sha256sum] = "f55c58f552ccab84f2634d08c4874e7f5ea3122e6a6c6a04de87c592a6f39ed2"
RDEPENDS:ethtool = " \
 glibc \
 libmnl \
"
