# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "almalinux-logos"
PE = "0"
PV = "100.3"
PR = "3.el10_0"
PACKAGES = "almalinux-backgrounds almalinux-logos almalinux-logos-httpd almalinux-logos-ipa"
PROVIDES = "rpm/almalinux-backgrounds rpm/almalinux-logos rpm/almalinux-logos-httpd rpm/almalinux-logos-ipa"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/almalinux-logos-100.3-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a735fb00d5a93fc53fa68fe3bab780605bb1f99706e5ed381e2e3fa557b7717"

URI_almalinux-backgrounds = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/almalinux-backgrounds-100.3-3.el10_0.noarch.rpm;name=almalinux-backgrounds;unpack=0"
SRC_URI += "${URI_almalinux-backgrounds}"
SRC_URI[almalinux-backgrounds.sha256sum] = "c4287a092c2d0ead9f40f022fe09154ffec180306484aab073769886c5a32a48"
RDEPENDS:almalinux-backgrounds = " \
 almalinux-logos \
"

URI_almalinux-logos = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/almalinux-logos-100.3-3.el10_0.x86_64_v2.rpm;name=almalinux-logos;unpack=0"
SRC_URI += "${URI_almalinux-logos}"
SRC_URI[almalinux-logos.sha256sum] = "4dc7fa14258df00d60a745f884d9a385ccc55000264012a643487e92b5d62fa4"
RDEPENDS:almalinux-logos = " \
 coreutils \
 bash \
"

URI_almalinux-logos-httpd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/almalinux-logos-httpd-100.3-3.el10_0.noarch.rpm;name=almalinux-logos-httpd;unpack=0"
SRC_URI += "${URI_almalinux-logos-httpd}"
SRC_URI[almalinux-logos-httpd.sha256sum] = "23511b0a83de40537fcce34f48936fb54d7de59251424be5c4220dd3ebd3dd87"
RDEPENDS:almalinux-logos-httpd = ""

URI_almalinux-logos-ipa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/almalinux-logos-ipa-100.3-3.el10_0.noarch.rpm;name=almalinux-logos-ipa;unpack=0"
SRC_URI += "${URI_almalinux-logos-ipa}"
SRC_URI[almalinux-logos-ipa.sha256sum] = "704a29c458ac77400fbfad97c4aa125dc091e73578fccca0656f201e0d29fb07"
RDEPENDS:almalinux-logos-ipa = ""
