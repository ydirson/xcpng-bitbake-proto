# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-App-cpanminus"
PE = "0"
PV = "1.7047"
PR = "6.el10"
PACKAGES = "perl-App-cpanminus perl-App-cpanminus-tests"
PROVIDES = "rpm/perl-App-cpanminus rpm/perl-App-cpanminus-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-App-cpanminus-1.7047-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa4ebf8c6e83f1c1e680168507cb892f9f816dcf1178a1773c735430c84e6f56"

URI_perl-App-cpanminus = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-App-cpanminus-1.7047-6.el10.noarch.rpm;name=perl-App-cpanminus;unpack=0"
SRC_URI += "${URI_perl-App-cpanminus}"
SRC_URI[perl-App-cpanminus.sha256sum] = "de5bebbfbda01880be77a2be5d82bdcbe19ef9dae08a160132066719a06f91e6"
RDEPENDS:perl-App-cpanminus = " \
 perl-File-pushd \
 perl-Safe \
 perl-libs \
 perl-local-lib \
 perl \
 perl-App-cpanminus \
 perl-Getopt-Long \
 perl-String-ShellQuote \
 perl-Symbol \
 perl-HTTP-Tiny \
 perl-CPAN-DistnameInfo \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Check \
 perl-CPAN-Meta-Requirements \
 perl-CPAN-Meta-YAML \
 perl-version \
 perl-Module-Build \
 perl-Digest-SHA \
 perl-Module-CoreList \
 perl-Module-CPANfile \
 perl-Module-Metadata \
 perl-YAML \
 perl-constant \
 perl-ExtUtils-Install \
 perl-ExtUtils-MakeMaker \
 perl-ExtUtils-Manifest \
 perl-File-Basename \
 perl-File-Copy \
 perl-PathTools \
 perl-Parse-PMFile \
 perl-File-Find \
 perl-interpreter \
 perl-File-Path \
 perl-File-Temp \
"

URI_perl-App-cpanminus-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-App-cpanminus-tests-1.7047-6.el10.noarch.rpm;name=perl-App-cpanminus-tests;unpack=0"
SRC_URI += "${URI_perl-App-cpanminus-tests}"
SRC_URI[perl-App-cpanminus-tests.sha256sum] = "3e61e5a3b2922377dcf8a94362818c0ddc0921c1d7399b2fb0c09599fba95bfb"
RDEPENDS:perl-App-cpanminus-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-App-cpanminus \
 bash \
 perl-interpreter \
"
