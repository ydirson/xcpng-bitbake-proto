# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xml-commons-resolver"
PE = "0"
PV = "1.2"
PR = "45.el10"
PACKAGES = "xml-commons-resolver xml-commons-resolver-javadoc"
PROVIDES = "rpm/xml-commons-resolver rpm/xml-commons-resolver-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xml-commons-resolver-1.2-45.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e944511155728b7eeef15df98a1191f4120edcf21d562f7b91b27ba479a0771f"

URI_xml-commons-resolver = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xml-commons-resolver-1.2-45.el10.noarch.rpm;name=xml-commons-resolver;unpack=0"
SRC_URI += "${URI_xml-commons-resolver}"
SRC_URI[xml-commons-resolver.sha256sum] = "c86597ee0dde746146895241c421dca6c7eec24b1b3de920bf35619c54410189"
RDEPENDS:xml-commons-resolver = " \
 bash \
 javapackages-filesystem \
 javapackages-tools \
"

URI_xml-commons-resolver-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xml-commons-resolver-javadoc-1.2-45.el10.noarch.rpm;name=xml-commons-resolver-javadoc;unpack=0"
SRC_URI += "${URI_xml-commons-resolver-javadoc}"
SRC_URI[xml-commons-resolver-javadoc.sha256sum] = "19c560506178df1394cb46961c00e66f3605c761ae77d69e59db703249a55213"
RDEPENDS:xml-commons-resolver-javadoc = " \
 javapackages-filesystem \
"
