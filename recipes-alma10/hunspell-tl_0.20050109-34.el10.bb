# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-tl"
PE = "0"
PV = "0.20050109"
PR = "34.el10"
PACKAGES = "hunspell-tl"
PROVIDES = "rpm/hunspell-tl"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-tl-0.20050109-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc654a91b21646a47e4b7a998ba787478eafb458543e48b939e92d73bf585390"

URI_hunspell-tl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-tl-0.20050109-34.el10.noarch.rpm;name=hunspell-tl;unpack=0"
SRC_URI += "${URI_hunspell-tl}"
SRC_URI[hunspell-tl.sha256sum] = "13fb798c596794665e7373962ae6d7564574c0c67e58190eb8da02bdf9b18ada"
RDEPENDS:hunspell-tl = " \
 hunspell-filesystem \
"
