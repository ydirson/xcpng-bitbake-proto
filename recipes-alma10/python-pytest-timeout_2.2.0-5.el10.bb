# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-pytest-timeout"
PE = "0"
PV = "2.2.0"
PR = "5.el10"
PACKAGES = "python3-pytest-timeout"
PROVIDES = "rpm/python3-pytest-timeout"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/python-pytest-timeout-2.2.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7dffe56d5c404a66a7f5fc7607774a048c622553bdf1a817f93509dab564a655"

URI_python3-pytest-timeout = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-pytest-timeout-2.2.0-5.el10.noarch.rpm;name=python3-pytest-timeout;unpack=0"
SRC_URI += "${URI_python3-pytest-timeout}"
SRC_URI[python3-pytest-timeout.sha256sum] = "7cca6422d1ce54ce54d9cf675ecb3dd709b0775a4b3ac79a4eb7d365f2cd1b9f"
RDEPENDS:python3-pytest-timeout = " \
 python3 \
 python3-pytest \
"
