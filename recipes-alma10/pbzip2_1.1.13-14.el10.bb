# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pbzip2"
PE = "0"
PV = "1.1.13"
PR = "14.el10"
PACKAGES = "pbzip2"
PROVIDES = "rpm/pbzip2"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/pbzip2-1.1.13-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff0bdd203318cd71ef98c41ba4617351d39e169b8ea9578893449c9bd0028a6b"

URI_pbzip2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pbzip2-1.1.13-14.el10.x86_64_v2.rpm;name=pbzip2;unpack=0"
SRC_URI += "${URI_pbzip2}"
SRC_URI[pbzip2.sha256sum] = "1a909431f2ca31a1de9f7d7b55859acc6cd54ed603a89bed5f5e27da5fc6a4d8"
RDEPENDS:pbzip2 = " \
 glibc \
 bzip2-libs \
 libgcc \
 libstdc++ \
"
