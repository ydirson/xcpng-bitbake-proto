# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-XML-Parser"
PE = "0"
PV = "2.47"
PR = "6.el10"
PACKAGES = "perl-XML-Parser perl-XML-Parser-tests"
PROVIDES = "rpm/perl-XML-Parser rpm/perl-XML-Parser-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-XML-Parser-2.47-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54075e7d91472179c0820b9a6d0550ca34e61170c7288fa5e83d0bf2de955527"

URI_perl-XML-Parser = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-XML-Parser-2.47-6.el10.x86_64_v2.rpm;name=perl-XML-Parser;unpack=0"
SRC_URI += "${URI_perl-XML-Parser}"
SRC_URI[perl-XML-Parser.sha256sum] = "b63e4b9496bab505d3abb27f303ff6a7fb718520007e5cd970a96f463a428b65"
RDEPENDS:perl-XML-Parser = " \
 perl-libs \
 perl-Carp \
 perl-libwww-perl \
 perl-IO \
 perl-URI \
 perl-overload \
 perl-PathTools \
 expat \
 glibc \
"

URI_perl-XML-Parser-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-XML-Parser-tests-2.47-6.el10.x86_64_v2.rpm;name=perl-XML-Parser-tests;unpack=0"
SRC_URI += "${URI_perl-XML-Parser-tests}"
SRC_URI[perl-XML-Parser-tests.sha256sum] = "3993028bf72f4e395d7fbcffc46bfca853a59e6b3f77d4c5f64504107acc1b86"
RDEPENDS:perl-XML-Parser-tests = " \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-FileHandle \
 perl-IO \
 perl-XML-Parser \
 bash \
 perl-if \
 perl-interpreter \
"
