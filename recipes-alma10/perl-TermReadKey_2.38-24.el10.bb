# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-TermReadKey"
PE = "0"
PV = "2.38"
PR = "24.el10"
PACKAGES = "perl-TermReadKey perl-TermReadKey-tests"
PROVIDES = "rpm/perl-TermReadKey rpm/perl-TermReadKey-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-TermReadKey-2.38-24.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "949d4f9ee3c24f92a7e6f1b73971f677db3f171f0fe700b58f5fe5aa58d5ed5a"

URI_perl-TermReadKey = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-TermReadKey-2.38-24.el10.x86_64_v2.rpm;name=perl-TermReadKey;unpack=0"
SRC_URI += "${URI_perl-TermReadKey}"
SRC_URI[perl-TermReadKey.sha256sum] = "19e473c79b303a8182316ca0f05e1bb65a847f867a9eacb207b9b87c96cd97d9"
RDEPENDS:perl-TermReadKey = " \
 perl-libs \
 perl-vars \
 perl-DynaLoader \
 glibc \
 perl-Exporter \
"

URI_perl-TermReadKey-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-TermReadKey-tests-2.38-24.el10.x86_64_v2.rpm;name=perl-TermReadKey-tests;unpack=0"
SRC_URI += "${URI_perl-TermReadKey-tests}"
SRC_URI[perl-TermReadKey-tests.sha256sum] = "8415f668021ecbca38e42641c1d5f32dbc2eb43563c9cb02fcc998b0de19ee14"
RDEPENDS:perl-TermReadKey-tests = " \
 perl-TermReadKey \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Fcntl \
 bash \
 perl-interpreter \
"
