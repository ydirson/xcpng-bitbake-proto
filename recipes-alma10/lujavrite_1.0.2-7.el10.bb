# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lujavrite"
PE = "0"
PV = "1.0.2"
PR = "7.el10"
PACKAGES = "lujavrite"
PROVIDES = "rpm/lujavrite"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/lujavrite-1.0.2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f87c27a0d334cdfecb4e206b30f1b5322f29f7ca213e765f6a641423750ad479"

URI_lujavrite = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/lujavrite-1.0.2-7.el10.x86_64_v2.rpm;name=lujavrite;unpack=0"
SRC_URI += "${URI_lujavrite}"
SRC_URI[lujavrite.sha256sum] = "d18af481f117328cdd41a80e2550c2a16deb1811e5a5e121d436ffa86ff0fc7b"
RDEPENDS:lujavrite = " \
 glibc \
 lua-libs \
"
