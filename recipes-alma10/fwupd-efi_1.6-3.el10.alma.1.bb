# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "fwupd-efi"
PE = "0"
PV = "1.6"
PR = "3.el10.alma.1"
PACKAGES = "fwupd-efi"
PROVIDES = "rpm/fwupd-efi"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/fwupd-efi-1.6-3.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92f5861a9f6dbc1e90970fa81db8581eb1a1bc4a6f909b5e29475230320c1cb7"

URI_fwupd-efi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/fwupd-efi-1.6-3.el10.alma.1.x86_64_v2.rpm;name=fwupd-efi;unpack=0"
SRC_URI += "${URI_fwupd-efi}"
SRC_URI[fwupd-efi.sha256sum] = "16bb17c4f4af334c8d9292c58e9dff12316e01a54eb4c646bfc1a90358e68155"
RDEPENDS:fwupd-efi = " \
 pkgconf-pkg-config \
"
