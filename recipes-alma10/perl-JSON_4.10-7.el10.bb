# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-JSON"
PE = "0"
PV = "4.10"
PR = "7.el10"
PACKAGES = "perl-JSON perl-JSON-tests"
PROVIDES = "rpm/perl-JSON rpm/perl-JSON-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-JSON-4.10-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86caccd8adc963f45b43bcc5e0b8643acc2bf72ef144e969be79c67074fba57a"

URI_perl-JSON = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-JSON-4.10-7.el10.noarch.rpm;name=perl-JSON;unpack=0"
SRC_URI += "${URI_perl-JSON}"
SRC_URI[perl-JSON.sha256sum] = "ae083a79d5a059143a0b86a3c5e2788895f41e6833b5553b70440b4875e62c53"
RDEPENDS:perl-JSON = " \
 perl-constant \
 perl-Math-BigInt \
 perl-libs \
 perl-Carp \
 perl-Encode \
 perl-overload \
 perl-B \
 perl-Exporter \
"

URI_perl-JSON-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-JSON-tests-4.10-7.el10.noarch.rpm;name=perl-JSON-tests;unpack=0"
SRC_URI += "${URI_perl-JSON-tests}"
SRC_URI[perl-JSON-tests.sha256sum] = "56f798f11b28cb8c69793e759c5909e0f31989baad4952a387925b8c018aab56"
RDEPENDS:perl-JSON-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-vars \
 perl-Tie-IxHash \
 perl-Encode \
 perl-overload \
 bash \
 perl-JSON \
 perl-Tie \
 coreutils \
 perl-interpreter \
 perl-Data-Dumper \
"
