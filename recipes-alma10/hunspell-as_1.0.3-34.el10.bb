# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-as"
PE = "0"
PV = "1.0.3"
PR = "34.el10"
PACKAGES = "hunspell-as"
PROVIDES = "rpm/hunspell-as"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-as-1.0.3-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9638bc19f8b9acb60ee4e8855a103ae77293c45fdf4e6536b196cd3b715007f0"

URI_hunspell-as = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-as-1.0.3-34.el10.noarch.rpm;name=hunspell-as;unpack=0"
SRC_URI += "${URI_hunspell-as}"
SRC_URI[hunspell-as.sha256sum] = "189e9868596f3aa39360df6e849ddb53b41e782ea720e341220ef436eb293d9b"
RDEPENDS:hunspell-as = " \
 hunspell-filesystem \
"
