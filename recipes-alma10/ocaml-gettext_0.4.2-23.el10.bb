# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ocaml-gettext"
PE = "0"
PV = "0.4.2"
PR = "23.el10"
PACKAGES = "ocaml-gettext ocaml-gettext-devel"
PROVIDES = "rpm/ocaml-gettext rpm/ocaml-gettext-devel"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/ocaml-gettext-0.4.2-23.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18ee157a3518214f15e0f920f494a678ee8f86cf288124a70a768bf4c173b1d6"

URI_ocaml-gettext = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-gettext-0.4.2-23.el10.x86_64_v2.rpm;name=ocaml-gettext;unpack=0"
SRC_URI += "${URI_ocaml-gettext}"
SRC_URI[ocaml-gettext.sha256sum] = "346c157c83bfceec1e08fc2b7d191a95413db209912f855c950423f3284cea0b"
RDEPENDS:ocaml-gettext = " \
 glibc \
 ocaml-runtime \
 ocaml-fileutils \
"

URI_ocaml-gettext-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-gettext-devel-0.4.2-23.el10.x86_64_v2.rpm;name=ocaml-gettext-devel;unpack=0"
SRC_URI += "${URI_ocaml-gettext-devel}"
SRC_URI[ocaml-gettext-devel.sha256sum] = "197c5df1fe37d6bb90930daea92e02c96bb461b30e3c4fb0d298b34eb3fea1e5"
RDEPENDS:ocaml-gettext-devel = " \
 ocaml-runtime \
 ocaml \
 ocaml-fileutils \
 ocaml-fileutils-devel \
 libzstd \
 ocaml-gettext \
 glibc \
"
