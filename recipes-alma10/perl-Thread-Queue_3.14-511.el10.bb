# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Thread-Queue"
PE = "0"
PV = "3.14"
PR = "511.el10"
PACKAGES = "perl-Thread-Queue perl-Thread-Queue-tests"
PROVIDES = "rpm/perl-Thread-Queue rpm/perl-Thread-Queue-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Thread-Queue-3.14-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9c5da5c4b6877ce9e121008fb4d5ce4ad63d8761ff80ab38ee875dc6daefdce"

URI_perl-Thread-Queue = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Thread-Queue-3.14-511.el10.noarch.rpm;name=perl-Thread-Queue;unpack=0"
SRC_URI += "${URI_perl-Thread-Queue}"
SRC_URI[perl-Thread-Queue.sha256sum] = "d797fbefb163376189a49252c6cb0f7a53f6a66d31c5fece7e6039fa36d6b703"
RDEPENDS:perl-Thread-Queue = " \
 perl-threads-shared \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
"

URI_perl-Thread-Queue-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Thread-Queue-tests-3.14-511.el10.noarch.rpm;name=perl-Thread-Queue-tests;unpack=0"
SRC_URI += "${URI_perl-Thread-Queue-tests}"
SRC_URI[perl-Thread-Queue-tests.sha256sum] = "1365880a0f130d712275c2d864446ede67656e30ad77b0914344b6b071055ffe"
RDEPENDS:perl-Thread-Queue-tests = " \
 perl-threads \
 perl-threads-shared \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Scalar-List-Utils \
 perl-Thread-Queue \
 bash \
 perl-Thread-Semaphore \
 perl-interpreter \
 perl-Exporter \
"
