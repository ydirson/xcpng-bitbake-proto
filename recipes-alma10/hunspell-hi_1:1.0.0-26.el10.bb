# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-hi"
PE = "1"
PV = "1.0.0"
PR = "26.el10"
PACKAGES = "hunspell-hi"
PROVIDES = "rpm/hunspell-hi"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-hi-1.0.0-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4feeced296f1f0e67f8ee839d8b4612404d7ff8be04468743d58cd2ee701b5a"

URI_hunspell-hi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-hi-1.0.0-26.el10.noarch.rpm;name=hunspell-hi;unpack=0"
SRC_URI += "${URI_hunspell-hi}"
SRC_URI[hunspell-hi.sha256sum] = "2138a0a84f487196d5b5c0786662f116a6cfb4e61bb7b4a2da8bf0d980a5970a"
RDEPENDS:hunspell-hi = " \
 hunspell-filesystem \
"
