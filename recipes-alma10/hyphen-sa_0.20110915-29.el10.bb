# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-sa"
PE = "0"
PV = "0.20110915"
PR = "29.el10"
PACKAGES = "hyphen-sa"
PROVIDES = "rpm/hyphen-sa"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-sa-0.20110915-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e1d810606164af47077d0cca739cc0e960d659ac051ad9d285bd893c875e1f9"

URI_hyphen-sa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-sa-0.20110915-29.el10.noarch.rpm;name=hyphen-sa;unpack=0"
SRC_URI += "${URI_hyphen-sa}"
SRC_URI[hyphen-sa.sha256sum] = "90e62fc3482f2814f07b94e92f730b07d55e1718cf906818dd193bf60f8a580a"
RDEPENDS:hyphen-sa = " \
 hyphen \
"
