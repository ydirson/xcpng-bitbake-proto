# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libfaketime"
PE = "0"
PV = "0.9.10"
PR = "11.el10"
PACKAGES = "libfaketime"
PROVIDES = "rpm/libfaketime"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/libfaketime-0.9.10-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b9a7c6ea58e5ab04784be0dd5bff9db24cf9863ec3ccf7ac95245a465639cdd"

URI_libfaketime = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libfaketime-0.9.10-11.el10.x86_64_v2.rpm;name=libfaketime;unpack=0"
SRC_URI += "${URI_libfaketime}"
SRC_URI[libfaketime.sha256sum] = "c5de66d4f076c091c1ba171c85dc2669ebec128f4797eb2e413f6526ce7999f2"
RDEPENDS:libfaketime = " \
 glibc \
 libgcc \
"
