# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-File-Temp"
PE = "1"
PV = "0.231.100"
PR = "512.el10"
PACKAGES = "perl-File-Temp perl-File-Temp-tests"
PROVIDES = "rpm/perl-File-Temp rpm/perl-File-Temp-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-File-Temp-0.231.100-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "549d48bda88a3b10e59bd28099a5c54edd04165db53f8e0805cc01a061bea5ea"

URI_perl-File-Temp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-File-Temp-0.231.100-512.el10.noarch.rpm;name=perl-File-Temp;unpack=0"
SRC_URI += "${URI_perl-File-Temp}"
SRC_URI[perl-File-Temp.sha256sum] = "f75fdad502e0d6efe61c5831dcf11f1fea523e167ccba431eb05d0600365722f"
RDEPENDS:perl-File-Temp = " \
 perl-constant \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-IO \
 perl-Fcntl \
 perl-POSIX \
 perl-overload \
 perl-PathTools \
 perl-parent \
 perl-Errno \
 perl-Exporter \
 perl-File-Path \
"

URI_perl-File-Temp-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-File-Temp-tests-0.231.100-512.el10.noarch.rpm;name=perl-File-Temp-tests;unpack=0"
SRC_URI += "${URI_perl-File-Temp-tests}"
SRC_URI[perl-File-Temp-tests.sha256sum] = "52909bbfd6a9eb005c52bed21851c53cde94686808958d62e4163482edf27c9e"
RDEPENDS:perl-File-Temp-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-ExtUtils-MakeMaker \
 perl-FileHandle \
 perl-Fcntl \
 bash \
 perl-PathTools \
 perl-interpreter \
 perl-File-Path \
 perl-File-Temp \
"
