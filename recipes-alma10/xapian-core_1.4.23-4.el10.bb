# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xapian-core"
PE = "0"
PV = "1.4.23"
PR = "4.el10"
PACKAGES = "xapian-core xapian-core-libs xapian-core-devel"
PROVIDES = "rpm/xapian-core rpm/xapian-core-libs rpm/xapian-core-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xapian-core-1.4.23-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52a5d3966a98eef174e5e344321c60e15d2ba9e6ade3aa238b8050c7a76ca3a5"

URI_xapian-core = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xapian-core-1.4.23-4.el10.x86_64_v2.rpm;name=xapian-core;unpack=0"
SRC_URI += "${URI_xapian-core}"
SRC_URI[xapian-core.sha256sum] = "283d8d552cddcb2effd432eca84cf812f6cf0403a4d4303cb4938a503865e330"
RDEPENDS:xapian-core = " \
 libgcc \
 xapian-core-libs \
 libstdc++ \
 bash \
 glibc \
"

URI_xapian-core-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xapian-core-libs-1.4.23-4.el10.x86_64_v2.rpm;name=xapian-core-libs;unpack=0"
SRC_URI += "${URI_xapian-core-libs}"
SRC_URI[xapian-core-libs.sha256sum] = "51760d93f659f31530da608d33de1bdaeac01662a58b3b98815fc478c7763197"
RDEPENDS:xapian-core-libs = " \
 libuuid \
 zlib-ng-compat \
 libgcc \
 libstdc++ \
 glibc \
"

URI_xapian-core-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xapian-core-devel-1.4.23-4.el10.x86_64_v2.rpm;name=xapian-core-devel;unpack=0"
SRC_URI += "${URI_xapian-core-devel}"
SRC_URI[xapian-core-devel.sha256sum] = "75899c0e474b39990f5f0a5860267b4f9bdf6f73e6269af1527a4f4763b131e6"
RDEPENDS:xapian-core-devel = " \
 pkgconf-pkg-config \
 libuuid-devel \
 bash \
 xapian-core \
 xapian-core-libs \
"
