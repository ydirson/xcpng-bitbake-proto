# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "php-pecl-apcu"
PE = "0"
PV = "5.1.23"
PR = "5.el10"
PACKAGES = "apcu-panel php-pecl-apcu php-pecl-apcu-devel"
PROVIDES = "rpm/apcu-panel rpm/php-pecl-apcu rpm/php-pecl-apcu-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/php-pecl-apcu-5.1.23-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1f3a52b12e201dead9175aed0cbf2094e1e66e323415e3977d6a34e4d2164e6"

URI_apcu-panel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/apcu-panel-5.1.23-5.el10.noarch.rpm;name=apcu-panel;unpack=0"
SRC_URI += "${URI_apcu-panel}"
SRC_URI[apcu-panel.sha256sum] = "dc011fa8715dac1a5cc4dfaba16e0f95af4f672eb37adfbaecde0323f78c00de"
RDEPENDS:apcu-panel = " \
 php-fpm \
 php-gd \
 php-pecl-apcu \
 httpd \
"

URI_php-pecl-apcu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-pecl-apcu-5.1.23-5.el10.x86_64_v2.rpm;name=php-pecl-apcu;unpack=0"
SRC_URI += "${URI_php-pecl-apcu}"
SRC_URI[php-pecl-apcu.sha256sum] = "7e39ff5637a593b8f6c9a2bb615b2a16e5c474e4db56b293006ba2b4f747d1e0"
RDEPENDS:php-pecl-apcu = " \
 glibc \
 php-common \
"

URI_php-pecl-apcu-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-pecl-apcu-devel-5.1.23-5.el10.x86_64_v2.rpm;name=php-pecl-apcu-devel;unpack=0"
SRC_URI += "${URI_php-pecl-apcu-devel}"
SRC_URI[php-pecl-apcu-devel.sha256sum] = "54d80119b80fef847a52d74a128351cd707d465f0b83ebac7653d0e655c722d0"
RDEPENDS:php-pecl-apcu-devel = " \
 php-pecl-apcu \
 php-devel \
"
