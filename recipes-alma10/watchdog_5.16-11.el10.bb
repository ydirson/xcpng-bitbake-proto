# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "watchdog"
PE = "0"
PV = "5.16"
PR = "11.el10"
PACKAGES = "watchdog"
PROVIDES = "rpm/watchdog"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/watchdog-5.16-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf454498ba5e75b47e1ba787a7852a1ca8e8c8bb4dadf66f2f7f709546f94d43"

URI_watchdog = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/watchdog-5.16-11.el10.x86_64_v2.rpm;name=watchdog;unpack=0"
SRC_URI += "${URI_watchdog}"
SRC_URI[watchdog.sha256sum] = "f36f3750b3edd6718bebb48393b8036f33c8619eb2e72d49927dae8a4230c715"
RDEPENDS:watchdog = " \
 glibc \
 systemd \
 bash \
"
