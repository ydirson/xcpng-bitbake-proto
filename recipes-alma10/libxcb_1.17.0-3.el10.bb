# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libxcb"
PE = "0"
PV = "1.17.0"
PR = "3.el10"
PACKAGES = "libxcb libxcb-devel libxcb-doc"
PROVIDES = "rpm/libxcb rpm/libxcb-devel rpm/libxcb-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libxcb-1.17.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8bc3ee753dd5200894fa19ed34c77dbbe450b6984fcbb1313b9d40417762632"

URI_libxcb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libxcb-1.17.0-3.el10.x86_64_v2.rpm;name=libxcb;unpack=0"
SRC_URI += "${URI_libxcb}"
SRC_URI[libxcb.sha256sum] = "81285982958b61c7b937e07153cd70f50d673b2e784b93bbcebc63bf1c8b1d22"
RDEPENDS:libxcb = " \
 glibc \
 libXau \
"

URI_libxcb-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libxcb-devel-1.17.0-3.el10.x86_64_v2.rpm;name=libxcb-devel;unpack=0"
SRC_URI += "${URI_libxcb-devel}"
SRC_URI[libxcb-devel.sha256sum] = "e0ff560cc6311817c913fe7bf072750f4d78cb4d0ad3326798b55c14222cc19c"
RDEPENDS:libxcb-devel = " \
 libxcb \
 libxcb-devel \
 pkgconf-pkg-config \
 libXau-devel \
"

URI_libxcb-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libxcb-doc-1.17.0-3.el10.noarch.rpm;name=libxcb-doc;unpack=0"
SRC_URI += "${URI_libxcb-doc}"
SRC_URI[libxcb-doc.sha256sum] = "fd0dff9387b3a2c5093d24cbae9775edefc918dbf0dd8229a6580794d147b094"
RDEPENDS:libxcb-doc = ""
