# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-software"
PE = "0"
PV = "47.4"
PR = "1.el10"
PACKAGES = "gnome-software gnome-software-fedora-langpacks gnome-software-devel"
PROVIDES = "rpm/gnome-software rpm/gnome-software-fedora-langpacks rpm/gnome-software-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-software-47.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2fd9c7af3002c5dff7909767397a3a6dccb7715ccc213cc4d0cf44e25142346f"

URI_gnome-software = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-software-47.4-1.el10.x86_64_v2.rpm;name=gnome-software;unpack=0"
SRC_URI += "${URI_gnome-software}"
SRC_URI[gnome-software.sha256sum] = "351f5d2e1c4e3bc0187968c30e1fa8c3bd0ba1efe478852d38ec187afea470d0"
RDEPENDS:gnome-software = " \
 ostree-libs \
 flatpak-libs \
 appstream \
 appstream-data \
 pango \
 PackageKit-glib \
 json-glib \
 gnome-menus \
 libadwaita \
 librsvg2 \
 libgcc \
 libxmlb \
 gdk-pixbuf2 \
 libgudev \
 flatpak \
 libsoup3 \
 gsettings-desktop-schemas \
 fwupd \
 polkit-libs \
 glib2 \
 glibc \
 gtk4 \
 iso-codes \
"

URI_gnome-software-fedora-langpacks = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-software-fedora-langpacks-47.4-1.el10.x86_64_v2.rpm;name=gnome-software-fedora-langpacks;unpack=0"
SRC_URI += "${URI_gnome-software-fedora-langpacks}"
SRC_URI[gnome-software-fedora-langpacks.sha256sum] = "66be37a8df3c39494e0fc3d86f4bef7ff8f4d7675bcaa0349d3ab260897c4c11"
RDEPENDS:gnome-software-fedora-langpacks = " \
 glibc \
 libgcc \
 gnome-software \
 glib2 \
"

URI_gnome-software-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gnome-software-devel-47.4-1.el10.x86_64_v2.rpm;name=gnome-software-devel;unpack=0"
SRC_URI += "${URI_gnome-software-devel}"
SRC_URI[gnome-software-devel.sha256sum] = "27eabccf32760d75810f61236957f620df553c567442a45520283b23120b4390"
RDEPENDS:gnome-software-devel = " \
 json-glib-devel \
 sysprof-capture-devel \
 glib2-devel \
 libsoup3-devel \
 polkit-devel \
 pkgconf-pkg-config \
 libxmlb-devel \
 appstream-devel \
 gnome-software \
 gtk4-devel \
"
