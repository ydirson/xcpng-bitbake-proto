# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "bash-completion"
PE = "1"
PV = "2.11"
PR = "16.el10"
PACKAGES = "bash-completion"
PROVIDES = "rpm/bash-completion"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/bash-completion-2.11-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1447cedc46abc1774682de98986ca42ccba0afc2a099db1b2ebab3517f08e417"

URI_bash-completion = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/bash-completion-2.11-16.el10.noarch.rpm;name=bash-completion;unpack=0"
SRC_URI += "${URI_bash-completion}"
SRC_URI[bash-completion.sha256sum] = "8f72586cb581dd5dffa1117cedc7adac41f97a3aa9211c3f101fc8ef7058209d"
RDEPENDS:bash-completion = " \
 bash \
 pkgconf-pkg-config \
"
