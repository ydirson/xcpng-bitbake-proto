# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Carp"
PE = "0"
PV = "1.54"
PR = "511.el10"
PACKAGES = "perl-Carp perl-Carp-tests"
PROVIDES = "rpm/perl-Carp rpm/perl-Carp-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Carp-1.54-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ef61e0d1fbf76f2d07758a52d6bfe2222e47dbf6f9beec4879b7041468b331a"

URI_perl-Carp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Carp-1.54-511.el10.noarch.rpm;name=perl-Carp;unpack=0"
SRC_URI += "${URI_perl-Carp}"
SRC_URI[perl-Carp.sha256sum] = "f8ba8f4202ecfc9efb5bd7040d44690e5ad7f3bfe284325a4b8b65bdb26d5e77"
RDEPENDS:perl-Carp = " \
 perl-Exporter \
 perl-libs \
 perl-Carp \
"

URI_perl-Carp-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Carp-tests-1.54-511.el10.noarch.rpm;name=perl-Carp-tests;unpack=0"
SRC_URI += "${URI_perl-Carp-tests}"
SRC_URI[perl-Carp-tests.sha256sum] = "7e5423024b8121cf328d8151ab30c4f9f92b3b9286c57035f2654d82adda3519"
RDEPENDS:perl-Carp-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-overload \
 perl-IPC-Open3 \
 bash \
 perl-interpreter \
 perl-Data-Dumper \
"
