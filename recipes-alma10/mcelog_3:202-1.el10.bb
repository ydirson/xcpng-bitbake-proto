# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mcelog"
PE = "3"
PV = "202"
PR = "1.el10"
PACKAGES = "mcelog"
PROVIDES = "rpm/mcelog"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/mcelog-202-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "358fdafe18a07016bf9628b8f262252880cefaf0304e50b6e5fe074a316b8880"

URI_mcelog = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/mcelog-202-1.el10.x86_64_v2.rpm;name=mcelog;unpack=0"
SRC_URI += "${URI_mcelog}"
SRC_URI[mcelog.sha256sum] = "77136a09fffd261634572d63825b1828adcee6776eabce2eaddd231ed978342b"
RDEPENDS:mcelog = " \
 glibc \
 systemd \
 bash \
"
