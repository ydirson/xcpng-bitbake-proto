# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "kabi-dw"
PE = "0"
PV = "0"
PR = "0.30.20250206giteedfcbf.el10"
PACKAGES = "kabi-dw"
PROVIDES = "rpm/kabi-dw"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/kabi-dw-0-0.30.20250206giteedfcbf.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ba0a1914c8afe82b33328324680cd0e204d66923988dab94866d8ead99f30bc"

URI_kabi-dw = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/kabi-dw-0-0.30.20250206giteedfcbf.el10.x86_64_v2.rpm;name=kabi-dw;unpack=0"
SRC_URI += "${URI_kabi-dw}"
SRC_URI[kabi-dw.sha256sum] = "6939eb1c4b7a202c98255abc099b61695e6f801a3c2ec8dff439afa81614ad1e"
RDEPENDS:kabi-dw = " \
 glibc \
 elfutils-libelf \
 elfutils-libs \
"
