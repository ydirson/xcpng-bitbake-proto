# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "flatpak-runtime-config"
PE = "0"
PV = "40"
PR = "4.el10"
PACKAGES = "flatpak-runtime-config"
PROVIDES = "rpm/flatpak-runtime-config"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/flatpak-runtime-config-40-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a9aeb8c0b7633eec03cbf2d59ddbeffd24c8458c4c38a89a949a2e8e57be3a0"

URI_flatpak-runtime-config = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/flatpak-runtime-config-40-4.el10.x86_64_v2.rpm;name=flatpak-runtime-config;unpack=0"
SRC_URI += "${URI_flatpak-runtime-config}"
SRC_URI[flatpak-runtime-config.sha256sum] = "1ee9af81ea6c4f8c52917f7feaa364fa860ef7739a987da31e510e19e4287f8b"
RDEPENDS:flatpak-runtime-config = " \
 glibc \
 fonts-filesystem \
 bash \
 findutils \
"
