# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pyxattr"
PE = "0"
PV = "0.7.2"
PR = "14.el10"
PACKAGES = "python3-pyxattr"
PROVIDES = "rpm/python3-pyxattr"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/pyxattr-0.7.2-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0d167cdae9667c4eaa5053c98774b84b9fa008e561ab1a9fcef8f79d12a6b46"

URI_python3-pyxattr = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-pyxattr-0.7.2-14.el10.x86_64_v2.rpm;name=python3-pyxattr;unpack=0"
SRC_URI += "${URI_python3-pyxattr}"
SRC_URI[python3-pyxattr.sha256sum] = "f84aa7bfc879d414d4876b493e5217d8b60aedef9d5b9d5fc7bfc1b9bb721593"
RDEPENDS:python3-pyxattr = " \
 glibc \
 python3 \
"
