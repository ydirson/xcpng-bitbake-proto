# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xz"
PE = "1"
PV = "5.6.2"
PR = "4.el10_0"
PACKAGES = "xz xz-libs xz-devel xz-lzma-compat xz-static"
PROVIDES = "rpm/xz rpm/xz-libs rpm/xz-devel rpm/xz-lzma-compat rpm/xz-static"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/xz-5.6.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8393ae2108a7bae26bdb88cf10b1c0e17e0b4338cdf1cc072e33bc960db7bda"

URI_xz = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/xz-5.6.2-4.el10_0.x86_64_v2.rpm;name=xz;unpack=0"
SRC_URI += "${URI_xz}"
SRC_URI[xz.sha256sum] = "c00d63d8b9cb2370b0ad30d9541c07c53eb4e102cb0ab5a5d2fc7512ae484b4b"
RDEPENDS:xz = " \
 glibc \
 bash \
 grep \
 xz-libs \
"

URI_xz-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/xz-libs-5.6.2-4.el10_0.x86_64_v2.rpm;name=xz-libs;unpack=0"
SRC_URI += "${URI_xz-libs}"
SRC_URI[xz-libs.sha256sum] = "b7c86e6258fbaa517d906a7c941b1ecdf46876afc8e5a678f3510831af850b7b"
RDEPENDS:xz-libs = " \
 glibc \
"

URI_xz-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xz-devel-5.6.2-4.el10_0.x86_64_v2.rpm;name=xz-devel;unpack=0"
SRC_URI += "${URI_xz-devel}"
SRC_URI[xz-devel.sha256sum] = "91547781b065a70683d73be32ae95f838e46b94bfbb75fbed4dc348cf33b4d23"
RDEPENDS:xz-devel = " \
 pkgconf-pkg-config \
 xz-libs \
"

URI_xz-lzma-compat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xz-lzma-compat-5.6.2-4.el10_0.x86_64_v2.rpm;name=xz-lzma-compat;unpack=0"
SRC_URI += "${URI_xz-lzma-compat}"
SRC_URI[xz-lzma-compat.sha256sum] = "467078e7ab2d60b09bd70548139f39474422592df480762c40888c333200372b"
RDEPENDS:xz-lzma-compat = " \
 glibc \
 xz \
 xz-libs \
"

URI_xz-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/xz-static-5.6.2-4.el10_0.x86_64_v2.rpm;name=xz-static;unpack=0"
SRC_URI += "${URI_xz-static}"
SRC_URI[xz-static.sha256sum] = "486ac5ae319dae09d3ed612ff84edc23792531b11d8f3f91926b0dd64451ba25"
RDEPENDS:xz-static = ""
