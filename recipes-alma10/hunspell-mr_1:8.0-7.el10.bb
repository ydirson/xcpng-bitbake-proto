# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-mr"
PE = "1"
PV = "8.0"
PR = "7.el10"
PACKAGES = "hunspell-mr"
PROVIDES = "rpm/hunspell-mr"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-mr-8.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1fd6265099204d2bb66f26fcc2450ba400653feb6be6a04827e34ec01156d3fe"

URI_hunspell-mr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-mr-8.0-7.el10.noarch.rpm;name=hunspell-mr;unpack=0"
SRC_URI += "${URI_hunspell-mr}"
SRC_URI[hunspell-mr.sha256sum] = "80b64de23224bc7c529b9b47058f86df1b0835b5170de1b2d538641ee662c2f5"
RDEPENDS:hunspell-mr = " \
 hunspell-filesystem \
"
