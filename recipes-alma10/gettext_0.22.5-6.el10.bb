# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gettext"
PE = "0"
PV = "0.22.5"
PR = "6.el10"
PACKAGES = "gettext gettext-envsubst gettext-libs gettext-runtime gettext-common-devel gettext-devel emacs-gettext msghack"
PROVIDES = "rpm/gettext rpm/gettext-envsubst rpm/gettext-libs rpm/gettext-runtime rpm/gettext-common-devel rpm/gettext-devel rpm/emacs-gettext rpm/msghack"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gettext-0.22.5-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43c76b83ae97f7b60bdc925f92ea21987c915d0db00f21ae0255d9e3e4a00928"

URI_gettext = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/gettext-0.22.5-6.el10.x86_64_v2.rpm;name=gettext;unpack=0"
SRC_URI += "${URI_gettext}"
SRC_URI[gettext.sha256sum] = "becbdec11d8fde48db87c7301ea82d4a53d38672a6d917a1da21c7273ab22d70"
RDEPENDS:gettext = " \
 libgcc \
 libxml2 \
 libgomp \
 gettext-libs \
 gettext-runtime \
 bash \
 glibc \
 libunistring \
"

URI_gettext-envsubst = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/gettext-envsubst-0.22.5-6.el10.x86_64_v2.rpm;name=gettext-envsubst;unpack=0"
SRC_URI += "${URI_gettext-envsubst}"
SRC_URI[gettext-envsubst.sha256sum] = "fc8056cd1047ea086f1d36587feebed03fae65ad3eed04a33e42ef073525587e"
RDEPENDS:gettext-envsubst = " \
 glibc \
"

URI_gettext-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/gettext-libs-0.22.5-6.el10.x86_64_v2.rpm;name=gettext-libs;unpack=0"
SRC_URI += "${URI_gettext-libs}"
SRC_URI[gettext-libs.sha256sum] = "74f2fa25353c96174a143fb1402f8a43b2285e59d7fd095f82a0193ad80c6201"
RDEPENDS:gettext-libs = " \
 libacl \
 libattr \
 libxml2 \
 libstdc++ \
 glibc \
 libunistring \
"

URI_gettext-runtime = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/gettext-runtime-0.22.5-6.el10.x86_64_v2.rpm;name=gettext-runtime;unpack=0"
SRC_URI += "${URI_gettext-runtime}"
SRC_URI[gettext-runtime.sha256sum] = "896b91c1684b056ece3653b2efc26a57b7d318520a38b57931fcf10475570285"
RDEPENDS:gettext-runtime = " \
 glibc \
 gettext-libs \
 bash \
 gettext-envsubst \
"

URI_gettext-common-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gettext-common-devel-0.22.5-6.el10.noarch.rpm;name=gettext-common-devel;unpack=0"
SRC_URI += "${URI_gettext-common-devel}"
SRC_URI[gettext-common-devel.sha256sum] = "13bd4495ee74787311558d412eb9a7fb995c464bc7ec620304a6c9da79f535c4"
RDEPENDS:gettext-common-devel = ""

URI_gettext-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gettext-devel-0.22.5-6.el10.x86_64_v2.rpm;name=gettext-devel;unpack=0"
SRC_URI += "${URI_gettext-devel}"
SRC_URI[gettext-devel.sha256sum] = "e187a7662e5283bcd2a34a0b8a18bd0fc1e15681debb9232000fc5d5c475869c"
RDEPENDS:gettext-devel = " \
 diffutils \
 gettext \
 gettext-libs \
 bash \
 glibc \
 gettext-common-devel \
 xz \
"

URI_emacs-gettext = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/emacs-gettext-0.22.5-6.el10.noarch.rpm;name=emacs-gettext;unpack=0"
SRC_URI += "${URI_emacs-gettext}"
SRC_URI[emacs-gettext.sha256sum] = "56ea30139475cac91c78a8cf84a3e5fcb6a149a9eee20ce136299b6deb44115b"
RDEPENDS:emacs-gettext = " \
 emacs \
"

URI_msghack = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/msghack-0.22.5-6.el10.noarch.rpm;name=msghack;unpack=0"
SRC_URI += "${URI_msghack}"
SRC_URI[msghack.sha256sum] = "4fac778e2372d7adf8a58b3e9e0d0420606cadae478ee1f50776d202c9ffd0ab"
RDEPENDS:msghack = " \
 python3 \
"
