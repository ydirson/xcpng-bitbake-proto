# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sblim-sfcCommon"
PE = "0"
PV = "1.0.1"
PR = "26.el10"
PACKAGES = "sblim-sfcCommon sblim-sfcCommon-devel"
PROVIDES = "rpm/sblim-sfcCommon rpm/sblim-sfcCommon-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/sblim-sfcCommon-1.0.1-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0d4b65e2de921e69ea63f4a80f9020c55b0945ddf5ba7efbadbd797cfdd0e73"

URI_sblim-sfcCommon = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sblim-sfcCommon-1.0.1-26.el10.x86_64_v2.rpm;name=sblim-sfcCommon;unpack=0"
SRC_URI += "${URI_sblim-sfcCommon}"
SRC_URI[sblim-sfcCommon.sha256sum] = "da1436ecbde2a581b9546703c5fca44cf97ae43566b85ce218858286ab740cd9"
RDEPENDS:sblim-sfcCommon = " \
 glibc \
"

URI_sblim-sfcCommon-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sblim-sfcCommon-devel-1.0.1-26.el10.x86_64_v2.rpm;name=sblim-sfcCommon-devel;unpack=0"
SRC_URI += "${URI_sblim-sfcCommon-devel}"
SRC_URI[sblim-sfcCommon-devel.sha256sum] = "65d184eb018be74c7a75163e55b0c7f206dd5372644c6f4a988711e6f3bba53e"
RDEPENDS:sblim-sfcCommon-devel = " \
 sblim-sfcCommon \
"
