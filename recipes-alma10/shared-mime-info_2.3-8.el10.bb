# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "shared-mime-info"
PE = "0"
PV = "2.3"
PR = "8.el10"
PACKAGES = "shared-mime-info"
PROVIDES = "rpm/shared-mime-info"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/shared-mime-info-2.3-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9bac0969617bcb8792bba437ee867b5c1e134f5a6b3c8c2337f355510d02ae02"

URI_shared-mime-info = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/shared-mime-info-2.3-8.el10.x86_64_v2.rpm;name=shared-mime-info;unpack=0"
SRC_URI += "${URI_shared-mime-info}"
SRC_URI[shared-mime-info.sha256sum] = "8295f8ec223ac62f2dcc6065a5d6485bc0a2f3ce848611977659ebc9e314f43a"
RDEPENDS:shared-mime-info = " \
 libgcc \
 libxml2 \
 libstdc++ \
 bash \
 glib2 \
 glibc \
"
