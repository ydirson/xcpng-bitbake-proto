# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "NetworkManager-libreswan"
PE = "0"
PV = "1.2.27"
PR = "2.el10_0"
PACKAGES = "NetworkManager-libreswan NetworkManager-libreswan-gnome"
PROVIDES = "rpm/NetworkManager-libreswan rpm/NetworkManager-libreswan-gnome"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/NetworkManager-libreswan-1.2.27-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91be2e898f420084bbac23320475ef3b4fc782e4b4c60513abf83ea1f6e3a2f4"

URI_NetworkManager-libreswan = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/NetworkManager-libreswan-1.2.27-2.el10_0.x86_64_v2.rpm;name=NetworkManager-libreswan;unpack=0"
SRC_URI += "${URI_NetworkManager-libreswan}"
SRC_URI[NetworkManager-libreswan.sha256sum] = "b39a92f5ac17db75743439102fdd863019e1c04667b3043fb7ce35e345a23ace"
RDEPENDS:NetworkManager-libreswan = " \
 libreswan \
 NetworkManager \
 libgcc \
 libnl3 \
 glib2 \
 dbus-common \
 glibc \
 NetworkManager-libnm \
"

URI_NetworkManager-libreswan-gnome = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/NetworkManager-libreswan-gnome-1.2.27-2.el10_0.x86_64_v2.rpm;name=NetworkManager-libreswan-gnome;unpack=0"
SRC_URI += "${URI_NetworkManager-libreswan-gnome}"
SRC_URI[NetworkManager-libreswan-gnome.sha256sum] = "22d29677922e161575738c4d21f0ae4d34ab25a774184d0d87ab78badaa0283e"
RDEPENDS:NetworkManager-libreswan-gnome = " \
 NetworkManager-libreswan \
 pango \
 NetworkManager-libnm \
 libnma \
 libnma-gtk4 \
 cairo \
 cairo-gobject \
 atk \
 shared-mime-info \
 libgcc \
 gdk-pixbuf2 \
 libsecret \
 graphene \
 vulkan-loader \
 harfbuzz \
 glib2 \
 gtk3 \
 glibc \
 gtk4 \
"
