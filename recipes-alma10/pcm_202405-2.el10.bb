# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pcm"
PE = "0"
PV = "202405"
PR = "2.el10"
PACKAGES = "pcm"
PROVIDES = "rpm/pcm"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/pcm-202405-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "083dac2fff606ec574131508303514d60d8df69d0b5ccd64df3febbabe5e3f6e"

URI_pcm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcm-202405-2.el10.x86_64_v2.rpm;name=pcm;unpack=0"
SRC_URI += "${URI_pcm}"
SRC_URI[pcm.sha256sum] = "c64aee5b85d187972591fc99e7d4ca935ada0c3d7d59287ed730e54c7e820a93"
RDEPENDS:pcm = " \
 glibc \
 libgcc \
 bash \
 libstdc++ \
"
