# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "librsvg2"
PE = "0"
PV = "2.57.1"
PR = "9.el10"
PACKAGES = "librsvg2 librsvg2-devel librsvg2-tools rsvg-pixbuf-loader"
PROVIDES = "rpm/librsvg2 rpm/librsvg2-devel rpm/librsvg2-tools rpm/rsvg-pixbuf-loader"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/librsvg2-2.57.1-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf8e430bbd1a01bb9f014111912a396b2b0ee9bb66fc656bb78e3310a814648f"

URI_librsvg2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/librsvg2-2.57.1-9.el10.x86_64_v2.rpm;name=librsvg2;unpack=0"
SRC_URI += "${URI_librsvg2}"
SRC_URI[librsvg2.sha256sum] = "83902060805903da8e6bc7eceadb8a62b0542e05bf7ccf6702fde409bd59280e"
RDEPENDS:librsvg2 = " \
 freetype \
 libpng \
 libgcc \
 harfbuzz \
 libxml2 \
 pango \
 gdk-pixbuf2 \
 fontconfig \
 cairo \
 glib2 \
 cairo-gobject \
 glibc \
 rsvg-pixbuf-loader \
"

URI_librsvg2-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/librsvg2-devel-2.57.1-9.el10.x86_64_v2.rpm;name=librsvg2-devel;unpack=0"
SRC_URI += "${URI_librsvg2-devel}"
SRC_URI[librsvg2-devel.sha256sum] = "a5035fbd3084df39ceb092cc9485e51a92d52d543bf39d53549e2e051e8441b0"
RDEPENDS:librsvg2-devel = " \
 glib2-devel \
 librsvg2 \
 pkgconf-pkg-config \
 gdk-pixbuf2-devel \
 cairo-devel \
"

URI_librsvg2-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/librsvg2-tools-2.57.1-9.el10.x86_64_v2.rpm;name=librsvg2-tools;unpack=0"
SRC_URI += "${URI_librsvg2-tools}"
SRC_URI[librsvg2-tools.sha256sum] = "db7beec29a5627277006e2f9ef13f0787d56c153845155aa918ce3b354e166df"
RDEPENDS:librsvg2-tools = " \
 librsvg2 \
 libgcc \
 libxml2 \
 pango \
 gdk-pixbuf2 \
 fontconfig \
 cairo \
 glib2 \
 cairo-gobject \
 glibc \
"

URI_rsvg-pixbuf-loader = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rsvg-pixbuf-loader-2.57.1-9.el10.x86_64_v2.rpm;name=rsvg-pixbuf-loader;unpack=0"
SRC_URI += "${URI_rsvg-pixbuf-loader}"
SRC_URI[rsvg-pixbuf-loader.sha256sum] = "4dc2cc3db207e6ffa6644fa2afcbc1742244765966a8570919fd8860092c397a"
RDEPENDS:rsvg-pixbuf-loader = " \
 freetype \
 libpng \
 librsvg2 \
 harfbuzz \
 libxml2 \
 pango \
 gdk-pixbuf2 \
 fontconfig \
 cairo \
 glib2 \
 cairo-gobject \
 glibc \
"
