# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-File-ShareDir"
PE = "0"
PV = "1.118"
PR = "14.el10"
PACKAGES = "perl-File-ShareDir perl-File-ShareDir-tests"
PROVIDES = "rpm/perl-File-ShareDir rpm/perl-File-ShareDir-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-File-ShareDir-1.118-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23c4aab8c04b0d7b0e69ad5f44a866f22bdfb8d3cd9911c554d42f13e0e75f53"

URI_perl-File-ShareDir = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-File-ShareDir-1.118-14.el10.noarch.rpm;name=perl-File-ShareDir;unpack=0"
SRC_URI += "${URI_perl-File-ShareDir}"
SRC_URI[perl-File-ShareDir.sha256sum] = "1ff1c7353917dc893b2dec1826b4f4c334ab228730e369db92b1f55a8eb8561f"
RDEPENDS:perl-File-ShareDir = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-Class-Inspector \
 perl-PathTools \
 perl-Exporter \
 perl-base \
"

URI_perl-File-ShareDir-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-File-ShareDir-tests-1.118-14.el10.noarch.rpm;name=perl-File-ShareDir-tests;unpack=0"
SRC_URI += "${URI_perl-File-ShareDir-tests}"
SRC_URI[perl-File-ShareDir-tests.sha256sum] = "6297ba8b1f013e3afeb1b2bba465c5e0d91b54dc391e5793555a7df10a8b239c"
RDEPENDS:perl-File-ShareDir-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-File-Basename \
 perl-POSIX \
 bash \
 perl-PathTools \
 perl-parent \
 perl-interpreter \
 perl-File-Path \
 perl-File-ShareDir \
"
