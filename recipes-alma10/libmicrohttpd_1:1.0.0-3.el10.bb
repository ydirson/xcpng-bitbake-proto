# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libmicrohttpd"
PE = "1"
PV = "1.0.0"
PR = "3.el10"
PACKAGES = "libmicrohttpd libmicrohttpd-devel libmicrohttpd-doc"
PROVIDES = "rpm/libmicrohttpd rpm/libmicrohttpd-devel rpm/libmicrohttpd-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libmicrohttpd-1.0.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "387a05d3e536ff29e1491944dbebd6a464793a91752676e1ef93d92a886279cf"

URI_libmicrohttpd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libmicrohttpd-1.0.0-3.el10.x86_64_v2.rpm;name=libmicrohttpd;unpack=0"
SRC_URI += "${URI_libmicrohttpd}"
SRC_URI[libmicrohttpd.sha256sum] = "5f8c198cd3cf6ee5091ebb8c00b4b9b53cd33d2cb7bb0f7ad386647ab2820b75"
RDEPENDS:libmicrohttpd = " \
 glibc \
 info \
 gnutls \
"

URI_libmicrohttpd-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libmicrohttpd-devel-1.0.0-3.el10.x86_64_v2.rpm;name=libmicrohttpd-devel;unpack=0"
SRC_URI += "${URI_libmicrohttpd-devel}"
SRC_URI[libmicrohttpd-devel.sha256sum] = "0ddb26e1e6925d9f5a9b17005843abbc084ba158fdf45398f4710aaca29520a4"
RDEPENDS:libmicrohttpd-devel = " \
 gnutls-devel \
 pkgconf-pkg-config \
 libmicrohttpd \
"

URI_libmicrohttpd-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libmicrohttpd-doc-1.0.0-3.el10.noarch.rpm;name=libmicrohttpd-doc;unpack=0"
SRC_URI += "${URI_libmicrohttpd-doc}"
SRC_URI[libmicrohttpd-doc.sha256sum] = "330479b68078b4d7b736fef810b2f3bad905a0f1a36806cfddcdb3306b02c1dd"
RDEPENDS:libmicrohttpd-doc = " \
 bash \
 libmicrohttpd \
"
