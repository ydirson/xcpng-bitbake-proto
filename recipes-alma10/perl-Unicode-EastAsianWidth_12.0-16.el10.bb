# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Unicode-EastAsianWidth"
PE = "0"
PV = "12.0"
PR = "16.el10"
PACKAGES = "perl-Unicode-EastAsianWidth"
PROVIDES = "rpm/perl-Unicode-EastAsianWidth"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Unicode-EastAsianWidth-12.0-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4fce3f9a999496777d0134aeb74dad2fe3a697b3a0e63f139ec6bed1eeee86b1"

URI_perl-Unicode-EastAsianWidth = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Unicode-EastAsianWidth-12.0-16.el10.noarch.rpm;name=perl-Unicode-EastAsianWidth;unpack=0"
SRC_URI += "${URI_perl-Unicode-EastAsianWidth}"
SRC_URI[perl-Unicode-EastAsianWidth.sha256sum] = "c60aa2d67915135bfdfadbc706f0c7b46910334614fadd8f2ed12cf45b83040d"
RDEPENDS:perl-Unicode-EastAsianWidth = " \
 perl-Exporter \
 perl-libs \
 perl-base \
 perl-vars \
"
