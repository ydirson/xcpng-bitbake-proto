# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "virt-top"
PE = "0"
PV = "1.1.1"
PR = "21.el10.alma.1"
PACKAGES = "virt-top"
PROVIDES = "rpm/virt-top"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/virt-top-1.1.1-21.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac752afef5d1f70662b89cf84406411b54bf4987ee44223d5e7e8c7da5a1196b"

URI_virt-top = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/virt-top-1.1.1-21.el10.alma.1.x86_64_v2.rpm;name=virt-top;unpack=0"
SRC_URI += "${URI_virt-top}"
SRC_URI[virt-top.sha256sum] = "1696494e8e23df8f49dc12a3aff530449aff7111f7debf3acd43cadec150ea8f"
RDEPENDS:virt-top = " \
 python3 \
 libxml2 \
 ncurses-libs \
 glibc \
 libvirt-libs \
"
