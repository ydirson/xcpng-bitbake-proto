# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sgml-common"
PE = "0"
PV = "0.6.3"
PR = "65.el10"
PACKAGES = "sgml-common xml-common"
PROVIDES = "rpm/sgml-common rpm/xml-common"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/sgml-common-0.6.3-65.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02dfdef31d17613cee599ab22f67d1cb0d14e5ff475d6c4979c18e668658518d"

URI_sgml-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sgml-common-0.6.3-65.el10.noarch.rpm;name=sgml-common;unpack=0"
SRC_URI += "${URI_sgml-common}"
SRC_URI[sgml-common.sha256sum] = "d7d004aec9666eadb1df40ced663a833fdc41725047ee8e736d946eb0631738e"
RDEPENDS:sgml-common = " \
 coreutils \
 bash \
"

URI_xml-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xml-common-0.6.3-65.el10.noarch.rpm;name=xml-common;unpack=0"
SRC_URI += "${URI_xml-common}"
SRC_URI[xml-common.sha256sum] = "850cda3bbf605e45e08c33124c08b9f42eb5a3a5ce7f9947c2a124b383ebe30d"
RDEPENDS:xml-common = " \
 bash \
 libxml2 \
"
