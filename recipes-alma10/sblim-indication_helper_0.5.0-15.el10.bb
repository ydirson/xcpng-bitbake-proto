# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sblim-indication_helper"
PE = "0"
PV = "0.5.0"
PR = "15.el10"
PACKAGES = "sblim-indication_helper sblim-indication_helper-devel"
PROVIDES = "rpm/sblim-indication_helper rpm/sblim-indication_helper-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/sblim-indication_helper-0.5.0-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4bc1221c117a0eefa17bd1155906a70a5c1d368cdae3cf37b617b01e533bed56"

URI_sblim-indication_helper = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sblim-indication_helper-0.5.0-15.el10.x86_64_v2.rpm;name=sblim-indication_helper;unpack=0"
SRC_URI += "${URI_sblim-indication_helper}"
SRC_URI[sblim-indication_helper.sha256sum] = "6aa9955c3a0edc9ecf33e58dea5d7b660a0d75c8f61576eeb4f5d512ae32cd76"
RDEPENDS:sblim-indication_helper = " \
 glibc \
"

URI_sblim-indication_helper-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sblim-indication_helper-devel-0.5.0-15.el10.x86_64_v2.rpm;name=sblim-indication_helper-devel;unpack=0"
SRC_URI += "${URI_sblim-indication_helper-devel}"
SRC_URI[sblim-indication_helper-devel.sha256sum] = "1333294aa32aebe696c5fab9c70e84f54eb848c5d4922bc4c33db755fbb026ae"
RDEPENDS:sblim-indication_helper-devel = " \
 glibc-devel \
 sblim-indication_helper \
 sblim-cmpi-devel \
"
