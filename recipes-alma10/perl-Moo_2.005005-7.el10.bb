# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Moo"
PE = "0"
PV = "2.005005"
PR = "7.el10"
PACKAGES = "perl-Moo"
PROVIDES = "rpm/perl-Moo"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-Moo-2.005005-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b71bb407d74686bfa2d9f2466e2f52bc724d974ef4806b423f314f857c72a87"

URI_perl-Moo = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Moo-2.005005-7.el10.noarch.rpm;name=perl-Moo;unpack=0"
SRC_URI += "${URI_perl-Moo}"
SRC_URI[perl-Moo.sha256sum] = "3ab77296483025f06afb2a5b4967be70597b7380177a2cb7a47e35ca0392bb04"
RDEPENDS:perl-Moo = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-Import-Into \
 perl-Module-Runtime \
 perl-mro \
 perl-Class-Method-Modifiers \
 perl-Devel-GlobalDestruction \
 perl-Role-Tiny \
 perl-Exporter \
 perl-Sub-Quote \
"
