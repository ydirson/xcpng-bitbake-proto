# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "postgresql16-pgvector"
PE = "0"
PV = "0.6.2"
PR = "6.el10_0"
PACKAGES = "pgvector"
PROVIDES = "rpm/pgvector"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/postgresql16-pgvector-0.6.2-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40e03e5dfce9b1f163062df460f7ec4bbfea0482351bcf6cdb718fb35e8a2d0d"

URI_pgvector = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pgvector-0.6.2-6.el10_0.x86_64_v2.rpm;name=pgvector;unpack=0"
SRC_URI += "${URI_pgvector}"
SRC_URI[pgvector.sha256sum] = "1f40663114519b789aa34c29133c2752482d127966ff5b56d50cd9adf4be52a6"
RDEPENDS:pgvector = " \
 glibc \
 postgresql-server \
"
