# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cockpit-machines"
PE = "0"
PV = "328.2"
PR = "1.el10_0"
PACKAGES = "cockpit-machines cockpit-machines"
PROVIDES = "rpm/cockpit-machines rpm/cockpit-machines"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/cockpit-machines-328.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fae80128f82ba91b1c38e9eaecaec7b117af5e2b2b930cd440e3563c4cd84ab9"

URI_cockpit-machines = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cockpit-machines-328.2-1.el10_0.noarch.rpm;name=cockpit-machines;unpack=0"
SRC_URI += "${URI_cockpit-machines}"
SRC_URI[cockpit-machines.sha256sum] = "e0a79838d51c53d20a7d6b7676dd9cafe121681ab13a40136d6805c4666b4325"
RDEPENDS:cockpit-machines = " \
 libvirt-daemon-config-network \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 virt-install \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-storage-core \
 qemu-kvm \
 cockpit-bridge \
 libvirt-dbus \
 libvirt-client \
"

URI_cockpit-machines = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/cockpit-machines-328.2-1.el10_0.noarch.rpm;name=cockpit-machines;unpack=0"
SRC_URI += "${URI_cockpit-machines}"
SRC_URI[cockpit-machines.sha256sum] = "e0a79838d51c53d20a7d6b7676dd9cafe121681ab13a40136d6805c4666b4325"
RDEPENDS:cockpit-machines = " \
 libvirt-daemon-config-network \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 virt-install \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-storage-core \
 qemu-kvm \
 cockpit-bridge \
 libvirt-dbus \
 libvirt-client \
"
