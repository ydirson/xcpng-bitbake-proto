# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ktls-utils"
PE = "0"
PV = "0.11"
PR = "3.el10"
PACKAGES = "ktls-utils"
PROVIDES = "rpm/ktls-utils"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/ktls-utils-0.11-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7de8dfaf92a20022bd19e234ec794f86b8d7be12e248eec8d2172de8599ac113"

URI_ktls-utils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/ktls-utils-0.11-3.el10.x86_64_v2.rpm;name=ktls-utils;unpack=0"
SRC_URI += "${URI_ktls-utils}"
SRC_URI[ktls-utils.sha256sum] = "cf5ab9bf92d8ce9f90057ae693e103c428f28405c23b57fce766ec84e2f53041"
RDEPENDS:ktls-utils = " \
 gnutls \
 keyutils-libs \
 libnl3 \
 bash \
 glib2 \
 glibc \
"
