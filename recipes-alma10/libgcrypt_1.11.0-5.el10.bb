# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libgcrypt"
PE = "0"
PV = "1.11.0"
PR = "5.el10"
PACKAGES = "libgcrypt libgcrypt-devel"
PROVIDES = "rpm/libgcrypt rpm/libgcrypt-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libgcrypt-1.11.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5407c9b8588af38361184d5530cfdc3c5582d0e6bdffa7759def5781bb0134f3"

URI_libgcrypt = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libgcrypt-1.11.0-5.el10.x86_64_v2.rpm;name=libgcrypt;unpack=0"
SRC_URI += "${URI_libgcrypt}"
SRC_URI[libgcrypt.sha256sum] = "2b627d3edc5fe080bcd8c3947f452b0d1e2b894646a131e59899843f7e867dd0"
RDEPENDS:libgcrypt = " \
 glibc \
 libgpg-error \
"

URI_libgcrypt-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libgcrypt-devel-1.11.0-5.el10.x86_64_v2.rpm;name=libgcrypt-devel;unpack=0"
SRC_URI += "${URI_libgcrypt-devel}"
SRC_URI[libgcrypt-devel.sha256sum] = "c2251aefa389c9072baef649b557f84de7a4c98dda8db9547e219079e73e1f71"
RDEPENDS:libgcrypt-devel = " \
 libgcrypt \
 pkgconf-pkg-config \
 libgpg-error-devel \
 libgpg-error \
 bash \
 glibc \
"
