# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libunistring"
PE = "0"
PV = "1.1"
PR = "10.el10"
PACKAGES = "libunistring libunistring-devel"
PROVIDES = "rpm/libunistring rpm/libunistring-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libunistring-1.1-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f4d3e23d27107539e31602f94d97d047537b9bc88e675353411e52e8cbc46df"

URI_libunistring = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libunistring-1.1-10.el10.x86_64_v2.rpm;name=libunistring;unpack=0"
SRC_URI += "${URI_libunistring}"
SRC_URI[libunistring.sha256sum] = "48d79b2364d82df1ce80e97a63754cf8d340bc481ebd5ea0968a83bcf2dfab94"
RDEPENDS:libunistring = " \
 glibc \
"

URI_libunistring-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libunistring-devel-1.1-10.el10.x86_64_v2.rpm;name=libunistring-devel;unpack=0"
SRC_URI += "${URI_libunistring-devel}"
SRC_URI[libunistring-devel.sha256sum] = "cb3099b866fbe915b85b042b4c3e1b314b5ffee3d296df203770865f1b4503fc"
RDEPENDS:libunistring-devel = " \
 libunistring \
"
