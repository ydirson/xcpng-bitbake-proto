# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "duktape"
PE = "0"
PV = "2.7.0"
PR = "10.el10"
PACKAGES = "duktape duktape-devel"
PROVIDES = "rpm/duktape rpm/duktape-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/duktape-2.7.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3071b657c96a4f7a26a74c567c534cf2f8e7049312e980324bacd5a2809016d"

URI_duktape = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/duktape-2.7.0-10.el10.x86_64_v2.rpm;name=duktape;unpack=0"
SRC_URI += "${URI_duktape}"
SRC_URI[duktape.sha256sum] = "da3353ab0298b8758da0e7bf30a53243a79e203f5df9168cc51abfde7d6b5ee8"
RDEPENDS:duktape = " \
 glibc \
"

URI_duktape-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/duktape-devel-2.7.0-10.el10.x86_64_v2.rpm;name=duktape-devel;unpack=0"
SRC_URI += "${URI_duktape-devel}"
SRC_URI[duktape-devel.sha256sum] = "892d1b8fc66916d6fd7dade3cb9a3807fc28da205cdd6d49b0a6771546cacc58"
RDEPENDS:duktape-devel = " \
 duktape \
 pkgconf-pkg-config \
"
