# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "open-sans-fonts"
PE = "0"
PV = "1.10"
PR = "24.el10"
PACKAGES = "open-sans-fonts"
PROVIDES = "rpm/open-sans-fonts"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/open-sans-fonts-1.10-24.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4dff4eab5af8d1a66a50756bf46fa7f9f1d1da887e6b5c1f4f94a8faae6f393"

URI_open-sans-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/open-sans-fonts-1.10-24.el10.noarch.rpm;name=open-sans-fonts;unpack=0"
SRC_URI += "${URI_open-sans-fonts}"
SRC_URI[open-sans-fonts.sha256sum] = "4211226285b5fe071f9d5d1609be60ff3cef2074ca232afdabfb367d2ee9c51d"
RDEPENDS:open-sans-fonts = " \
 fonts-filesystem \
"
