# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ecj"
PE = "1"
PV = "4.23"
PR = "11.el10"
PACKAGES = "ecj"
PROVIDES = "rpm/ecj"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ecj-4.23-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30d1e1aeb750dc635d3c4fd16157fa3e7e8e07a306f690b8cfcd4a0ff16c7c8c"

URI_ecj = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ecj-4.23-11.el10.noarch.rpm;name=ecj;unpack=0"
SRC_URI += "${URI_ecj}"
SRC_URI[ecj.sha256sum] = "718959c0dbd78944e06e3990edc1bbaf40a99e1aacf33e34ce93c70cbc14a582"
RDEPENDS:ecj = " \
 java-21-openjdk-headless \
 bash \
 javapackages-filesystem \
 javapackages-tools \
"
