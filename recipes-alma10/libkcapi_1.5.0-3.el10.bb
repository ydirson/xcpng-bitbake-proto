# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libkcapi"
PE = "0"
PV = "1.5.0"
PR = "3.el10"
PACKAGES = "libkcapi libkcapi-hasher libkcapi-hmaccalc libkcapi-devel libkcapi-doc libkcapi-fipscheck libkcapi-static libkcapi-tests libkcapi-tools"
PROVIDES = "rpm/libkcapi rpm/libkcapi-hasher rpm/libkcapi-hmaccalc rpm/libkcapi-devel rpm/libkcapi-doc rpm/libkcapi-fipscheck rpm/libkcapi-static rpm/libkcapi-tests rpm/libkcapi-tools"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libkcapi-1.5.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8db4b9d9cb2f52a5d1a7bd1d3cee72399ebdec7979c174e8c7c2a6d66db8c90"

URI_libkcapi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libkcapi-1.5.0-3.el10.x86_64_v2.rpm;name=libkcapi;unpack=0"
SRC_URI += "${URI_libkcapi}"
SRC_URI[libkcapi.sha256sum] = "2bd4305a36ea8879935756b37ba71add69b4b2bc204514beafa94a7408dee263"
RDEPENDS:libkcapi = " \
 glibc \
 systemd \
"

URI_libkcapi-hasher = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libkcapi-hasher-1.5.0-3.el10.x86_64_v2.rpm;name=libkcapi-hasher;unpack=0"
SRC_URI += "${URI_libkcapi-hasher}"
SRC_URI[libkcapi-hasher.sha256sum] = "9df87a347b79eb056a4f1f18ab8b0e49477b3acf6760e2453c104fd414cbabfd"
RDEPENDS:libkcapi-hasher = " \
 glibc \
 libkcapi \
"

URI_libkcapi-hmaccalc = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libkcapi-hmaccalc-1.5.0-3.el10.x86_64_v2.rpm;name=libkcapi-hmaccalc;unpack=0"
SRC_URI += "${URI_libkcapi-hmaccalc}"
SRC_URI[libkcapi-hmaccalc.sha256sum] = "53009a44d6274f2790c3445e142df7b2506b56c84c57ad07d799b40a32d4a84f"
RDEPENDS:libkcapi-hmaccalc = " \
 libkcapi-hasher \
"

URI_libkcapi-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libkcapi-devel-1.5.0-3.el10.x86_64_v2.rpm;name=libkcapi-devel;unpack=0"
SRC_URI += "${URI_libkcapi-devel}"
SRC_URI[libkcapi-devel.sha256sum] = "4addd0c22567501365321beec0e91763c64d0028a2e93b6efe46b758a0e4bfe5"
RDEPENDS:libkcapi-devel = " \
 libkcapi \
 pkgconf-pkg-config \
"

URI_libkcapi-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libkcapi-doc-1.5.0-3.el10.noarch.rpm;name=libkcapi-doc;unpack=0"
SRC_URI += "${URI_libkcapi-doc}"
SRC_URI[libkcapi-doc.sha256sum] = "14f3be8b1e86ed27ab228ad4afe22a6c1b26440bddbd4065d72d1d10ffe1530a"
RDEPENDS:libkcapi-doc = " \
 libkcapi \
"

URI_libkcapi-fipscheck = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libkcapi-fipscheck-1.5.0-3.el10.x86_64_v2.rpm;name=libkcapi-fipscheck;unpack=0"
SRC_URI += "${URI_libkcapi-fipscheck}"
SRC_URI[libkcapi-fipscheck.sha256sum] = "45aee78b9476345b01bd1b68d5f34b326f401fcd625b4b8dba43ef2e93a64389"
RDEPENDS:libkcapi-fipscheck = " \
 libkcapi-hasher \
"

URI_libkcapi-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libkcapi-static-1.5.0-3.el10.x86_64_v2.rpm;name=libkcapi-static;unpack=0"
SRC_URI += "${URI_libkcapi-static}"
SRC_URI[libkcapi-static.sha256sum] = "f86b82df989914b7026083715e3c224ecc2e7cfbfed04dec5fd65ab134ef52fe"
RDEPENDS:libkcapi-static = " \
 libkcapi-devel \
"

URI_libkcapi-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libkcapi-tests-1.5.0-3.el10.x86_64_v2.rpm;name=libkcapi-tests;unpack=0"
SRC_URI += "${URI_libkcapi-tests}"
SRC_URI[libkcapi-tests.sha256sum] = "932799ed7b6eb06b752431e1ad9bbf96a1450b8165b05d8ce51a96b188513ca3"
RDEPENDS:libkcapi-tests = " \
 libkcapi \
 libkcapi-hmaccalc \
 openssl \
 libkcapi-tools \
 bash \
 glibc \
 coreutils \
 perl-interpreter \
"

URI_libkcapi-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libkcapi-tools-1.5.0-3.el10.x86_64_v2.rpm;name=libkcapi-tools;unpack=0"
SRC_URI += "${URI_libkcapi-tools}"
SRC_URI[libkcapi-tools.sha256sum] = "3af0c166ea004ffc25fa9dab45a7f9f1d46d3777cb03bdbd1ce284beeb5975b4"
RDEPENDS:libkcapi-tools = " \
 glibc \
 libkcapi \
 libkcapi-hasher \
"
