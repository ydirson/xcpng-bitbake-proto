# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libhandy"
PE = "0"
PV = "1.8.3"
PR = "4.el10"
PACKAGES = "libhandy libhandy-devel"
PROVIDES = "rpm/libhandy rpm/libhandy-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libhandy-1.8.3-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af09d0b9c8cd4c7462fd5780016957c72311e0f442e2eae46614e5345a41b340"

URI_libhandy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libhandy-1.8.3-4.el10.x86_64_v2.rpm;name=libhandy;unpack=0"
SRC_URI += "${URI_libhandy}"
SRC_URI[libhandy.sha256sum] = "6d94b5cbb1313195b7f88d3d731cb97af1c2316ddfcc94b89d9911fc3d2de745"
RDEPENDS:libhandy = " \
 atk \
 libgcc \
 fribidi \
 pango \
 gdk-pixbuf2 \
 cairo \
 glib2 \
 gtk3 \
 glibc \
"

URI_libhandy-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libhandy-devel-1.8.3-4.el10.x86_64_v2.rpm;name=libhandy-devel;unpack=0"
SRC_URI += "${URI_libhandy-devel}"
SRC_URI[libhandy-devel.sha256sum] = "5d5194f123cc2b6ad1844eeada2e1d52fa5f07b8d1ab353fef522a6129970cfa"
RDEPENDS:libhandy-devel = " \
 libhandy \
 pkgconf-pkg-config \
 gtk3-devel \
"
