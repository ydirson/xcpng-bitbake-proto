# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-requests-gssapi"
PE = "0"
PV = "1.2.3"
PR = "13.el10"
PACKAGES = "python3-requests-gssapi"
PROVIDES = "rpm/python3-requests-gssapi"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-requests-gssapi-1.2.3-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e33864dc0c6333d6887c7d04c382390b9db6e760145617f3c753f0f2eee3f961"

URI_python3-requests-gssapi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-requests-gssapi-1.2.3-13.el10.noarch.rpm;name=python3-requests-gssapi;unpack=0"
SRC_URI += "${URI_python3-requests-gssapi}"
SRC_URI[python3-requests-gssapi.sha256sum] = "a298d6f8878c778369c3d66462048e2fa6b551d7aa5d9d87dcb03404100e2f15"
RDEPENDS:python3-requests-gssapi = " \
 python3 \
 python3-requests \
 python3-gssapi \
"
