# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Term-Cap"
PE = "0"
PV = "1.18"
PR = "511.el10"
PACKAGES = "perl-Term-Cap perl-Term-Cap-tests"
PROVIDES = "rpm/perl-Term-Cap rpm/perl-Term-Cap-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Term-Cap-1.18-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4a81029eb26e5c07dbbdd0308b984f26cb0e3f1ae96676c569009045e1399a0"

URI_perl-Term-Cap = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Term-Cap-1.18-511.el10.noarch.rpm;name=perl-Term-Cap;unpack=0"
SRC_URI += "${URI_perl-Term-Cap}"
SRC_URI[perl-Term-Cap.sha256sum] = "e6c0e01f8d0170d762de6f3d481c064186b35aafb2afefa8218708b637e4ecb6"
RDEPENDS:perl-Term-Cap = " \
 ncurses \
 perl-vars \
 perl-libs \
 perl-Carp \
"

URI_perl-Term-Cap-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Term-Cap-tests-1.18-511.el10.noarch.rpm;name=perl-Term-Cap-tests;unpack=0"
SRC_URI += "${URI_perl-Term-Cap-tests}"
SRC_URI[perl-Term-Cap-tests.sha256sum] = "5284e42b6faf5f7102f49be2120b10e571e148d915f9ca49c833aab60231813d"
RDEPENDS:perl-Term-Cap-tests = " \
 perl-Test-Harness \
 perl-Test-Simple \
 bash \
 perl-Term-Cap \
 perl-interpreter \
"
