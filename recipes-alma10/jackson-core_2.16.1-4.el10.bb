# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jackson-core"
PE = "0"
PV = "2.16.1"
PR = "4.el10"
PACKAGES = "jackson-core"
PROVIDES = "rpm/jackson-core"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/jackson-core-2.16.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0bc41273b85a9dbf06494b57bee3c207f9165872fd1a36d380ebd535e26ed55"

URI_jackson-core = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/jackson-core-2.16.1-4.el10.noarch.rpm;name=jackson-core;unpack=0"
SRC_URI += "${URI_jackson-core}"
SRC_URI[jackson-core.sha256sum] = "6e155b3a48079f65ea6bc1f9caa3c46a5b99050a7b036a6d14ee9b60dcd7c9e5"
RDEPENDS:jackson-core = " \
 javapackages-filesystem \
 java-21-openjdk-headless \
"
