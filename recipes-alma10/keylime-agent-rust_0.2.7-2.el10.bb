# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "keylime-agent-rust"
PE = "0"
PV = "0.2.7"
PR = "2.el10"
PACKAGES = "keylime-agent-rust"
PROVIDES = "rpm/keylime-agent-rust"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/keylime-agent-rust-0.2.7-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ba04a8d91764a7544c40ee91d73af8a7e7f3a4a7ff9a27f7532e5a1bdb90d5e"

URI_keylime-agent-rust = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/keylime-agent-rust-0.2.7-2.el10.x86_64_v2.rpm;name=keylime-agent-rust;unpack=0"
SRC_URI += "${URI_keylime-agent-rust}"
SRC_URI[keylime-agent-rust.sha256sum] = "b97894eddf37e31948aa17a20a7c61983d8fe2040fb8e894c77b50e83a7d43a7"
RDEPENDS:keylime-agent-rust = " \
 util-linux-core \
 openssl-libs \
 libgcc \
 bash \
 keylime-base \
 tpm2-tss \
 glibc \
"
