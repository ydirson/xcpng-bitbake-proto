# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Test-Warnings"
PE = "0"
PV = "0.033"
PR = "3.el10"
PACKAGES = "perl-Test-Warnings"
PROVIDES = "rpm/perl-Test-Warnings"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Test-Warnings-0.033-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1da935abd357d9846b950d0d7dd8bf5d0de19a1601c71ad125a6f191d51ce8ee"

URI_perl-Test-Warnings = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Test-Warnings-0.033-3.el10.noarch.rpm;name=perl-Test-Warnings;unpack=0"
SRC_URI += "${URI_perl-Test-Warnings}"
SRC_URI[perl-Test-Warnings.sha256sum] = "20220a911ad95a86082703811118cdaafc83aea8c30601140fbfe47743250fda"
RDEPENDS:perl-Test-Warnings = " \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-parent \
 perl-Exporter \
"
