# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mingw-termcap"
PE = "0"
PV = "1.3.1"
PR = "39.el10"
PACKAGES = "mingw32-termcap mingw64-termcap mingw32-termcap-static mingw64-termcap-static"
PROVIDES = "rpm/mingw32-termcap rpm/mingw64-termcap rpm/mingw32-termcap-static rpm/mingw64-termcap-static"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/mingw-termcap-1.3.1-39.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe9a9eefec9e46af92490f172c510552efbf31fd10bce7e3401fb3f8b356fe03"

URI_mingw32-termcap = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw32-termcap-1.3.1-39.el10.noarch.rpm;name=mingw32-termcap;unpack=0"
SRC_URI += "${URI_mingw32-termcap}"
SRC_URI[mingw32-termcap.sha256sum] = "efd61cfbab544ff4d51eb2fe937f9d8e8e453f35a719b5ca5eb7076527cdd224"
RDEPENDS:mingw32-termcap = " \
 mingw32-crt \
 mingw32-filesystem \
"

URI_mingw64-termcap = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw64-termcap-1.3.1-39.el10.noarch.rpm;name=mingw64-termcap;unpack=0"
SRC_URI += "${URI_mingw64-termcap}"
SRC_URI[mingw64-termcap.sha256sum] = "839570258a98dbdb62659587c75571b5ec824387bba2ccd3e0a85ea5337b3957"
RDEPENDS:mingw64-termcap = " \
 mingw64-crt \
 mingw64-filesystem \
"

URI_mingw32-termcap-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mingw32-termcap-static-1.3.1-39.el10.noarch.rpm;name=mingw32-termcap-static;unpack=0"
SRC_URI += "${URI_mingw32-termcap-static}"
SRC_URI[mingw32-termcap-static.sha256sum] = "786b53c06772d6b6a96c594c234d02df4e7e1a3de9731a98e7d4c4b7868fe9e1"
RDEPENDS:mingw32-termcap-static = " \
 mingw32-termcap \
"

URI_mingw64-termcap-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mingw64-termcap-static-1.3.1-39.el10.noarch.rpm;name=mingw64-termcap-static;unpack=0"
SRC_URI += "${URI_mingw64-termcap-static}"
SRC_URI[mingw64-termcap-static.sha256sum] = "298b276682d3cc1407bf3b69a681c852f10a446a9688cec95c6be0bdbe62a60b"
RDEPENDS:mingw64-termcap-static = " \
 mingw64-termcap \
"
