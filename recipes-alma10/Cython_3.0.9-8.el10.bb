# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "Cython"
PE = "0"
PV = "3.0.9"
PR = "8.el10"
PACKAGES = "python3-cython"
PROVIDES = "rpm/python3-cython"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/Cython-3.0.9-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3ab4205b143d40ec28fc1b2a96ea1008b648f110e69a140d3031e0f91f169e6"

URI_python3-cython = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-cython-3.0.9-8.el10.x86_64_v2.rpm;name=python3-cython;unpack=0"
SRC_URI += "${URI_python3-cython}"
SRC_URI[python3-cython.sha256sum] = "61960466bb2a985cd0119990ed70bce13295fec89322c7be7242187f271fe459"
RDEPENDS:python3-cython = " \
 glibc \
 python3 \
"
