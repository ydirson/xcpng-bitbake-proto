# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "driverctl"
PE = "0"
PV = "0.115"
PR = "2.el10"
PACKAGES = "driverctl"
PROVIDES = "rpm/driverctl"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/driverctl-0.115-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "163d1ae9639a352eaab7ea6ec20d94d07c60d5bbeb63c81bb1b223095ff30d55"

URI_driverctl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/driverctl-0.115-2.el10.noarch.rpm;name=driverctl;unpack=0"
SRC_URI += "${URI_driverctl}"
SRC_URI[driverctl.sha256sum] = "606363c647916b3eac3cbadd44c9027be8f623604085eb2b10419776fbc2210d"
RDEPENDS:driverctl = " \
 coreutils \
 systemd-udev \
 bash \
"
