# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-nl"
PE = "0"
PV = "2.20.19"
PR = "15.el10"
PACKAGES = "hunspell-nl"
PROVIDES = "rpm/hunspell-nl"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-nl-2.20.19-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "531154c7ad7b0a5279039b9dfd0bf208c1aa70c50d55a2ee4947afbaad2d4a8d"

URI_hunspell-nl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-nl-2.20.19-15.el10.noarch.rpm;name=hunspell-nl;unpack=0"
SRC_URI += "${URI_hunspell-nl}"
SRC_URI[hunspell-nl.sha256sum] = "b5c6c169fd5ad4183419ccefa1b71651dd62169efce8a693b972dc959c2e2127"
RDEPENDS:hunspell-nl = " \
 hunspell \
"
