# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "graphviz"
PE = "0"
PV = "9.0.0"
PR = "15.el10"
PACKAGES = "graphviz graphviz-doc graphviz-gd graphviz-python3 graphviz-ruby graphviz-devel graphviz-go graphviz-graphs graphviz-java graphviz-lua graphviz-perl graphviz-tcl"
PROVIDES = "rpm/graphviz rpm/graphviz-doc rpm/graphviz-gd rpm/graphviz-python3 rpm/graphviz-ruby rpm/graphviz-devel rpm/graphviz-go rpm/graphviz-graphs rpm/graphviz-java rpm/graphviz-lua rpm/graphviz-perl rpm/graphviz-tcl"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/graphviz-9.0.0-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76e417c1500659ac2bda1ce65c4ba3e59a4d1019d91ff0187281a0762fa7d107"

URI_graphviz = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/graphviz-9.0.0-15.el10.x86_64_v2.rpm;name=graphviz;unpack=0"
SRC_URI += "${URI_graphviz}"
SRC_URI[graphviz.sha256sum] = "cd98550c7bd992fe0e3c2f3e09ec327e087eb92f66456767f1d8e6749999f23b"
RDEPENDS:graphviz = " \
 libtool-ltdl \
 pango \
 fontconfig \
 libX11 \
 poppler-glib \
 urw-base35-fonts \
 libXrender \
 libstdc++ \
 cairo \
 gd \
 zlib-ng-compat \
 librsvg2 \
 libgcc \
 libwebp \
 gdk-pixbuf2 \
 libgs \
 bash \
 expat \
 freetype \
 harfbuzz \
 glib2 \
 glibc \
"

URI_graphviz-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/graphviz-doc-9.0.0-15.el10.x86_64_v2.rpm;name=graphviz-doc;unpack=0"
SRC_URI += "${URI_graphviz-doc}"
SRC_URI[graphviz-doc.sha256sum] = "db2c28cdfad71c196327d645187093b540eacfb2908ff22a224dfe79a9ca819b"
RDEPENDS:graphviz-doc = ""

URI_graphviz-gd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/graphviz-gd-9.0.0-15.el10.x86_64_v2.rpm;name=graphviz-gd;unpack=0"
SRC_URI += "${URI_graphviz-gd}"
SRC_URI[graphviz-gd.sha256sum] = "db3a0ca3530958617efdaf9865b45eca2064626a938b3acc3668f53c35bd728c"
RDEPENDS:graphviz-gd = " \
 gd \
 zlib-ng-compat \
 libtool-ltdl \
 harfbuzz \
 pango \
 cairo \
 glib2 \
 expat \
 glibc \
 graphviz \
"

URI_graphviz-python3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/graphviz-python3-9.0.0-15.el10.x86_64_v2.rpm;name=graphviz-python3;unpack=0"
SRC_URI += "${URI_graphviz-python3}"
SRC_URI[graphviz-python3.sha256sum] = "036808b78dd4f0dd73df7b74dbfd3e635de4d12a391300bd7dd59f7ae421392e"
RDEPENDS:graphviz-python3 = " \
 python3 \
 zlib-ng-compat \
 libtool-ltdl \
 libgcc \
 libstdc++ \
 expat \
 glibc \
 graphviz \
"

URI_graphviz-ruby = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/graphviz-ruby-9.0.0-15.el10.x86_64_v2.rpm;name=graphviz-ruby;unpack=0"
SRC_URI += "${URI_graphviz-ruby}"
SRC_URI[graphviz-ruby.sha256sum] = "2a0a1817b9d7a665673a1285a13223244969241f4622ef28fe23b9d9ba2ebd71"
RDEPENDS:graphviz-ruby = " \
 zlib-ng-compat \
 libtool-ltdl \
 libgcc \
 ruby \
 libstdc++ \
 ruby-libs \
 expat \
 glibc \
 graphviz \
"

URI_graphviz-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/graphviz-devel-9.0.0-15.el10.x86_64_v2.rpm;name=graphviz-devel;unpack=0"
SRC_URI += "${URI_graphviz-devel}"
SRC_URI[graphviz-devel.sha256sum] = "e2fd2ed454977de528d1a2c6e9d1936568cfa48a3d2ba7aa9011056d22a08d68"
RDEPENDS:graphviz-devel = " \
 graphviz \
 graphviz-gd \
 pkgconf-pkg-config \
"

URI_graphviz-go = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/graphviz-go-9.0.0-15.el10.x86_64_v2.rpm;name=graphviz-go;unpack=0"
SRC_URI += "${URI_graphviz-go}"
SRC_URI[graphviz-go.sha256sum] = "d3fc2f5398c332bfa16c205d1087cb73161e2d3b3e45c0cb76fd804613c7aebf"
RDEPENDS:graphviz-go = " \
 zlib-ng-compat \
 libtool-ltdl \
 libgcc \
 libstdc++ \
 expat \
 glibc \
 graphviz \
 golang \
"

URI_graphviz-graphs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/graphviz-graphs-9.0.0-15.el10.x86_64_v2.rpm;name=graphviz-graphs;unpack=0"
SRC_URI += "${URI_graphviz-graphs}"
SRC_URI[graphviz-graphs.sha256sum] = "36928647ebed1d5f7bd91cc03e1b5a93d211f10620f9c247882eae8b1f447954"
RDEPENDS:graphviz-graphs = ""

URI_graphviz-java = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/graphviz-java-9.0.0-15.el10.x86_64_v2.rpm;name=graphviz-java;unpack=0"
SRC_URI += "${URI_graphviz-java}"
SRC_URI[graphviz-java.sha256sum] = "459560d73e4ec5803be8006ee1f17081f08533d1ecc0b8705bad0423e4abd380"
RDEPENDS:graphviz-java = " \
 zlib-ng-compat \
 libtool-ltdl \
 libgcc \
 libstdc++ \
 expat \
 glibc \
 graphviz \
"

URI_graphviz-lua = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/graphviz-lua-9.0.0-15.el10.x86_64_v2.rpm;name=graphviz-lua;unpack=0"
SRC_URI += "${URI_graphviz-lua}"
SRC_URI[graphviz-lua.sha256sum] = "5bd2f035ba1cdb5682352fc302c72ea451843a946fedf0fd988f8a5eb121b6ed"
RDEPENDS:graphviz-lua = " \
 zlib-ng-compat \
 libtool-ltdl \
 lua-libs \
 libgcc \
 libstdc++ \
 lua \
 expat \
 glibc \
 graphviz \
"

URI_graphviz-perl = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/graphviz-perl-9.0.0-15.el10.x86_64_v2.rpm;name=graphviz-perl;unpack=0"
SRC_URI += "${URI_graphviz-perl}"
SRC_URI[graphviz-perl.sha256sum] = "2b5513d3a6e2d07e143a6c6e24b0a6c8b8dfa9f288a14cdbc515aaf81263bbb6"
RDEPENDS:graphviz-perl = " \
 zlib-ng-compat \
 perl-libs \
 libtool-ltdl \
 libxcrypt \
 libgcc \
 perl-DynaLoader \
 libstdc++ \
 expat \
 glibc \
 graphviz \
 perl-Exporter \
 perl-base \
"

URI_graphviz-tcl = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/graphviz-tcl-9.0.0-15.el10.x86_64_v2.rpm;name=graphviz-tcl;unpack=0"
SRC_URI += "${URI_graphviz-tcl}"
SRC_URI[graphviz-tcl.sha256sum] = "960a61c5418d7318c32c3661f44d34c8599eaf30946a474a945f2a69798981f3"
RDEPENDS:graphviz-tcl = " \
 gd \
 zlib-ng-compat \
 libtool-ltdl \
 freetype \
 libgcc \
 harfbuzz \
 tk \
 pango \
 fontconfig \
 tcl \
 libstdc++ \
 glib2 \
 cairo \
 expat \
 glibc \
 graphviz \
"
