# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "umockdev"
PE = "0"
PV = "0.18.3"
PR = "2.el10"
PACKAGES = "umockdev umockdev-devel"
PROVIDES = "rpm/umockdev rpm/umockdev-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/umockdev-0.18.3-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1328c19c77a13563a766243f832c3a758942c86a8a358eaf8d89a2c961af693d"

URI_umockdev = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/umockdev-0.18.3-2.el10.x86_64_v2.rpm;name=umockdev;unpack=0"
SRC_URI += "${URI_umockdev}"
SRC_URI[umockdev.sha256sum] = "c4ad1d410dc2daf1b0c37253d8658a60bc5bc577d861d1a7b88fdc2ad730687b"
RDEPENDS:umockdev = " \
 libpcap \
 systemd-libs \
 bash \
 glib2 \
 glibc \
 libselinux \
"

URI_umockdev-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/umockdev-devel-0.18.3-2.el10.x86_64_v2.rpm;name=umockdev-devel;unpack=0"
SRC_URI += "${URI_umockdev-devel}"
SRC_URI[umockdev-devel.sha256sum] = "f07472143ffa69ed6a03e98d0c68012b3471cdc1e72c6f32c4af085ea85b3f5c"
RDEPENDS:umockdev-devel = " \
 umockdev \
 glib2-devel \
 pkgconf-pkg-config \
"
