# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "unzip"
PE = "0"
PV = "6.0"
PR = "68.el10"
PACKAGES = "unzip"
PROVIDES = "rpm/unzip"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/unzip-6.0-68.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "105b989e884c15523b13a95502103110dbc71fc5d8ff01f7730466215dcf09d2"

URI_unzip = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/unzip-6.0-68.el10.x86_64_v2.rpm;name=unzip;unpack=0"
SRC_URI += "${URI_unzip}"
SRC_URI[unzip.sha256sum] = "61fe741d79502002f0fa00d129635e43ab528cac2f8133a5c566edb032714f72"
RDEPENDS:unzip = " \
 glibc \
 bash \
 bzip2-libs \
"
