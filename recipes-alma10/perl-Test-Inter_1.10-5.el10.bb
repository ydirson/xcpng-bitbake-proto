# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Test-Inter"
PE = "0"
PV = "1.10"
PR = "5.el10"
PACKAGES = "perl-Test-Inter perl-Test-Inter-tests"
PROVIDES = "rpm/perl-Test-Inter rpm/perl-Test-Inter-tests"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-Test-Inter-1.10-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2bbf9baaaa6aa5b7ceacecf97d0278a62046fb813eb57bd856a57e4adb47658f"

URI_perl-Test-Inter = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Test-Inter-1.10-5.el10.noarch.rpm;name=perl-Test-Inter;unpack=0"
SRC_URI += "${URI_perl-Test-Inter}"
SRC_URI[perl-Test-Inter.sha256sum] = "2f2ea3217fc3f8172ae34778758bea0277cbb178fb20ab9c90d3918e9f641e9a"
RDEPENDS:perl-Test-Inter = " \
 perl-libs \
 perl-IO \
 perl-File-Basename \
 perl-PathTools \
 perl-lib \
"

URI_perl-Test-Inter-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Test-Inter-tests-1.10-5.el10.noarch.rpm;name=perl-Test-Inter-tests;unpack=0"
SRC_URI += "${URI_perl-Test-Inter-tests}"
SRC_URI[perl-Test-Inter-tests.sha256sum] = "9a1f082645178272ce0118ba5088f006b36db7cc1cfe8887dfd49ea75a7014ab"
RDEPENDS:perl-Test-Inter-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Inter \
 bash \
 perl-interpreter \
 perl-lib \
"
