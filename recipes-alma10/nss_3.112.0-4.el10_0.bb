# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "nss"
PE = "0"
PV = "3.112.0"
PR = "4.el10_0"
PACKAGES = "nspr nspr-devel nss nss-devel nss-softokn nss-softokn-devel nss-softokn-freebl nss-softokn-freebl-devel nss-sysinit nss-tools nss-util nss-util-devel nss-pkcs11-devel"
PROVIDES = "rpm/nspr rpm/nspr-devel rpm/nss rpm/nss-devel rpm/nss-softokn rpm/nss-softokn-devel rpm/nss-softokn-freebl rpm/nss-softokn-freebl-devel rpm/nss-sysinit rpm/nss-tools rpm/nss-util rpm/nss-util-devel rpm/nss-pkcs11-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/nss-3.112.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "baafcec849eca88a230d441e8e29e2661dc6586b07ababd347fc94c4d0487985"

URI_nspr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nspr-4.36.0-4.el10_0.x86_64_v2.rpm;name=nspr;unpack=0"
SRC_URI += "${URI_nspr}"
SRC_URI[nspr.sha256sum] = "31d26b19c9201d94e11bd57be069cb178fa6a46e249f8e5491bcfb341fbf22f6"
RDEPENDS:nspr = " \
 glibc \
"

URI_nspr-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nspr-devel-4.36.0-4.el10_0.x86_64_v2.rpm;name=nspr-devel;unpack=0"
SRC_URI += "${URI_nspr-devel}"
SRC_URI[nspr-devel.sha256sum] = "4012c3949fa1b9614b0f2936ec0fabf61c865989437d52dee8b97d298ddfedba"
RDEPENDS:nspr-devel = " \
 bash \
 pkgconf-pkg-config \
 nspr \
"

URI_nss = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nss-3.112.0-4.el10_0.x86_64_v2.rpm;name=nss;unpack=0"
SRC_URI += "${URI_nss}"
SRC_URI[nss.sha256sum] = "62d780173e10f008fc0ee873855708f07203c8513711a8a124709c76d31bf73d"
RDEPENDS:nss = " \
 crypto-policies \
 nss-softokn \
 p11-kit-trust \
 nss-sysinit \
 nss-util \
 bash \
 glibc \
 nspr \
"

URI_nss-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nss-devel-3.112.0-4.el10_0.x86_64_v2.rpm;name=nss-devel;unpack=0"
SRC_URI += "${URI_nss-devel}"
SRC_URI[nss-devel.sha256sum] = "235f434f4887b13fd59f7b472c55ae5d0e6f67122c735943d355aaeb2afc50f2"
RDEPENDS:nss-devel = " \
 nspr-devel \
 nss \
 nss-softokn-devel \
 pkgconf-pkg-config \
 bash \
 nss-util-devel \
"

URI_nss-softokn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nss-softokn-3.112.0-4.el10_0.x86_64_v2.rpm;name=nss-softokn;unpack=0"
SRC_URI += "${URI_nss-softokn}"
SRC_URI[nss-softokn.sha256sum] = "b022f2d189cc0b60c8f8656cd571a7c09b889881237317c15acac3e4fc5482ff"
RDEPENDS:nss-softokn = " \
 nss-softokn-freebl \
 sqlite-libs \
 nss-util \
 glibc \
 nspr \
"

URI_nss-softokn-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nss-softokn-devel-3.112.0-4.el10_0.x86_64_v2.rpm;name=nss-softokn-devel;unpack=0"
SRC_URI += "${URI_nss-softokn-devel}"
SRC_URI[nss-softokn-devel.sha256sum] = "e315aa49dcfd1d296c097e3b0f0d5270c0eb45df5bad558ee223bffa86602177"
RDEPENDS:nss-softokn-devel = " \
 nspr-devel \
 nss-softokn \
 pkgconf-pkg-config \
 nss-softokn-freebl-devel \
 bash \
 nss-util-devel \
"

URI_nss-softokn-freebl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nss-softokn-freebl-3.112.0-4.el10_0.x86_64_v2.rpm;name=nss-softokn-freebl;unpack=0"
SRC_URI += "${URI_nss-softokn-freebl}"
SRC_URI[nss-softokn-freebl.sha256sum] = "3d3e39c21f471c750221209923c807d8821385eafaa1370f0dcfa570d642aa49"
RDEPENDS:nss-softokn-freebl = " \
 glibc \
 nss-util \
 bash \
 nspr \
"

URI_nss-softokn-freebl-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nss-softokn-freebl-devel-3.112.0-4.el10_0.x86_64_v2.rpm;name=nss-softokn-freebl-devel;unpack=0"
SRC_URI += "${URI_nss-softokn-freebl-devel}"
SRC_URI[nss-softokn-freebl-devel.sha256sum] = "caf6dce01f0647dca366efdbf543b10da8965a165d34ba0391ae27b944166de2"
RDEPENDS:nss-softokn-freebl-devel = " \
 nss-softokn-freebl \
"

URI_nss-sysinit = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nss-sysinit-3.112.0-4.el10_0.x86_64_v2.rpm;name=nss-sysinit;unpack=0"
SRC_URI += "${URI_nss-sysinit}"
SRC_URI[nss-sysinit.sha256sum] = "ccc4b86a31d3dc6283dcc9d269141d7d52f5df175eb74c3737a6c6e5e160c287"
RDEPENDS:nss-sysinit = " \
 glibc \
 nss \
 bash \
 nss-util \
 sed \
 coreutils \
 nspr \
"

URI_nss-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nss-tools-3.112.0-4.el10_0.x86_64_v2.rpm;name=nss-tools;unpack=0"
SRC_URI += "${URI_nss-tools}"
SRC_URI[nss-tools.sha256sum] = "673b322ef75fe6e31e3251bc8e39d29d6d8104883993a5c7c900e4d4d2640b3a"
RDEPENDS:nss-tools = " \
 zlib-ng-compat \
 nss \
 nss-util \
 glibc \
 nspr \
"

URI_nss-util = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nss-util-3.112.0-4.el10_0.x86_64_v2.rpm;name=nss-util;unpack=0"
SRC_URI += "${URI_nss-util}"
SRC_URI[nss-util.sha256sum] = "99113324e25db29b48ee4ae68695e7f55a6042213e1a8b8341686d322296d5f8"
RDEPENDS:nss-util = " \
 glibc \
 nspr \
"

URI_nss-util-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nss-util-devel-3.112.0-4.el10_0.x86_64_v2.rpm;name=nss-util-devel;unpack=0"
SRC_URI += "${URI_nss-util-devel}"
SRC_URI[nss-util-devel.sha256sum] = "5f58e3de3f241a837f4cad238ccfe9472783389eb71460b568479a957f943bb2"
RDEPENDS:nss-util-devel = " \
 nspr-devel \
 nss-util \
 bash \
 pkgconf-pkg-config \
"

URI_nss-pkcs11-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/nss-pkcs11-devel-3.112.0-4.el10_0.x86_64_v2.rpm;name=nss-pkcs11-devel;unpack=0"
SRC_URI += "${URI_nss-pkcs11-devel}"
SRC_URI[nss-pkcs11-devel.sha256sum] = "cb6e0b1115951100d18ae66d1f7544a3ec00762a46a0608ed8606482dac115c1"
RDEPENDS:nss-pkcs11-devel = " \
 nss-softokn-freebl-devel \
 nss-devel \
"
