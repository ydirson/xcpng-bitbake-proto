# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-configshell"
PE = "1"
PV = "1.1.30"
PR = "8.el10"
PACKAGES = "python3-configshell"
PROVIDES = "rpm/python3-configshell"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/python-configshell-1.1.30-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d6ca8fdf255b188a4a2f462cf521973a43cbcfb99a490c4951affe3b0755724"

URI_python3-configshell = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-configshell-1.1.30-8.el10.noarch.rpm;name=python3-configshell;unpack=0"
SRC_URI += "${URI_python3-configshell}"
SRC_URI[python3-configshell.sha256sum] = "66a0f41a116b4f4cb57cb2fa997926feca1be67494433e9c1485c3460e71d4a5"
RDEPENDS:python3-configshell = " \
 python3 \
 python3-urwid \
 python3-six \
 python3-pyparsing \
"
