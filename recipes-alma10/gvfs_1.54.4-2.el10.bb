# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gvfs"
PE = "0"
PV = "1.54.4"
PR = "2.el10"
PACKAGES = "gvfs gvfs-client gvfs-fuse gvfs-goa gvfs-gphoto2 gvfs-mtp gvfs-smb"
PROVIDES = "rpm/gvfs rpm/gvfs-client rpm/gvfs-fuse rpm/gvfs-goa rpm/gvfs-gphoto2 rpm/gvfs-mtp rpm/gvfs-smb"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gvfs-1.54.4-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bde121f7dcbcdd17d875b2a202379b8b2422761a3b058c867bb710af36916c6f"

URI_gvfs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gvfs-1.54.4-2.el10.x86_64_v2.rpm;name=gvfs;unpack=0"
SRC_URI += "${URI_gvfs}"
SRC_URI[gvfs.sha256sum] = "2d95385a03012da26738f6a56016c40a41267e5a61f2a95be965cf3646111e5a"
RDEPENDS:gvfs = " \
 systemd-libs \
 gvfs-client \
 libudisks2 \
 gcr-libs \
 libgcc \
 libxml2 \
 avahi-glib \
 libgudev \
 libsecret \
 avahi-libs \
 bash \
 libsoup3 \
 gsettings-desktop-schemas \
 polkit \
 polkit-libs \
 wsdd \
 glib2 \
 glibc \
 udisks2 \
"

URI_gvfs-client = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gvfs-client-1.54.4-2.el10.x86_64_v2.rpm;name=gvfs-client;unpack=0"
SRC_URI += "${URI_gvfs-client}"
SRC_URI[gvfs-client.sha256sum] = "f1b45fc399dea0c5615d2960f4067aea8363491e5d39b48db28f378fdc88787d"
RDEPENDS:gvfs-client = " \
 glibc \
 libgcc \
 glib2 \
"

URI_gvfs-fuse = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gvfs-fuse-1.54.4-2.el10.x86_64_v2.rpm;name=gvfs-fuse;unpack=0"
SRC_URI += "${URI_gvfs-fuse}"
SRC_URI[gvfs-fuse.sha256sum] = "6d65f8cc6b72f7c3a0b3435bbb38c2e329dfe88155bad55ee286d27271e74b61"
RDEPENDS:gvfs-fuse = " \
 gvfs \
 gvfs-client \
 fuse3 \
 fuse3-libs \
 glib2 \
 glibc \
"

URI_gvfs-goa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gvfs-goa-1.54.4-2.el10.x86_64_v2.rpm;name=gvfs-goa;unpack=0"
SRC_URI += "${URI_gvfs-goa}"
SRC_URI[gvfs-goa.sha256sum] = "b557b537cb74d55e810870367aa39e12d22148b3497ca0fe6e19bdd42489fd95"
RDEPENDS:gvfs-goa = " \
 gvfs \
 gvfs-client \
 bash \
 glib2 \
 gnome-online-accounts \
 glibc \
"

URI_gvfs-gphoto2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gvfs-gphoto2-1.54.4-2.el10.x86_64_v2.rpm;name=gvfs-gphoto2;unpack=0"
SRC_URI += "${URI_gvfs-gphoto2}"
SRC_URI[gvfs-gphoto2.sha256sum] = "ad08c1261c69fe52dfd69c5725dd9c87c143e2cccefd66cc616c7b626eaf9812"
RDEPENDS:gvfs-gphoto2 = " \
 gvfs \
 gvfs-client \
 libgphoto2 \
 libgudev \
 bash \
 glib2 \
 glibc \
"

URI_gvfs-mtp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gvfs-mtp-1.54.4-2.el10.x86_64_v2.rpm;name=gvfs-mtp;unpack=0"
SRC_URI += "${URI_gvfs-mtp}"
SRC_URI[gvfs-mtp.sha256sum] = "792e4e9269a97cd9b5bf7ba51ef9532de34010d09a0ef061e6f53cef5e1f965d"
RDEPENDS:gvfs-mtp = " \
 gvfs \
 gvfs-client \
 libgudev \
 bash \
 glib2 \
 libmtp \
 glibc \
 libusb1 \
"

URI_gvfs-smb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gvfs-smb-1.54.4-2.el10.x86_64_v2.rpm;name=gvfs-smb;unpack=0"
SRC_URI += "${URI_gvfs-smb}"
SRC_URI[gvfs-smb.sha256sum] = "7737d42d4dd3eb43da10db436ba2e4fc5913ec794175c37d57767e6eb3748512"
RDEPENDS:gvfs-smb = " \
 libsmbclient \
 gvfs \
 gvfs-client \
 libgcc \
 bash \
 glib2 \
 glibc \
"
