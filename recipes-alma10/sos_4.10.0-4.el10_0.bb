# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sos"
PE = "0"
PV = "4.10.0"
PR = "4.el10_0"
PACKAGES = "sos sos-audit"
PROVIDES = "rpm/sos rpm/sos-audit"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/sos-4.10.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "456dbe8e1281a041004888551ef6d66cb7ee233250f2b80cb5ba2877a37922ba"

URI_sos = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/sos-4.10.0-4.el10_0.noarch.rpm;name=sos;unpack=0"
SRC_URI += "${URI_sos}"
SRC_URI[sos.sha256sum] = "48219fec7104978d4599350a4a2040434684c48ee4850e0b105ce2925736f574"
RDEPENDS:sos = " \
 python3 \
 python3-pyyaml \
 python3-requests \
 python3-setuptools \
 python3-packaging \
 python3-pexpect \
"

URI_sos-audit = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sos-audit-4.10.0-4.el10_0.noarch.rpm;name=sos-audit;unpack=0"
SRC_URI += "${URI_sos-audit}"
SRC_URI[sos-audit.sha256sum] = "8cf06193ff8b15f10ebfa9d1c6e7cad39d983032ba97e9681ae6c1427ec5a2a4"
RDEPENDS:sos-audit = " \
 bash \
"
