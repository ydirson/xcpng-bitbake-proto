# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xmlsec1"
PE = "1"
PV = "1.2.39"
PR = "3.el10"
PACKAGES = "xmlsec1 xmlsec1-nss xmlsec1-openssl xmlsec1-devel xmlsec1-openssl-devel xmlsec1-nss-devel"
PROVIDES = "rpm/xmlsec1 rpm/xmlsec1-nss rpm/xmlsec1-openssl rpm/xmlsec1-devel rpm/xmlsec1-openssl-devel rpm/xmlsec1-nss-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xmlsec1-1.2.39-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8039d87833da7ba15538ba44fea81d12cf0fa749925236680e98972dbfb84d61"

URI_xmlsec1 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xmlsec1-1.2.39-3.el10.x86_64_v2.rpm;name=xmlsec1;unpack=0"
SRC_URI += "${URI_xmlsec1}"
SRC_URI[xmlsec1.sha256sum] = "fa29fa72f9237ba251c9ca9cfea84e47eaf4358cdc3211e9254b7f2973a1bb0e"
RDEPENDS:xmlsec1 = " \
 glibc \
 libxslt \
 libxml2 \
 libtool-ltdl \
"

URI_xmlsec1-nss = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xmlsec1-nss-1.2.39-3.el10.x86_64_v2.rpm;name=xmlsec1-nss;unpack=0"
SRC_URI += "${URI_xmlsec1-nss}"
SRC_URI[xmlsec1-nss.sha256sum] = "f33fb69dbca936cadcb0cc716cedfa9e312ba4ecf7208f6985dd57d4c785c163"
RDEPENDS:xmlsec1-nss = " \
 nss \
 libxslt \
 libtool-ltdl \
 libxml2 \
 nss-util \
 glibc \
 xmlsec1 \
 nspr \
"

URI_xmlsec1-openssl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xmlsec1-openssl-1.2.39-3.el10.x86_64_v2.rpm;name=xmlsec1-openssl;unpack=0"
SRC_URI += "${URI_xmlsec1-openssl}"
SRC_URI[xmlsec1-openssl.sha256sum] = "bc67e573155944fe1748459447b8f614cfa7c9b935c1cdbba70b5dd0077d6742"
RDEPENDS:xmlsec1-openssl = " \
 libxslt \
 libtool-ltdl \
 openssl-libs \
 libxml2 \
 glibc \
 xmlsec1 \
"

URI_xmlsec1-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xmlsec1-devel-1.2.39-3.el10.x86_64_v2.rpm;name=xmlsec1-devel;unpack=0"
SRC_URI += "${URI_xmlsec1-devel}"
SRC_URI[xmlsec1-devel.sha256sum] = "7ffdd5d7fa4445cfb9a02efd51530e9d8bc6efc2fbf690229aaf85e2415b6607"
RDEPENDS:xmlsec1-devel = " \
 libxml2-devel \
 libxslt-devel \
 pkgconf-pkg-config \
 openssl-devel \
 bash \
 xmlsec1 \
"

URI_xmlsec1-openssl-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xmlsec1-openssl-devel-1.2.39-3.el10.x86_64_v2.rpm;name=xmlsec1-openssl-devel;unpack=0"
SRC_URI += "${URI_xmlsec1-openssl-devel}"
SRC_URI[xmlsec1-openssl-devel.sha256sum] = "5e477ac91a31250bed910f0734bbfc31b5c4a32533ab4109e3c0c6211ef83d7e"
RDEPENDS:xmlsec1-openssl-devel = " \
 libxml2-devel \
 libxslt-devel \
 xmlsec1-devel \
 pkgconf-pkg-config \
 xmlsec1-openssl \
"

URI_xmlsec1-nss-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/xmlsec1-nss-devel-1.2.39-3.el10.x86_64_v2.rpm;name=xmlsec1-nss-devel;unpack=0"
SRC_URI += "${URI_xmlsec1-nss-devel}"
SRC_URI[xmlsec1-nss-devel.sha256sum] = "e9ae049ebcd8ff4b2b3c9ce7112c9630618f02c6b228d293272b1b05724a9cde"
RDEPENDS:xmlsec1-nss-devel = " \
 libxml2-devel \
 nspr-devel \
 libxslt-devel \
 nss-devel \
 xmlsec1-devel \
 pkgconf-pkg-config \
 xmlsec1-nss \
"
