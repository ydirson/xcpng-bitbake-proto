# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xerces-j2"
PE = "0"
PV = "2.12.2"
PR = "14.el10"
PACKAGES = "xerces-j2 xerces-j2-demo xerces-j2-javadoc"
PROVIDES = "rpm/xerces-j2 rpm/xerces-j2-demo rpm/xerces-j2-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xerces-j2-2.12.2-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e9d0f9d376dc2b7d1194e20aeee2ee1d8687c52442a2099c60fcf7fa176aa44"

URI_xerces-j2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xerces-j2-2.12.2-14.el10.noarch.rpm;name=xerces-j2;unpack=0"
SRC_URI += "${URI_xerces-j2}"
SRC_URI[xerces-j2.sha256sum] = "95b7de39b8745871a771bf4124b60492bc98d2ae92f1fdc078f86048555143ce"
RDEPENDS:xerces-j2 = " \
 javapackages-filesystem \
 javapackages-tools \
 bash \
 xml-commons-apis \
 xml-commons-resolver \
"

URI_xerces-j2-demo = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xerces-j2-demo-2.12.2-14.el10.noarch.rpm;name=xerces-j2-demo;unpack=0"
SRC_URI += "${URI_xerces-j2-demo}"
SRC_URI[xerces-j2-demo.sha256sum] = "392eca8d1637b9b150f450f2ef8c7609bd1a87f66ae83aaeb97c6498f8985d1c"
RDEPENDS:xerces-j2-demo = " \
 xerces-j2 \
"

URI_xerces-j2-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xerces-j2-javadoc-2.12.2-14.el10.noarch.rpm;name=xerces-j2-javadoc;unpack=0"
SRC_URI += "${URI_xerces-j2-javadoc}"
SRC_URI[xerces-j2-javadoc.sha256sum] = "cee52e5dde509de00eecf82af1d5ec5d98bf289fe592c9d589a7a671181727ef"
RDEPENDS:xerces-j2-javadoc = " \
 javapackages-filesystem \
"
