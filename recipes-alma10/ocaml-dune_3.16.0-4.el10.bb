# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ocaml-dune"
PE = "0"
PV = "3.16.0"
PR = "4.el10"
PACKAGES = "ocaml-dune ocaml-dune-emacs ocaml-chrome-trace ocaml-chrome-trace-devel ocaml-dune-action-plugin ocaml-dune-action-plugin-devel ocaml-dune-build-info ocaml-dune-build-info-devel ocaml-dune-configurator ocaml-dune-glob ocaml-dune-glob-devel ocaml-dune-private-libs ocaml-dune-private-libs-devel ocaml-dune-rpc ocaml-dune-rpc-devel ocaml-dune-site ocaml-dune-site-devel ocaml-dyn ocaml-dyn-devel ocaml-ocamlc-loc ocaml-ocamlc-loc-devel ocaml-ordering ocaml-ordering-devel ocaml-stdune ocaml-stdune-devel ocaml-xdg ocaml-xdg-devel"
PROVIDES = "rpm/ocaml-dune rpm/ocaml-dune-emacs rpm/ocaml-chrome-trace rpm/ocaml-chrome-trace-devel rpm/ocaml-dune-action-plugin rpm/ocaml-dune-action-plugin-devel rpm/ocaml-dune-build-info rpm/ocaml-dune-build-info-devel rpm/ocaml-dune-configurator rpm/ocaml-dune-glob rpm/ocaml-dune-glob-devel rpm/ocaml-dune-private-libs rpm/ocaml-dune-private-libs-devel rpm/ocaml-dune-rpc rpm/ocaml-dune-rpc-devel rpm/ocaml-dune-site rpm/ocaml-dune-site-devel rpm/ocaml-dyn rpm/ocaml-dyn-devel rpm/ocaml-ocamlc-loc rpm/ocaml-ocamlc-loc-devel rpm/ocaml-ordering rpm/ocaml-ordering-devel rpm/ocaml-stdune rpm/ocaml-stdune-devel rpm/ocaml-xdg rpm/ocaml-xdg-devel"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/ocaml-dune-3.16.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2194f450dc9467deb3fcdafdbf036dcff6b6bd5e7d7ef839eb66257d1405f415"

URI_ocaml-dune = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-dune-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-dune;unpack=0"
SRC_URI += "${URI_ocaml-dune}"
SRC_URI[ocaml-dune.sha256sum] = "749235a377c1d34c8073f3daa8e522b451704c4e8c79b8833f5805b5303e2d05"
RDEPENDS:ocaml-dune = " \
 glibc \
 ocaml-compiler-libs \
 ocaml-rpm-macros \
"

URI_ocaml-dune-emacs = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-dune-emacs-3.16.0-4.el10.noarch.rpm;name=ocaml-dune-emacs;unpack=0"
SRC_URI += "${URI_ocaml-dune-emacs}"
SRC_URI[ocaml-dune-emacs.sha256sum] = "b359fb0bccb1cb532f849df171e7c575eb86dbd6c87bc9c3bed95a8846dc5d9d"
RDEPENDS:ocaml-dune-emacs = " \
 ocaml-dune \
 emacs-filesystem \
"

URI_ocaml-chrome-trace = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-chrome-trace-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-chrome-trace;unpack=0"
SRC_URI += "${URI_ocaml-chrome-trace}"
SRC_URI[ocaml-chrome-trace.sha256sum] = "f4c916092e774afefb170a5fcc180d5bd2d5c63585f455d55b7ff9049b1be854"
RDEPENDS:ocaml-chrome-trace = " \
 glibc \
 ocaml-runtime \
 ocaml-dune \
"

URI_ocaml-chrome-trace-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-chrome-trace-devel-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-chrome-trace-devel;unpack=0"
SRC_URI += "${URI_ocaml-chrome-trace-devel}"
SRC_URI[ocaml-chrome-trace-devel.sha256sum] = "352798bf98ab916a60ee22aebfff5c041f426e218d79fb78d0d747f09a2cbe5f"
RDEPENDS:ocaml-chrome-trace-devel = " \
 ocaml-runtime \
 ocaml \
 ocaml-chrome-trace \
"

URI_ocaml-dune-action-plugin = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-dune-action-plugin-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-dune-action-plugin;unpack=0"
SRC_URI += "${URI_ocaml-dune-action-plugin}"
SRC_URI[ocaml-dune-action-plugin.sha256sum] = "add50d66bace4ba0b3ee192279b2fc6d7b556c7f3ab603a0ae64eaddc6342448"
RDEPENDS:ocaml-dune-action-plugin = " \
 ocaml-runtime \
 ocaml-ordering \
 ocaml-stdune \
 ocaml-xdg \
 ocaml-dune \
 ocaml-dune-glob \
 glibc \
 ocaml-dune-rpc \
 ocaml-dyn \
"

URI_ocaml-dune-action-plugin-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-dune-action-plugin-devel-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-dune-action-plugin-devel;unpack=0"
SRC_URI += "${URI_ocaml-dune-action-plugin-devel}"
SRC_URI[ocaml-dune-action-plugin-devel.sha256sum] = "2e0eba704082bbf5500627494a7cc0db9be4d5cd0bc1dd2cb92485240fa98817"
RDEPENDS:ocaml-dune-action-plugin-devel = " \
 ocaml \
 ocaml-runtime \
 ocaml-ordering \
 ocaml-ordering-devel \
 ocaml-stdune \
 ocaml-stdune-devel \
 ocaml-xdg \
 ocaml-dune-action-plugin \
 ocaml-dune-glob \
 ocaml-dune-glob-devel \
 ocaml-dune-rpc \
 ocaml-dune-rpc-devel \
 ocaml-dyn \
 ocaml-dyn-devel \
"

URI_ocaml-dune-build-info = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-dune-build-info-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-dune-build-info;unpack=0"
SRC_URI += "${URI_ocaml-dune-build-info}"
SRC_URI[ocaml-dune-build-info.sha256sum] = "46e3a8550d370e30e93e699acbce89b98c0b78173bfc8de55d50f69bd36877d9"
RDEPENDS:ocaml-dune-build-info = " \
 glibc \
 ocaml-runtime \
 ocaml-dune \
"

URI_ocaml-dune-build-info-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-dune-build-info-devel-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-dune-build-info-devel;unpack=0"
SRC_URI += "${URI_ocaml-dune-build-info-devel}"
SRC_URI[ocaml-dune-build-info-devel.sha256sum] = "b878de5db1c40892f219c58c229dda1753d1c80f3d1a8095b209944b9bf0d04f"
RDEPENDS:ocaml-dune-build-info-devel = " \
 ocaml-runtime \
 ocaml \
 ocaml-dune-build-info \
"

URI_ocaml-dune-configurator = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-dune-configurator-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-dune-configurator;unpack=0"
SRC_URI += "${URI_ocaml-dune-configurator}"
SRC_URI[ocaml-dune-configurator.sha256sum] = "3aad6998046aec4776e310eb3b8797560d13e8dbb6d868bb7e3d83060115885c"
RDEPENDS:ocaml-dune-configurator = " \
 glibc \
 ocaml-runtime \
 ocaml-dune \
 ocaml-stdune \
"

URI_ocaml-dune-glob = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-dune-glob-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-dune-glob;unpack=0"
SRC_URI += "${URI_ocaml-dune-glob}"
SRC_URI[ocaml-dune-glob.sha256sum] = "782df1c924b69fa33b58424e75b9962c17ec7f1bf6cb664e095409f99b9c5b18"
RDEPENDS:ocaml-dune-glob = " \
 ocaml-runtime \
 ocaml-ordering \
 ocaml-stdune \
 ocaml-dune-private-libs \
 ocaml-dune \
 glibc \
 ocaml-dyn \
"

URI_ocaml-dune-glob-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-dune-glob-devel-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-dune-glob-devel;unpack=0"
SRC_URI += "${URI_ocaml-dune-glob-devel}"
SRC_URI[ocaml-dune-glob-devel.sha256sum] = "aa64305b267dcaacafea4593481d0a5cc1ef81c2039fe8c705f356929f2d71de"
RDEPENDS:ocaml-dune-glob-devel = " \
 ocaml \
 ocaml-runtime \
 ocaml-ordering \
 ocaml-stdune \
 ocaml-stdune-devel \
 ocaml-dune-glob \
 ocaml-dune-private-libs \
 ocaml-dune-private-libs-devel \
 ocaml-dyn \
 ocaml-dyn-devel \
"

URI_ocaml-dune-private-libs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-dune-private-libs-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-dune-private-libs;unpack=0"
SRC_URI += "${URI_ocaml-dune-private-libs}"
SRC_URI[ocaml-dune-private-libs.sha256sum] = "57830fd614cc26edfddbdcf38198777da82303cac51352aa6af56c4f95c09f6f"
RDEPENDS:ocaml-dune-private-libs = " \
 glibc \
 ocaml-runtime \
 ocaml-dune \
 ocaml-stdune \
"

URI_ocaml-dune-private-libs-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-dune-private-libs-devel-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-dune-private-libs-devel;unpack=0"
SRC_URI += "${URI_ocaml-dune-private-libs-devel}"
SRC_URI[ocaml-dune-private-libs-devel.sha256sum] = "4a9befbf08d2ff098fc3f4d8bb005a0464449fd65838ed210f6448b407c73e67"
RDEPENDS:ocaml-dune-private-libs-devel = " \
 ocaml-dune-private-libs \
 ocaml-runtime \
 ocaml \
 ocaml-dyn-devel \
"

URI_ocaml-dune-rpc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-dune-rpc-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-dune-rpc;unpack=0"
SRC_URI += "${URI_ocaml-dune-rpc}"
SRC_URI[ocaml-dune-rpc.sha256sum] = "33693ab20972f906033e8c62d8bd8f0124f408b1174cdf925d46c4dc624be850"
RDEPENDS:ocaml-dune-rpc = " \
 ocaml-runtime \
 ocaml-ordering \
 ocaml-stdune \
 ocaml-xdg \
 ocaml-dune \
 glibc \
 ocaml-dyn \
"

URI_ocaml-dune-rpc-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-dune-rpc-devel-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-dune-rpc-devel;unpack=0"
SRC_URI += "${URI_ocaml-dune-rpc-devel}"
SRC_URI[ocaml-dune-rpc-devel.sha256sum] = "022cdbf1c164c8f2fa49534fd07ca46c1bf6fa04033c2dc7ae021e428197f777"
RDEPENDS:ocaml-dune-rpc-devel = " \
 ocaml \
 ocaml-runtime \
 ocaml-ordering \
 ocaml-ordering-devel \
 ocaml-stdune \
 ocaml-stdune-devel \
 ocaml-xdg \
 ocaml-xdg-devel \
 ocaml-dune-rpc \
 ocaml-dyn \
 ocaml-dyn-devel \
"

URI_ocaml-dune-site = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-dune-site-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-dune-site;unpack=0"
SRC_URI += "${URI_ocaml-dune-site}"
SRC_URI[ocaml-dune-site.sha256sum] = "c7bca4eb4ef0e3aed1ca0ebea010052ba769b2618f898cf1cb843c6d95261a2c"
RDEPENDS:ocaml-dune-site = " \
 ocaml-runtime \
 ocaml-compiler-libs \
 ocaml-dune-private-libs \
 ocaml-dune \
 glibc \
"

URI_ocaml-dune-site-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-dune-site-devel-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-dune-site-devel;unpack=0"
SRC_URI += "${URI_ocaml-dune-site-devel}"
SRC_URI[ocaml-dune-site-devel.sha256sum] = "071949f25816b94e5ba8b7101084c7e7a474c996bd3f0d5a2482c28d75abf605"
RDEPENDS:ocaml-dune-site-devel = " \
 ocaml-runtime \
 ocaml \
 ocaml-dune-private-libs \
 ocaml-dune-private-libs-devel \
 ocaml-dune-site \
"

URI_ocaml-dyn = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-dyn-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-dyn;unpack=0"
SRC_URI += "${URI_ocaml-dyn}"
SRC_URI[ocaml-dyn.sha256sum] = "48f0dec8cedea4ea96959c3b680319baaa1008c8e7fb8d4bf6437c8771abb543"
RDEPENDS:ocaml-dyn = " \
 glibc \
 ocaml-runtime \
 ocaml-ordering \
 ocaml-dune \
"

URI_ocaml-dyn-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-dyn-devel-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-dyn-devel;unpack=0"
SRC_URI += "${URI_ocaml-dyn-devel}"
SRC_URI[ocaml-dyn-devel.sha256sum] = "e723560d3d6933c38c1e2965746ed1a5f0bc2bcd9701d517ef05c7a2f419afba"
RDEPENDS:ocaml-dyn-devel = " \
 ocaml \
 ocaml-runtime \
 ocaml-ordering \
 ocaml-ordering-devel \
 ocaml-dyn \
"

URI_ocaml-ocamlc-loc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-ocamlc-loc-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-ocamlc-loc;unpack=0"
SRC_URI += "${URI_ocaml-ocamlc-loc}"
SRC_URI[ocaml-ocamlc-loc.sha256sum] = "36b9ca3da473253f3ea7c40876db263b6b3bfebe215b9c0340965bce87d6790f"
RDEPENDS:ocaml-ocamlc-loc = " \
 ocaml-runtime \
 ocaml-ordering \
 ocaml-dune \
 glibc \
 ocaml-dyn \
"

URI_ocaml-ocamlc-loc-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-ocamlc-loc-devel-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-ocamlc-loc-devel;unpack=0"
SRC_URI += "${URI_ocaml-ocamlc-loc-devel}"
SRC_URI[ocaml-ocamlc-loc-devel.sha256sum] = "454121c666db37d6853586bc9540ff2f8310353af3ab23a791437a681d9ed09a"
RDEPENDS:ocaml-ocamlc-loc-devel = " \
 ocaml \
 ocaml-runtime \
 ocaml-ordering \
 ocaml-ocamlc-loc \
 ocaml-dyn \
 ocaml-dyn-devel \
"

URI_ocaml-ordering = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-ordering-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-ordering;unpack=0"
SRC_URI += "${URI_ocaml-ordering}"
SRC_URI[ocaml-ordering.sha256sum] = "2dfd34839fbfb6b7c8562f89efc78837af1b94d64b894c3a0c88d93c41077d14"
RDEPENDS:ocaml-ordering = " \
 glibc \
 ocaml-runtime \
 ocaml-dune \
"

URI_ocaml-ordering-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-ordering-devel-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-ordering-devel;unpack=0"
SRC_URI += "${URI_ocaml-ordering-devel}"
SRC_URI[ocaml-ordering-devel.sha256sum] = "34697a8ef3e3e80768a0b259893cdfbbf00344ba590e93c9b9f9bd1a4957d75d"
RDEPENDS:ocaml-ordering-devel = " \
 ocaml-runtime \
 ocaml-ordering \
"

URI_ocaml-stdune = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-stdune-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-stdune;unpack=0"
SRC_URI += "${URI_ocaml-stdune}"
SRC_URI[ocaml-stdune.sha256sum] = "cfd842c5c6eb71dc4936aaff78ffdcb91b52bd2e4b598f91c5f23cc5dda4b483"
RDEPENDS:ocaml-stdune = " \
 ocaml-runtime \
 ocaml-ordering \
 ocaml-dune \
 glibc \
 ocaml-dyn \
"

URI_ocaml-stdune-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-stdune-devel-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-stdune-devel;unpack=0"
SRC_URI += "${URI_ocaml-stdune-devel}"
SRC_URI[ocaml-stdune-devel.sha256sum] = "de26d76361755b99944476dd7d0fbab1fdaadf10ced1bb7d15634dd78997e706"
RDEPENDS:ocaml-stdune-devel = " \
 ocaml \
 ocaml-runtime \
 ocaml-ordering \
 ocaml-ordering-devel \
 ocaml-stdune \
 ocaml-dyn \
 ocaml-dyn-devel \
"

URI_ocaml-xdg = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-xdg-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-xdg;unpack=0"
SRC_URI += "${URI_ocaml-xdg}"
SRC_URI[ocaml-xdg.sha256sum] = "56f83e7f4f86f14c0fad67811e59dbe6618cac6c7b9721b93b9b722e5e472eff"
RDEPENDS:ocaml-xdg = " \
 glibc \
 ocaml-runtime \
 ocaml-dune \
"

URI_ocaml-xdg-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ocaml-xdg-devel-3.16.0-4.el10.x86_64_v2.rpm;name=ocaml-xdg-devel;unpack=0"
SRC_URI += "${URI_ocaml-xdg-devel}"
SRC_URI[ocaml-xdg-devel.sha256sum] = "101c1b324966dd73694ddbe759330e1ee2fab69fbe9e6ae8df4f577e038cdf5e"
RDEPENDS:ocaml-xdg-devel = " \
 ocaml-runtime \
 ocaml \
 ocaml-xdg \
"
