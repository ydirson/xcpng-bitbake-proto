# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ghostscript"
PE = "0"
PV = "10.02.1"
PR = "16.el10_0"
PACKAGES = "ghostscript ghostscript-doc ghostscript-tools-fonts ghostscript-tools-printing libgs ghostscript-tools-dvipdf libgs-devel ghostscript-gtk"
PROVIDES = "rpm/ghostscript rpm/ghostscript-doc rpm/ghostscript-tools-fonts rpm/ghostscript-tools-printing rpm/libgs rpm/ghostscript-tools-dvipdf rpm/libgs-devel rpm/ghostscript-gtk"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ghostscript-10.02.1-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9534859d6d5ae053d91dd148076b9f79bbcb3d8d242c674a6e36c78ceb906201"

URI_ghostscript = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ghostscript-10.02.1-16.el10_0.x86_64_v2.rpm;name=ghostscript;unpack=0"
SRC_URI += "${URI_ghostscript}"
SRC_URI[ghostscript.sha256sum] = "249e016f49607eee1be9916d78ec7572ac30481c9388dff8448f6d495fce8036"
RDEPENDS:ghostscript = " \
 ghostscript-tools-printing \
 libgs \
 bash \
 jbig2dec-libs \
 glibc \
 ghostscript-tools-fonts \
"

URI_ghostscript-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ghostscript-doc-10.02.1-16.el10_0.noarch.rpm;name=ghostscript-doc;unpack=0"
SRC_URI += "${URI_ghostscript-doc}"
SRC_URI[ghostscript-doc.sha256sum] = "3f1b60a67eecc30c597d1f768163d3503fffbb49da34031d04739bd07ba6e87e"
RDEPENDS:ghostscript-doc = " \
 ghostscript \
"

URI_ghostscript-tools-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ghostscript-tools-fonts-10.02.1-16.el10_0.noarch.rpm;name=ghostscript-tools-fonts;unpack=0"
SRC_URI += "${URI_ghostscript-tools-fonts}"
SRC_URI[ghostscript-tools-fonts.sha256sum] = "f241758178d18373dc0c9cb3749b477f152865d9168e3e2375f35b116091e34d"
RDEPENDS:ghostscript-tools-fonts = " \
 bash \
 ghostscript \
"

URI_ghostscript-tools-printing = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ghostscript-tools-printing-10.02.1-16.el10_0.noarch.rpm;name=ghostscript-tools-printing;unpack=0"
SRC_URI += "${URI_ghostscript-tools-printing}"
SRC_URI[ghostscript-tools-printing.sha256sum] = "346e1a416a0a1bb35398d5cd665d457d5a38821bde5b90a62107f4b7ab631bfa"
RDEPENDS:ghostscript-tools-printing = " \
 bash \
 ghostscript \
"

URI_libgs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libgs-10.02.1-16.el10_0.x86_64_v2.rpm;name=libgs;unpack=0"
SRC_URI += "${URI_libgs}"
SRC_URI[libgs.sha256sum] = "5bab3ef6c94d5988bdd36313118a923b0fc66a95e933fba02c16b3e940401641"
RDEPENDS:libgs = " \
 urw-base35-fonts \
 zlib-ng-compat \
 freetype \
 libpng \
 lcms2 \
 openjpeg2 \
 adobe-mappings-cmap \
 adobe-mappings-cmap-deprecated \
 adobe-mappings-pdf \
 cups-libs \
 libpaper \
 fontconfig \
 libijs \
 google-droid-sans-fonts \
 jbig2dec-libs \
 glibc \
 libjpeg-turbo \
 libtiff \
"

URI_ghostscript-tools-dvipdf = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ghostscript-tools-dvipdf-10.02.1-16.el10_0.noarch.rpm;name=ghostscript-tools-dvipdf;unpack=0"
SRC_URI += "${URI_ghostscript-tools-dvipdf}"
SRC_URI[ghostscript-tools-dvipdf.sha256sum] = "fc9fab2864c9319a7e8c74d89d24b8812d80358b77c307fef386ada0406b8ac5"
RDEPENDS:ghostscript-tools-dvipdf = " \
 texlive-dvips \
 bash \
 ghostscript \
"

URI_libgs-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libgs-devel-10.02.1-16.el10_0.x86_64_v2.rpm;name=libgs-devel;unpack=0"
SRC_URI += "${URI_libgs-devel}"
SRC_URI[libgs-devel.sha256sum] = "d16566fe80d285e98af88a655cb2f2afb5e0d03e3a1eb5ada10148e3fd9dfaed"
RDEPENDS:libgs-devel = " \
 libgs \
"

URI_ghostscript-gtk = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ghostscript-gtk-10.02.1-16.el10_0.x86_64_v2.rpm;name=ghostscript-gtk;unpack=0"
SRC_URI += "${URI_ghostscript-gtk}"
SRC_URI[ghostscript-gtk.sha256sum] = "a8494da9cfca73aedaeb80cdfaf7c4865085f974d819288a2aa31071448638d6"
RDEPENDS:ghostscript-gtk = " \
 gdk-pixbuf2 \
 libgs \
 cairo \
 glib2 \
 gtk3 \
 glibc \
"
