# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mtx"
PE = "0"
PV = "1.3.12"
PR = "34.el10"
PACKAGES = "mtx"
PROVIDES = "rpm/mtx"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mtx-1.3.12-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b08bf9ff06b646b80715e16229949927f69c97f88971d1873d90433325587e4b"

URI_mtx = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mtx-1.3.12-34.el10.x86_64_v2.rpm;name=mtx;unpack=0"
SRC_URI += "${URI_mtx}"
SRC_URI[mtx.sha256sum] = "1419e4b7bfc45d2289284581bfb600ad30a4fdc1cb4af74713eea7423f65bf91"
RDEPENDS:mtx = " \
 glibc \
"
