# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "slirp4netns"
PE = "0"
PV = "1.3.2"
PR = "1.el10"
PACKAGES = "slirp4netns"
PROVIDES = "rpm/slirp4netns"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/slirp4netns-1.3.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0766a1224d4500e56e26cbe82aa1b5988a13752ad95286ba10f2236dff1d67fc"

URI_slirp4netns = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/slirp4netns-1.3.2-1.el10.x86_64_v2.rpm;name=slirp4netns;unpack=0"
SRC_URI += "${URI_slirp4netns}"
SRC_URI[slirp4netns.sha256sum] = "a49dfa45643b7a008d7121f3a7f16107601b39b2da262b0af53530b994e4ab38"
RDEPENDS:slirp4netns = " \
 glibc \
 libslirp \
 glib2 \
 libseccomp \
"
