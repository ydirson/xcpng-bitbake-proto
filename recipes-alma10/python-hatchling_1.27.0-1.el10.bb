# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-hatchling"
PE = "0"
PV = "1.27.0"
PR = "1.el10"
PACKAGES = "python3-hatchling"
PROVIDES = "rpm/python3-hatchling"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/python-hatchling-1.27.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c58d8a744a986550a3444629b036c471e40a853cd5bd5241b7afefa89d19160a"

URI_python3-hatchling = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-hatchling-1.27.0-1.el10.noarch.rpm;name=python3-hatchling;unpack=0"
SRC_URI += "${URI_python3-hatchling}"
SRC_URI[python3-hatchling.sha256sum] = "cf61603da81ce16099d1a8eea5816b8b2c89226bd8e14ad11fb619f8e69925e0"
RDEPENDS:python3-hatchling = " \
 python3 \
 python3-trove-classifiers \
 python3-pluggy \
 python3-pathspec \
 python3-packaging \
"
