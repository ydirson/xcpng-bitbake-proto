# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "wayland-utils"
PE = "0"
PV = "1.2.0"
PR = "6.el10"
PACKAGES = "wayland-utils"
PROVIDES = "rpm/wayland-utils"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/wayland-utils-1.2.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f621fe1910a7451d6ce32b121e380884d39bbc976362daf959cead63e469fdd"

URI_wayland-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/wayland-utils-1.2.0-6.el10.x86_64_v2.rpm;name=wayland-utils;unpack=0"
SRC_URI += "${URI_wayland-utils}"
SRC_URI[wayland-utils.sha256sum] = "f6e1373365b8b6896905b17267d673d054371623f6aec326a102950bca2f805f"
RDEPENDS:wayland-utils = " \
 glibc \
 libdrm \
 libwayland-client \
"
