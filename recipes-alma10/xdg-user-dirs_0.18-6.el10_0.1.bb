# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xdg-user-dirs"
PE = "0"
PV = "0.18"
PR = "6.el10_0.1"
PACKAGES = "xdg-user-dirs"
PROVIDES = "rpm/xdg-user-dirs"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xdg-user-dirs-0.18-6.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b77f3bdcd5ff0851d5eff80c8df3bce73f0853f62c6262d86844f0b01203609e"

URI_xdg-user-dirs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xdg-user-dirs-0.18-6.el10_0.1.x86_64_v2.rpm;name=xdg-user-dirs;unpack=0"
SRC_URI += "${URI_xdg-user-dirs}"
SRC_URI[xdg-user-dirs.sha256sum] = "30c931599c7b12c4465d125d41d2c5884be9d4c1363430ea2e0f21d80471f394"
RDEPENDS:xdg-user-dirs = " \
 glibc \
 filesystem \
 bash \
"
