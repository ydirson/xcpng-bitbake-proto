# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-mai"
PE = "0"
PV = "1.0.1"
PR = "32.el10"
PACKAGES = "hunspell-mai"
PROVIDES = "rpm/hunspell-mai"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-mai-1.0.1-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15e18bd2ec8c4fd663c4394d1edc9da7b5d275dcfa1e4795a470968ec2860753"

URI_hunspell-mai = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-mai-1.0.1-32.el10.noarch.rpm;name=hunspell-mai;unpack=0"
SRC_URI += "${URI_hunspell-mai}"
SRC_URI[hunspell-mai.sha256sum] = "937bc8d115454fb7b73c962099910038b05e4a49fdbeb0b460a8bffcc279cd34"
RDEPENDS:hunspell-mai = " \
 hunspell-filesystem \
"
