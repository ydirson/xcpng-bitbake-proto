# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libyang"
PE = "0"
PV = "2.1.148"
PR = "2.el10"
PACKAGES = "libyang libyang-devel libyang-devel-doc libyang-tools"
PROVIDES = "rpm/libyang rpm/libyang-devel rpm/libyang-devel-doc rpm/libyang-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libyang-2.1.148-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02b2f71d6db81bd1427227dad969f502117460a7521b9d07f096fcace1a043ed"

URI_libyang = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libyang-2.1.148-2.el10.x86_64_v2.rpm;name=libyang;unpack=0"
SRC_URI += "${URI_libyang}"
SRC_URI[libyang.sha256sum] = "46eb22214aba42f6a730cda93dffb413cf85ee9bd7fbd3038c55f0f78753fdc8"
RDEPENDS:libyang = " \
 glibc \
 pcre2 \
"

URI_libyang-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libyang-devel-2.1.148-2.el10.x86_64_v2.rpm;name=libyang-devel;unpack=0"
SRC_URI += "${URI_libyang-devel}"
SRC_URI[libyang-devel.sha256sum] = "4e056b3ef50c7404ff184bddd48dbd3f08e9368b56ebca656fc6b9b0e981c9a4"
RDEPENDS:libyang-devel = " \
 pcre2-devel \
 pkgconf-pkg-config \
 libyang \
"

URI_libyang-devel-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libyang-devel-doc-2.1.148-2.el10.x86_64_v2.rpm;name=libyang-devel-doc;unpack=0"
SRC_URI += "${URI_libyang-devel-doc}"
SRC_URI[libyang-devel-doc.sha256sum] = "9953236d97e172ba23da4c5969c5c738466e086166088a7735251dec212769a7"
RDEPENDS:libyang-devel-doc = " \
 libyang \
"

URI_libyang-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libyang-tools-2.1.148-2.el10.x86_64_v2.rpm;name=libyang-tools;unpack=0"
SRC_URI += "${URI_libyang-tools}"
SRC_URI[libyang-tools.sha256sum] = "0b4a793bf89db12102b2755a45cdc84ce5f21691b91e615243ec0631d10abeec"
RDEPENDS:libyang-tools = " \
 glibc \
 libyang \
"
