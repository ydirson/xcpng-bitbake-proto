# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "liberation-narrow-fonts"
PE = "2"
PV = "1.07.6"
PR = "16.el10"
PACKAGES = "liberation-narrow-fonts"
PROVIDES = "rpm/liberation-narrow-fonts"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/liberation-narrow-fonts-1.07.6-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8352f09a9b349df9ace35224a5ca4f2594534544711d4bb6d294afaafef3e71"

URI_liberation-narrow-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/liberation-narrow-fonts-1.07.6-16.el10.noarch.rpm;name=liberation-narrow-fonts;unpack=0"
SRC_URI += "${URI_liberation-narrow-fonts}"
SRC_URI[liberation-narrow-fonts.sha256sum] = "5293da75e16be7c3668b59d3417fe835867ddc7d58d4f58618690eeb3e5a184d"
RDEPENDS:liberation-narrow-fonts = " \
 fonts-filesystem \
"
