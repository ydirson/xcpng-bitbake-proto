# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "apache-commons-parent"
PE = "0"
PV = "66"
PR = "4.el10"
PACKAGES = "apache-commons-parent"
PROVIDES = "rpm/apache-commons-parent"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/apache-commons-parent-66-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1db344a8e402db492334e3adab17dee924b1e2fb729006cfc3d4b7da864d5a56"

URI_apache-commons-parent = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/apache-commons-parent-66-4.el10.noarch.rpm;name=apache-commons-parent;unpack=0"
SRC_URI += "${URI_apache-commons-parent}"
SRC_URI[apache-commons-parent.sha256sum] = "e8baa942cf95ba023eedf587d138c29239065120c5d796f318f895daef2c4844"
RDEPENDS:apache-commons-parent = " \
 maven-surefire-plugin \
 maven-jar-plugin \
 maven-antrun-plugin \
 javapackages-filesystem \
 maven-assembly-plugin \
 moditect \
 maven-bundle-plugin \
 maven-compiler-plugin \
 build-helper-maven-plugin \
 apache-parent \
"
