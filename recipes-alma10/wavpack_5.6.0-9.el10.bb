# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "wavpack"
PE = "0"
PV = "5.6.0"
PR = "9.el10"
PACKAGES = "wavpack wavpack-devel"
PROVIDES = "rpm/wavpack rpm/wavpack-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/wavpack-5.6.0-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6be0e975d35d625246679a2e8a65d24eab93928f839f15b88ac795b8e3a8f3f"

URI_wavpack = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/wavpack-5.6.0-9.el10.x86_64_v2.rpm;name=wavpack;unpack=0"
SRC_URI += "${URI_wavpack}"
SRC_URI[wavpack.sha256sum] = "fa5c7ab2b42cf724a45a3cbd640442ac9adf592f760d85672b401cc04c54209c"
RDEPENDS:wavpack = " \
 glibc \
"

URI_wavpack-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/wavpack-devel-5.6.0-9.el10.x86_64_v2.rpm;name=wavpack-devel;unpack=0"
SRC_URI += "${URI_wavpack-devel}"
SRC_URI[wavpack-devel.sha256sum] = "62707a760426ae18671bc6915e5926480feb577952b613501f060e7b17ee066d"
RDEPENDS:wavpack-devel = " \
 wavpack \
 pkgconf-pkg-config \
"
