# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libva"
PE = "0"
PV = "2.22.0"
PR = "2.el10"
PACKAGES = "libva libva-devel"
PROVIDES = "rpm/libva rpm/libva-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libva-2.22.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9bea30667e17d6a7c7b4eca96e28e2505ef1656df6f978bb9824fbed4c3babf"

URI_libva = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libva-2.22.0-2.el10.x86_64_v2.rpm;name=libva;unpack=0"
SRC_URI += "${URI_libva}"
SRC_URI[libva.sha256sum] = "9437180a43b650d77e246410e81ab4a1b7f89746c20c9511e9c3b98ad3d14e06"
RDEPENDS:libva = " \
 libXfixes \
 libwayland-client \
 libglvnd-glx \
 mesa-filesystem \
 libX11 \
 libxcb \
 libX11-xcb \
 glibc \
 libdrm \
 libXext \
"

URI_libva-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libva-devel-2.22.0-2.el10.x86_64_v2.rpm;name=libva-devel;unpack=0"
SRC_URI += "${URI_libva-devel}"
SRC_URI[libva-devel.sha256sum] = "26aa4edfa363236783a8a76e7e8f94ce4cfdb8065d164af8170b7fb45b3404ae"
RDEPENDS:libva-devel = " \
 wayland-devel \
 libva-devel \
 pkgconf-pkg-config \
 libva \
"
