# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libdex"
PE = "0"
PV = "0.8.1"
PR = "1.el10"
PACKAGES = "libdex libdex-devel libdex-devel-docs"
PROVIDES = "rpm/libdex rpm/libdex-devel rpm/libdex-devel-docs"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libdex-0.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6793cc18eb353865591985b5e7ccd1d2c0fe025aedce219bbb579665ba4db3e5"

URI_libdex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libdex-0.8.1-1.el10.x86_64_v2.rpm;name=libdex;unpack=0"
SRC_URI += "${URI_libdex}"
SRC_URI[libdex.sha256sum] = "12ba0cd2e87bc54c1f3704c02f5b79547d00fd1c564dd925e991bc176b775062"
RDEPENDS:libdex = " \
 libatomic \
 libgcc \
 glib2 \
 glibc \
 liburing \
"

URI_libdex-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libdex-devel-0.8.1-1.el10.x86_64_v2.rpm;name=libdex-devel;unpack=0"
SRC_URI += "${URI_libdex-devel}"
SRC_URI[libdex-devel.sha256sum] = "0e4ecbc3122c7ba05d77b2a09fc54b62236520346cfeb8873b8f8102223eae89"
RDEPENDS:libdex-devel = " \
 glib2-devel \
 libdex \
 pkgconf-pkg-config \
"

URI_libdex-devel-docs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdex-devel-docs-0.8.1-1.el10.noarch.rpm;name=libdex-devel-docs;unpack=0"
SRC_URI += "${URI_libdex-devel-docs}"
SRC_URI[libdex-devel-docs.sha256sum] = "2e536ff8fdd6b9d2eb0e5ada71cff46202a9ba631f067950748064eadd7f1275"
RDEPENDS:libdex-devel-docs = " \
 libdex \
"
