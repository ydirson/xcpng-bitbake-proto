# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libvdpau"
PE = "0"
PV = "1.5"
PR = "8.el10"
PACKAGES = "libvdpau libvdpau-trace libvdpau-devel libvdpau-docs"
PROVIDES = "rpm/libvdpau rpm/libvdpau-trace rpm/libvdpau-devel rpm/libvdpau-docs"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libvdpau-1.5-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6fd2cb348f404cd52054d858e25657ded4edd64b671e0baab535e6adc0450589"

URI_libvdpau = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvdpau-1.5-8.el10.x86_64_v2.rpm;name=libvdpau;unpack=0"
SRC_URI += "${URI_libvdpau}"
SRC_URI[libvdpau.sha256sum] = "47dcda58daff17054fc74116dea500b7ed831813bbafd8692e7098a9729cdf87"
RDEPENDS:libvdpau = " \
 glibc \
 libX11 \
 libXext \
"

URI_libvdpau-trace = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvdpau-trace-1.5-8.el10.x86_64_v2.rpm;name=libvdpau-trace;unpack=0"
SRC_URI += "${URI_libvdpau-trace}"
SRC_URI[libvdpau-trace.sha256sum] = "22cc706e1392e26b2d129fdcebec474bf9b42dff190a5a931076abfd78305c63"
RDEPENDS:libvdpau-trace = " \
 glibc \
 libvdpau \
"

URI_libvdpau-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libvdpau-devel-1.5-8.el10.x86_64_v2.rpm;name=libvdpau-devel;unpack=0"
SRC_URI += "${URI_libvdpau-devel}"
SRC_URI[libvdpau-devel.sha256sum] = "c81904a28e8c4a81447e4dfa8637c81af37d5c308955e522a0d402696953d457"
RDEPENDS:libvdpau-devel = " \
 libX11-devel \
 libvdpau \
 libvdpau-trace \
 pkgconf-pkg-config \
"

URI_libvdpau-docs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libvdpau-docs-1.5-8.el10.noarch.rpm;name=libvdpau-docs;unpack=0"
SRC_URI += "${URI_libvdpau-docs}"
SRC_URI[libvdpau-docs.sha256sum] = "5c865172887304857b48a4bb0e0619dea4a01c80b529917e2aa5e02a66a6e736"
RDEPENDS:libvdpau-docs = ""
