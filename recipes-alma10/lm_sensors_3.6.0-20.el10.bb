# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lm_sensors"
PE = "0"
PV = "3.6.0"
PR = "20.el10"
PACKAGES = "lm_sensors lm_sensors-devel lm_sensors-libs lm_sensors-sensord"
PROVIDES = "rpm/lm_sensors rpm/lm_sensors-devel rpm/lm_sensors-libs rpm/lm_sensors-sensord"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/lm_sensors-3.6.0-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d678b4386742db80e93f0ec623884aed765209d18631954b5265762e19164b9e"

URI_lm_sensors = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lm_sensors-3.6.0-20.el10.x86_64_v2.rpm;name=lm_sensors;unpack=0"
SRC_URI += "${URI_lm_sensors}"
SRC_URI[lm_sensors.sha256sum] = "ef6c390912bf83b5da9695fc535243f1454f4ba27e639a2f40d958e4d3bedac6"
RDEPENDS:lm_sensors = " \
 perl-constant \
 lm_sensors-libs \
 systemd \
 perl-libs \
 perl-vars \
 kmod \
 dmidecode \
 perl-Fcntl \
 perl-File-Basename \
 bash \
 glibc \
 perl-interpreter \
"

URI_lm_sensors-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lm_sensors-devel-3.6.0-20.el10.x86_64_v2.rpm;name=lm_sensors-devel;unpack=0"
SRC_URI += "${URI_lm_sensors-devel}"
SRC_URI[lm_sensors-devel.sha256sum] = "0456cc45474e34349a42e2147810def62456591fe1a51c3d19847981a7becd51"
RDEPENDS:lm_sensors-devel = " \
 lm_sensors-libs \
"

URI_lm_sensors-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lm_sensors-libs-3.6.0-20.el10.x86_64_v2.rpm;name=lm_sensors-libs;unpack=0"
SRC_URI += "${URI_lm_sensors-libs}"
SRC_URI[lm_sensors-libs.sha256sum] = "f4c4159d0f1ab7dfed80caa83cece9cb7193ada1cffd24ec585b02190249f9f4"
RDEPENDS:lm_sensors-libs = " \
 glibc \
"

URI_lm_sensors-sensord = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lm_sensors-sensord-3.6.0-20.el10.x86_64_v2.rpm;name=lm_sensors-sensord;unpack=0"
SRC_URI += "${URI_lm_sensors-sensord}"
SRC_URI[lm_sensors-sensord.sha256sum] = "e0ddb49c6a8e9f053d9d6a856abd7e68ae7731889fe9d5716448eadba0ed044c"
RDEPENDS:lm_sensors-sensord = " \
 lm_sensors \
 lm_sensors-libs \
 bash \
 glibc \
 rrdtool \
"
