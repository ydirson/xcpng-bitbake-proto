# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libxkbfile"
PE = "0"
PV = "1.1.3"
PR = "3.el10"
PACKAGES = "libxkbfile libxkbfile-devel"
PROVIDES = "rpm/libxkbfile rpm/libxkbfile-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libxkbfile-1.1.3-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09caef3c5420c1ea2fc9cf3e2cc108b6e3c910e5ff7f27c651f4f38f48398764"

URI_libxkbfile = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libxkbfile-1.1.3-3.el10.x86_64_v2.rpm;name=libxkbfile;unpack=0"
SRC_URI += "${URI_libxkbfile}"
SRC_URI[libxkbfile.sha256sum] = "41cc6503c961a4fe954fc2f845daeab69fd90be2531ebbbec7a909f8ce27420c"
RDEPENDS:libxkbfile = " \
 glibc \
 libX11 \
"

URI_libxkbfile-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libxkbfile-devel-1.1.3-3.el10.x86_64_v2.rpm;name=libxkbfile-devel;unpack=0"
SRC_URI += "${URI_libxkbfile-devel}"
SRC_URI[libxkbfile-devel.sha256sum] = "5840a04dfa6dea3938137074b94902732f9a308c75e7e7f1897a4f64ad6594b4"
RDEPENDS:libxkbfile-devel = " \
 libX11-devel \
 xorg-x11-proto-devel \
 libxkbfile \
 pkgconf-pkg-config \
"
