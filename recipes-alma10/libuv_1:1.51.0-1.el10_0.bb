# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libuv"
PE = "1"
PV = "1.51.0"
PR = "1.el10_0"
PACKAGES = "libuv libuv-devel libuv-static"
PROVIDES = "rpm/libuv rpm/libuv-devel rpm/libuv-static"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libuv-1.51.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dfd2ec264a20a166d6e33247b556bb7adf06e5887d9837fd73517aa7b8417136"

URI_libuv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libuv-1.51.0-1.el10_0.x86_64_v2.rpm;name=libuv;unpack=0"
SRC_URI += "${URI_libuv}"
SRC_URI[libuv.sha256sum] = "eae959fecf065091b332ecdd353787b3b783c0e511a7fe1bdecef5a4a7f44862"
RDEPENDS:libuv = " \
 glibc \
"

URI_libuv-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libuv-devel-1.51.0-1.el10_0.x86_64_v2.rpm;name=libuv-devel;unpack=0"
SRC_URI += "${URI_libuv-devel}"
SRC_URI[libuv-devel.sha256sum] = "d9ccb63cdc995ef7fc1143df867725b6a996c3158a1a68d7c11185745c1a8635"
RDEPENDS:libuv-devel = " \
 libuv \
 cmake-filesystem \
 pkgconf-pkg-config \
 libuv-static \
"

URI_libuv-static = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libuv-static-1.51.0-1.el10_0.x86_64_v2.rpm;name=libuv-static;unpack=0"
SRC_URI += "${URI_libuv-static}"
SRC_URI[libuv-static.sha256sum] = "7b1de95c7572b7bd852b59b1e02ce4ee755f009f10d7edd93b2e9df9fe8aac6f"
RDEPENDS:libuv-static = " \
 libuv-devel \
 pkgconf-pkg-config \
"
