# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "spice"
PE = "0"
PV = "0.15.1"
PR = "3.el10"
PACKAGES = "spice-server spice-server-devel"
PROVIDES = "rpm/spice-server rpm/spice-server-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/spice-0.15.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "acbf0753c59150219defdccc8e917e95b444e3141b020e3da37c8d3210f6623b"

URI_spice-server = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/spice-server-0.15.1-3.el10.x86_64_v2.rpm;name=spice-server;unpack=0"
SRC_URI += "${URI_spice-server}"
SRC_URI[spice-server.sha256sum] = "d77fe8134215da8a2be115c93bc0f49a83b964b88ce913de2385dcb23924f655"
RDEPENDS:spice-server = " \
 zlib-ng-compat \
 gstreamer1 \
 lz4-libs \
 libgcc \
 openssl-libs \
 gstreamer1-plugins-base \
 cyrus-sasl-lib \
 libstdc++ \
 glib2 \
 glibc \
 opus \
 libjpeg-turbo \
 pixman \
 orc \
"

URI_spice-server-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/spice-server-devel-0.15.1-3.el10.x86_64_v2.rpm;name=spice-server-devel;unpack=0"
SRC_URI += "${URI_spice-server-devel}"
SRC_URI[spice-server-devel.sha256sum] = "863ab584ce257c58f2f7e2c792681d523533dfd72b9b4e55f93a10c10304e06f"
RDEPENDS:spice-server-devel = " \
 glib2-devel \
 libcacard-devel \
 pkgconf-pkg-config \
 openssl-devel \
 spice-protocol \
 spice-server \
 pixman-devel \
"
