# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "at-spi2-core"
PE = "0"
PV = "2.52.0"
PR = "3.el10"
PACKAGES = "at-spi2-atk at-spi2-atk-devel at-spi2-core at-spi2-core-devel atk atk-devel"
PROVIDES = "rpm/at-spi2-atk rpm/at-spi2-atk-devel rpm/at-spi2-core rpm/at-spi2-core-devel rpm/atk rpm/atk-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/at-spi2-core-2.52.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ec3f442e9cb8aaa4ce0f8d394fca7f3044ad072152ff4c2ab57944486c891f8"

URI_at-spi2-atk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/at-spi2-atk-2.52.0-3.el10.x86_64_v2.rpm;name=at-spi2-atk;unpack=0"
SRC_URI += "${URI_at-spi2-atk}"
SRC_URI[at-spi2-atk.sha256sum] = "ce996afbc1a1d69055d55ca288f4fa46d905a9a633b91707dbc6f6c8f354b3ce"
RDEPENDS:at-spi2-atk = " \
 atk \
 glib2 \
 glibc \
 dbus-libs \
 at-spi2-core \
"

URI_at-spi2-atk-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/at-spi2-atk-devel-2.52.0-3.el10.x86_64_v2.rpm;name=at-spi2-atk-devel;unpack=0"
SRC_URI += "${URI_at-spi2-atk-devel}"
SRC_URI[at-spi2-atk-devel.sha256sum] = "12adcee2b8ce7a90f22980a691eb4211f88a1e2087a307305235e6c87ab19aa0"
RDEPENDS:at-spi2-atk-devel = " \
 at-spi2-core-devel \
 atk-devel \
 glib2-devel \
 pkgconf-pkg-config \
 dbus-devel \
 at-spi2-atk \
"

URI_at-spi2-core = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/at-spi2-core-2.52.0-3.el10.x86_64_v2.rpm;name=at-spi2-core;unpack=0"
SRC_URI += "${URI_at-spi2-core}"
SRC_URI[at-spi2-core.sha256sum] = "5119d4923238c5b082d49b91a078f71edfe27819cc311dde48c8f9ac0a3b5719"
RDEPENDS:at-spi2-core = " \
 systemd-libs \
 libXi \
 libX11 \
 xprop \
 bash \
 glib2 \
 dbus \
 libXtst \
 glibc \
 dbus-libs \
"

URI_at-spi2-core-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/at-spi2-core-devel-2.52.0-3.el10.x86_64_v2.rpm;name=at-spi2-core-devel;unpack=0"
SRC_URI += "${URI_at-spi2-core-devel}"
SRC_URI[at-spi2-core-devel.sha256sum] = "b1a709790ef96e29f2770a27a852294c2819527fbc07af5413aaa63cfe4f124c"
RDEPENDS:at-spi2-core-devel = " \
 glib2-devel \
 libXi-devel \
 pkgconf-pkg-config \
 libX11-devel \
 dbus-devel \
 libXtst-devel \
 at-spi2-core \
"

URI_atk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/atk-2.52.0-3.el10.x86_64_v2.rpm;name=atk;unpack=0"
SRC_URI += "${URI_atk}"
SRC_URI[atk.sha256sum] = "533d2a14b5a2d9c5a94931d2c54d9b669486cfb1cee3b772d4e48c7df845df48"
RDEPENDS:atk = " \
 glibc \
 glib2 \
 at-spi2-core \
"

URI_atk-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/atk-devel-2.52.0-3.el10.x86_64_v2.rpm;name=atk-devel;unpack=0"
SRC_URI += "${URI_atk-devel}"
SRC_URI[atk-devel.sha256sum] = "9d39dcdb6dcf9bb3e92e834aad430dd3ba9d395d87bcc66fbbda77cd355ab72b"
RDEPENDS:atk-devel = " \
 atk \
 glib2-devel \
 pkgconf-pkg-config \
"
