# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "linuxptp"
PE = "0"
PV = "4.4"
PR = "2.el10"
PACKAGES = "linuxptp linuxptp-selinux"
PROVIDES = "rpm/linuxptp rpm/linuxptp-selinux"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/linuxptp-4.4-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35a8e45501bcf7d7e617e89df86b79546d7cfe93f8bb22b090974af30ea368d4"

URI_linuxptp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/linuxptp-4.4-2.el10.x86_64_v2.rpm;name=linuxptp;unpack=0"
SRC_URI += "${URI_linuxptp}"
SRC_URI[linuxptp.sha256sum] = "5990172190cf994c23787d55335dfd5995baee5366f7078fc5baf818e3de3da8"
RDEPENDS:linuxptp = " \
 systemd \
 gnutls \
 linuxptp-selinux \
 bash \
 glibc \
"

URI_linuxptp-selinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/linuxptp-selinux-4.4-2.el10.noarch.rpm;name=linuxptp-selinux;unpack=0"
SRC_URI += "${URI_linuxptp-selinux}"
SRC_URI[linuxptp-selinux.sha256sum] = "7bf71fff2da4c76da8e1002593e23986b65f44ad8caaa8cdd3d2b7212da1e429"
RDEPENDS:linuxptp-selinux = " \
 policycoreutils-python-utils \
 policycoreutils \
 bash \
 selinux-policy \
 libselinux-utils \
 selinux-policy-targeted \
"
