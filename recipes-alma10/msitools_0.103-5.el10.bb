# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "msitools"
PE = "0"
PV = "0.103"
PR = "5.el10"
PACKAGES = "libmsi1 libmsi1-devel msitools"
PROVIDES = "rpm/libmsi1 rpm/libmsi1-devel rpm/msitools"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/msitools-0.103-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74587c54d2f40926f70939ed3e1ad200c69c9342582f479017d6215cb439e03f"

URI_libmsi1 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libmsi1-0.103-5.el10.x86_64_v2.rpm;name=libmsi1;unpack=0"
SRC_URI += "${URI_libmsi1}"
SRC_URI[libmsi1.sha256sum] = "d98f79d568850b83f8ef7353a0fc318378f196a91024574d8e102a9b3538f3de"
RDEPENDS:libmsi1 = " \
 glibc \
 libgcc \
 libgsf \
 glib2 \
"

URI_libmsi1-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libmsi1-devel-0.103-5.el10.x86_64_v2.rpm;name=libmsi1-devel;unpack=0"
SRC_URI += "${URI_libmsi1-devel}"
SRC_URI[libmsi1-devel.sha256sum] = "b14c715e7d3bc3e1505c0a13218c8fb40fe0103b4853dc16a2f5de56bd6d4a4a"
RDEPENDS:libmsi1-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 libmsi1 \
"

URI_msitools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/msitools-0.103-5.el10.x86_64_v2.rpm;name=msitools;unpack=0"
SRC_URI += "${URI_msitools}"
SRC_URI[msitools.sha256sum] = "97272bcf4b9827b47c8decc70cbc1441b00a700deea5ce94331154b7e2ba193b"
RDEPENDS:msitools = " \
 libmsi1 \
 libgcab1 \
 libgcc \
 libxml2 \
 bash \
 glib2 \
 libgsf \
 glibc \
"
