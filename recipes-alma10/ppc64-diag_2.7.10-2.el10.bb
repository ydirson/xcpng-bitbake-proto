# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ppc64-diag"
PE = "0"
PV = "2.7.10"
PR = "2.el10"
PACKAGES = ""
PROVIDES = ""


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/ppc64-diag-2.7.10-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c805723ae4247367c40520ae662334def27747fac215a8fbdd175485b782e94"
