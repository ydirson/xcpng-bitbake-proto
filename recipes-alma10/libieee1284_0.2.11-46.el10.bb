# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libieee1284"
PE = "0"
PV = "0.2.11"
PR = "46.el10"
PACKAGES = "libieee1284 libieee1284-devel"
PROVIDES = "rpm/libieee1284 rpm/libieee1284-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libieee1284-0.2.11-46.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ca7910d36a580a46ec3aca2731bef5c42f355b5e3274f6c93b615f2525b53d2"

URI_libieee1284 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libieee1284-0.2.11-46.el10.x86_64_v2.rpm;name=libieee1284;unpack=0"
SRC_URI += "${URI_libieee1284}"
SRC_URI[libieee1284.sha256sum] = "39df6202d2cc811115df8ee00f55cb5e0a095e265f914d1c97c98f0d94e3f74b"
RDEPENDS:libieee1284 = " \
 glibc \
"

URI_libieee1284-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libieee1284-devel-0.2.11-46.el10.x86_64_v2.rpm;name=libieee1284-devel;unpack=0"
SRC_URI += "${URI_libieee1284-devel}"
SRC_URI[libieee1284-devel.sha256sum] = "382075605e8eea0d059a1e07960a2f268bddd93c6bd896bc760219059b854e30"
RDEPENDS:libieee1284-devel = " \
 libieee1284 \
"
