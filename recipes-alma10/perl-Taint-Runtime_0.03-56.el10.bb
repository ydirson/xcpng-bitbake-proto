# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Taint-Runtime"
PE = "0"
PV = "0.03"
PR = "56.el10"
PACKAGES = "perl-Taint-Runtime perl-Taint-Runtime-tests"
PROVIDES = "rpm/perl-Taint-Runtime rpm/perl-Taint-Runtime-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Taint-Runtime-0.03-56.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f0a4ff1cd6ded38346ace0923bc9967c3434e5de050a5513721a33810bf3da1"

URI_perl-Taint-Runtime = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Taint-Runtime-0.03-56.el10.x86_64_v2.rpm;name=perl-Taint-Runtime;unpack=0"
SRC_URI += "${URI_perl-Taint-Runtime}"
SRC_URI[perl-Taint-Runtime.sha256sum] = "ea1cbfa61844155c3586d8080df69ba16e5bee8c1d5b83007243144800b49d70"
RDEPENDS:perl-Taint-Runtime = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-interpreter \
 glibc \
 perl-Taint-Runtime \
 perl-Exporter \
 perl-Benchmark \
"

URI_perl-Taint-Runtime-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Taint-Runtime-tests-0.03-56.el10.x86_64_v2.rpm;name=perl-Taint-Runtime-tests;unpack=0"
SRC_URI += "${URI_perl-Taint-Runtime-tests}"
SRC_URI[perl-Taint-Runtime-tests.sha256sum] = "9a0be57a32cf74857f4abd1701a4b0bff9dc49897f47847ec35070fb034d3e05"
RDEPENDS:perl-Taint-Runtime-tests = " \
 perl-Test-Harness \
 perl-Test-Simple \
 bash \
 perl-Taint-Runtime \
 perl-interpreter \
"
