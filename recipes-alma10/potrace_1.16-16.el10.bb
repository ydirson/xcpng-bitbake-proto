# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "potrace"
PE = "0"
PV = "1.16"
PR = "16.el10"
PACKAGES = "potrace potrace-devel potrace-doc"
PROVIDES = "rpm/potrace rpm/potrace-devel rpm/potrace-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/potrace-1.16-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ac6a6f5b60dab4ec86c12036204573a57b34037f6eedef8a3e2804d3a8db4f2"

URI_potrace = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/potrace-1.16-16.el10.x86_64_v2.rpm;name=potrace;unpack=0"
SRC_URI += "${URI_potrace}"
SRC_URI[potrace.sha256sum] = "ce9685fbf6c3852482b6f8edef6c4adc62721ab68f4e2b8b02ea6811a0a7f7dc"
RDEPENDS:potrace = " \
 glibc \
 zlib-ng-compat \
"

URI_potrace-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/potrace-devel-1.16-16.el10.x86_64_v2.rpm;name=potrace-devel;unpack=0"
SRC_URI += "${URI_potrace-devel}"
SRC_URI[potrace-devel.sha256sum] = "61ae1f38ecace5c5e483ce79aed9c0db3ddb10b652c0917d023109738a4169ab"
RDEPENDS:potrace-devel = " \
 potrace \
"

URI_potrace-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/potrace-doc-1.16-16.el10.noarch.rpm;name=potrace-doc;unpack=0"
SRC_URI += "${URI_potrace-doc}"
SRC_URI[potrace-doc.sha256sum] = "c2fc38bf65d1070222da2be434aaffab7e6b98b9c29ba09465d7b071a2cda879"
RDEPENDS:potrace-doc = ""
