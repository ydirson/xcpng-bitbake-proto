# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Module-Load"
PE = "1"
PV = "0.36"
PR = "511.el10"
PACKAGES = "perl-Module-Load perl-Module-Load-tests"
PROVIDES = "rpm/perl-Module-Load rpm/perl-Module-Load-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Module-Load-0.36-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c594d490f9dfc34513516d4e020bd6bbc8970ead4770f7c1894e334873e638f1"

URI_perl-Module-Load = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Module-Load-0.36-511.el10.noarch.rpm;name=perl-Module-Load;unpack=0"
SRC_URI += "${URI_perl-Module-Load}"
SRC_URI[perl-Module-Load.sha256sum] = "04b36e1069ef8dee690a71ae89c7c9c900d61ed5a26a15329effede65cb8b680"
RDEPENDS:perl-Module-Load = " \
 perl-PathTools \
 perl-libs \
"

URI_perl-Module-Load-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Module-Load-tests-0.36-511.el10.noarch.rpm;name=perl-Module-Load-tests;unpack=0"
SRC_URI += "${URI_perl-Module-Load-tests}"
SRC_URI[perl-Module-Load-tests.sha256sum] = "1d07ed1f7bdb62ca4f1766dadba4b16af6756348c65d68f5195e40e0d83cef5c"
RDEPENDS:perl-Module-Load-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-vars \
 perl-Module-Load \
 bash \
 perl-interpreter \
 perl-Data-Dumper \
 perl-Exporter \
 perl-lib \
"
