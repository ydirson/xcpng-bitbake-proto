# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Class-Inspector"
PE = "0"
PV = "1.36"
PR = "19.el10"
PACKAGES = "perl-Class-Inspector perl-Class-Inspector-tests"
PROVIDES = "rpm/perl-Class-Inspector rpm/perl-Class-Inspector-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Class-Inspector-1.36-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2277708fcd3782212a268a91c8f941806ee347d2db5cf044e3ffe88ce78e67f1"

URI_perl-Class-Inspector = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Class-Inspector-1.36-19.el10.noarch.rpm;name=perl-Class-Inspector;unpack=0"
SRC_URI += "${URI_perl-Class-Inspector}"
SRC_URI[perl-Class-Inspector.sha256sum] = "d95de6a8f3ffddb37ca1916d4e17869e7fbcecf92b1b70fa78cb7fa6cdc95209"
RDEPENDS:perl-Class-Inspector = " \
 perl-libs \
 perl-Class-Inspector \
 perl-PathTools \
 perl-Exporter \
 perl-base \
"

URI_perl-Class-Inspector-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Class-Inspector-tests-1.36-19.el10.noarch.rpm;name=perl-Class-Inspector-tests;unpack=0"
SRC_URI += "${URI_perl-Class-Inspector-tests}"
SRC_URI[perl-Class-Inspector-tests.sha256sum] = "19957effe95724b7daee097157c324d79af8e471d7fd81af9efe7002e3f230a7"
RDEPENDS:perl-Class-Inspector-tests = " \
 perl-constant \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-vars \
 perl-Class-Inspector \
 bash \
 perl-interpreter \
 perl-base \
"
