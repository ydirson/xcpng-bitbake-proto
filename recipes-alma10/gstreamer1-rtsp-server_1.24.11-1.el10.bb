# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gstreamer1-rtsp-server"
PE = "0"
PV = "1.24.11"
PR = "1.el10"
PACKAGES = "gstreamer1-rtsp-server gstreamer1-rtsp-server-devel"
PROVIDES = "rpm/gstreamer1-rtsp-server rpm/gstreamer1-rtsp-server-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gstreamer1-rtsp-server-1.24.11-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "41e389fa71118d387e0ad6d53445935e35d36c9a441f168d93a7681d7128c035"

URI_gstreamer1-rtsp-server = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gstreamer1-rtsp-server-1.24.11-1.el10.x86_64_v2.rpm;name=gstreamer1-rtsp-server;unpack=0"
SRC_URI += "${URI_gstreamer1-rtsp-server}"
SRC_URI[gstreamer1-rtsp-server.sha256sum] = "8283c2a1533c9a2dfff91ac1c23c7aaca863f5d5b9a2ea9f15cb2e315c98b165"
RDEPENDS:gstreamer1-rtsp-server = " \
 glibc \
 gstreamer1-plugins-base \
 glib2 \
 gstreamer1 \
"

URI_gstreamer1-rtsp-server-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gstreamer1-rtsp-server-devel-1.24.11-1.el10.x86_64_v2.rpm;name=gstreamer1-rtsp-server-devel;unpack=0"
SRC_URI += "${URI_gstreamer1-rtsp-server-devel}"
SRC_URI[gstreamer1-rtsp-server-devel.sha256sum] = "ee2f5344589607e50479797c326c29b7fbc4369f240b2ff2afa8778ad4970893"
RDEPENDS:gstreamer1-rtsp-server-devel = " \
 gstreamer1 \
 gstreamer1-devel \
 pkgconf-pkg-config \
 gstreamer1-plugins-base \
 gstreamer1-plugins-base-devel \
 gstreamer1-rtsp-server \
 glib2 \
 glibc \
"
