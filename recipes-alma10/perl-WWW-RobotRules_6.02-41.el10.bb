# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-WWW-RobotRules"
PE = "0"
PV = "6.02"
PR = "41.el10"
PACKAGES = "perl-WWW-RobotRules perl-WWW-RobotRules-tests"
PROVIDES = "rpm/perl-WWW-RobotRules rpm/perl-WWW-RobotRules-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-WWW-RobotRules-6.02-41.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3272f3875fd4b082c9b8df135f0efb4dff8985300dbcf768798f687549ce0c6"

URI_perl-WWW-RobotRules = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-WWW-RobotRules-6.02-41.el10.noarch.rpm;name=perl-WWW-RobotRules;unpack=0"
SRC_URI += "${URI_perl-WWW-RobotRules}"
SRC_URI[perl-WWW-RobotRules.sha256sum] = "a73e89b27fa10458526a2f36a5fecbb07af4f408ef5d29686242666abf01ee66"
RDEPENDS:perl-WWW-RobotRules = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-URI \
 perl-Fcntl \
 perl-WWW-RobotRules \
"

URI_perl-WWW-RobotRules-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-WWW-RobotRules-tests-6.02-41.el10.noarch.rpm;name=perl-WWW-RobotRules-tests;unpack=0"
SRC_URI += "${URI_perl-WWW-RobotRules-tests}"
SRC_URI[perl-WWW-RobotRules-tests.sha256sum] = "351c4f36681591b4af029380147819fa6b40c998725c242e9c19c35f2fb1fedb"
RDEPENDS:perl-WWW-RobotRules-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Carp \
 perl-WWW-RobotRules \
 bash \
 coreutils \
 perl-interpreter \
"
