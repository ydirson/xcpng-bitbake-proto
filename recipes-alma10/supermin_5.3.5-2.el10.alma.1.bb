# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "supermin"
PE = "0"
PV = "5.3.5"
PR = "2.el10.alma.1"
PACKAGES = "supermin supermin-devel"
PROVIDES = "rpm/supermin rpm/supermin-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/supermin-5.3.5-2.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3259d2a0144a4b560d190330704d709481dd5d7b02c8889695d88f4f67bd71a4"

URI_supermin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/supermin-5.3.5-2.el10.alma.1.x86_64_v2.rpm;name=supermin;unpack=0"
SRC_URI += "${URI_supermin}"
SRC_URI[supermin.sha256sum] = "f55029a8c96083281385b6c3fcb528d03581adae6694b089d8309e6be6fc2eb3"
RDEPENDS:supermin = " \
 e2fsprogs \
 e2fsprogs-libs \
 util-linux \
 tar \
 libcom_err \
 glibc \
 rpm \
 cpio \
 rpm-libs \
"

URI_supermin-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/supermin-devel-5.3.5-2.el10.alma.1.x86_64_v2.rpm;name=supermin-devel;unpack=0"
SRC_URI += "${URI_supermin-devel}"
SRC_URI[supermin-devel.sha256sum] = "43eebfdca9a8ad2eae4e6b42062c163aa23f72105e2ec77aebd864eb4d8bf4ba"
RDEPENDS:supermin-devel = " \
 dnf \
 rpm-build \
 dnf-plugins-core \
 bash \
 supermin \
 findutils \
"
