# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-HTTP-Daemon"
PE = "0"
PV = "6.16"
PR = "7.el10"
PACKAGES = "perl-HTTP-Daemon perl-HTTP-Daemon-tests"
PROVIDES = "rpm/perl-HTTP-Daemon rpm/perl-HTTP-Daemon-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-HTTP-Daemon-6.16-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc46a62fc6518bc50a77a9feaf59988696a0a804e272b9794ca79534ce70aff8"

URI_perl-HTTP-Daemon = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-HTTP-Daemon-6.16-7.el10.noarch.rpm;name=perl-HTTP-Daemon;unpack=0"
SRC_URI += "${URI_perl-HTTP-Daemon}"
SRC_URI[perl-HTTP-Daemon.sha256sum] = "28e887f70e0a69a65b3defbc1ba20d6d6a1a56fb760f40eef335da8773eae435"
RDEPENDS:perl-HTTP-Daemon = " \
 perl-libs \
 perl-Carp \
 perl-Socket \
 perl-IO-Socket-IP \
 perl-LWP-MediaTypes \
 perl-HTTP-Date \
 perl-HTTP-Message \
"

URI_perl-HTTP-Daemon-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-HTTP-Daemon-tests-6.16-7.el10.noarch.rpm;name=perl-HTTP-Daemon-tests;unpack=0"
SRC_URI += "${URI_perl-HTTP-Daemon-tests}"
SRC_URI[perl-HTTP-Daemon-tests.sha256sum] = "15938ff8bafd19d6a16c7c70945e14679e58a44bfa80384da7a871f889c5d18f"
RDEPENDS:perl-HTTP-Daemon-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-libwww-perl \
 perl-Test-Simple \
 perl-IO \
 perl-Socket \
 perl-Module-Metadata \
 perl-File-Temp \
 perl-PathTools \
 bash \
 perl-Test-Needs \
 perl-interpreter \
 perl-HTTP-Daemon \
 perl-lib \
 perl-MIME-Base64 \
"
