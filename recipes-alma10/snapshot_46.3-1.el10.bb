# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "snapshot"
PE = "0"
PV = "46.3"
PR = "1.el10"
PACKAGES = "snapshot"
PROVIDES = "rpm/snapshot"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/snapshot-46.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00163a418a890deeaa5c260dbc914287f6752f31bd3730427633241412384a71"

URI_snapshot = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/snapshot-46.3-1.el10.x86_64_v2.rpm;name=snapshot;unpack=0"
SRC_URI += "${URI_snapshot}"
SRC_URI[snapshot.sha256sum] = "d05e3d9889d134b8e068ad8670292c3b7424411fff314ff0d35babf7cc2dc9ee"
RDEPENDS:snapshot = " \
 gstreamer1 \
 gstreamer1-plugins-bad-free \
 libgcc \
 gstreamer1-plugins-base \
 glib2 \
 graphene \
 glibc \
 gtk4 \
 hicolor-icon-theme \
 libadwaita \
"
