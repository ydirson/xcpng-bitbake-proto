# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tcpdump"
PE = "14"
PV = "4.99.4"
PR = "10.el10"
PACKAGES = "tcpdump"
PROVIDES = "rpm/tcpdump"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tcpdump-4.99.4-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e289048eaad62cad7b8c4ab6f56de3133e83d1f0fdc9e158ab7ac39fedbb2e60"

URI_tcpdump = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tcpdump-4.99.4-10.el10.x86_64_v2.rpm;name=tcpdump;unpack=0"
SRC_URI += "${URI_tcpdump}"
SRC_URI[tcpdump.sha256sum] = "a34c68440381ad3a7ca23869f9161bde5e7aad39cd14df329ace56f7f6b2eb2b"
RDEPENDS:tcpdump = " \
 libpcap \
 shadow-utils \
 openssl-libs \
 bash \
 glibc \
"
