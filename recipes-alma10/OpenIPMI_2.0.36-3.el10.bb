# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "OpenIPMI"
PE = "0"
PV = "2.0.36"
PR = "3.el10"
PACKAGES = "OpenIPMI OpenIPMI-lanserv OpenIPMI-libs OpenIPMI-devel"
PROVIDES = "rpm/OpenIPMI rpm/OpenIPMI-lanserv rpm/OpenIPMI-libs rpm/OpenIPMI-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/OpenIPMI-2.0.36-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c027edcdc2abb2cd818321032475089189faba9dc8049577c7331f5beaa1bba"

URI_OpenIPMI = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/OpenIPMI-2.0.36-3.el10.x86_64_v2.rpm;name=OpenIPMI;unpack=0"
SRC_URI += "${URI_OpenIPMI}"
SRC_URI[OpenIPMI.sha256sum] = "204f5c4bd8bda8de322d325b6c3934a69002602ec5ca3f8f6f0951ad5eac4ae5"
RDEPENDS:OpenIPMI = " \
 systemd \
 net-snmp-libs \
 readline \
 gdbm-libs \
 bash \
 glib2 \
 OpenIPMI-libs \
 glibc \
"

URI_OpenIPMI-lanserv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/OpenIPMI-lanserv-2.0.36-3.el10.x86_64_v2.rpm;name=OpenIPMI-lanserv;unpack=0"
SRC_URI += "${URI_OpenIPMI-lanserv}"
SRC_URI[OpenIPMI-lanserv.sha256sum] = "02b477857dcb425e4d6580a5f61c1a8f4031672d72e631bff64ac960000d7c2c"
RDEPENDS:OpenIPMI-lanserv = " \
 openssl-libs \
 OpenIPMI \
 popt \
 OpenIPMI-libs \
 glibc \
"

URI_OpenIPMI-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/OpenIPMI-libs-2.0.36-3.el10.x86_64_v2.rpm;name=OpenIPMI-libs;unpack=0"
SRC_URI += "${URI_OpenIPMI-libs}"
SRC_URI[OpenIPMI-libs.sha256sum] = "0be7ce5a9c5fe9fd7646c5c18e7c68e14b72473801e8a18a02121d4e3bbffab9"
RDEPENDS:OpenIPMI-libs = " \
 net-snmp-libs \
 openssl-libs \
 gdbm-libs \
 ncurses-libs \
 glib2 \
 glibc \
"

URI_OpenIPMI-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/OpenIPMI-devel-2.0.36-3.el10.x86_64_v2.rpm;name=OpenIPMI-devel;unpack=0"
SRC_URI += "${URI_OpenIPMI-devel}"
SRC_URI[OpenIPMI-devel.sha256sum] = "ea88ccfb90c9c7cbaadee0f54f16e7adfc39149d2f0003939debe89beb3d0507"
RDEPENDS:OpenIPMI-devel = " \
 ncurses-devel \
 OpenIPMI-devel \
 pkgconf-pkg-config \
 OpenIPMI \
 OpenIPMI-lanserv \
 OpenIPMI-libs \
"
