# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Digest"
PE = "0"
PV = "1.20"
PR = "511.el10"
PACKAGES = "perl-Digest perl-Digest-tests"
PROVIDES = "rpm/perl-Digest rpm/perl-Digest-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Digest-1.20-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b598fe5fd0c63ef275d7b2f265ee735e699d7ffa9174364c332f88ca3dd8962"

URI_perl-Digest = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Digest-1.20-511.el10.noarch.rpm;name=perl-Digest;unpack=0"
SRC_URI += "${URI_perl-Digest}"
SRC_URI[perl-Digest.sha256sum] = "9f3f1c35ecaac233cd58aa91c4ab0426738d01ed848b2d324c8c313bf39b114b"
RDEPENDS:perl-Digest = " \
 perl-libs \
 perl-Carp \
 perl-Digest \
 perl-Exporter \
 perl-MIME-Base64 \
"

URI_perl-Digest-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Digest-tests-1.20-511.el10.noarch.rpm;name=perl-Digest-tests;unpack=0"
SRC_URI += "${URI_perl-Digest-tests}"
SRC_URI[perl-Digest-tests.sha256sum] = "d034a297be18d10288aa18ffc29db03dca1e1c30df89d746f10c2b07b8fa3511"
RDEPENDS:perl-Digest-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Digest \
 perl-File-Temp \
 bash \
 perl-interpreter \
 perl-lib \
"
