# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libdmx"
PE = "0"
PV = "1.1.5"
PR = "4.el10"
PACKAGES = "libdmx libdmx-devel"
PROVIDES = "rpm/libdmx rpm/libdmx-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/libdmx-1.1.5-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d878c58ea6a5b03f9e26ab07281ec4dc67702d08f0fa57cdaf4815f081eb1f3"

URI_libdmx = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdmx-1.1.5-4.el10.x86_64_v2.rpm;name=libdmx;unpack=0"
SRC_URI += "${URI_libdmx}"
SRC_URI[libdmx.sha256sum] = "54cea0ccf245702a743f97078d16ca093768613741a49c995eded54405223f91"
RDEPENDS:libdmx = " \
 glibc \
 libX11 \
 libXext \
"

URI_libdmx-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdmx-devel-1.1.5-4.el10.x86_64_v2.rpm;name=libdmx-devel;unpack=0"
SRC_URI += "${URI_libdmx-devel}"
SRC_URI[libdmx-devel.sha256sum] = "a9d4aac6a362db157d561f877e90f96a7c458239febb788d97b74e6646a2871c"
RDEPENDS:libdmx-devel = " \
 libXext-devel \
 pkgconf-pkg-config \
 libX11-devel \
 xorg-x11-proto-devel \
 libdmx \
"
