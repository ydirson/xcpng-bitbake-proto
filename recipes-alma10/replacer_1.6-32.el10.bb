# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "replacer"
PE = "0"
PV = "1.6"
PR = "32.el10"
PACKAGES = "replacer replacer-javadoc"
PROVIDES = "rpm/replacer rpm/replacer-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/replacer-1.6-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "281cc07c038dc4ee0e58ef433b2125b8169cb92213a0bdfdbbdca598dd6a6938"

URI_replacer = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/replacer-1.6-32.el10.noarch.rpm;name=replacer;unpack=0"
SRC_URI += "${URI_replacer}"
SRC_URI[replacer.sha256sum] = "1c34cdd33b72abe0ad107eee8d187ae6c57f8f6e6045c48675943b10125c509c"
RDEPENDS:replacer = " \
 apache-commons-io \
 javapackages-filesystem \
 apache-commons-lang3 \
 xerces-j2 \
 maven-lib \
 ant-lib \
"

URI_replacer-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/replacer-javadoc-1.6-32.el10.noarch.rpm;name=replacer-javadoc;unpack=0"
SRC_URI += "${URI_replacer-javadoc}"
SRC_URI[replacer-javadoc.sha256sum] = "7b8360e07174dc0fbfe3b404dcf5c84a0664355d5695e3d80ee5240a43db3c0f"
RDEPENDS:replacer-javadoc = " \
 javapackages-filesystem \
"
