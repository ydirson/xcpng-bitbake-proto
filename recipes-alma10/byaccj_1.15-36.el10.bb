# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "byaccj"
PE = "0"
PV = "1.15"
PR = "36.el10"
PACKAGES = "byaccj"
PROVIDES = "rpm/byaccj"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/byaccj-1.15-36.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab2fbb64d0edaa9466fa201d8a399826f510d8a2a04c89a24fd9180abf180b73"

URI_byaccj = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/byaccj-1.15-36.el10.x86_64_v2.rpm;name=byaccj;unpack=0"
SRC_URI += "${URI_byaccj}"
SRC_URI[byaccj.sha256sum] = "7870f520e38b09b2ad779883a267e3eddda1c7c925c3359249c61eded76109c7"
RDEPENDS:byaccj = " \
 glibc \
"
