# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "plexus-languages"
PE = "0"
PV = "1.2.0"
PR = "7.el10"
PACKAGES = "plexus-languages plexus-languages-javadoc"
PROVIDES = "rpm/plexus-languages rpm/plexus-languages-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/plexus-languages-1.2.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c974da31c8f9c095eaf69cce92e06087ce094dc917d62ecb8ffb85f4a48de9da"

URI_plexus-languages = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-languages-1.2.0-7.el10.noarch.rpm;name=plexus-languages;unpack=0"
SRC_URI += "${URI_plexus-languages}"
SRC_URI[plexus-languages.sha256sum] = "8d1d4bae56bd942203aa0bfd2c44a6be5a661b62525f137f6b3ad582b47b68cf"
RDEPENDS:plexus-languages = " \
 objectweb-asm \
 qdox \
 javapackages-filesystem \
"

URI_plexus-languages-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-languages-javadoc-1.2.0-7.el10.noarch.rpm;name=plexus-languages-javadoc;unpack=0"
SRC_URI += "${URI_plexus-languages-javadoc}"
SRC_URI[plexus-languages-javadoc.sha256sum] = "0ec1cbcfe6278ca6fbb6d5632afa971f3e1a9026288daca080f7e9cc6053c07b"
RDEPENDS:plexus-languages-javadoc = " \
 javapackages-filesystem \
"
