# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "convmv"
PE = "0"
PV = "2.05"
PR = "18.el10"
PACKAGES = "convmv"
PROVIDES = "rpm/convmv"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/convmv-2.05-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "185814066bb5c4df4e677463f1260ef67ee17ccce4a72c7d25f871a2c3d63697"

URI_convmv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/convmv-2.05-18.el10.noarch.rpm;name=convmv;unpack=0"
SRC_URI += "${URI_convmv}"
SRC_URI[convmv.sha256sum] = "bdc62682b62ec2d1905feb6e5493fa923113f81cef9df6935b398a00b4e6a6ee"
RDEPENDS:convmv = " \
 perl-libs \
 perl-Unicode-Normalize \
 perl-Getopt-Long \
 perl-File-Basename \
 perl-Encode \
 perl-File-Compare \
 perl-PathTools \
 perl-File-Find \
 perl-interpreter \
"
