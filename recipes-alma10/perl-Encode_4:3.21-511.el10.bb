# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Encode"
PE = "4"
PV = "3.21"
PR = "511.el10"
PACKAGES = "perl-Encode perl-Encode-devel perl-encoding perl-Encode-tests"
PROVIDES = "rpm/perl-Encode rpm/perl-Encode-devel rpm/perl-encoding rpm/perl-Encode-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Encode-3.21-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8593d7054789a886da268d6319ac0b394ef5b326315b15e82a3cf05132f72d7a"

URI_perl-Encode = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Encode-3.21-511.el10.x86_64_v2.rpm;name=perl-Encode;unpack=0"
SRC_URI += "${URI_perl-Encode}"
SRC_URI[perl-Encode.sha256sum] = "26b5b664c8f2e479f9061afeebbb0b17e5551c59db35ce94145abcf918c03f2d"
RDEPENDS:perl-Encode = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-Storable \
 perl-Getopt-Long \
 perl-File-Basename \
 perl-Getopt-Std \
 perl-Encode \
 perl-overload \
 perl-parent \
 glibc \
 perl-interpreter \
 perl-Exporter \
 perl-MIME-Base64 \
"

URI_perl-Encode-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Encode-devel-3.21-511.el10.x86_64_v2.rpm;name=perl-Encode-devel;unpack=0"
SRC_URI += "${URI_perl-Encode-devel}"
SRC_URI[perl-Encode-devel.sha256sum] = "94936f2e97865102660c4bb2b7ec1d6ae61548a04c3f8e05e71ca87abe53a17c"
RDEPENDS:perl-Encode-devel = " \
 perl-constant \
 perl-libs \
 perl-vars \
 perl-Getopt-Std \
 perl-Encode \
 perl-File-Find \
 perl-interpreter \
"

URI_perl-encoding = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-encoding-3.00-511.el10.x86_64_v2.rpm;name=perl-encoding;unpack=0"
SRC_URI += "${URI_perl-encoding}"
SRC_URI[perl-encoding.sha256sum] = "7ba5f0dd54ed6788920d9c445fb0c338aa91b5d652d6a82405d98a20728e88d2"
RDEPENDS:perl-encoding = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-Filter \
 perl-Encode \
"

URI_perl-Encode-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Encode-tests-3.21-511.el10.x86_64_v2.rpm;name=perl-Encode-tests;unpack=0"
SRC_URI += "${URI_perl-Encode-tests}"
SRC_URI[perl-Encode-tests.sha256sum] = "2241ccc2b3382f59ee5913421507f5e7d2ed4cbda76de83fdd64b72a66a5ac3a"
RDEPENDS:perl-Encode-tests = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-FileHandle \
 perl-FindBin \
 perl-open \
 perl-overload \
 perl-Symbol \
 perl-Benchmark \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-vars \
 perl-IO \
 perl-IPC-Open3 \
 perl-JSON-PP \
 perl-Tie \
 perl-lib \
 perl-MIME-Base64 \
 perl-Devel-Peek \
 perl-Encode \
 bash \
 perl-encoding \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Copy \
 perl-PathTools \
 perl-interpreter \
 perl-File-Temp \
"
