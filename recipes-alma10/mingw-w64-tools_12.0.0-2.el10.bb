# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mingw-w64-tools"
PE = "0"
PV = "12.0.0"
PR = "2.el10"
PACKAGES = "mingw-w64-tools"
PROVIDES = "rpm/mingw-w64-tools"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/mingw-w64-tools-12.0.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22e00d2e7107f06b3065840347e9616b13afeb7e694309bc2861a1ff8b9968e3"

URI_mingw-w64-tools = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw-w64-tools-12.0.0-2.el10.x86_64_v2.rpm;name=mingw-w64-tools;unpack=0"
SRC_URI += "${URI_mingw-w64-tools}"
SRC_URI[mingw-w64-tools.sha256sum] = "b6177833a0f5319766b05ab4a2147a861e0adf9d8e3bee49a2274d0a66d43f3d"
RDEPENDS:mingw-w64-tools = " \
 glibc \
"
