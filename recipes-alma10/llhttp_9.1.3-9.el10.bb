# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "llhttp"
PE = "0"
PV = "9.1.3"
PR = "9.el10"
PACKAGES = "llhttp llhttp-devel"
PROVIDES = "rpm/llhttp rpm/llhttp-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/llhttp-9.1.3-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "025d9d06ae5b5a1c92afd13fd9666c02e17b3ff84b6a5ba12fbc381c90bf09dc"

URI_llhttp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/llhttp-9.1.3-9.el10.x86_64_v2.rpm;name=llhttp;unpack=0"
SRC_URI += "${URI_llhttp}"
SRC_URI[llhttp.sha256sum] = "cf4cb69278f9d47c013a1a7a3fe511aa5c2ede0eba14b28ed8fb38b528d25a5c"
RDEPENDS:llhttp = " \
 glibc \
"

URI_llhttp-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/llhttp-devel-9.1.3-9.el10.x86_64_v2.rpm;name=llhttp-devel;unpack=0"
SRC_URI += "${URI_llhttp-devel}"
SRC_URI[llhttp-devel.sha256sum] = "e827ab4d9030b6fc7517bee7d2a303c60bc739551337c86f5db7ee02fd1e5f7d"
RDEPENDS:llhttp-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 llhttp \
"
