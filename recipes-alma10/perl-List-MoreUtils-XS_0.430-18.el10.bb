# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-List-MoreUtils-XS"
PE = "0"
PV = "0.430"
PR = "18.el10"
PACKAGES = "perl-List-MoreUtils-XS perl-List-MoreUtils-XS-tests"
PROVIDES = "rpm/perl-List-MoreUtils-XS rpm/perl-List-MoreUtils-XS-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-List-MoreUtils-XS-0.430-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e59a5701623e15058cbfae2cca9db9890e524e8d6497c545ae11658ae5a9dabd"

URI_perl-List-MoreUtils-XS = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-List-MoreUtils-XS-0.430-18.el10.x86_64_v2.rpm;name=perl-List-MoreUtils-XS;unpack=0"
SRC_URI += "${URI_perl-List-MoreUtils-XS}"
SRC_URI[perl-List-MoreUtils-XS.sha256sum] = "dffe329127b85230e5f4a08a374f6473f9753a2086cd49378b2536cb3088fbf0"
RDEPENDS:perl-List-MoreUtils-XS = " \
 glibc \
 perl-libs \
 perl-base \
 perl-vars \
"

URI_perl-List-MoreUtils-XS-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-List-MoreUtils-XS-tests-0.430-18.el10.x86_64_v2.rpm;name=perl-List-MoreUtils-XS-tests;unpack=0"
SRC_URI += "${URI_perl-List-MoreUtils-XS-tests}"
SRC_URI[perl-List-MoreUtils-XS-tests.sha256sum] = "294ed5c1f41085391dcf4d9ce9c999510fd8735448adf59f67a681230b698288"
RDEPENDS:perl-List-MoreUtils-XS-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-Scalar-List-Utils \
 perl-Math-Complex \
 perl-POSIX \
 perl-overload \
 bash \
 perl-base \
 perl-Tie \
 perl-interpreter \
 perl-List-MoreUtils-XS \
 perl-Exporter \
 perl-lib \
"
