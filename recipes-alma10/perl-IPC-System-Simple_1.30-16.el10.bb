# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-IPC-System-Simple"
PE = "0"
PV = "1.30"
PR = "16.el10"
PACKAGES = "perl-IPC-System-Simple perl-IPC-System-Simple-tests"
PROVIDES = "rpm/perl-IPC-System-Simple rpm/perl-IPC-System-Simple-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-IPC-System-Simple-1.30-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e42e313f4e8cb951a6891143c7dbd66d186d3c476949481bcdc2671e0d5da09"

URI_perl-IPC-System-Simple = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-IPC-System-Simple-1.30-16.el10.noarch.rpm;name=perl-IPC-System-Simple;unpack=0"
SRC_URI += "${URI_perl-IPC-System-Simple}"
SRC_URI[perl-IPC-System-Simple.sha256sum] = "70520e27709978cb886d9d07fd16d59ee5b8849317974e0d52986083481e188b"
RDEPENDS:perl-IPC-System-Simple = " \
 perl-constant \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-POSIX \
 perl-Exporter \
"

URI_perl-IPC-System-Simple-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-IPC-System-Simple-tests-1.30-16.el10.noarch.rpm;name=perl-IPC-System-Simple-tests;unpack=0"
SRC_URI += "${URI_perl-IPC-System-Simple-tests}"
SRC_URI[perl-IPC-System-Simple-tests.sha256sum] = "740c992c4120b1961752b0adee1f7dd07c838599ec133f64c0ffe749f266345a"
RDEPENDS:perl-IPC-System-Simple-tests = " \
 perl-constant \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Scalar-List-Utils \
 perl-File-Basename \
 bash \
 perl-IPC-System-Simple \
 perl-interpreter \
"
