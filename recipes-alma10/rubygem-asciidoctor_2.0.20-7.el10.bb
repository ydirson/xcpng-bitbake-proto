# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rubygem-asciidoctor"
PE = "0"
PV = "2.0.20"
PR = "7.el10"
PACKAGES = "rubygem-asciidoctor rubygem-asciidoctor-doc"
PROVIDES = "rpm/rubygem-asciidoctor rpm/rubygem-asciidoctor-doc"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/rubygem-asciidoctor-2.0.20-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00f4c8d1df4054e0f683cb75d9431cba0c5282db35dc5dafd5e3a1a6b069240a"

URI_rubygem-asciidoctor = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-asciidoctor-2.0.20-7.el10.noarch.rpm;name=rubygem-asciidoctor;unpack=0"
SRC_URI += "${URI_rubygem-asciidoctor}"
SRC_URI[rubygem-asciidoctor.sha256sum] = "226664b1978bc7c70970b6a97ed7fe3785646406cb146a0247f13c6e57e72a47"
RDEPENDS:rubygem-asciidoctor = " \
 rubygems \
 ruby \
"

URI_rubygem-asciidoctor-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-asciidoctor-doc-2.0.20-7.el10.noarch.rpm;name=rubygem-asciidoctor-doc;unpack=0"
SRC_URI += "${URI_rubygem-asciidoctor-doc}"
SRC_URI[rubygem-asciidoctor-doc.sha256sum] = "e81a2637afdda7fe98b909a61fd42342392789c48dc67be1bc14d12a8886b10d"
RDEPENDS:rubygem-asciidoctor-doc = " \
 rubygem-asciidoctor \
"
