# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libXv"
PE = "0"
PV = "1.0.12"
PR = "5.el10"
PACKAGES = "libXv libXv-devel"
PROVIDES = "rpm/libXv rpm/libXv-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libXv-1.0.12-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1fc6520f5614e5e89cac8f6c3866166dfffc068a32358c4cbfeef14bd8869d63"

URI_libXv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXv-1.0.12-5.el10.x86_64_v2.rpm;name=libXv;unpack=0"
SRC_URI += "${URI_libXv}"
SRC_URI[libXv.sha256sum] = "9742fa51ddf598492553d2a79c2f5889fe4f6d785e9e9f110d1c78dd5eaeb098"
RDEPENDS:libXv = " \
 glibc \
 libX11 \
 libXext \
"

URI_libXv-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXv-devel-1.0.12-5.el10.x86_64_v2.rpm;name=libXv-devel;unpack=0"
SRC_URI += "${URI_libXv-devel}"
SRC_URI[libXv-devel.sha256sum] = "cb2e85a53b23a8557816df625ee4c7c945d8e7a8ea969e8baee409c231c6fc98"
RDEPENDS:libXv-devel = " \
 libXext-devel \
 pkgconf-pkg-config \
 libX11-devel \
 xorg-x11-proto-devel \
 libXv \
"
