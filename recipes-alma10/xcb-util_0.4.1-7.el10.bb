# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xcb-util"
PE = "0"
PV = "0.4.1"
PR = "7.el10"
PACKAGES = "xcb-util xcb-util-devel"
PROVIDES = "rpm/xcb-util rpm/xcb-util-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xcb-util-0.4.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e007a14c44375025299bacbf08b0dd18843e739751c6d31984f5d423604d22f7"

URI_xcb-util = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xcb-util-0.4.1-7.el10.x86_64_v2.rpm;name=xcb-util;unpack=0"
SRC_URI += "${URI_xcb-util}"
SRC_URI[xcb-util.sha256sum] = "fe22dc9705029bb7bad8c91edc32e16374a219aa9efe95b25a6028c82d7c770f"
RDEPENDS:xcb-util = " \
 glibc \
 libxcb \
"

URI_xcb-util-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xcb-util-devel-0.4.1-7.el10.x86_64_v2.rpm;name=xcb-util-devel;unpack=0"
SRC_URI += "${URI_xcb-util-devel}"
SRC_URI[xcb-util-devel.sha256sum] = "694160d87edcc82eddd2fcfc05cce6e65a9af4988213c271dc829c2df868f8a0"
RDEPENDS:xcb-util-devel = " \
 xcb-util \
 libxcb-devel \
 pkgconf-pkg-config \
"
