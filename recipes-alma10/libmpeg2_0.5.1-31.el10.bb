# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libmpeg2"
PE = "0"
PV = "0.5.1"
PR = "31.el10"
PACKAGES = "libmpeg2 libmpeg2-devel mpeg2dec"
PROVIDES = "rpm/libmpeg2 rpm/libmpeg2-devel rpm/mpeg2dec"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/libmpeg2-0.5.1-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f76b53d61c0184d63838d70a8da934deeceace67435844b3b17ea4e031d7a53"

URI_libmpeg2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libmpeg2-0.5.1-31.el10.x86_64_v2.rpm;name=libmpeg2;unpack=0"
SRC_URI += "${URI_libmpeg2}"
SRC_URI[libmpeg2.sha256sum] = "383dc3935e52fb57266c69e06c75831b6ea50ae79ce6a369f2e69f30e5d6ff21"
RDEPENDS:libmpeg2 = " \
 glibc \
"

URI_libmpeg2-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libmpeg2-devel-0.5.1-31.el10.x86_64_v2.rpm;name=libmpeg2-devel;unpack=0"
SRC_URI += "${URI_libmpeg2-devel}"
SRC_URI[libmpeg2-devel.sha256sum] = "5d5f4d86829b2be0beaa0a270fe09b403e846fe3286acf07fd1f4211da00a369"
RDEPENDS:libmpeg2-devel = " \
 libmpeg2 \
 pkgconf-pkg-config \
"

URI_mpeg2dec = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mpeg2dec-0.5.1-31.el10.x86_64_v2.rpm;name=mpeg2dec;unpack=0"
SRC_URI += "${URI_mpeg2dec}"
SRC_URI[mpeg2dec.sha256sum] = "20acff58a3faece74801c8b78dad1dd02c351938491644d5bf4bfec0f94d6f5c"
RDEPENDS:mpeg2dec = " \
 libX11 \
 libmpeg2 \
 libXv \
 glibc \
 sdl12-compat \
 libXext \
"
