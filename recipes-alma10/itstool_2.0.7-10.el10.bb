# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "itstool"
PE = "0"
PV = "2.0.7"
PR = "10.el10"
PACKAGES = "itstool"
PROVIDES = "rpm/itstool"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/itstool-2.0.7-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7f5bc8c61b1049fa98f3142ce255ad9a6a83bda09cdb5ff14151cf01688b5ac"

URI_itstool = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/itstool-2.0.7-10.el10.noarch.rpm;name=itstool;unpack=0"
SRC_URI += "${URI_itstool}"
SRC_URI[itstool.sha256sum] = "e28c95c6d9ed65a6162a1d7de8000cfe0989749a3f3b3db64d369ae59dadfa3c"
RDEPENDS:itstool = " \
 python3 \
 python3-libxml2 \
"
