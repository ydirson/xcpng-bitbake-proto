# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sscg"
PE = "0"
PV = "3.0.5"
PR = "9.el10"
PACKAGES = "sscg"
PROVIDES = "rpm/sscg"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/sscg-3.0.5-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76ac22c922fef10d3b1ee361f653ea6f324f42eb49892419139ad7cab8f6c6d2"

URI_sscg = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sscg-3.0.5-9.el10.x86_64_v2.rpm;name=sscg;unpack=0"
SRC_URI += "${URI_sscg}"
SRC_URI[sscg.sha256sum] = "c4d131cbd40198c51fed1eee16fda0a3661647eab51c1b3b45121c91047bce9d"
RDEPENDS:sscg = " \
 openssl-libs \
 popt \
 libtalloc \
 glibc \
 libpath_utils \
"
