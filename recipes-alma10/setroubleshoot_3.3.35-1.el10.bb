# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "setroubleshoot"
PE = "0"
PV = "3.3.35"
PR = "1.el10"
PACKAGES = "setroubleshoot setroubleshoot-server"
PROVIDES = "rpm/setroubleshoot rpm/setroubleshoot-server"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/setroubleshoot-3.3.35-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cad939cd16d258416f1dd563b9b69ab513d8e4bf4a950f47cedfd6b691825eb5"

URI_setroubleshoot = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/setroubleshoot-3.3.35-1.el10.x86_64_v2.rpm;name=setroubleshoot;unpack=0"
SRC_URI += "${URI_setroubleshoot}"
SRC_URI[setroubleshoot.sha256sum] = "abb03344a6b37acc408dc2ac78fb82d72599849084428ef549d06ea7ce071672"
RDEPENDS:setroubleshoot = " \
 python3 \
 python3-gobject \
 desktop-file-utils \
 setroubleshoot-server \
 xdg-utils \
 python3-dasbus \
 dbus \
 gtk3 \
 libnotify \
"

URI_setroubleshoot-server = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/setroubleshoot-server-3.3.35-1.el10.x86_64_v2.rpm;name=setroubleshoot-server;unpack=0"
SRC_URI += "${URI_setroubleshoot-server}"
SRC_URI[setroubleshoot-server.sha256sum] = "3e173175bc9694bde11a5a86a31b059a4859d12b5c923924dbbc2710e3d35333"
RDEPENDS:setroubleshoot-server = " \
 python3 \
 policycoreutils-python-utils \
 python3-dbus \
 dbus \
 python3-gobject-base \
 dbus-libs \
 libselinux \
 setroubleshoot-plugins \
 python3-libselinux \
 libcap-ng \
 python3-libxml2 \
 python3-rpm \
 audit \
 audit-libs \
 python3-six \
 bash \
 python3-systemd \
 python3-audit \
 python3-dasbus \
 polkit \
 glibc \
 initscripts-service \
"
