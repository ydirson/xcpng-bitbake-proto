# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "wireguard-tools"
PE = "0"
PV = "1.0.20210914"
PR = "6.el10"
PACKAGES = "wireguard-tools"
PROVIDES = "rpm/wireguard-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/wireguard-tools-1.0.20210914-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4c059d3ea50d74a028d0bb1eb870cfb587bfbfbb0bfd5674c46cfd85138ea4c"

URI_wireguard-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/wireguard-tools-1.0.20210914-6.el10.x86_64_v2.rpm;name=wireguard-tools;unpack=0"
SRC_URI += "${URI_wireguard-tools}"
SRC_URI[wireguard-tools.sha256sum] = "2d229ee5d959d34c4a2e4dbd6a8db15825ec017e39871863b75daaddc4351c89"
RDEPENDS:wireguard-tools = " \
 glibc \
 systemd \
 bash \
 systemd-resolved \
"
