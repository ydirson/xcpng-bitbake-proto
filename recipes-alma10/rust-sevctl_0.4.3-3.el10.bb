# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rust-sevctl"
PE = "0"
PV = "0.4.3"
PR = "3.el10"
PACKAGES = "sevctl"
PROVIDES = "rpm/sevctl"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/rust-sevctl-0.4.3-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28c990c2644efbf85d91b0eb1bf39b2dda1b64586478a4fee127e98c0fe1b437"

URI_sevctl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sevctl-0.4.3-3.el10.x86_64_v2.rpm;name=sevctl;unpack=0"
SRC_URI += "${URI_sevctl}"
SRC_URI[sevctl.sha256sum] = "d644d4c1b453d750fc90acedab221621c104541275c2dfd3f9296ce9c2aff067"
RDEPENDS:sevctl = " \
 glibc \
 openssl-libs \
 libgcc \
"
