# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "protobuf"
PE = "0"
PV = "3.19.6"
PR = "11.el10"
PACKAGES = "protobuf protobuf-lite python3-protobuf protobuf-compiler protobuf-devel protobuf-lite-devel protobuf-emacs protobuf-vim"
PROVIDES = "rpm/protobuf rpm/protobuf-lite rpm/python3-protobuf rpm/protobuf-compiler rpm/protobuf-devel rpm/protobuf-lite-devel rpm/protobuf-emacs rpm/protobuf-vim"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/protobuf-3.19.6-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86b20dbb682114d738b179cd3c555069f3b165dfbe4801199c15eff682ddd393"

URI_protobuf = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/protobuf-3.19.6-11.el10.x86_64_v2.rpm;name=protobuf;unpack=0"
SRC_URI += "${URI_protobuf}"
SRC_URI[protobuf.sha256sum] = "323d83fde01349d1e64b454974c7a38d8c19fc4aa7cd083ba56fcd7e4f2877c8"
RDEPENDS:protobuf = " \
 glibc \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
"

URI_protobuf-lite = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/protobuf-lite-3.19.6-11.el10.x86_64_v2.rpm;name=protobuf-lite;unpack=0"
SRC_URI += "${URI_protobuf-lite}"
SRC_URI[protobuf-lite.sha256sum] = "02b3d6540dfcbbbdff4c16f5ea5803ebb7df726c58abdcf45943ab53e84cc96b"
RDEPENDS:protobuf-lite = " \
 glibc \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
"

URI_python3-protobuf = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-protobuf-3.19.6-11.el10.x86_64_v2.rpm;name=python3-protobuf;unpack=0"
SRC_URI += "${URI_python3-protobuf}"
SRC_URI[python3-protobuf.sha256sum] = "686546868fbd3957b575e2068d742c705f53744a89231ab0c06aaafff9a09282"
RDEPENDS:python3-protobuf = " \
 python3 \
 protobuf \
 libgcc \
 libstdc++ \
 glibc \
"

URI_protobuf-compiler = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/protobuf-compiler-3.19.6-11.el10.x86_64_v2.rpm;name=protobuf-compiler;unpack=0"
SRC_URI += "${URI_protobuf-compiler}"
SRC_URI[protobuf-compiler.sha256sum] = "2c51966384dcfa552b6ae3a54d88e6487921ff06814a49047cefef5f09ac426e"
RDEPENDS:protobuf-compiler = " \
 protobuf \
 zlib-ng-compat \
 libgcc \
 libstdc++ \
 glibc \
"

URI_protobuf-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/protobuf-devel-3.19.6-11.el10.x86_64_v2.rpm;name=protobuf-devel;unpack=0"
SRC_URI += "${URI_protobuf-devel}"
SRC_URI[protobuf-devel.sha256sum] = "ab3a418ef58188b76afb7c6aa55a0f52a07f7623fd482ef3ffa710523814b0c9"
RDEPENDS:protobuf-devel = " \
 protobuf \
 zlib-ng-compat-devel \
 pkgconf-pkg-config \
 protobuf-compiler \
"

URI_protobuf-lite-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/protobuf-lite-devel-3.19.6-11.el10.x86_64_v2.rpm;name=protobuf-lite-devel;unpack=0"
SRC_URI += "${URI_protobuf-lite-devel}"
SRC_URI[protobuf-lite-devel.sha256sum] = "795a0be8c0044c8c19236552073120233c94da9b1dff1cb2fc429c056cc42a8e"
RDEPENDS:protobuf-lite-devel = " \
 protobuf-lite \
 pkgconf-pkg-config \
 protobuf-devel \
"

URI_protobuf-emacs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/protobuf-emacs-3.19.6-11.el10.noarch.rpm;name=protobuf-emacs;unpack=0"
SRC_URI += "${URI_protobuf-emacs}"
SRC_URI[protobuf-emacs.sha256sum] = "da32e4bf06d70d5cb738299e6e95781b986315232c6b7332df59db8b0c3d1a9f"
RDEPENDS:protobuf-emacs = " \
 emacs-filesystem \
"

URI_protobuf-vim = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/protobuf-vim-3.19.6-11.el10.noarch.rpm;name=protobuf-vim;unpack=0"
SRC_URI += "${URI_protobuf-vim}"
SRC_URI[protobuf-vim.sha256sum] = "07d9800e9cb8cdcb0ab64f2bc157a73285ff6888f814d88b2f5426591e7b08cf"
RDEPENDS:protobuf-vim = " \
 vim-filesystem \
"
