# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "json-c"
PE = "0"
PV = "0.18"
PR = "3.el10"
PACKAGES = "json-c json-c-devel json-c-doc"
PROVIDES = "rpm/json-c rpm/json-c-devel rpm/json-c-doc"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/json-c-0.18-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37ff72ae86a0784bfe60b1620da198474d870a2cb2f721b21dfe941ef5e11936"

URI_json-c = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/json-c-0.18-3.el10.x86_64_v2.rpm;name=json-c;unpack=0"
SRC_URI += "${URI_json-c}"
SRC_URI[json-c.sha256sum] = "5a4c0d366e18ff76af370aeb4f22b01e425fe169b189ece6f070ed9214ffed9e"
RDEPENDS:json-c = " \
 glibc \
"

URI_json-c-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/json-c-devel-0.18-3.el10.x86_64_v2.rpm;name=json-c-devel;unpack=0"
SRC_URI += "${URI_json-c-devel}"
SRC_URI[json-c-devel.sha256sum] = "0c0c1cec69b176d10ac507b2654c2c34710624da307f54f3fdacbc24ccbcacaf"
RDEPENDS:json-c-devel = " \
 json-c \
 cmake-filesystem \
 pkgconf-pkg-config \
"

URI_json-c-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/json-c-doc-0.18-3.el10.x86_64_v2.rpm;name=json-c-doc;unpack=0"
SRC_URI += "${URI_json-c-doc}"
SRC_URI[json-c-doc.sha256sum] = "fdc77ddc784c952c613ca855773bbcab17349be4f4123cdb2166e291dbc74b2c"
RDEPENDS:json-c-doc = " \
 json-c \
"
