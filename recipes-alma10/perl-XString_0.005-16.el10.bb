# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-XString"
PE = "0"
PV = "0.005"
PR = "16.el10"
PACKAGES = "perl-XString perl-XString-tests"
PROVIDES = "rpm/perl-XString rpm/perl-XString-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-XString-0.005-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd16788399d5af43021405a18e0248b8c202146acdff0fb7fde72d85472e8375"

URI_perl-XString = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-XString-0.005-16.el10.x86_64_v2.rpm;name=perl-XString;unpack=0"
SRC_URI += "${URI_perl-XString}"
SRC_URI[perl-XString.sha256sum] = "fa61a09b038f78ee9448817ae3d52b94f61a9fdb107e7eda73c3b90ab9a7f4b8"
RDEPENDS:perl-XString = " \
 glibc \
 perl-libs \
"

URI_perl-XString-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-XString-tests-0.005-16.el10.x86_64_v2.rpm;name=perl-XString-tests;unpack=0"
SRC_URI += "${URI_perl-XString-tests}"
SRC_URI[perl-XString-tests.sha256sum] = "acf9fc85dfd6f5e25b7e3bb3c540868d377086fc25b843e118716c8e508e73fa"
RDEPENDS:perl-XString-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-XString \
 bash \
 perl-B \
 perl-interpreter \
"
