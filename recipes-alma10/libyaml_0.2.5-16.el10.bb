# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libyaml"
PE = "0"
PV = "0.2.5"
PR = "16.el10"
PACKAGES = "libyaml libyaml-devel"
PROVIDES = "rpm/libyaml rpm/libyaml-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libyaml-0.2.5-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6617b40da7022d5cfcca7b2f3061690c808d4fdb6e0f3a39929e7f2faf54b37"

URI_libyaml = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libyaml-0.2.5-16.el10.x86_64_v2.rpm;name=libyaml;unpack=0"
SRC_URI += "${URI_libyaml}"
SRC_URI[libyaml.sha256sum] = "f28dbfcf7c545d29e434f06c493fc01010787c8a506fef05c79bb93d855809f4"
RDEPENDS:libyaml = " \
 glibc \
"

URI_libyaml-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libyaml-devel-0.2.5-16.el10.x86_64_v2.rpm;name=libyaml-devel;unpack=0"
SRC_URI += "${URI_libyaml-devel}"
SRC_URI[libyaml-devel.sha256sum] = "29e863eab177fa6568301f93930248d8675961696c46775872f693294c88f189"
RDEPENDS:libyaml-devel = " \
 pkgconf-pkg-config \
 libyaml \
"
