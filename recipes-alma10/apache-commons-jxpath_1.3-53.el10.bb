# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "apache-commons-jxpath"
PE = "0"
PV = "1.3"
PR = "53.el10"
PACKAGES = "apache-commons-jxpath apache-commons-jxpath-javadoc"
PROVIDES = "rpm/apache-commons-jxpath rpm/apache-commons-jxpath-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/apache-commons-jxpath-1.3-53.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a27272e88cf9e7d0859c11624058294c78d24e1debb5985fc6f52305bdf56edf"

URI_apache-commons-jxpath = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/apache-commons-jxpath-1.3-53.el10.noarch.rpm;name=apache-commons-jxpath;unpack=0"
SRC_URI += "${URI_apache-commons-jxpath}"
SRC_URI[apache-commons-jxpath.sha256sum] = "726d712b79a9b8db4368418b9021ebe943e4969cb63a1a2b018b5b48f736e1c6"
RDEPENDS:apache-commons-jxpath = " \
 javapackages-filesystem \
"

URI_apache-commons-jxpath-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/apache-commons-jxpath-javadoc-1.3-53.el10.noarch.rpm;name=apache-commons-jxpath-javadoc;unpack=0"
SRC_URI += "${URI_apache-commons-jxpath-javadoc}"
SRC_URI[apache-commons-jxpath-javadoc.sha256sum] = "efc38e22c0b25a88e5602920c49f3f33c5e997c36a2c48a4467f4bd0d99740d8"
RDEPENDS:apache-commons-jxpath-javadoc = " \
 javapackages-filesystem \
"
