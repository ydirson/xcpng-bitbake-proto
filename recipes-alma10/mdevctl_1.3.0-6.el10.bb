# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mdevctl"
PE = "0"
PV = "1.3.0"
PR = "6.el10"
PACKAGES = "mdevctl"
PROVIDES = "rpm/mdevctl"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mdevctl-1.3.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b240357694928e72a8fc09f3f2f346218a573e872ae99be0dff64b25b9481674"

URI_mdevctl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mdevctl-1.3.0-6.el10.x86_64_v2.rpm;name=mdevctl;unpack=0"
SRC_URI += "${URI_mdevctl}"
SRC_URI[mdevctl.sha256sum] = "b5560235aa4a712bbf3f5aeeb7a798b974a04cd09a840c34c66aee2c88664967"
RDEPENDS:mdevctl = " \
 glibc \
 systemd-udev \
 libgcc \
"
