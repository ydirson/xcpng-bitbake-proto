# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtlocation"
PE = "0"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = "qt6-qtlocation qt6-qtlocation-devel qt6-qtlocation-examples qt6-qtlocation-tests"
PROVIDES = "rpm/qt6-qtlocation rpm/qt6-qtlocation-devel rpm/qt6-qtlocation-examples rpm/qt6-qtlocation-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtlocation-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d1b8777b5fd71f3f56dc4e5b5f9fe00ff6aa5698190b3c5565fdd763c3a3f98"

URI_qt6-qtlocation = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtlocation-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtlocation;unpack=0"
SRC_URI += "${URI_qt6-qtlocation}"
SRC_URI[qt6-qtlocation.sha256sum] = "5327125f332aa0b1f624606c232cf8064d92f10345713f1b6fea224b5be6730d"
RDEPENDS:qt6-qtlocation = " \
 qt6-qtdeclarative \
 qt6-qtbase \
 qt6-qtpositioning \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qtlocation-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtlocation-devel-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtlocation-devel;unpack=0"
SRC_URI += "${URI_qt6-qtlocation-devel}"
SRC_URI[qt6-qtlocation-devel.sha256sum] = "d3c9b69c5df8486c965cc4d919108ae2c1dce39fdb9b67a0cc19fa01cccf9b9f"
RDEPENDS:qt6-qtlocation-devel = " \
 qt6-qtdeclarative-devel \
 cmake-filesystem \
 qt6-qtlocation \
 pkgconf-pkg-config \
 qt6-qtpositioning-devel \
 qt6-qtbase-devel \
"

URI_qt6-qtlocation-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtlocation-examples-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtlocation-examples;unpack=0"
SRC_URI += "${URI_qt6-qtlocation-examples}"
SRC_URI[qt6-qtlocation-examples.sha256sum] = "4f919d7a8cc27d3ff02d0c1f1ece324ef6e05fc95b414f5b002bb75a02de2005"
RDEPENDS:qt6-qtlocation-examples = " \
 qt6-qtdeclarative \
 qt6-qtlocation \
 libgcc \
 qt6-qtbase \
 qt6-qtpositioning \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qtlocation-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtlocation-tests-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtlocation-tests;unpack=0"
SRC_URI += "${URI_qt6-qtlocation-tests}"
SRC_URI[qt6-qtlocation-tests.sha256sum] = "d7ced1403abca9d034937c6c5130fa92c40fc238a35be6012a28fa6f890da025"
RDEPENDS:qt6-qtlocation-tests = " \
 qt6-qtdeclarative \
 qt6-qtlocation \
 libgcc \
 qt6-qtbase \
 qt6-qtpositioning \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"
