# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "maven-dependency-analyzer"
PE = "0"
PV = "1.13.2"
PR = "7.el10"
PACKAGES = "maven-dependency-analyzer maven-dependency-analyzer-javadoc"
PROVIDES = "rpm/maven-dependency-analyzer rpm/maven-dependency-analyzer-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/maven-dependency-analyzer-1.13.2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f37960c6a0772b15b3b8e59c7a544f51c845798926aef4724ddd10b68ee48551"

URI_maven-dependency-analyzer = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-dependency-analyzer-1.13.2-7.el10.noarch.rpm;name=maven-dependency-analyzer;unpack=0"
SRC_URI += "${URI_maven-dependency-analyzer}"
SRC_URI[maven-dependency-analyzer.sha256sum] = "0c0b7f751aba060a74e32a852df0a66788d5298ff4411984ed2b5736ff5a0dc8"
RDEPENDS:maven-dependency-analyzer = " \
 objectweb-asm \
 atinject \
 apache-commons-io \
 javapackages-filesystem \
 slf4j \
 maven-lib \
"

URI_maven-dependency-analyzer-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-dependency-analyzer-javadoc-1.13.2-7.el10.noarch.rpm;name=maven-dependency-analyzer-javadoc;unpack=0"
SRC_URI += "${URI_maven-dependency-analyzer-javadoc}"
SRC_URI[maven-dependency-analyzer-javadoc.sha256sum] = "d91d776c6146cccb6bd622bf02c9ff74c23c47785b5d8250e6a138f3a3e0f4e8"
RDEPENDS:maven-dependency-analyzer-javadoc = " \
 javapackages-filesystem \
"
