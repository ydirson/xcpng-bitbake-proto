# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-autodie"
PE = "0"
PV = "2.37"
PR = "512.el10"
PACKAGES = "perl-autodie perl-autodie-tests"
PROVIDES = "rpm/perl-autodie rpm/perl-autodie-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-autodie-2.37-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec3cbb5b9bce8b1392e1c0240134da2a36cafd0fe5c6d60cf7ef16ef651e899f"

URI_perl-autodie = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-autodie-2.37-512.el10.noarch.rpm;name=perl-autodie;unpack=0"
SRC_URI += "${URI_perl-autodie}"
SRC_URI[perl-autodie.sha256sum] = "eaef9a8864dab0bb3e507f4dad0bc90c3bd75037ce8262fd32a8642b578210e1"
RDEPENDS:perl-autodie = " \
 perl-constant \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-Fcntl \
 perl-POSIX \
 perl-overload \
 perl-IPC-System-Simple \
 perl-parent \
 perl-B \
 perl-autodie \
 perl-Exporter \
 perl-Tie-RefHash \
"

URI_perl-autodie-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-autodie-tests-2.37-512.el10.noarch.rpm;name=perl-autodie-tests;unpack=0"
SRC_URI += "${URI_perl-autodie-tests}"
SRC_URI[perl-autodie-tests.sha256sum] = "cd167466d4771c72c0d3b006dbc18fee73d4e7e607489aaae2bc17d934308bea"
RDEPENDS:perl-autodie-tests = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Import-Into \
 perl-FindBin \
 perl-Socket \
 perl-open \
 perl-parent \
 perl-BSD-Resource \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-IO \
 perl-lib \
 bash \
 perl-autodie \
 perl-Exporter \
 perl-constant \
 perl-Fcntl \
 perl-POSIX \
 perl-File-Copy \
 perl-PathTools \
 perl-interpreter \
 perl-File-Temp \
"
