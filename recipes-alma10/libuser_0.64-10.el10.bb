# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libuser"
PE = "0"
PV = "0.64"
PR = "10.el10"
PACKAGES = "libuser libuser-devel python3-libuser"
PROVIDES = "rpm/libuser rpm/libuser-devel rpm/python3-libuser"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libuser-0.64-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf58b6097de99e1fc4028efb03e5f27f69ba022106d95910871815e7df0c7609"

URI_libuser = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libuser-0.64-10.el10.x86_64_v2.rpm;name=libuser;unpack=0"
SRC_URI += "${URI_libuser}"
SRC_URI[libuser.sha256sum] = "309b57492cd95ff96635fbffa7d29be3a86597de8ccdabef46a1240b4f0b5257"
RDEPENDS:libuser = " \
 libxcrypt \
 audit-libs \
 pam-libs \
 popt \
 glib2 \
 glibc \
 libselinux \
 openldap \
"

URI_libuser-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libuser-devel-0.64-10.el10.x86_64_v2.rpm;name=libuser-devel;unpack=0"
SRC_URI += "${URI_libuser-devel}"
SRC_URI[libuser-devel.sha256sum] = "ebf35b59fec26fd303a7fc0fba811d558f009cf19f1bcef70ea7e013aa67f53f"
RDEPENDS:libuser-devel = " \
 libuser \
 glib2-devel \
 pkgconf-pkg-config \
"

URI_python3-libuser = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-libuser-0.64-10.el10.x86_64_v2.rpm;name=python3-libuser;unpack=0"
SRC_URI += "${URI_python3-libuser}"
SRC_URI[python3-libuser.sha256sum] = "8c1a8c116c3f2adb6d7ed37fe14ddb24c75ac19dbebfe43cf3aec67f3c4535f6"
RDEPENDS:python3-libuser = " \
 libuser \
 python3 \
 libxcrypt \
 audit-libs \
 glib2 \
 glibc \
 libselinux \
"
