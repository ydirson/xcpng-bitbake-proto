# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Software-License"
PE = "0"
PV = "0.104006"
PR = "4.el10"
PACKAGES = "perl-Software-License perl-Software-License-tests"
PROVIDES = "rpm/perl-Software-License rpm/perl-Software-License-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Software-License-0.104006-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1abf56c5769933567907664a7ae9ffcaf3c232c976a9442f0a84c0fb5d9656ef"

URI_perl-Software-License = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Software-License-0.104006-4.el10.noarch.rpm;name=perl-Software-License;unpack=0"
SRC_URI += "${URI_perl-Software-License}"
SRC_URI[perl-Software-License.sha256sum] = "49ecab75d298e1915645c6424db88bef49de93edb84f530ffd8b1f00988fc171"
RDEPENDS:perl-Software-License = " \
 perl-libs \
 perl-Carp \
 perl-IO \
 perl-Software-License \
 perl-Module-Load \
 perl-Text-Template \
 perl-PathTools \
 perl-parent \
 perl-Data-Section \
"

URI_perl-Software-License-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Software-License-tests-0.104006-4.el10.noarch.rpm;name=perl-Software-License-tests;unpack=0"
SRC_URI += "${URI_perl-Software-License-tests}"
SRC_URI[perl-Software-License-tests.sha256sum] = "dc6d39e8bf4462e5a0af7ef43e19a8ff5e0b13e4cd3efbe00c29ff6931bf170d"
RDEPENDS:perl-Software-License-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-ExtUtils-MakeMaker \
 perl-Try-Tiny \
 perl-Software-License \
 bash \
 perl-PathTools \
 perl-interpreter \
"
