# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sg3_utils"
PE = "0"
PV = "1.48"
PR = "7.el10"
PACKAGES = "sg3_utils sg3_utils-libs sg3_utils-devel"
PROVIDES = "rpm/sg3_utils rpm/sg3_utils-libs rpm/sg3_utils-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/sg3_utils-1.48-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d45c24a2839caa6c2733aaada6ab289159fadbaea050ef587922b52da445abc7"

URI_sg3_utils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/sg3_utils-1.48-7.el10.x86_64_v2.rpm;name=sg3_utils;unpack=0"
SRC_URI += "${URI_sg3_utils}"
SRC_URI[sg3_utils.sha256sum] = "dd832e29f219c6660c1601c8a37b4f7a7b019f7964363e6d89e262b8f8b713ea"
RDEPENDS:sg3_utils = " \
 glibc \
 sg3_utils-libs \
 libgcc \
 bash \
"

URI_sg3_utils-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/sg3_utils-libs-1.48-7.el10.x86_64_v2.rpm;name=sg3_utils-libs;unpack=0"
SRC_URI += "${URI_sg3_utils-libs}"
SRC_URI[sg3_utils-libs.sha256sum] = "b41e46cf438fb11fbe155a634a80b66d7b9582f93682d2bc4b2cd5c420c98fad"
RDEPENDS:sg3_utils-libs = " \
 glibc \
"

URI_sg3_utils-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/sg3_utils-devel-1.48-7.el10.x86_64_v2.rpm;name=sg3_utils-devel;unpack=0"
SRC_URI += "${URI_sg3_utils-devel}"
SRC_URI[sg3_utils-devel.sha256sum] = "9a861934a0e68824515756cd846252277f5db7ba04ca2ddeb266351c39987e4e"
RDEPENDS:sg3_utils-devel = " \
 sg3_utils-libs \
"
