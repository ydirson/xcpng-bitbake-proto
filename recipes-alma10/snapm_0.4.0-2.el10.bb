# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "snapm"
PE = "0"
PV = "0.4.0"
PR = "2.el10"
PACKAGES = "python3-snapm python3-snapm-doc snapm"
PROVIDES = "rpm/python3-snapm rpm/python3-snapm-doc rpm/snapm"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/snapm-0.4.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "717d8e478e18c90b0e60230b59848da60af863f2b6ce380eb3fbe8de0fe45095"

URI_python3-snapm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-snapm-0.4.0-2.el10.noarch.rpm;name=python3-snapm;unpack=0"
SRC_URI += "${URI_python3-snapm}"
SRC_URI[python3-snapm.sha256sum] = "bd519e265969026b4011d14a8eba7af33e2d04305289c18a5e434ad59ad5319f"
RDEPENDS:python3-snapm = " \
 python3 \
 python3-wcwidth \
 python3-boom \
 python3-dateutil \
 python3-dbus-client-gen \
 python3-dbus-python-client-gen \
 python3-justbytes \
 python3-packaging \
"

URI_python3-snapm-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-snapm-doc-0.4.0-2.el10.noarch.rpm;name=python3-snapm-doc;unpack=0"
SRC_URI += "${URI_python3-snapm-doc}"
SRC_URI[python3-snapm-doc.sha256sum] = "06fe54b1d7106c23ac8b78ba2972f8086410b4b726556bd47fd267d699229072"
RDEPENDS:python3-snapm-doc = ""

URI_snapm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/snapm-0.4.0-2.el10.noarch.rpm;name=snapm;unpack=0"
SRC_URI += "${URI_snapm}"
SRC_URI[snapm.sha256sum] = "1c4f43ef4e69ca13fdc6389e4a3f819c9b059eca1eccdad6d375a344d3b4d592"
RDEPENDS:snapm = " \
 python3 \
 python3-snapm \
"
