# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Sub-Uplevel"
PE = "1"
PV = "0.2800"
PR = "25.el10"
PACKAGES = "perl-Sub-Uplevel perl-Sub-Uplevel-tests"
PROVIDES = "rpm/perl-Sub-Uplevel rpm/perl-Sub-Uplevel-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Sub-Uplevel-0.2800-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63fe2dcc0e60544ea097865dd4ce8b44fcd1cc65d27d09722e17fecf68209b0b"

URI_perl-Sub-Uplevel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Sub-Uplevel-0.2800-25.el10.noarch.rpm;name=perl-Sub-Uplevel;unpack=0"
SRC_URI += "${URI_perl-Sub-Uplevel}"
SRC_URI[perl-Sub-Uplevel.sha256sum] = "f878331c26499cb509607e92d293e47c522f5d884771145de433f38e950aae7e"
RDEPENDS:perl-Sub-Uplevel = " \
 perl-constant \
 perl-libs \
 perl-Carp \
"

URI_perl-Sub-Uplevel-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Sub-Uplevel-tests-0.2800-25.el10.noarch.rpm;name=perl-Sub-Uplevel-tests;unpack=0"
SRC_URI += "${URI_perl-Sub-Uplevel-tests}"
SRC_URI[perl-Sub-Uplevel-tests.sha256sum] = "283c330c8bac9b43049f04cf40518bff587681d72e9cfbd00ee21cd98d9d68ab"
RDEPENDS:perl-Sub-Uplevel-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-ExtUtils-MakeMaker \
 bash \
 perl-PathTools \
 perl-Sub-Uplevel \
 perl-interpreter \
 perl-Exporter \
 perl-lib \
"
