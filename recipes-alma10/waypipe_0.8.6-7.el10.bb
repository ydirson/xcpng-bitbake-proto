# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "waypipe"
PE = "0"
PV = "0.8.6"
PR = "7.el10"
PACKAGES = "waypipe"
PROVIDES = "rpm/waypipe"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/waypipe-0.8.6-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c38d6cee34be501c7cbaaaf2da041c78fd412950715411d46d942d67fd06afaf"

URI_waypipe = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/waypipe-0.8.6-7.el10.x86_64_v2.rpm;name=waypipe;unpack=0"
SRC_URI += "${URI_waypipe}"
SRC_URI[waypipe.sha256sum] = "4334d15eabc6001723c0d2f3f0c96e1ab4dd92582d0fb36055ca4b2755c6bc94"
RDEPENDS:waypipe = " \
 glibc \
 lz4-libs \
 mesa-libgbm \
 libzstd \
"
