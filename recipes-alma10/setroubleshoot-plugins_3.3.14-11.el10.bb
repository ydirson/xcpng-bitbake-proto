# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "setroubleshoot-plugins"
PE = "0"
PV = "3.3.14"
PR = "11.el10"
PACKAGES = "setroubleshoot-plugins"
PROVIDES = "rpm/setroubleshoot-plugins"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/setroubleshoot-plugins-3.3.14-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "463c67006b3fb0c556b25a4e48967712e980b77c2198212dfea3e967e5ce3731"

URI_setroubleshoot-plugins = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/setroubleshoot-plugins-3.3.14-11.el10.noarch.rpm;name=setroubleshoot-plugins;unpack=0"
SRC_URI += "${URI_setroubleshoot-plugins}"
SRC_URI[setroubleshoot-plugins.sha256sum] = "d9b25a073ce7ccb033370de1798fcb20bf013dc7710dbd6c198aa69f92734e07"
RDEPENDS:setroubleshoot-plugins = " \
 setroubleshoot-server \
"
