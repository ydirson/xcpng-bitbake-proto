# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyperv-daemons"
PE = "0"
PV = "0"
PR = "0.49.20220731git.el10"
PACKAGES = "hyperv-daemons hyperv-daemons-license hyperv-tools hypervfcopyd hypervkvpd hypervvssd"
PROVIDES = "rpm/hyperv-daemons rpm/hyperv-daemons-license rpm/hyperv-tools rpm/hypervfcopyd rpm/hypervkvpd rpm/hypervvssd"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyperv-daemons-0-0.49.20220731git.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54ac1bde3948216099feca1fee424fa6bcd02cfeac6500aa2a07212bd707fa1a"

URI_hyperv-daemons = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyperv-daemons-0-0.49.20220731git.el10.x86_64_v2.rpm;name=hyperv-daemons;unpack=0"
SRC_URI += "${URI_hyperv-daemons}"
SRC_URI[hyperv-daemons.sha256sum] = "af8cab3fce5bc39273bfb0eee1ecc101f53b850a713b529b2482f0d2fa23b418"
RDEPENDS:hyperv-daemons = " \
 hypervvssd \
 hypervfcopyd \
 hypervkvpd \
"

URI_hyperv-daemons-license = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyperv-daemons-license-0-0.49.20220731git.el10.noarch.rpm;name=hyperv-daemons-license;unpack=0"
SRC_URI += "${URI_hyperv-daemons-license}"
SRC_URI[hyperv-daemons-license.sha256sum] = "7aa89a5ab1182d60ab29ae3b746b399aa72a2920f8e838375ff4d941c548dbc3"
RDEPENDS:hyperv-daemons-license = ""

URI_hyperv-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyperv-tools-0-0.49.20220731git.el10.noarch.rpm;name=hyperv-tools;unpack=0"
SRC_URI += "${URI_hyperv-tools}"
SRC_URI[hyperv-tools.sha256sum] = "91dbfe854f43677348e3427d4db6ce373832c3e8fdee9d7913ae8a9de5b522e1"
RDEPENDS:hyperv-tools = " \
 python3 \
"

URI_hypervfcopyd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hypervfcopyd-0-0.49.20220731git.el10.x86_64_v2.rpm;name=hypervfcopyd;unpack=0"
SRC_URI += "${URI_hypervfcopyd}"
SRC_URI[hypervfcopyd.sha256sum] = "3e53d0c12710168c1063003bcc0ff0e32d51f1584d7604232d06eedeb76c61ef"
RDEPENDS:hypervfcopyd = " \
 glibc \
 hyperv-daemons-license \
 systemd \
 bash \
"

URI_hypervkvpd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hypervkvpd-0-0.49.20220731git.el10.x86_64_v2.rpm;name=hypervkvpd;unpack=0"
SRC_URI += "${URI_hypervkvpd}"
SRC_URI[hypervkvpd.sha256sum] = "e7ecf42d008d8d2d460fcb868fe2f7e17e6eb9793f35c9ea9599278d6e2a1e79"
RDEPENDS:hypervkvpd = " \
 glibc \
 hyperv-daemons-license \
 systemd \
 bash \
"

URI_hypervvssd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hypervvssd-0-0.49.20220731git.el10.x86_64_v2.rpm;name=hypervvssd;unpack=0"
SRC_URI += "${URI_hypervvssd}"
SRC_URI[hypervvssd.sha256sum] = "25da15a2d9a181a8b0597539045ab3402a257b6f9e5ebd0123802937abfe9546"
RDEPENDS:hypervvssd = " \
 glibc \
 hyperv-daemons-license \
 systemd \
 bash \
"
