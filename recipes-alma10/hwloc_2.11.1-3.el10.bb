# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hwloc"
PE = "0"
PV = "2.11.1"
PR = "3.el10"
PACKAGES = "hwloc hwloc-libs hwloc-devel hwloc-gui"
PROVIDES = "rpm/hwloc rpm/hwloc-libs rpm/hwloc-devel rpm/hwloc-gui"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/hwloc-2.11.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6544f0810cbfbd42284a4801e0e7e2afa2e62fb510a872d58c2f41fd2ec6417f"

URI_hwloc = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/hwloc-2.11.1-3.el10.x86_64_v2.rpm;name=hwloc;unpack=0"
SRC_URI += "${URI_hwloc}"
SRC_URI[hwloc.sha256sum] = "bf90da8c0e2633e2c8af20f62d7ceb2cad9cad388892103fc9bf75a68210e8bd"
RDEPENDS:hwloc = " \
 systemd \
 hwloc-libs \
 bash \
 ncurses-libs \
 glibc \
"

URI_hwloc-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/hwloc-libs-2.11.1-3.el10.x86_64_v2.rpm;name=hwloc-libs;unpack=0"
SRC_URI += "${URI_hwloc-libs}"
SRC_URI[hwloc-libs.sha256sum] = "21157180a1c51411985359722f47a5dd7b6533a21d6a862edab6312c7323b4ff"
RDEPENDS:hwloc-libs = " \
 libpciaccess \
 systemd-libs \
 libxml2 \
 ocl-icd \
 glibc \
"

URI_hwloc-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hwloc-devel-2.11.1-3.el10.x86_64_v2.rpm;name=hwloc-devel;unpack=0"
SRC_URI += "${URI_hwloc-devel}"
SRC_URI[hwloc-devel.sha256sum] = "235dafde5e32216bc13617f6680be363b0037d138e643652fe2458ef38494b13"
RDEPENDS:hwloc-devel = " \
 libxml2-devel \
 pkgconf-pkg-config \
 libpciaccess-devel \
 hwloc-libs \
 rdma-core-devel \
"

URI_hwloc-gui = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hwloc-gui-2.11.1-3.el10.x86_64_v2.rpm;name=hwloc-gui;unpack=0"
SRC_URI += "${URI_hwloc-gui}"
SRC_URI[hwloc-gui.sha256sum] = "3265c45d840fec984730f43f29adcd5452fc1ca7ea26dc16a9842dbc6582a83b"
RDEPENDS:hwloc-gui = " \
 libX11 \
 hwloc-libs \
 ncurses-libs \
 cairo \
 glibc \
"
