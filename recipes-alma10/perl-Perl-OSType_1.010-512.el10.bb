# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Perl-OSType"
PE = "0"
PV = "1.010"
PR = "512.el10"
PACKAGES = "perl-Perl-OSType perl-Perl-OSType-tests"
PROVIDES = "rpm/perl-Perl-OSType rpm/perl-Perl-OSType-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Perl-OSType-1.010-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "683725397bbc65ad1587d1db30b489274153cbe2dad7c5791014d6aeda6967c0"

URI_perl-Perl-OSType = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Perl-OSType-1.010-512.el10.noarch.rpm;name=perl-Perl-OSType;unpack=0"
SRC_URI += "${URI_perl-Perl-OSType}"
SRC_URI[perl-Perl-OSType.sha256sum] = "046d05fcff956d8c1a27e330da854acc6f53c3813ae884b4213140f8d0e9d610"
RDEPENDS:perl-Perl-OSType = " \
 perl-Exporter \
 perl-libs \
"

URI_perl-Perl-OSType-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Perl-OSType-tests-1.010-512.el10.noarch.rpm;name=perl-Perl-OSType-tests;unpack=0"
SRC_URI += "${URI_perl-Perl-OSType-tests}"
SRC_URI[perl-Perl-OSType-tests.sha256sum] = "5b8b0923db732befe96efe8224ef1b2c7c2dcd7439a91ad44bdbe2211a53dcdf"
RDEPENDS:perl-Perl-OSType-tests = " \
 perl-constant \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 bash \
 perl-Perl-OSType \
 perl-interpreter \
"
