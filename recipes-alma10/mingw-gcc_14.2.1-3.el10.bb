# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mingw-gcc"
PE = "0"
PV = "14.2.1"
PR = "3.el10"
PACKAGES = "mingw32-cpp mingw32-gcc mingw32-gcc-c++ mingw32-libgcc mingw32-libstdc++ mingw64-cpp mingw64-gcc mingw64-gcc-c++ mingw64-libgcc mingw64-libstdc++ mingw32-gcc-gfortran mingw32-gcc-objc++ mingw32-gcc-objc mingw32-gcc-plugin-devel mingw32-libgomp mingw64-gcc-gfortran mingw64-gcc-objc++ mingw64-gcc-objc mingw64-gcc-plugin-devel mingw64-libgomp ucrt64-cpp ucrt64-gcc ucrt64-gcc-c++ ucrt64-gcc-gfortran ucrt64-gcc-objc++ ucrt64-gcc-objc ucrt64-gcc-plugin-devel ucrt64-libgcc ucrt64-libgomp ucrt64-libstdc++"
PROVIDES = "rpm/mingw32-cpp rpm/mingw32-gcc rpm/mingw32-gcc-c++ rpm/mingw32-libgcc rpm/mingw32-libstdc++ rpm/mingw64-cpp rpm/mingw64-gcc rpm/mingw64-gcc-c++ rpm/mingw64-libgcc rpm/mingw64-libstdc++ rpm/mingw32-gcc-gfortran rpm/mingw32-gcc-objc++ rpm/mingw32-gcc-objc rpm/mingw32-gcc-plugin-devel rpm/mingw32-libgomp rpm/mingw64-gcc-gfortran rpm/mingw64-gcc-objc++ rpm/mingw64-gcc-objc rpm/mingw64-gcc-plugin-devel rpm/mingw64-libgomp rpm/ucrt64-cpp rpm/ucrt64-gcc rpm/ucrt64-gcc-c++ rpm/ucrt64-gcc-gfortran rpm/ucrt64-gcc-objc++ rpm/ucrt64-gcc-objc rpm/ucrt64-gcc-plugin-devel rpm/ucrt64-libgcc rpm/ucrt64-libgomp rpm/ucrt64-libstdc++"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/mingw-gcc-14.2.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0bb5854b15b530159c9bd47b017b23d19edf98e6f10537274cade44acd4cc03c"

URI_mingw32-cpp = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw32-cpp-14.2.1-3.el10.x86_64_v2.rpm;name=mingw32-cpp;unpack=0"
SRC_URI += "${URI_mingw32-cpp}"
SRC_URI[mingw32-cpp.sha256sum] = "4dad7916d626ace9d22d8f98454d73fa52c462d0fa3b26c80e5e0eb804e0d240"
RDEPENDS:mingw32-cpp = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 libgcc \
 libmpc \
 libstdc++ \
 mingw32-filesystem \
 glibc \
"

URI_mingw32-gcc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw32-gcc-14.2.1-3.el10.x86_64_v2.rpm;name=mingw32-gcc;unpack=0"
SRC_URI += "${URI_mingw32-gcc}"
SRC_URI[mingw32-gcc.sha256sum] = "53e5cf7a735564e1daff57e55e141ff3aa74ff11ab5bcc95230eaa86832b352b"
RDEPENDS:mingw32-gcc = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 mingw32-winpthreads-static \
 libgcc \
 libmpc \
 libstdc++ \
 bash \
 mingw32-crt \
 mingw32-binutils \
 mingw32-cpp \
 glibc \
 mingw32-headers \
 mingw32-libgcc \
"

URI_mingw32-gcc-c++ = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw32-gcc-c++-14.2.1-3.el10.x86_64_v2.rpm;name=mingw32-gcc-c++;unpack=0"
SRC_URI += "${URI_mingw32-gcc-c++}"
SRC_URI[mingw32-gcc-c++.sha256sum] = "9d89df86f38a839f36888c47a1204ab5c99c4faaeaf96886f196d45daab40cda"
RDEPENDS:mingw32-gcc-c++ = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 libgcc \
 libmpc \
 libstdc++ \
 mingw32-gcc \
 glibc \
"

URI_mingw32-libgcc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw32-libgcc-14.2.1-3.el10.x86_64_v2.rpm;name=mingw32-libgcc;unpack=0"
SRC_URI += "${URI_mingw32-libgcc}"
SRC_URI[mingw32-libgcc.sha256sum] = "74c5cf57baa0669bad46e00afce04480e62106f55176cbd70513fcd27443dc30"
RDEPENDS:mingw32-libgcc = " \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-winpthreads \
"

URI_mingw32-libstdc++ = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw32-libstdc++-14.2.1-3.el10.x86_64_v2.rpm;name=mingw32-libstdc++;unpack=0"
SRC_URI += "${URI_mingw32-libstdc++}"
SRC_URI[mingw32-libstdc++.sha256sum] = "d0419a667faa9eb68d2afbd93ed87cff159ddd7e0ce421535a78f431c44b724a"
RDEPENDS:mingw32-libstdc++ = " \
 mingw32-filesystem \
 mingw32-crt \
 mingw32-winpthreads \
 mingw32-libgcc \
"

URI_mingw64-cpp = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw64-cpp-14.2.1-3.el10.x86_64_v2.rpm;name=mingw64-cpp;unpack=0"
SRC_URI += "${URI_mingw64-cpp}"
SRC_URI[mingw64-cpp.sha256sum] = "8dcee9f90578100a46402cde0b9484573705a1043d9d0c4621ff181ee17dbdcf"
RDEPENDS:mingw64-cpp = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 libgcc \
 mingw64-filesystem \
 libmpc \
 libstdc++ \
 glibc \
"

URI_mingw64-gcc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw64-gcc-14.2.1-3.el10.x86_64_v2.rpm;name=mingw64-gcc;unpack=0"
SRC_URI += "${URI_mingw64-gcc}"
SRC_URI[mingw64-gcc.sha256sum] = "d56ad43be8e5c1342300706df2549309891e5625d64c9293dcae4ffa88d92608"
RDEPENDS:mingw64-gcc = " \
 mingw64-winpthreads-static \
 gmp \
 zlib-ng-compat \
 mpfr \
 libgcc \
 mingw64-binutils \
 mingw64-crt \
 mingw64-cpp \
 libmpc \
 libstdc++ \
 bash \
 mingw64-headers \
 mingw64-libgcc \
 glibc \
"

URI_mingw64-gcc-c++ = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw64-gcc-c++-14.2.1-3.el10.x86_64_v2.rpm;name=mingw64-gcc-c++;unpack=0"
SRC_URI += "${URI_mingw64-gcc-c++}"
SRC_URI[mingw64-gcc-c++.sha256sum] = "515e848ab55292fdd5604e2107fe1d32f2fc84229ef6efbfd6677285f29bdcc2"
RDEPENDS:mingw64-gcc-c++ = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 libgcc \
 mingw64-gcc \
 libmpc \
 libstdc++ \
 glibc \
"

URI_mingw64-libgcc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw64-libgcc-14.2.1-3.el10.x86_64_v2.rpm;name=mingw64-libgcc;unpack=0"
SRC_URI += "${URI_mingw64-libgcc}"
SRC_URI[mingw64-libgcc.sha256sum] = "8f5ca786b60f735ded72dcbedab4b1aa2c147e7ab7c1dbf67d6fabcf3797b7ed"
RDEPENDS:mingw64-libgcc = " \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-winpthreads \
"

URI_mingw64-libstdc++ = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw64-libstdc++-14.2.1-3.el10.x86_64_v2.rpm;name=mingw64-libstdc++;unpack=0"
SRC_URI += "${URI_mingw64-libstdc++}"
SRC_URI[mingw64-libstdc++.sha256sum] = "0030ea85b03f4651989c91882a0c344b40b2dac28cb801ec075befc757076d36"
RDEPENDS:mingw64-libstdc++ = " \
 mingw64-filesystem \
 mingw64-crt \
 mingw64-winpthreads \
 mingw64-libgcc \
"

URI_mingw32-gcc-gfortran = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mingw32-gcc-gfortran-14.2.1-3.el10.x86_64_v2.rpm;name=mingw32-gcc-gfortran;unpack=0"
SRC_URI += "${URI_mingw32-gcc-gfortran}"
SRC_URI[mingw32-gcc-gfortran.sha256sum] = "4aa65f26a9c3d2320b07d43ed6bd1ffe2c420067ea6f6835196c7cd2b00928f7"
RDEPENDS:mingw32-gcc-gfortran = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 mingw32-winpthreads \
 libgcc \
 libmpc \
 libstdc++ \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-gcc \
 glibc \
 mingw32-libgcc \
"

URI_mingw32-gcc-objc++ = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mingw32-gcc-objc++-14.2.1-3.el10.x86_64_v2.rpm;name=mingw32-gcc-objc++;unpack=0"
SRC_URI += "${URI_mingw32-gcc-objc++}"
SRC_URI[mingw32-gcc-objc++.sha256sum] = "909da8cbdfc664efd71c2fdbc9f57a49c8ecc15dfb32415fd6d188d45709f019"
RDEPENDS:mingw32-gcc-objc++ = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 libgcc \
 libmpc \
 mingw32-gcc-c++ \
 libstdc++ \
 mingw32-gcc-objc \
 glibc \
"

URI_mingw32-gcc-objc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mingw32-gcc-objc-14.2.1-3.el10.x86_64_v2.rpm;name=mingw32-gcc-objc;unpack=0"
SRC_URI += "${URI_mingw32-gcc-objc}"
SRC_URI[mingw32-gcc-objc.sha256sum] = "6626f6c44a785cf11bc5fc2031569687e948616bf9eb383f11d43d4d98bebaf1"
RDEPENDS:mingw32-gcc-objc = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 mingw32-winpthreads \
 libgcc \
 libmpc \
 libstdc++ \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-gcc \
 glibc \
 mingw32-libgcc \
"

URI_mingw32-gcc-plugin-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mingw32-gcc-plugin-devel-14.2.1-3.el10.x86_64_v2.rpm;name=mingw32-gcc-plugin-devel;unpack=0"
SRC_URI += "${URI_mingw32-gcc-plugin-devel}"
SRC_URI[mingw32-gcc-plugin-devel.sha256sum] = "912fc00b6d59d675a51293ffd519f3ddff4c87e93daf299d6d3461a9acd8d2ba"
RDEPENDS:mingw32-gcc-plugin-devel = " \
 libgcc \
 libmpc-devel \
 libstdc++ \
 mingw32-gcc \
 glibc \
 mpfr-devel \
 gmp-devel \
"

URI_mingw32-libgomp = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mingw32-libgomp-14.2.1-3.el10.x86_64_v2.rpm;name=mingw32-libgomp;unpack=0"
SRC_URI += "${URI_mingw32-libgomp}"
SRC_URI[mingw32-libgomp.sha256sum] = "bff4c325b15fd2f5ac623c4869a6494db0f9d870efb9ad98fdb19342f08c4db0"
RDEPENDS:mingw32-libgomp = " \
 mingw32-winpthreads \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-gcc \
 mingw32-libgcc \
"

URI_mingw64-gcc-gfortran = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mingw64-gcc-gfortran-14.2.1-3.el10.x86_64_v2.rpm;name=mingw64-gcc-gfortran;unpack=0"
SRC_URI += "${URI_mingw64-gcc-gfortran}"
SRC_URI[mingw64-gcc-gfortran.sha256sum] = "07c995a35875d153455a105b9e97c55395758e6d224f33a10db81b37f02115bf"
RDEPENDS:mingw64-gcc-gfortran = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 libgcc \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-gcc \
 libmpc \
 libstdc++ \
 mingw64-libgcc \
 glibc \
 mingw64-winpthreads \
"

URI_mingw64-gcc-objc++ = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mingw64-gcc-objc++-14.2.1-3.el10.x86_64_v2.rpm;name=mingw64-gcc-objc++;unpack=0"
SRC_URI += "${URI_mingw64-gcc-objc++}"
SRC_URI[mingw64-gcc-objc++.sha256sum] = "c1508c09683b4a380b13c20cb5b7fe58b3e79c44442d5dfe4d1041b08ed34764"
RDEPENDS:mingw64-gcc-objc++ = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 libgcc \
 libmpc \
 mingw64-gcc-c++ \
 libstdc++ \
 glibc \
 mingw64-gcc-objc \
"

URI_mingw64-gcc-objc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mingw64-gcc-objc-14.2.1-3.el10.x86_64_v2.rpm;name=mingw64-gcc-objc;unpack=0"
SRC_URI += "${URI_mingw64-gcc-objc}"
SRC_URI[mingw64-gcc-objc.sha256sum] = "2c898003ee6052d1c0c859832e28fce23894f39a06fa448aaaccc36669f10c3b"
RDEPENDS:mingw64-gcc-objc = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 libgcc \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-gcc \
 libmpc \
 libstdc++ \
 mingw64-libgcc \
 glibc \
 mingw64-winpthreads \
"

URI_mingw64-gcc-plugin-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mingw64-gcc-plugin-devel-14.2.1-3.el10.x86_64_v2.rpm;name=mingw64-gcc-plugin-devel;unpack=0"
SRC_URI += "${URI_mingw64-gcc-plugin-devel}"
SRC_URI[mingw64-gcc-plugin-devel.sha256sum] = "796aab72316b4bf08eb8764ff0af1fcdec9d9adcf44e4f86df7e9bb68680ead2"
RDEPENDS:mingw64-gcc-plugin-devel = " \
 libgcc \
 mingw64-gcc \
 libmpc-devel \
 libstdc++ \
 glibc \
 mpfr-devel \
 gmp-devel \
"

URI_mingw64-libgomp = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mingw64-libgomp-14.2.1-3.el10.x86_64_v2.rpm;name=mingw64-libgomp;unpack=0"
SRC_URI += "${URI_mingw64-libgomp}"
SRC_URI[mingw64-libgomp.sha256sum] = "d1d263322b92f1cfcf94f1438f7f1c525022d7b2f851cf9686470eddc6ca1fec"
RDEPENDS:mingw64-libgomp = " \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-gcc \
 mingw64-libgcc \
 mingw64-winpthreads \
"

URI_ucrt64-cpp = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ucrt64-cpp-14.2.1-3.el10.x86_64_v2.rpm;name=ucrt64-cpp;unpack=0"
SRC_URI += "${URI_ucrt64-cpp}"
SRC_URI[ucrt64-cpp.sha256sum] = "634189206cb13222bc3b68c861252dfdfe36b3e0213b2856da7f57129c12b33c"
RDEPENDS:ucrt64-cpp = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 ucrt64-filesystem \
 libgcc \
 libmpc \
 libstdc++ \
 glibc \
"

URI_ucrt64-gcc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ucrt64-gcc-14.2.1-3.el10.x86_64_v2.rpm;name=ucrt64-gcc;unpack=0"
SRC_URI += "${URI_ucrt64-gcc}"
SRC_URI[ucrt64-gcc.sha256sum] = "bc989030f4379f9bba69e96dca829fa2ef543f5ff2f527b4aa3b12efc65098c4"
RDEPENDS:ucrt64-gcc = " \
 ucrt64-binutils \
 gmp \
 zlib-ng-compat \
 mpfr \
 ucrt64-crt \
 ucrt64-cpp \
 libgcc \
 ucrt64-headers \
 ucrt64-libgcc \
 libmpc \
 ucrt64-winpthreads-static \
 libstdc++ \
 bash \
 glibc \
"

URI_ucrt64-gcc-c++ = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ucrt64-gcc-c++-14.2.1-3.el10.x86_64_v2.rpm;name=ucrt64-gcc-c++;unpack=0"
SRC_URI += "${URI_ucrt64-gcc-c++}"
SRC_URI[ucrt64-gcc-c++.sha256sum] = "11b40423884a1be552f48c4922a394e26ae694d06f5d1d955d4424d9436bfaba"
RDEPENDS:ucrt64-gcc-c++ = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 ucrt64-gcc \
 libgcc \
 libmpc \
 libstdc++ \
 glibc \
"

URI_ucrt64-gcc-gfortran = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ucrt64-gcc-gfortran-14.2.1-3.el10.x86_64_v2.rpm;name=ucrt64-gcc-gfortran;unpack=0"
SRC_URI += "${URI_ucrt64-gcc-gfortran}"
SRC_URI[ucrt64-gcc-gfortran.sha256sum] = "7486ad3f1ed65daaf94f84ce79d69c76392b9257b8ab27b04daef97b3690a8c9"
RDEPENDS:ucrt64-gcc-gfortran = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 ucrt64-crt \
 ucrt64-filesystem \
 ucrt64-gcc \
 libgcc \
 ucrt64-libgcc \
 ucrt64-winpthreads \
 libmpc \
 libstdc++ \
 glibc \
"

URI_ucrt64-gcc-objc++ = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ucrt64-gcc-objc++-14.2.1-3.el10.x86_64_v2.rpm;name=ucrt64-gcc-objc++;unpack=0"
SRC_URI += "${URI_ucrt64-gcc-objc++}"
SRC_URI[ucrt64-gcc-objc++.sha256sum] = "e3f05bb41ae82bf4d797721d0a68525a8128861c95acaf85ef89097ae65ab640"
RDEPENDS:ucrt64-gcc-objc++ = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 ucrt64-gcc-c++ \
 ucrt64-gcc-objc \
 libgcc \
 libmpc \
 libstdc++ \
 glibc \
"

URI_ucrt64-gcc-objc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ucrt64-gcc-objc-14.2.1-3.el10.x86_64_v2.rpm;name=ucrt64-gcc-objc;unpack=0"
SRC_URI += "${URI_ucrt64-gcc-objc}"
SRC_URI[ucrt64-gcc-objc.sha256sum] = "97b0d32df20da7b8a0c1982ca51d46f54b00983d7ac8c2e564ee19742924a0e6"
RDEPENDS:ucrt64-gcc-objc = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 ucrt64-crt \
 ucrt64-filesystem \
 ucrt64-gcc \
 libgcc \
 ucrt64-libgcc \
 ucrt64-winpthreads \
 libmpc \
 libstdc++ \
 glibc \
"

URI_ucrt64-gcc-plugin-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ucrt64-gcc-plugin-devel-14.2.1-3.el10.x86_64_v2.rpm;name=ucrt64-gcc-plugin-devel;unpack=0"
SRC_URI += "${URI_ucrt64-gcc-plugin-devel}"
SRC_URI[ucrt64-gcc-plugin-devel.sha256sum] = "d09e7508e8e3e8ec3bed9ddee6997c51abbb84cc7cf1d40752c61378db74ae3d"
RDEPENDS:ucrt64-gcc-plugin-devel = " \
 ucrt64-gcc \
 libgcc \
 libmpc-devel \
 libstdc++ \
 glibc \
 mpfr-devel \
 gmp-devel \
"

URI_ucrt64-libgcc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ucrt64-libgcc-14.2.1-3.el10.x86_64_v2.rpm;name=ucrt64-libgcc;unpack=0"
SRC_URI += "${URI_ucrt64-libgcc}"
SRC_URI[ucrt64-libgcc.sha256sum] = "9f3c7105fa25d29c14bcaaae7d3c89092c3f1df35d3f01afb9bb89cb98fe0b8c"
RDEPENDS:ucrt64-libgcc = " \
 ucrt64-crt \
 ucrt64-filesystem \
 ucrt64-winpthreads \
"

URI_ucrt64-libgomp = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ucrt64-libgomp-14.2.1-3.el10.x86_64_v2.rpm;name=ucrt64-libgomp;unpack=0"
SRC_URI += "${URI_ucrt64-libgomp}"
SRC_URI[ucrt64-libgomp.sha256sum] = "afcf4c2ea8e9e1ce14a9967cbf5aae7ea1ddcc6446280c1e55967e5a6a747e58"
RDEPENDS:ucrt64-libgomp = " \
 ucrt64-crt \
 ucrt64-filesystem \
 ucrt64-gcc \
 ucrt64-libgcc \
 ucrt64-winpthreads \
"

URI_ucrt64-libstdc++ = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ucrt64-libstdc++-14.2.1-3.el10.x86_64_v2.rpm;name=ucrt64-libstdc++;unpack=0"
SRC_URI += "${URI_ucrt64-libstdc++}"
SRC_URI[ucrt64-libstdc++.sha256sum] = "f9bebea963ddde9723e4ae6ee499edce176e347c4014735b7ffeb86476c10a31"
RDEPENDS:ucrt64-libstdc++ = " \
 ucrt64-filesystem \
 ucrt64-crt \
 ucrt64-libgcc \
 ucrt64-winpthreads \
"
