# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libgweather"
PE = "1"
PV = "4.4.4"
PR = "3.el10"
PACKAGES = "libgweather libgweather-devel libgweather-doc"
PROVIDES = "rpm/libgweather rpm/libgweather-devel rpm/libgweather-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libgweather-4.4.4-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9c4470fc2d9cb7747456ba62b68bf73d868e9fdbc700b28d0d9c08cbf1be3d3"

URI_libgweather = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libgweather-4.4.4-3.el10.x86_64_v2.rpm;name=libgweather;unpack=0"
SRC_URI += "${URI_libgweather}"
SRC_URI[libgweather.sha256sum] = "12865defc2c10055edae7fed6978e5ab8e915fd4a797b122c1f793e45144ef58"
RDEPENDS:libgweather = " \
 libsoup3 \
 libgcc \
 libxml2 \
 json-glib \
 glib2 \
 glibc \
 geocode-glib \
"

URI_libgweather-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libgweather-devel-4.4.4-3.el10.x86_64_v2.rpm;name=libgweather-devel;unpack=0"
SRC_URI += "${URI_libgweather-devel}"
SRC_URI[libgweather-devel.sha256sum] = "a714a0bcebf74b0cd5bcfe7cc4f1b8346fea7cd105d2c6148fc894fbe56af9d4"
RDEPENDS:libgweather-devel = " \
 json-glib-devel \
 libxml2-devel \
 glib2-devel \
 libsoup3-devel \
 pkgconf-pkg-config \
 geocode-glib-devel \
 libgweather \
"

URI_libgweather-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libgweather-doc-4.4.4-3.el10.x86_64_v2.rpm;name=libgweather-doc;unpack=0"
SRC_URI += "${URI_libgweather-doc}"
SRC_URI[libgweather-doc.sha256sum] = "5e6edace54ff6e13cd32b37b421b2d5d75dca3b42a6b1fb75e419ea5c5e4e4fb"
RDEPENDS:libgweather-doc = ""
