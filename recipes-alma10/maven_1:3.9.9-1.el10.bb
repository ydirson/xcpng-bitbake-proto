# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "maven"
PE = "1"
PV = "3.9.9"
PR = "1.el10"
PACKAGES = "maven maven-lib maven-openjdk21 maven-javadoc maven-unbound"
PROVIDES = "rpm/maven rpm/maven-lib rpm/maven-openjdk21 rpm/maven-javadoc rpm/maven-unbound"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/maven-3.9.9-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "820dd9c1f453d11a07ac4a1ded213e24fb115b216c4b7703cd349e84ab4c14d0"

URI_maven = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/maven-3.9.9-1.el10.noarch.rpm;name=maven;unpack=0"
SRC_URI += "${URI_maven}"
SRC_URI[maven.sha256sum] = "529bd2938708ba51136d9a2b39921f8a4242559792792ffe2ddd7e4ff8d04627"
RDEPENDS:maven = " \
 alternatives \
 bash \
 maven-unbound \
 maven-lib \
"

URI_maven-lib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/maven-lib-3.9.9-1.el10.noarch.rpm;name=maven-lib;unpack=0"
SRC_URI += "${URI_maven-lib}"
SRC_URI[maven-lib.sha256sum] = "5b6739e7d3ccff97450ffdb59e61b7cb9886dd52bca59df63476e8bdfd483684"
RDEPENDS:maven-lib = " \
 plexus-cipher \
 atinject \
 apache-commons-cli \
 plexus-classworlds \
 plexus-containers-component-annotations \
 plexus-utils \
 javapackages-filesystem \
 jakarta-annotations \
 plexus-interpolation \
 plexus-sec-dispatcher \
 jansi \
 sisu \
 slf4j \
 google-guice \
 maven-resolver \
 maven-shared-utils \
 maven-wagon \
 guava \
"

URI_maven-openjdk21 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/maven-openjdk21-3.9.9-1.el10.noarch.rpm;name=maven-openjdk21;unpack=0"
SRC_URI += "${URI_maven-openjdk21}"
SRC_URI[maven-openjdk21.sha256sum] = "1e3f95fa23b5d3309b2cab2e2b060c80121ade402f9a826197cdb04dba544c54"
RDEPENDS:maven-openjdk21 = " \
 maven \
 java-21-openjdk-headless \
 javapackages-tools \
"

URI_maven-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-javadoc-3.9.9-1.el10.noarch.rpm;name=maven-javadoc;unpack=0"
SRC_URI += "${URI_maven-javadoc}"
SRC_URI[maven-javadoc.sha256sum] = "c1a602207724399280ef11a3494ae4893264b7c77b60426f2e8e48cc5f1ade6c"
RDEPENDS:maven-javadoc = " \
 javapackages-filesystem \
"

URI_maven-unbound = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-unbound-3.9.9-1.el10.noarch.rpm;name=maven-unbound;unpack=0"
SRC_URI += "${URI_maven-unbound}"
SRC_URI[maven-unbound.sha256sum] = "2a7680e88be645e9727441ead4d44c80e386444cb57fd1bc5ae298a68f61e434"
RDEPENDS:maven-unbound = " \
 maven \
 javapackages-tools \
"
