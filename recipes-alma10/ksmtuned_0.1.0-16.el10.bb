# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ksmtuned"
PE = "0"
PV = "0.1.0"
PR = "16.el10"
PACKAGES = "ksmtuned"
PROVIDES = "rpm/ksmtuned"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ksmtuned-0.1.0-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "759521b49c1cdd6347883df96b9c5a302c8510bcbe2ce29f2be52bb60427664e"

URI_ksmtuned = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ksmtuned-0.1.0-16.el10.x86_64_v2.rpm;name=ksmtuned;unpack=0"
SRC_URI += "${URI_ksmtuned}"
SRC_URI[ksmtuned.sha256sum] = "d2bc51753c1f9f689abaf4516fd2ebd78e8a27069aa2d01bb73332e1900e2868"
RDEPENDS:ksmtuned = " \
 glibc \
 systemd \
 bash \
"
