# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "fprintd"
PE = "0"
PV = "1.94.5"
PR = "1.el10_0"
PACKAGES = "fprintd fprintd-pam fprintd-devel"
PROVIDES = "rpm/fprintd rpm/fprintd-pam rpm/fprintd-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/fprintd-1.94.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "128c159d5693d9a1b0e79fe7bd7960f694a6733a6dfc6ee48c912963882d8832"

URI_fprintd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fprintd-1.94.5-1.el10_0.x86_64_v2.rpm;name=fprintd;unpack=0"
SRC_URI += "${URI_fprintd}"
SRC_URI[fprintd.sha256sum] = "8f3ea4e323c965f90ea50a9130e3baa2ec9224cc2928f7e96c7741fc897b1afc"
RDEPENDS:fprintd = " \
 libgcc \
 polkit-libs \
 glib2 \
 glibc \
 libfprint \
"

URI_fprintd-pam = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fprintd-pam-1.94.5-1.el10_0.x86_64_v2.rpm;name=fprintd-pam;unpack=0"
SRC_URI += "${URI_fprintd-pam}"
SRC_URI[fprintd-pam.sha256sum] = "926d815747e29feaa854ff821d2868359b84f4de8a3bcb5b773982dfea2a396a"
RDEPENDS:fprintd-pam = " \
 systemd-libs \
 libgcc \
 authselect \
 pam-libs \
 bash \
 fprintd \
 glibc \
"

URI_fprintd-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/fprintd-devel-1.94.5-1.el10_0.noarch.rpm;name=fprintd-devel;unpack=0"
SRC_URI += "${URI_fprintd-devel}"
SRC_URI[fprintd-devel.sha256sum] = "7e5a39b70610459125dc131e48e3711b4e61f46ce0cc78f9923fb5330550575f"
RDEPENDS:fprintd-devel = " \
 fprintd \
"
