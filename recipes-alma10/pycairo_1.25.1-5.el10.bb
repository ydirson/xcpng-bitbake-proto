# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pycairo"
PE = "0"
PV = "1.25.1"
PR = "5.el10"
PACKAGES = "python3-cairo python3-cairo-devel"
PROVIDES = "rpm/python3-cairo rpm/python3-cairo-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/pycairo-1.25.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1c4cfd0dc60ebce808578a9a4aafe8040f59570dbcd28be987de903923b2ec4"

URI_python3-cairo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-cairo-1.25.1-5.el10.x86_64_v2.rpm;name=python3-cairo;unpack=0"
SRC_URI += "${URI_python3-cairo}"
SRC_URI[python3-cairo.sha256sum] = "fabdf8178d2d1983af2fc982e8e4099cafce5b035d49e311c9e4031c40317ba7"
RDEPENDS:python3-cairo = " \
 glibc \
 python3 \
 cairo \
"

URI_python3-cairo-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-cairo-devel-1.25.1-5.el10.x86_64_v2.rpm;name=python3-cairo-devel;unpack=0"
SRC_URI += "${URI_python3-cairo-devel}"
SRC_URI[python3-cairo-devel.sha256sum] = "81f143524838addb2845718b7f18bca024d91a63ec22cf94e22bae15f6db7b14"
RDEPENDS:python3-cairo-devel = " \
 python3-cairo \
 pkgconf-pkg-config \
 cairo-devel \
 python3-devel \
"
