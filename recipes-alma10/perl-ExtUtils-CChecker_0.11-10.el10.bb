# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-CChecker"
PE = "0"
PV = "0.11"
PR = "10.el10"
PACKAGES = "perl-ExtUtils-CChecker"
PROVIDES = "rpm/perl-ExtUtils-CChecker"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-ExtUtils-CChecker-0.11-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5845999cb5e74f81c97d7015956469ee8fed86580f03ae70744e9a3d2ba344e"

URI_perl-ExtUtils-CChecker = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-ExtUtils-CChecker-0.11-10.el10.noarch.rpm;name=perl-ExtUtils-CChecker;unpack=0"
SRC_URI += "${URI_perl-ExtUtils-CChecker}"
SRC_URI[perl-ExtUtils-CChecker.sha256sum] = "6991894924ced65b5dca1df5af6dbb07f2d389baeee8bf009559053a6fead3f8"
RDEPENDS:perl-ExtUtils-CChecker = " \
 perl-Module-Build \
 perl-libs \
 perl-Carp \
 perl-ExtUtils-CBuilder \
"
