# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "keepalived"
PE = "0"
PV = "2.2.8"
PR = "9.el10"
PACKAGES = "keepalived"
PROVIDES = "rpm/keepalived"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/keepalived-2.2.8-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8892b6d8d7e85967c16d727a6dda787fd972bddbab7f75927fa39a9dae5e8329"

URI_keepalived = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/keepalived-2.2.8-9.el10.x86_64_v2.rpm;name=keepalived;unpack=0"
SRC_URI += "${URI_keepalived}"
SRC_URI[keepalived.sha256sum] = "67a1557ef88fb05cea9b2a544ec96b86cf4f2c10c7bf02c71e4af4caa335cf2d"
RDEPENDS:keepalived = " \
 systemd \
 net-snmp-agent-libs \
 systemd-libs \
 net-snmp-libs \
 openssl-libs \
 libnl3 \
 libmnl \
 bash \
 libnftnl \
 glibc \
 file-libs \
"
