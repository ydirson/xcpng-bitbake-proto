# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tokyocabinet"
PE = "0"
PV = "1.4.48"
PR = "28.el10_0"
PACKAGES = "tokyocabinet tokyocabinet-devel tokyocabinet-devel-doc"
PROVIDES = "rpm/tokyocabinet rpm/tokyocabinet-devel rpm/tokyocabinet-devel-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tokyocabinet-1.4.48-28.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96bc920d8ff68ed172db18946d89f284a0020cc26f3a3259c19a0d5f9c0dbc9d"

URI_tokyocabinet = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tokyocabinet-1.4.48-28.el10_0.x86_64_v2.rpm;name=tokyocabinet;unpack=0"
SRC_URI += "${URI_tokyocabinet}"
SRC_URI[tokyocabinet.sha256sum] = "c0729ff8f54189aeaea9317a60b1c413e769db266641dc8827efaf60354740c5"
RDEPENDS:tokyocabinet = " \
 glibc \
 zlib-ng-compat \
 bzip2-libs \
"

URI_tokyocabinet-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/tokyocabinet-devel-1.4.48-28.el10_0.x86_64_v2.rpm;name=tokyocabinet-devel;unpack=0"
SRC_URI += "${URI_tokyocabinet-devel}"
SRC_URI[tokyocabinet-devel.sha256sum] = "670117f26528c91e72d55fd95006337851d6869f4211d0af3971d94126c94b03"
RDEPENDS:tokyocabinet-devel = " \
 tokyocabinet \
 pkgconf-pkg-config \
"

URI_tokyocabinet-devel-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/tokyocabinet-devel-doc-1.4.48-28.el10_0.noarch.rpm;name=tokyocabinet-devel-doc;unpack=0"
SRC_URI += "${URI_tokyocabinet-devel-doc}"
SRC_URI[tokyocabinet-devel-doc.sha256sum] = "083baf00462e06124519250e1785521d4db6d0ad2dd953e5cab24d2c7bf19b60"
RDEPENDS:tokyocabinet-devel-doc = " \
 tokyocabinet \
 pkgconf-pkg-config \
"
