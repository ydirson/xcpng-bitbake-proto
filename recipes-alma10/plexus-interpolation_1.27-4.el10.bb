# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "plexus-interpolation"
PE = "0"
PV = "1.27"
PR = "4.el10"
PACKAGES = "plexus-interpolation plexus-interpolation-javadoc"
PROVIDES = "rpm/plexus-interpolation rpm/plexus-interpolation-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/plexus-interpolation-1.27-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c2aa70355140cbdeb47735d841012beaf42f80cbaa90e8ff967a808cf2f377c"

URI_plexus-interpolation = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/plexus-interpolation-1.27-4.el10.noarch.rpm;name=plexus-interpolation;unpack=0"
SRC_URI += "${URI_plexus-interpolation}"
SRC_URI[plexus-interpolation.sha256sum] = "9a5a016771f128ec995723ebb79f555518b2aae0cece859a55e722b217afd3e2"
RDEPENDS:plexus-interpolation = " \
 javapackages-filesystem \
"

URI_plexus-interpolation-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-interpolation-javadoc-1.27-4.el10.noarch.rpm;name=plexus-interpolation-javadoc;unpack=0"
SRC_URI += "${URI_plexus-interpolation-javadoc}"
SRC_URI[plexus-interpolation-javadoc.sha256sum] = "e5bbd9af2ed44626b8fbcbe1a8b67e8a4ec405a4b604d9c18f797d3fd8f23a35"
RDEPENDS:plexus-interpolation-javadoc = " \
 javapackages-filesystem \
"
