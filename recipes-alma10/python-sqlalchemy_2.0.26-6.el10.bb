# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-sqlalchemy"
PE = "0"
PV = "2.0.26"
PR = "6.el10"
PACKAGES = "python3-sqlalchemy python-sqlalchemy-doc"
PROVIDES = "rpm/python3-sqlalchemy rpm/python-sqlalchemy-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-sqlalchemy-2.0.26-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72ee8b8eda521e48bbeebde0a2bca41993e41848fb6203d5be7925632ebe733c"

URI_python3-sqlalchemy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-sqlalchemy-2.0.26-6.el10.x86_64_v2.rpm;name=python3-sqlalchemy;unpack=0"
SRC_URI += "${URI_python3-sqlalchemy}"
SRC_URI[python3-sqlalchemy.sha256sum] = "1cf99c3b84837a3740be6ec7b1992688ddb9a5a9387f1c3d2317954c8f6e53b8"
RDEPENDS:python3-sqlalchemy = " \
 glibc \
 python3-greenlet \
 python3 \
 python3-typing-extensions \
"

URI_python-sqlalchemy-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python-sqlalchemy-doc-2.0.26-6.el10.noarch.rpm;name=python-sqlalchemy-doc;unpack=0"
SRC_URI += "${URI_python-sqlalchemy-doc}"
SRC_URI[python-sqlalchemy-doc.sha256sum] = "454d49752ca20725f4022a6628db9a4523ec4c8b94d1bc5edef0ba2e7bd1f3e2"
RDEPENDS:python-sqlalchemy-doc = ""
