# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-lb"
PE = "0"
PV = "0.20121128"
PR = "26.el10"
PACKAGES = "hunspell-lb mythes-lb"
PROVIDES = "rpm/hunspell-lb rpm/mythes-lb"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-lb-0.20121128-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7556e8e6a79c2f2664e403a4437ac094bd189de78005b84b651c5b324c323790"

URI_hunspell-lb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-lb-0.20121128-26.el10.noarch.rpm;name=hunspell-lb;unpack=0"
SRC_URI += "${URI_hunspell-lb}"
SRC_URI[hunspell-lb.sha256sum] = "28c22107ae6342712d61628a2e95afed5d8dc7930ff80d9a083c80b8c27e77c3"
RDEPENDS:hunspell-lb = " \
 hunspell-filesystem \
"

URI_mythes-lb = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mythes-lb-0.20121128-26.el10.noarch.rpm;name=mythes-lb;unpack=0"
SRC_URI += "${URI_mythes-lb}"
SRC_URI[mythes-lb.sha256sum] = "bc8027d98f1fc40fa610990850fe422e2c68e664f8b4a914439a5d0e9014eeca"
RDEPENDS:mythes-lb = ""
