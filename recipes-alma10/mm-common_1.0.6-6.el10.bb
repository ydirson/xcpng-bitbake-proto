# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mm-common"
PE = "0"
PV = "1.0.6"
PR = "6.el10"
PACKAGES = "mm-common mm-common-docs"
PROVIDES = "rpm/mm-common rpm/mm-common-docs"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/mm-common-1.0.6-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9dc3b21e64dcf0275099f759a895930cd163a686a479677136178d626f2d9e44"

URI_mm-common = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mm-common-1.0.6-6.el10.noarch.rpm;name=mm-common;unpack=0"
SRC_URI += "${URI_mm-common}"
SRC_URI[mm-common.sha256sum] = "18004b1b898ea389a4834c51f51f56f9300cc8d9d6c392ebf9914135ecb699af"
RDEPENDS:mm-common = " \
 python3 \
 libxslt \
 pkgconf-pkg-config \
 doxygen \
 bash \
 graphviz \
"

URI_mm-common-docs = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mm-common-docs-1.0.6-6.el10.noarch.rpm;name=mm-common-docs;unpack=0"
SRC_URI += "${URI_mm-common-docs}"
SRC_URI[mm-common-docs.sha256sum] = "7e1e691d179c7cf7c8666c7b598077e3c87409ac9a276d4e6b91a14e31da52b6"
RDEPENDS:mm-common-docs = " \
 mm-common \
"
