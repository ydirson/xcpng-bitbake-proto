# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-psycopg2"
PE = "0"
PV = "2.9.9"
PR = "6.el10"
PACKAGES = "python3-psycopg2 python-psycopg2-doc python3-psycopg2-debug python3-psycopg2-tests"
PROVIDES = "rpm/python3-psycopg2 rpm/python-psycopg2-doc rpm/python3-psycopg2-debug rpm/python3-psycopg2-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-psycopg2-2.9.9-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50a8ea985eb90a0ee2ac0eb7bd2ce5a12b0200122d78a98e1d384fcc5b22f5af"

URI_python3-psycopg2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-psycopg2-2.9.9-6.el10.x86_64_v2.rpm;name=python3-psycopg2;unpack=0"
SRC_URI += "${URI_python3-psycopg2}"
SRC_URI[python3-psycopg2.sha256sum] = "35c842c88be0be8a4fe9d7aa785838218676331015b8451ab1ca8453b5eca6e5"
RDEPENDS:python3-psycopg2 = " \
 glibc \
 python3 \
 libpq \
"

URI_python-psycopg2-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python-psycopg2-doc-2.9.9-6.el10.x86_64_v2.rpm;name=python-psycopg2-doc;unpack=0"
SRC_URI += "${URI_python-psycopg2-doc}"
SRC_URI[python-psycopg2-doc.sha256sum] = "d516b74a78642cf9ad90df195d51709622f4087c941ac2dea058dd1b82b53d57"
RDEPENDS:python-psycopg2-doc = ""

URI_python3-psycopg2-debug = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-psycopg2-debug-2.9.9-6.el10.x86_64_v2.rpm;name=python3-psycopg2-debug;unpack=0"
SRC_URI += "${URI_python3-psycopg2-debug}"
SRC_URI[python3-psycopg2-debug.sha256sum] = "a4700f818a8b682eebba9d34e6594fe9a903cc4820751801ba0f04e046936953"
RDEPENDS:python3-psycopg2-debug = " \
 glibc \
 python3-psycopg2 \
 python3 \
 libpq \
"

URI_python3-psycopg2-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-psycopg2-tests-2.9.9-6.el10.x86_64_v2.rpm;name=python3-psycopg2-tests;unpack=0"
SRC_URI += "${URI_python3-psycopg2-tests}"
SRC_URI[python3-psycopg2-tests.sha256sum] = "4581eca88d2594ce0e0209192eca379c3d9c56847dd312aaad614cbcc9ba8813"
RDEPENDS:python3-psycopg2-tests = " \
 python3 \
 python3-psycopg2 \
"
