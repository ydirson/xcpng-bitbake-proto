# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cronie"
PE = "0"
PV = "1.7.0"
PR = "9.el10"
PACKAGES = "cronie cronie-anacron cronie-noanacron"
PROVIDES = "rpm/cronie rpm/cronie-anacron rpm/cronie-noanacron"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/cronie-1.7.0-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eab3497f7f78e29a32757ad77c70409cff83ce566447e511898d28bbe279d3e0"

URI_cronie = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cronie-1.7.0-9.el10.x86_64_v2.rpm;name=cronie;unpack=0"
SRC_URI += "${URI_cronie}"
SRC_URI[cronie.sha256sum] = "4d7d6c921bd5d7bc77e5dea89ee2c7c1e7d2c8202b7ab304dd988f2508877353"
RDEPENDS:cronie = " \
 glibc \
 cronie-noanacron \
 audit-libs \
 pam \
 pam-libs \
 libselinux \
 bash \
 sed \
 coreutils \
"

URI_cronie-anacron = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cronie-anacron-1.7.0-9.el10.x86_64_v2.rpm;name=cronie-anacron;unpack=0"
SRC_URI += "${URI_cronie-anacron}"
SRC_URI[cronie-anacron.sha256sum] = "8e75ffcb886df7e1ed033e2def89476428895bd10680af0a898c94b8aa77feb2"
RDEPENDS:cronie-anacron = " \
 crontabs \
 bash \
 glibc \
 coreutils \
 cronie \
"

URI_cronie-noanacron = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cronie-noanacron-1.7.0-9.el10.x86_64_v2.rpm;name=cronie-noanacron;unpack=0"
SRC_URI += "${URI_cronie-noanacron}"
SRC_URI[cronie-noanacron.sha256sum] = "1e85aa9cb993ddc9bc5c5aadeafea6bdb08cefc6108bcc60748ba7745492578f"
RDEPENDS:cronie-noanacron = " \
 crontabs \
 cronie \
"
