# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "PyYAML"
PE = "0"
PV = "6.0.1"
PR = "19.el10"
PACKAGES = "python3-pyyaml"
PROVIDES = "rpm/python3-pyyaml"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/PyYAML-6.0.1-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f73a743e1085d23e5aa2f4fda90e296679b23dd300e7baab29ffca127011fb09"

URI_python3-pyyaml = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-pyyaml-6.0.1-19.el10.x86_64_v2.rpm;name=python3-pyyaml;unpack=0"
SRC_URI += "${URI_python3-pyyaml}"
SRC_URI[python3-pyyaml.sha256sum] = "05df6f2eee449fedc19c42582201b2e7bb918ebefebd727a298c2add000c499d"
RDEPENDS:python3-pyyaml = " \
 glibc \
 python3 \
 libyaml \
"
