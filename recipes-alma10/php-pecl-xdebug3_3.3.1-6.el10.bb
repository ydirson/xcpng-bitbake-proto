# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "php-pecl-xdebug3"
PE = "0"
PV = "3.3.1"
PR = "6.el10"
PACKAGES = "php-pecl-xdebug3"
PROVIDES = "rpm/php-pecl-xdebug3"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/php-pecl-xdebug3-3.3.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "848799b965e362c185151fc246c9c25b7209971a63c7f71ab5e8410626f4e1c4"

URI_php-pecl-xdebug3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-pecl-xdebug3-3.3.1-6.el10.x86_64_v2.rpm;name=php-pecl-xdebug3;unpack=0"
SRC_URI += "${URI_php-pecl-xdebug3}"
SRC_URI[php-pecl-xdebug3.sha256sum] = "b209a54421a00164dcd33865713d259e0c36dcbabed7a887f9388d450a9a3170"
RDEPENDS:php-pecl-xdebug3 = " \
 glibc \
 php-common \
 zlib-ng-compat \
"
