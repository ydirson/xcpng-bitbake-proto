# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "leptonica"
PE = "0"
PV = "1.84.1"
PR = "5.el10"
PACKAGES = "leptonica leptonica-devel leptonica-tools"
PROVIDES = "rpm/leptonica rpm/leptonica-devel rpm/leptonica-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/leptonica-1.84.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f96cd78c9b0200876ec572c2d439a55d1ee240cc34ce1953182e7e8e83b0832"

URI_leptonica = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/leptonica-1.84.1-5.el10.x86_64_v2.rpm;name=leptonica;unpack=0"
SRC_URI += "${URI_leptonica}"
SRC_URI[leptonica.sha256sum] = "f9040bf62517b2ed4a0e634847fc7cfdd20df0dbc89be577a50c8cc799528b4d"
RDEPENDS:leptonica = " \
 giflib \
 zlib-ng-compat \
 libpng \
 libwebp \
 glibc \
 libjpeg-turbo \
 libtiff \
"

URI_leptonica-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/leptonica-devel-1.84.1-5.el10.x86_64_v2.rpm;name=leptonica-devel;unpack=0"
SRC_URI += "${URI_leptonica-devel}"
SRC_URI[leptonica-devel.sha256sum] = "da6ef6bdb9740cb545e11c5fdfc59bf9bf01b315658a86d5c89c96c1ec4b71dc"
RDEPENDS:leptonica-devel = " \
 libtiff-devel \
 cmake-filesystem \
 zlib-ng-compat-devel \
 leptonica \
 libwebp-devel \
 pkgconf-pkg-config \
 libpng-devel \
 libjpeg-turbo-devel \
"

URI_leptonica-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/leptonica-tools-1.84.1-5.el10.x86_64_v2.rpm;name=leptonica-tools;unpack=0"
SRC_URI += "${URI_leptonica-tools}"
SRC_URI[leptonica-tools.sha256sum] = "4499de8684b054c5324ab5c6a468cc3ee06533c34e8ed4d5df90117597e76cc3"
RDEPENDS:leptonica-tools = " \
 glibc \
 leptonica \
"
