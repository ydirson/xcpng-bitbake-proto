# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "orca"
PE = "0"
PV = "46.2"
PR = "2.el10"
PACKAGES = "orca"
PROVIDES = "rpm/orca"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/orca-46.2-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "135fc74cf9bf96a31f06780b1af94401898821c33e601ce4e61707b94652fe0b"

URI_orca = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/orca-46.2-2.el10.noarch.rpm;name=orca;unpack=0"
SRC_URI += "${URI_orca}"
SRC_URI[orca.sha256sum] = "663ea4e3307cb9136baf22781d14447fbee8bb6803e7f181e4f2a30ebb00a793"
RDEPENDS:orca = " \
 python3 \
 speech-dispatcher \
 python3-brlapi \
 python3-speechd \
 python3-pyatspi \
 libwnck3 \
 python3-louis \
"
