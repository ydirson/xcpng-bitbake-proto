# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mod_lookup_identity"
PE = "0"
PV = "1.0.0"
PR = "22.el10"
PACKAGES = "mod_lookup_identity"
PROVIDES = "rpm/mod_lookup_identity"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mod_lookup_identity-1.0.0-22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1109caba95418405655c7e3ce1c784de623326ca532410df25768bb794bad57f"

URI_mod_lookup_identity = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mod_lookup_identity-1.0.0-22.el10.x86_64_v2.rpm;name=mod_lookup_identity;unpack=0"
SRC_URI += "${URI_mod_lookup_identity}"
SRC_URI[mod_lookup_identity.sha256sum] = "b87dfbcd8d049f5a8c1f1eb5d83f3fe335ba1a95d121b2094104f447f9407a44"
RDEPENDS:mod_lookup_identity = " \
 glibc \
 dbus-libs \
 httpd-core \
"
