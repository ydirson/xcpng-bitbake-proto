# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jdom"
PE = "0"
PV = "1.1.3"
PR = "38.el10"
PACKAGES = "jdom jdom-demo jdom-javadoc"
PROVIDES = "rpm/jdom rpm/jdom-demo rpm/jdom-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/jdom-1.1.3-38.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eacd4489ba01f0aaa72221b0b34b227b00bf01fcfad70fd5f6327025d16a9859"

URI_jdom = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jdom-1.1.3-38.el10.noarch.rpm;name=jdom;unpack=0"
SRC_URI += "${URI_jdom}"
SRC_URI[jdom.sha256sum] = "86590ac360ccf1036fe6a1ffcd7903e339a0b56f8814619a1635f1362e7fc343"
RDEPENDS:jdom = " \
 javapackages-filesystem \
"

URI_jdom-demo = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jdom-demo-1.1.3-38.el10.noarch.rpm;name=jdom-demo;unpack=0"
SRC_URI += "${URI_jdom-demo}"
SRC_URI[jdom-demo.sha256sum] = "fc8312d9b04da304001b76a356b09c38a0814eed2f4a471f7c01f90de6600f5c"
RDEPENDS:jdom-demo = " \
 jdom \
"

URI_jdom-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jdom-javadoc-1.1.3-38.el10.noarch.rpm;name=jdom-javadoc;unpack=0"
SRC_URI += "${URI_jdom-javadoc}"
SRC_URI[jdom-javadoc.sha256sum] = "d9eaeba99b86a50ed2c72a35f01f3cc1c819659f428a35a6a55cedb6a8dfe472"
RDEPENDS:jdom-javadoc = " \
 javapackages-filesystem \
"
