# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "plexus-testing"
PE = "0"
PV = "1.3.0"
PR = "4.el10"
PACKAGES = "plexus-testing plexus-testing-javadoc"
PROVIDES = "rpm/plexus-testing rpm/plexus-testing-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/plexus-testing-1.3.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a5c70b812dfe73dc6693897f679599ccc3a350048b66360a0d4701d98f061c6"

URI_plexus-testing = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-testing-1.3.0-4.el10.noarch.rpm;name=plexus-testing;unpack=0"
SRC_URI += "${URI_plexus-testing}"
SRC_URI[plexus-testing.sha256sum] = "d07dd0e545e477412beb0d3cb8e0bb9e6cf4a880544febb87c339b8358771202"
RDEPENDS:plexus-testing = " \
 junit5 \
 google-guice \
 javapackages-filesystem \
 sisu \
"

URI_plexus-testing-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-testing-javadoc-1.3.0-4.el10.noarch.rpm;name=plexus-testing-javadoc;unpack=0"
SRC_URI += "${URI_plexus-testing-javadoc}"
SRC_URI[plexus-testing-javadoc.sha256sum] = "edf2614ba84f8e88269260d944c9312fa6cd95abafb8ed71e4175eca71581e16"
RDEPENDS:plexus-testing-javadoc = " \
 javapackages-filesystem \
"
