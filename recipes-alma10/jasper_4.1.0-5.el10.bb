# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jasper"
PE = "0"
PV = "4.1.0"
PR = "5.el10"
PACKAGES = "jasper jasper-libs jasper-utils jasper-devel"
PROVIDES = "rpm/jasper rpm/jasper-libs rpm/jasper-utils rpm/jasper-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/jasper-4.1.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2f2ddeb0c2a19e18c2894641121ef3b0497bfd5ab8de102e429930300e7c0b9"

URI_jasper = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jasper-4.1.0-5.el10.x86_64_v2.rpm;name=jasper;unpack=0"
SRC_URI += "${URI_jasper}"
SRC_URI[jasper.sha256sum] = "6d6dc7474bc3d727be708e25af23da5fa01c8a42cc87662d028dc5461d392adc"
RDEPENDS:jasper = " \
 glibc \
 jasper-libs \
"

URI_jasper-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jasper-libs-4.1.0-5.el10.x86_64_v2.rpm;name=jasper-libs;unpack=0"
SRC_URI += "${URI_jasper-libs}"
SRC_URI[jasper-libs.sha256sum] = "64ef37c3a665dd79ca6edd729ad991a27e5d820872d4c51067ce0de04ec4e74f"
RDEPENDS:jasper-libs = " \
 glibc \
 libjpeg-turbo \
"

URI_jasper-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jasper-utils-4.1.0-5.el10.x86_64_v2.rpm;name=jasper-utils;unpack=0"
SRC_URI += "${URI_jasper-utils}"
SRC_URI[jasper-utils.sha256sum] = "dde4f1001bd259e5ea546182e8266952e1cf4c7e8313522a7adc8f34f475cc73"
RDEPENDS:jasper-utils = " \
 jasper \
 jasper-libs \
 libglvnd-glx \
 libglvnd-opengl \
 mesa-libGLU \
 glibc \
 freeglut \
"

URI_jasper-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jasper-devel-4.1.0-5.el10.x86_64_v2.rpm;name=jasper-devel;unpack=0"
SRC_URI += "${URI_jasper-devel}"
SRC_URI[jasper-devel.sha256sum] = "5c1ba70c7316c88ea587fd93a45709b7ae9e9b53456f446703314950c626e64b"
RDEPENDS:jasper-devel = " \
 jasper-libs \
 pkgconf-pkg-config \
 libjpeg-turbo-devel \
"
