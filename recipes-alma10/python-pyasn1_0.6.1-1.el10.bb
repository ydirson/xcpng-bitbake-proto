# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-pyasn1"
PE = "0"
PV = "0.6.1"
PR = "1.el10"
PACKAGES = "python3-pyasn1 python3-pyasn1-modules python-pyasn1-doc"
PROVIDES = "rpm/python3-pyasn1 rpm/python3-pyasn1-modules rpm/python-pyasn1-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-pyasn1-0.6.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5adaebf3319ac4a6159f31d4b9c4e176f694a4a4b7fbbca0848a4aed3fe8f079"

URI_python3-pyasn1 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-pyasn1-0.6.1-1.el10.noarch.rpm;name=python3-pyasn1;unpack=0"
SRC_URI += "${URI_python3-pyasn1}"
SRC_URI[python3-pyasn1.sha256sum] = "029b123cc167ed555185dd42ec510938f3e4919ed29a8b3022c4d1b447120d5c"
RDEPENDS:python3-pyasn1 = " \
 python3 \
"

URI_python3-pyasn1-modules = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-pyasn1-modules-0.6.1-1.el10.noarch.rpm;name=python3-pyasn1-modules;unpack=0"
SRC_URI += "${URI_python3-pyasn1-modules}"
SRC_URI[python3-pyasn1-modules.sha256sum] = "d90ae265ba089382244d19ec831c6529d99052844febc618fc2c229efe696369"
RDEPENDS:python3-pyasn1-modules = " \
 python3 \
 python3-pyasn1 \
"

URI_python-pyasn1-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python-pyasn1-doc-0.6.1-1.el10.noarch.rpm;name=python-pyasn1-doc;unpack=0"
SRC_URI += "${URI_python-pyasn1-doc}"
SRC_URI[python-pyasn1-doc.sha256sum] = "14255c2b77a574aa6b8444e1e08b8d305a9e7bb3317d32383b725cfb40ff3bea"
RDEPENDS:python-pyasn1-doc = ""
