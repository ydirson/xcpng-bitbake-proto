# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-sr"
PE = "0"
PV = "0.20130330"
PR = "28.el10"
PACKAGES = "hunspell-sr hyphen-sr"
PROVIDES = "rpm/hunspell-sr rpm/hyphen-sr"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-sr-0.20130330-28.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d015bef264d77be5239eb4836ff24a7c3281d99c106349c18571f8eb737038e"

URI_hunspell-sr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-sr-0.20130330-28.el10.noarch.rpm;name=hunspell-sr;unpack=0"
SRC_URI += "${URI_hunspell-sr}"
SRC_URI[hunspell-sr.sha256sum] = "0148b1d098e823c25fbc5b4fa24951ada430f24349d0f8aa8222043fd49a2405"
RDEPENDS:hunspell-sr = " \
 hunspell \
"

URI_hyphen-sr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-sr-0.20130330-28.el10.noarch.rpm;name=hyphen-sr;unpack=0"
SRC_URI += "${URI_hyphen-sr}"
SRC_URI[hyphen-sr.sha256sum] = "f6af88d50819b92d3836dac9a480d599ff4d82c61a39cc20c259cebf1400942b"
RDEPENDS:hyphen-sr = " \
 hyphen \
"
