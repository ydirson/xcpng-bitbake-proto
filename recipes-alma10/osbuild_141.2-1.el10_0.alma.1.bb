# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "osbuild"
PE = "0"
PV = "141.2"
PR = "1.el10_0.alma.1"
PACKAGES = "osbuild osbuild-depsolve-dnf osbuild-luks2 osbuild-lvm2 osbuild-ostree osbuild-selinux python3-osbuild osbuild-tools"
PROVIDES = "rpm/osbuild rpm/osbuild-depsolve-dnf rpm/osbuild-luks2 rpm/osbuild-lvm2 rpm/osbuild-ostree rpm/osbuild-selinux rpm/python3-osbuild rpm/osbuild-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/osbuild-141.2-1.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "720d71608eb4e88834f2f9ebc5c6ec766cf5aa7d9596b94f5ed1101589a036c9"

URI_osbuild = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/osbuild-141.2-1.el10_0.alma.1.noarch.rpm;name=osbuild;unpack=0"
SRC_URI += "${URI_osbuild}"
SRC_URI[osbuild.sha256sum] = "f5117aa2fdae907b8f0a73e825977b9d1a3320418f9b9bca509c57eb1f676bac"
RDEPENDS:osbuild = " \
 python3 \
 e2fsprogs \
 systemd \
 bubblewrap \
 python3-osbuild \
 util-linux \
 tar \
 qemu-img \
 curl \
 python3-librepo \
 policycoreutils \
 skopeo \
 bash \
 osbuild-selinux \
 glibc \
 coreutils \
"

URI_osbuild-depsolve-dnf = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/osbuild-depsolve-dnf-141.2-1.el10_0.alma.1.noarch.rpm;name=osbuild-depsolve-dnf;unpack=0"
SRC_URI += "${URI_osbuild-depsolve-dnf}"
SRC_URI[osbuild-depsolve-dnf.sha256sum] = "945f2c7a9be322f3a014b9701bf2e479392eefbbe13bc6303414908284018f85"
RDEPENDS:osbuild-depsolve-dnf = " \
 python3 \
 osbuild \
 python3-dnf \
"

URI_osbuild-luks2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/osbuild-luks2-141.2-1.el10_0.alma.1.noarch.rpm;name=osbuild-luks2;unpack=0"
SRC_URI += "${URI_osbuild-luks2}"
SRC_URI[osbuild-luks2.sha256sum] = "11ad1d8b1f6b2077ecbfdd48d39ad64e34c490be0912ab3e7cbbeb4d4b1b5228"
RDEPENDS:osbuild-luks2 = " \
 python3 \
 osbuild \
 cryptsetup \
"

URI_osbuild-lvm2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/osbuild-lvm2-141.2-1.el10_0.alma.1.noarch.rpm;name=osbuild-lvm2;unpack=0"
SRC_URI += "${URI_osbuild-lvm2}"
SRC_URI[osbuild-lvm2.sha256sum] = "f872fb3508589f9c85a31ec447c7eedc43ad1d1c0f7e5e31ba57d99ffba95950"
RDEPENDS:osbuild-lvm2 = " \
 python3 \
 osbuild \
 lvm2 \
"

URI_osbuild-ostree = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/osbuild-ostree-141.2-1.el10_0.alma.1.noarch.rpm;name=osbuild-ostree;unpack=0"
SRC_URI += "${URI_osbuild-ostree}"
SRC_URI[osbuild-ostree.sha256sum] = "879f69d1df4de3949ea8bf55e05f4522806444c86fb6adbddd5da2d7a6c15bd0"
RDEPENDS:osbuild-ostree = " \
 python3 \
 osbuild \
 ostree \
 rpm-ostree \
"

URI_osbuild-selinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/osbuild-selinux-141.2-1.el10_0.alma.1.noarch.rpm;name=osbuild-selinux;unpack=0"
SRC_URI += "${URI_osbuild-selinux}"
SRC_URI[osbuild-selinux.sha256sum] = "ea05fd3cca9590b59fe131bbd833fcd04ff5d585ed3ca73f8fd0108c43d886f0"
RDEPENDS:osbuild-selinux = " \
 osbuild \
 policycoreutils-python-utils \
 policycoreutils \
 bash \
 selinux-policy \
 libselinux-utils \
 selinux-policy-targeted \
"

URI_python3-osbuild = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-osbuild-141.2-1.el10_0.alma.1.noarch.rpm;name=python3-osbuild;unpack=0"
SRC_URI += "${URI_python3-osbuild}"
SRC_URI[python3-osbuild.sha256sum] = "130675e4a6609c66688ed83cf1a4ba869e7ac5396b29f414475e9618f56b64f1"
RDEPENDS:python3-osbuild = " \
 python3 \
 python3-jsonschema \
"

URI_osbuild-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/osbuild-tools-141.2-1.el10_0.alma.1.noarch.rpm;name=osbuild-tools;unpack=0"
SRC_URI += "${URI_osbuild-tools}"
SRC_URI[osbuild-tools.sha256sum] = "71ed42f1b684fa8ca7f3120280e9d2317c5863e79670fa411490efa9c93ae49e"
RDEPENDS:osbuild-tools = " \
 python3 \
 python3-pyyaml \
 osbuild \
 python3-dnf \
"
