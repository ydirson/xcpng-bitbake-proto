# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gsettings-desktop-schemas"
PE = "0"
PV = "47.1"
PR = "3.el10_0"
PACKAGES = "gsettings-desktop-schemas gsettings-desktop-schemas-devel"
PROVIDES = "rpm/gsettings-desktop-schemas rpm/gsettings-desktop-schemas-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/gsettings-desktop-schemas-47.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f2f3d208a1fdcbe76b4ed4469ac19fc2191abc768223d2f4359254354377b21"

URI_gsettings-desktop-schemas = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/gsettings-desktop-schemas-47.1-3.el10_0.x86_64_v2.rpm;name=gsettings-desktop-schemas;unpack=0"
SRC_URI += "${URI_gsettings-desktop-schemas}"
SRC_URI[gsettings-desktop-schemas.sha256sum] = "0dcc64d00ea4f74dff45bb93695b15a17a886dd070ce8f95a4c22b123e0a6c83"
RDEPENDS:gsettings-desktop-schemas = " \
 glib2 \
"

URI_gsettings-desktop-schemas-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gsettings-desktop-schemas-devel-47.1-3.el10_0.x86_64_v2.rpm;name=gsettings-desktop-schemas-devel;unpack=0"
SRC_URI += "${URI_gsettings-desktop-schemas-devel}"
SRC_URI[gsettings-desktop-schemas-devel.sha256sum] = "ae1ee769859f03697d51d7708432ad75f67402d1b9576166022544810c23961d"
RDEPENDS:gsettings-desktop-schemas-devel = " \
 gsettings-desktop-schemas \
 pkgconf-pkg-config \
"
