# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-system-monitor"
PE = "0"
PV = "46.0"
PR = "1.el10"
PACKAGES = "gnome-system-monitor"
PROVIDES = "rpm/gnome-system-monitor"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-system-monitor-46.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e9992c1c2f45930f92ec52c0c8df2eedfc961449150dee3f3e43aa675296d56"

URI_gnome-system-monitor = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-system-monitor-46.0-1.el10.x86_64_v2.rpm;name=gnome-system-monitor;unpack=0"
SRC_URI += "${URI_gnome-system-monitor}"
SRC_URI[gnome-system-monitor.sha256sum] = "9f01ab154728edc819283b90b3f623831367cda3e3fa168185472d1daeb22d2f"
RDEPENDS:gnome-system-monitor = " \
 gtkmm4.0 \
 systemd-libs \
 librsvg2 \
 libgcc \
 libsigc++30 \
 pango \
 gdk-pixbuf2 \
 glibmm2.68 \
 libstdc++ \
 glib2 \
 cairo \
 graphene \
 glibc \
 libgtop2 \
 gtk4 \
 hicolor-icon-theme \
 libadwaita \
"
