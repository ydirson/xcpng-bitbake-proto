# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-XML-SAX"
PE = "0"
PV = "1.02"
PR = "18.el10"
PACKAGES = "perl-XML-SAX perl-XML-SAX-tests"
PROVIDES = "rpm/perl-XML-SAX rpm/perl-XML-SAX-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-XML-SAX-1.02-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec52229548729bc7fc6a4717cdda21989b11ebd3a8c1928f4ae61a5dfd344bcc"

URI_perl-XML-SAX = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-XML-SAX-1.02-18.el10.noarch.rpm;name=perl-XML-SAX;unpack=0"
SRC_URI += "${URI_perl-XML-SAX}"
SRC_URI[perl-XML-SAX.sha256sum] = "5ad1b163ca10ad63128e9de263bd4358d7b9572cd27b8acdc922d373f1542398"
RDEPENDS:perl-XML-SAX = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-IO \
 perl-libwww-perl \
 perl-File-Basename \
 perl-Encode \
 perl-overload \
 perl-Symbol \
 bash \
 perl-PathTools \
 perl-XML-NamespaceSupport \
 perl-XML-SAX-Base \
 perl-XML-SAX \
 perl-Exporter \
 perl-File-Temp \
"

URI_perl-XML-SAX-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-XML-SAX-tests-1.02-18.el10.noarch.rpm;name=perl-XML-SAX-tests;unpack=0"
SRC_URI += "${URI_perl-XML-SAX-tests}"
SRC_URI[perl-XML-SAX-tests.sha256sum] = "a8757f0b524daf62802f6b4e2572c57b2e6028dc6c45b0253fa6399a251e8f9c"
RDEPENDS:perl-XML-SAX-tests = " \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 perl-vars \
 perl-IO \
 perl-XML-SAX \
 bash \
 perl-XML-SAX-Base \
 perl-autodie \
 perl-interpreter \
 perl-File-Path \
 perl-base \
"
