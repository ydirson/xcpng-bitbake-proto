# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtspeech"
PE = "0"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = "qt6-qtspeech qt6-qtspeech-devel qt6-qtspeech-speechd qt6-qtspeech-examples qt6-qtspeech-tests"
PROVIDES = "rpm/qt6-qtspeech rpm/qt6-qtspeech-devel rpm/qt6-qtspeech-speechd rpm/qt6-qtspeech-examples rpm/qt6-qtspeech-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtspeech-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51db67c1162d17a13fe1f876f83d2d066008bd952ab8eba36762b1912da7ac3d"

URI_qt6-qtspeech = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtspeech-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtspeech;unpack=0"
SRC_URI += "${URI_qt6-qtspeech}"
SRC_URI[qt6-qtspeech.sha256sum] = "e2d0cfc929e924b1bfb69ab8c27d4f242896711e9c7a2920126db09c99fb2dc6"
RDEPENDS:qt6-qtspeech = " \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 qt6-qtbase \
 libstdc++ \
 glibc \
"

URI_qt6-qtspeech-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtspeech-devel-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtspeech-devel;unpack=0"
SRC_URI += "${URI_qt6-qtspeech-devel}"
SRC_URI[qt6-qtspeech-devel.sha256sum] = "760b164bbedc0578928c59d5e0926d883a71e7db74c7623297cb3794453037b5"
RDEPENDS:qt6-qtspeech-devel = " \
 qt6-qtspeech \
 cmake-filesystem \
 qt6-qtmultimedia-devel \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
"

URI_qt6-qtspeech-speechd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtspeech-speechd-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtspeech-speechd;unpack=0"
SRC_URI += "${URI_qt6-qtspeech-speechd}"
SRC_URI[qt6-qtspeech-speechd.sha256sum] = "fa823e754c056ed56d688340b39303e413670937fd4dc5b07ed43fa6e0b18ca4"
RDEPENDS:qt6-qtspeech-speechd = " \
 qt6-qtspeech \
 cmake-filesystem \
 speech-dispatcher-libs \
 qt6-qtbase \
 libstdc++ \
 glibc \
"

URI_qt6-qtspeech-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtspeech-examples-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtspeech-examples;unpack=0"
SRC_URI += "${URI_qt6-qtspeech-examples}"
SRC_URI[qt6-qtspeech-examples.sha256sum] = "cdaa313855af4b396affabba205076bad75d82bb4cd93afb3912814787c9ce5a"
RDEPENDS:qt6-qtspeech-examples = " \
 qt6-qtspeech \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qtspeech-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtspeech-tests-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtspeech-tests;unpack=0"
SRC_URI += "${URI_qt6-qtspeech-tests}"
SRC_URI[qt6-qtspeech-tests.sha256sum] = "cad5a549beab28b533310778177007b11b4eb363f2776884a04edc0b557c20b8"
RDEPENDS:qt6-qtspeech-tests = " \
 qt6-qtspeech \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"
