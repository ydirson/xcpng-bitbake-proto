# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xcb-util-image"
PE = "0"
PV = "0.4.1"
PR = "7.el10"
PACKAGES = "xcb-util-image xcb-util-image-devel"
PROVIDES = "rpm/xcb-util-image rpm/xcb-util-image-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xcb-util-image-0.4.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1dde9c72cbfbb93e6bbd7c4edbf0829d59457e0210931153bfb979ffade461e7"

URI_xcb-util-image = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xcb-util-image-0.4.1-7.el10.x86_64_v2.rpm;name=xcb-util-image;unpack=0"
SRC_URI += "${URI_xcb-util-image}"
SRC_URI[xcb-util-image.sha256sum] = "181893ac6ce831141869a79253526881cbba5e02b613079295b0d817cdef5d72"
RDEPENDS:xcb-util-image = " \
 glibc \
 libxcb \
 xcb-util \
"

URI_xcb-util-image-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xcb-util-image-devel-0.4.1-7.el10.x86_64_v2.rpm;name=xcb-util-image-devel;unpack=0"
SRC_URI += "${URI_xcb-util-image-devel}"
SRC_URI[xcb-util-image-devel.sha256sum] = "3cfa8ca61232bd0edd746476de3cde293d26bb35d34fcb910047880b5153d057"
RDEPENDS:xcb-util-image-devel = " \
 libxcb-devel \
 xcb-util-image \
 pkgconf-pkg-config \
"
