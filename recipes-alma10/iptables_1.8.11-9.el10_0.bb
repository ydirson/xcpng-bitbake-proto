# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "iptables"
PE = "0"
PV = "1.8.11"
PR = "9.el10_0"
PACKAGES = "iptables-libs iptables-devel iptables-nft iptables-nft-services iptables-utils"
PROVIDES = "rpm/iptables-libs rpm/iptables-devel rpm/iptables-nft rpm/iptables-nft-services rpm/iptables-utils"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/iptables-1.8.11-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0c26c5182661dc23ae15a8245a470207d38707e7374a729e9c3b7438dac2b54"

URI_iptables-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/iptables-libs-1.8.11-9.el10_0.x86_64_v2.rpm;name=iptables-libs;unpack=0"
SRC_URI += "${URI_iptables-libs}"
SRC_URI[iptables-libs.sha256sum] = "4b9e8ac45495cdb384ef91af039831c0ad9cf697bc0c5f9c54f7b9c7666c5d43"
RDEPENDS:iptables-libs = " \
 glibc \
 libnetfilter_conntrack \
"

URI_iptables-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/iptables-devel-1.8.11-9.el10_0.x86_64_v2.rpm;name=iptables-devel;unpack=0"
SRC_URI += "${URI_iptables-devel}"
SRC_URI[iptables-devel.sha256sum] = "efd3fe827cd22e3ebed19264e883e132fa1c5518aa89c9a4950c71f8fb011477"
RDEPENDS:iptables-devel = " \
 pkgconf-pkg-config \
 iptables-libs \
"

URI_iptables-nft = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/iptables-nft-1.8.11-9.el10_0.x86_64_v2.rpm;name=iptables-nft;unpack=0"
SRC_URI += "${URI_iptables-nft}"
SRC_URI[iptables-nft.sha256sum] = "cf61b58d9834df1eaa747a75ac049a91c209b5fdef71b57710b775a20c8304b9"
RDEPENDS:iptables-nft = " \
 coreutils \
 libmnl \
 iptables-libs \
 kernel-modules-extra \
 bash \
 libnftnl \
 glibc \
 alternatives \
 kernel-debug-modules-extra \
"

URI_iptables-nft-services = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/iptables-nft-services-1.8.11-9.el10_0.noarch.rpm;name=iptables-nft-services;unpack=0"
SRC_URI += "${URI_iptables-nft-services}"
SRC_URI[iptables-nft-services.sha256sum] = "62aeae4ca5c5f61344e36f87c095abf28ca3a08c9d5ab4e4e9ea09c8739b4558"
RDEPENDS:iptables-nft-services = " \
 iptables-nft \
 bash \
"

URI_iptables-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/iptables-utils-1.8.11-9.el10_0.x86_64_v2.rpm;name=iptables-utils;unpack=0"
SRC_URI += "${URI_iptables-utils}"
SRC_URI[iptables-utils.sha256sum] = "283a69a6135a8cc7f7222013d97c8616943bda127767a2d895ba31e95e643c7e"
RDEPENDS:iptables-utils = " \
 libpcap \
 libnfnetlink \
 iptables-nft \
 bash \
 glibc \
"
