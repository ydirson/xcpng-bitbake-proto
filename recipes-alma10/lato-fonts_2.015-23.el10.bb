# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lato-fonts"
PE = "0"
PV = "2.015"
PR = "23.el10"
PACKAGES = "lato-fonts"
PROVIDES = "rpm/lato-fonts"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/lato-fonts-2.015-23.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a038034af5a38d3636756f4813ed172d5119605a991467c3f0d849ce1cf6a535"

URI_lato-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lato-fonts-2.015-23.el10.noarch.rpm;name=lato-fonts;unpack=0"
SRC_URI += "${URI_lato-fonts}"
SRC_URI[lato-fonts.sha256sum] = "72e8638dd02fef6a97de1746729a28cb23c868d4b13d293e318f69e5bc2c63bd"
RDEPENDS:lato-fonts = " \
 fonts-filesystem \
"
