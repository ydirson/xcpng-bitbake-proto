# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "bpftrace"
PE = "0"
PV = "0.22.1"
PR = "1.el10"
PACKAGES = "bpftrace"
PROVIDES = "rpm/bpftrace"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/bpftrace-0.22.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a36eff99718979bf1c24628860d73a0c3ee2722d28eedbed26d1fb51863e761c"

URI_bpftrace = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/bpftrace-0.22.1-1.el10.x86_64_v2.rpm;name=bpftrace;unpack=0"
SRC_URI += "${URI_bpftrace}"
SRC_URI[bpftrace.sha256sum] = "aff45f40e7e554447703b0ebc2b16b9ed334bd4f6dbeaa65b768cad9998d9b5a"
RDEPENDS:bpftrace = " \
 zlib-ng-compat \
 libgcc \
 libbpf \
 clang-libs \
 elfutils-libelf \
 libstdc++ \
 lldb \
 bcc \
 glibc \
 llvm-libs \
"
