# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "apr-util"
PE = "0"
PV = "1.6.3"
PR = "21.el10"
PACKAGES = "apr-util apr-util-devel apr-util-ldap apr-util-lmdb apr-util-mysql apr-util-odbc apr-util-openssl apr-util-pgsql apr-util-sqlite"
PROVIDES = "rpm/apr-util rpm/apr-util-devel rpm/apr-util-ldap rpm/apr-util-lmdb rpm/apr-util-mysql rpm/apr-util-odbc rpm/apr-util-openssl rpm/apr-util-pgsql rpm/apr-util-sqlite"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/apr-util-1.6.3-21.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b81533273ab61aae0af1493b5d1fde427221a88c24a2a5d4f25e850380ef19ee"

URI_apr-util = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/apr-util-1.6.3-21.el10.x86_64_v2.rpm;name=apr-util;unpack=0"
SRC_URI += "${URI_apr-util}"
SRC_URI[apr-util.sha256sum] = "018bc0c29c7bff3647297940f6aee6a0695e02c4f6105baebd8762df857de647"
RDEPENDS:apr-util = " \
 libuuid \
 libxcrypt \
 apr \
 expat \
 glibc \
"

URI_apr-util-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/apr-util-devel-1.6.3-21.el10.x86_64_v2.rpm;name=apr-util-devel;unpack=0"
SRC_URI += "${URI_apr-util-devel}"
SRC_URI[apr-util-devel.sha256sum] = "c7812c538a752e111c8d37d889f832c2d2087782b2b02631150e48da8ae894ff"
RDEPENDS:apr-util-devel = " \
 openldap-devel \
 apr-devel \
 pkgconf-pkg-config \
 apr-util \
 expat-devel \
 bash \
"

URI_apr-util-ldap = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/apr-util-ldap-1.6.3-21.el10.x86_64_v2.rpm;name=apr-util-ldap;unpack=0"
SRC_URI += "${URI_apr-util-ldap}"
SRC_URI[apr-util-ldap.sha256sum] = "b9cbeab6b3e9a620212c758b3437a51868df982d33d0ac7a0848cbb918fa5e1b"
RDEPENDS:apr-util-ldap = " \
 glibc \
 openldap \
 apr-util \
"

URI_apr-util-lmdb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/apr-util-lmdb-1.6.3-21.el10.x86_64_v2.rpm;name=apr-util-lmdb;unpack=0"
SRC_URI += "${URI_apr-util-lmdb}"
SRC_URI[apr-util-lmdb.sha256sum] = "bf7697ebdf278e9ae9b3e925ef0babf2d9f4fb1d26efc705abf934dbc2adde43"
RDEPENDS:apr-util-lmdb = " \
 glibc \
 lmdb-libs \
 apr-util \
"

URI_apr-util-mysql = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/apr-util-mysql-1.6.3-21.el10.x86_64_v2.rpm;name=apr-util-mysql;unpack=0"
SRC_URI += "${URI_apr-util-mysql}"
SRC_URI[apr-util-mysql.sha256sum] = "aa2a68c1c3d90de901531c7ada717dff952cb9b74cf5bdd9b7aae0750341cdde"
RDEPENDS:apr-util-mysql = " \
 glibc \
 mariadb-connector-c \
 apr-util \
"

URI_apr-util-odbc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/apr-util-odbc-1.6.3-21.el10.x86_64_v2.rpm;name=apr-util-odbc;unpack=0"
SRC_URI += "${URI_apr-util-odbc}"
SRC_URI[apr-util-odbc.sha256sum] = "e41299c49da1f12f9e5a6081f7223477554322fa0bd707d5e774782dc95c6e05"
RDEPENDS:apr-util-odbc = " \
 glibc \
 unixODBC \
 apr-util \
"

URI_apr-util-openssl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/apr-util-openssl-1.6.3-21.el10.x86_64_v2.rpm;name=apr-util-openssl;unpack=0"
SRC_URI += "${URI_apr-util-openssl}"
SRC_URI[apr-util-openssl.sha256sum] = "92e0564ebd71b84a80357656453442fa9b9d12de8a970e8c6ab4128a99ba4027"
RDEPENDS:apr-util-openssl = " \
 glibc \
 openssl-libs \
 apr-util \
"

URI_apr-util-pgsql = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/apr-util-pgsql-1.6.3-21.el10.x86_64_v2.rpm;name=apr-util-pgsql;unpack=0"
SRC_URI += "${URI_apr-util-pgsql}"
SRC_URI[apr-util-pgsql.sha256sum] = "6780005e0cd91449891e3594d6c42c43e4c749c942c68460d87a4875881012dd"
RDEPENDS:apr-util-pgsql = " \
 glibc \
 apr-util \
 libpq \
"

URI_apr-util-sqlite = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/apr-util-sqlite-1.6.3-21.el10.x86_64_v2.rpm;name=apr-util-sqlite;unpack=0"
SRC_URI += "${URI_apr-util-sqlite}"
SRC_URI[apr-util-sqlite.sha256sum] = "33b1d1367b97fa6e1b03c1fe8bf0ee8d708f58e806b5aa2b14e30383063b1ff3"
RDEPENDS:apr-util-sqlite = " \
 glibc \
 sqlite-libs \
 apr-util \
"
