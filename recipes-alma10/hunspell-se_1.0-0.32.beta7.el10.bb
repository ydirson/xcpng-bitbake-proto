# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-se"
PE = "0"
PV = "1.0"
PR = "0.32.beta7.el10"
PACKAGES = "hunspell-se"
PROVIDES = "rpm/hunspell-se"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-se-1.0-0.32.beta7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7bef15a5e5344c2e98c02867e1ace237f6a75737b04cc92076ba262c1cc4ad1"

URI_hunspell-se = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-se-1.0-0.32.beta7.el10.noarch.rpm;name=hunspell-se;unpack=0"
SRC_URI += "${URI_hunspell-se}"
SRC_URI[hunspell-se.sha256sum] = "d1a20b675b4a9ccb54795646f4ced3e864bc21c0e46f6cedacad35c65abf2513"
RDEPENDS:hunspell-se = " \
 hunspell \
"
