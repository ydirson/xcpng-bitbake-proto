# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "paktype-naskh-basic-fonts"
PE = "0"
PV = "6.0"
PR = "14.el10"
PACKAGES = "paktype-naskh-basic-fonts"
PROVIDES = "rpm/paktype-naskh-basic-fonts"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/paktype-naskh-basic-fonts-6.0-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c24f50361421cac9c5bc2f93dd8e9c02ea85a936fba10c97dacd7cb03571e40c"

URI_paktype-naskh-basic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/paktype-naskh-basic-fonts-6.0-14.el10.noarch.rpm;name=paktype-naskh-basic-fonts;unpack=0"
SRC_URI += "${URI_paktype-naskh-basic-fonts}"
SRC_URI[paktype-naskh-basic-fonts.sha256sum] = "f14e276c3bc9b39464a5c605d768fbf551118178e444c230a350dec4a59890be"
RDEPENDS:paktype-naskh-basic-fonts = " \
 fonts-filesystem \
"
