# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-IO-Socket-IP"
PE = "0"
PV = "0.42"
PR = "512.el10"
PACKAGES = "perl-IO-Socket-IP perl-IO-Socket-IP-tests"
PROVIDES = "rpm/perl-IO-Socket-IP rpm/perl-IO-Socket-IP-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-IO-Socket-IP-0.42-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd1ec12de4568119c59de08e7d00c65ea7380594feec3549c8b32f40b4f1c01f"

URI_perl-IO-Socket-IP = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-IO-Socket-IP-0.42-512.el10.noarch.rpm;name=perl-IO-Socket-IP;unpack=0"
SRC_URI += "${URI_perl-IO-Socket-IP}"
SRC_URI[perl-IO-Socket-IP.sha256sum] = "e17497fb60842857e947028e41da4b669ca261b7c187442e39d3ebd7473534f7"
RDEPENDS:perl-IO-Socket-IP = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-IO \
 perl-Socket \
 perl-POSIX \
 perl-Errno \
 perl-base \
"

URI_perl-IO-Socket-IP-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-IO-Socket-IP-tests-0.42-512.el10.noarch.rpm;name=perl-IO-Socket-IP-tests;unpack=0"
SRC_URI += "${URI_perl-IO-Socket-IP-tests}"
SRC_URI[perl-IO-Socket-IP-tests.sha256sum] = "94160a3688f81a88be14a39c84c0616cdf0ebc9722ac9e886d86068f56b1659a"
RDEPENDS:perl-IO-Socket-IP-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-IO \
 perl-Socket \
 perl-IO-Socket-IP \
 bash \
 perl-Errno \
 perl-interpreter \
 perl-base \
"
