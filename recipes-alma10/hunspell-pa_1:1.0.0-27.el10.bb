# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-pa"
PE = "1"
PV = "1.0.0"
PR = "27.el10"
PACKAGES = "hunspell-pa"
PROVIDES = "rpm/hunspell-pa"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-pa-1.0.0-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01fd27fd51a43017a6c5b27c95a6be75e1cb4dd3426c61d3a1a9d764014f53f3"

URI_hunspell-pa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-pa-1.0.0-27.el10.noarch.rpm;name=hunspell-pa;unpack=0"
SRC_URI += "${URI_hunspell-pa}"
SRC_URI[hunspell-pa.sha256sum] = "b1ae4fd8821091f2399aad1c3802f41e9fb257f692f0d902e78d450641c948eb"
RDEPENDS:hunspell-pa = " \
 hunspell \
"
