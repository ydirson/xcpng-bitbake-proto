# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "liboqs"
PE = "0"
PV = "0.12.0"
PR = "2.el10"
PACKAGES = "liboqs liboqs-devel"
PROVIDES = "rpm/liboqs rpm/liboqs-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/liboqs-0.12.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "910cdb5c66f1fcd7e4091b4457d83a2aa16a2064b3cd30b19af0cf93ba9fb580"

URI_liboqs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/liboqs-0.12.0-2.el10.x86_64_v2.rpm;name=liboqs;unpack=0"
SRC_URI += "${URI_liboqs}"
SRC_URI[liboqs.sha256sum] = "b3822033c3abc5fdc6880cfc4591ca0e3aead450286ac3f353923104a07f0616"
RDEPENDS:liboqs = " \
 glibc \
"

URI_liboqs-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/liboqs-devel-0.12.0-2.el10.x86_64_v2.rpm;name=liboqs-devel;unpack=0"
SRC_URI += "${URI_liboqs-devel}"
SRC_URI[liboqs-devel.sha256sum] = "ea408a9e897820acf032d46911504cb2a0a3cd4e49671ecfe8318345504fe576"
RDEPENDS:liboqs-devel = " \
 openssl-devel \
 cmake-filesystem \
 pkgconf-pkg-config \
 liboqs \
"
