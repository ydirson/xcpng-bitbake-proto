# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mstflint"
PE = "0"
PV = "4.30.0"
PR = "1.el10"
PACKAGES = "mstflint"
PROVIDES = "rpm/mstflint"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mstflint-4.30.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "24eb1961415916d909a5c75c7c1e91e2184469c295d1f2ccfcf03b65ba78015d"

URI_mstflint = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mstflint-4.30.0-1.el10.x86_64_v2.rpm;name=mstflint;unpack=0"
SRC_URI += "${URI_mstflint}"
SRC_URI[mstflint.sha256sum] = "8ef291eade994b894771a48b6c8ed34595374963d729df8ef55ac663f6f974f9"
RDEPENDS:mstflint = " \
 python3 \
 zlib-ng-compat \
 libgcc \
 libstdc++ \
 bash \
 expat \
 glibc \
"
