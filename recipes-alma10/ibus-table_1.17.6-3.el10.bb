# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ibus-table"
PE = "0"
PV = "1.17.6"
PR = "3.el10"
PACKAGES = "ibus-table ibus-table-devel ibus-table-tests"
PROVIDES = "rpm/ibus-table rpm/ibus-table-devel rpm/ibus-table-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ibus-table-1.17.6-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c39bad3160e123cc73d2ffb29936ca47dfeef48dd24c908d81948891d8db1fe"

URI_ibus-table = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ibus-table-1.17.6-3.el10.noarch.rpm;name=ibus-table;unpack=0"
SRC_URI += "${URI_ibus-table}"
SRC_URI[ibus-table.sha256sum] = "0247dbc6d49010ccde332226b210c4257e2365216a482f088ab9ace05b771375"
RDEPENDS:ibus-table = " \
 python3 \
 ibus \
 bash \
"

URI_ibus-table-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ibus-table-devel-1.17.6-3.el10.noarch.rpm;name=ibus-table-devel;unpack=0"
SRC_URI += "${URI_ibus-table-devel}"
SRC_URI[ibus-table-devel.sha256sum] = "71557290ec3534316a2f1b33e3cdc4add70c5fe158628362f1a2a8108fee7d6f"
RDEPENDS:ibus-table-devel = " \
 ibus-table \
 pkgconf-pkg-config \
"

URI_ibus-table-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ibus-table-tests-1.17.6-3.el10.noarch.rpm;name=ibus-table-tests;unpack=0"
SRC_URI += "${URI_ibus-table-tests}"
SRC_URI[ibus-table-tests.sha256sum] = "3fd0ecd55c06b72a8da0382ea8fe003c03b37d0cdc52f56883ef3b3de6a7ff9a"
RDEPENDS:ibus-table-tests = " \
 python3 \
 ibus-table \
"
