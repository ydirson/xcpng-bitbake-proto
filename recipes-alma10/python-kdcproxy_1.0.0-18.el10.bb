# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-kdcproxy"
PE = "0"
PV = "1.0.0"
PR = "18.el10"
PACKAGES = "python3-kdcproxy"
PROVIDES = "rpm/python3-kdcproxy"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-kdcproxy-1.0.0-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b62f14413dc1087af39938d824fa957ee4843aa76040385519a152fd98075c78"

URI_python3-kdcproxy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-kdcproxy-1.0.0-18.el10.noarch.rpm;name=python3-kdcproxy;unpack=0"
SRC_URI += "${URI_python3-kdcproxy}"
SRC_URI[python3-kdcproxy.sha256sum] = "bf31140be5ceeff3c043737d1c1b533a380a5d37f5289fbc445612a6e489be57"
RDEPENDS:python3-kdcproxy = " \
 python3-pyasn1 \
 python3-dns \
 python3 \
"
