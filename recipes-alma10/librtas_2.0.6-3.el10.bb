# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "librtas"
PE = "0"
PV = "2.0.6"
PR = "3.el10"
PACKAGES = ""
PROVIDES = ""


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/librtas-2.0.6-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f0052d9b078803ab075da8a474e29aff0571a78c1be8d2c853df287acf2314a"
