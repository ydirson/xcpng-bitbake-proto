# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "beust-jcommander"
PE = "0"
PV = "1.82"
PR = "10.el10"
PACKAGES = "beust-jcommander beust-jcommander-javadoc"
PROVIDES = "rpm/beust-jcommander rpm/beust-jcommander-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/beust-jcommander-1.82-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcc05ecd90be5493a8b8280c3fd3f5d125f3d80a249549d7c0ff245be5ab0385"

URI_beust-jcommander = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/beust-jcommander-1.82-10.el10.noarch.rpm;name=beust-jcommander;unpack=0"
SRC_URI += "${URI_beust-jcommander}"
SRC_URI[beust-jcommander.sha256sum] = "9f74fb8cfa175a3f3068a090f8c883c4e5da413458efc8c1aceb5a48bcfdbb31"
RDEPENDS:beust-jcommander = " \
 javapackages-filesystem \
"

URI_beust-jcommander-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/beust-jcommander-javadoc-1.82-10.el10.noarch.rpm;name=beust-jcommander-javadoc;unpack=0"
SRC_URI += "${URI_beust-jcommander-javadoc}"
SRC_URI[beust-jcommander-javadoc.sha256sum] = "5fcce60109a39f7892a293163854f078a16bd69a6f65f7b81737f216dddc81d8"
RDEPENDS:beust-jcommander-javadoc = " \
 javapackages-filesystem \
"
