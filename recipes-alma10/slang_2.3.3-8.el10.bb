# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "slang"
PE = "0"
PV = "2.3.3"
PR = "8.el10"
PACKAGES = "slang slang-devel slang-slsh"
PROVIDES = "rpm/slang rpm/slang-devel rpm/slang-slsh"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/slang-2.3.3-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2d22b2edee55a6730c932014e8ba5eb590908057af1ae09b260f64e11e2087d"

URI_slang = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/slang-2.3.3-8.el10.x86_64_v2.rpm;name=slang;unpack=0"
SRC_URI += "${URI_slang}"
SRC_URI[slang.sha256sum] = "e8de2cd931ca3c41d2929ffcb095c78664d6a15efe455fd08653ea976707c023"
RDEPENDS:slang = " \
 glibc \
"

URI_slang-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/slang-devel-2.3.3-8.el10.x86_64_v2.rpm;name=slang-devel;unpack=0"
SRC_URI += "${URI_slang-devel}"
SRC_URI[slang-devel.sha256sum] = "0556477ae5fe4850021b33134a572024e6d926a717567fd146e7dfaba4dcd95e"
RDEPENDS:slang-devel = " \
 slang \
 pkgconf-pkg-config \
"

URI_slang-slsh = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/slang-slsh-2.3.3-8.el10.x86_64_v2.rpm;name=slang-slsh;unpack=0"
SRC_URI += "${URI_slang-slsh}"
SRC_URI[slang-slsh.sha256sum] = "e51279d6773157af7c58442e922786ad2e89ffcd225c9f6b8b17d51ff966f229"
RDEPENDS:slang-slsh = " \
 glibc \
 slang \
 zlib-ng-compat \
 libpng \
"
