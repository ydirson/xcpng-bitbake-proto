# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "chrony"
PE = "0"
PV = "4.6.1"
PR = "1.el10"
PACKAGES = "chrony"
PROVIDES = "rpm/chrony"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/chrony-4.6.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30ec5487ec03629100e567c70704b222d81db4906088b270bc7137291e5575b2"

URI_chrony = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/chrony-4.6.1-1.el10.x86_64_v2.rpm;name=chrony;unpack=0"
SRC_URI += "${URI_chrony}"
SRC_URI[chrony.sha256sum] = "ecb3b70ac4c550fac5a4285f761a2daaf0f3401d3ac3010f372832f96d5b8399"
RDEPENDS:chrony = " \
 tzdata \
 shadow-utils \
 systemd \
 gnutls \
 libcap \
 bash \
 libseccomp \
 glibc \
 libedit \
"
