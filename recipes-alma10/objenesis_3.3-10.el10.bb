# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "objenesis"
PE = "0"
PV = "3.3"
PR = "10.el10"
PACKAGES = "objenesis objenesis-javadoc"
PROVIDES = "rpm/objenesis rpm/objenesis-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/objenesis-3.3-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b289db051a8fe8e0d57b232e558218fe435b11a5ef7f58eecce98e0d9a39530"

URI_objenesis = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/objenesis-3.3-10.el10.noarch.rpm;name=objenesis;unpack=0"
SRC_URI += "${URI_objenesis}"
SRC_URI[objenesis.sha256sum] = "4b475e3e8966ac0dafc3eef980303c630ad139a3acb289fa7b8b5f29e8511e8e"
RDEPENDS:objenesis = " \
 javapackages-filesystem \
"

URI_objenesis-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/objenesis-javadoc-3.3-10.el10.noarch.rpm;name=objenesis-javadoc;unpack=0"
SRC_URI += "${URI_objenesis-javadoc}"
SRC_URI[objenesis-javadoc.sha256sum] = "583d483203cc889e67bbcda8f7cd9c8ffdf509cadf7ccc88fc2a48dcc7002087"
RDEPENDS:objenesis-javadoc = " \
 javapackages-filesystem \
"
