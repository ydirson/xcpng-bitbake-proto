# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-colorama"
PE = "0"
PV = "0.4.6"
PR = "13.el10"
PACKAGES = "python3-colorama"
PROVIDES = "rpm/python3-colorama"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/python-colorama-0.4.6-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4c48e329332ca26942e844e0764e14db2a032c80723733cb7f5a318445447c2"

URI_python3-colorama = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-colorama-0.4.6-13.el10.noarch.rpm;name=python3-colorama;unpack=0"
SRC_URI += "${URI_python3-colorama}"
SRC_URI[python3-colorama.sha256sum] = "a447179b8e31a4eae687eeb5faa6ed52430c823d14f2e7b1a8120be1b1bca783"
RDEPENDS:python3-colorama = " \
 python3 \
"
