# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-drgn"
PE = "0"
PV = "0.0.29"
PR = "1.el10"
PACKAGES = "drgn"
PROVIDES = "rpm/drgn"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-drgn-0.0.29-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cdd706a9dcb4026626faa01d8f57149f13c5744667b0f82ef545d778ac84fcc3"

URI_drgn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/drgn-0.0.29-1.el10.x86_64_v2.rpm;name=drgn;unpack=0"
SRC_URI += "${URI_drgn}"
SRC_URI[drgn.sha256sum] = "948a9b5521496cc0f506e5c661d211bd3af2eb5eecebb22bd29bb54492b798f9"
RDEPENDS:drgn = " \
 python3 \
 libgcc \
 elfutils-libelf \
 libgomp \
 elfutils-libs \
 glibc \
 libkdumpfile \
"
