# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "p11-kit"
PE = "0"
PV = "0.25.5"
PR = "7.el10"
PACKAGES = "p11-kit p11-kit-trust p11-kit-devel p11-kit-server"
PROVIDES = "rpm/p11-kit rpm/p11-kit-trust rpm/p11-kit-devel rpm/p11-kit-server"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/p11-kit-0.25.5-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dcd72ae43cb1ad0eaa95a2f1cb83a27f241f68557c8001c291e0089593a09606"

URI_p11-kit = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/p11-kit-0.25.5-7.el10.x86_64_v2.rpm;name=p11-kit;unpack=0"
SRC_URI += "${URI_p11-kit}"
SRC_URI[p11-kit.sha256sum] = "1d207c2783aa66eaa969ef45f676081a042d1c703c19be9897066f6be2557bba"
RDEPENDS:p11-kit = " \
 glibc \
 libffi \
 libtasn1 \
"

URI_p11-kit-trust = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/p11-kit-trust-0.25.5-7.el10.x86_64_v2.rpm;name=p11-kit-trust;unpack=0"
SRC_URI += "${URI_p11-kit-trust}"
SRC_URI[p11-kit-trust.sha256sum] = "c5a466416970a6e240fb69851d6bf7e0f6519b587f6d5bd708a23878e4eb857c"
RDEPENDS:p11-kit-trust = " \
 p11-kit \
 bash \
 libtasn1 \
 glibc \
 alternatives \
"

URI_p11-kit-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/p11-kit-devel-0.25.5-7.el10.x86_64_v2.rpm;name=p11-kit-devel;unpack=0"
SRC_URI += "${URI_p11-kit-devel}"
SRC_URI[p11-kit-devel.sha256sum] = "f1430ef1c5a123acc9192c4b4589cd8a978c0affa94dac51f587796100a1b269"
RDEPENDS:p11-kit-devel = " \
 p11-kit \
 pkgconf-pkg-config \
"

URI_p11-kit-server = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/p11-kit-server-0.25.5-7.el10.x86_64_v2.rpm;name=p11-kit-server;unpack=0"
SRC_URI += "${URI_p11-kit-server}"
SRC_URI[p11-kit-server.sha256sum] = "7c499f22ba4526648cac129795177790ca66163fbe7d86fdd9b185f00837c20b"
RDEPENDS:p11-kit-server = " \
 glibc \
 libffi \
 p11-kit \
 systemd-libs \
"
