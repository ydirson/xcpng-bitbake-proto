# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Test2-Suite"
PE = "0"
PV = "0.000163"
PR = "4.el10"
PACKAGES = "perl-Test2-Suite perl-Test2-Suite-tests"
PROVIDES = "rpm/perl-Test2-Suite rpm/perl-Test2-Suite-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Test2-Suite-0.000163-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2667bcea667f3a409c192c1effc54a63ee9cb2ab908b0c25664ffcc659e41760"

URI_perl-Test2-Suite = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Test2-Suite-0.000163-4.el10.noarch.rpm;name=perl-Test2-Suite;unpack=0"
SRC_URI += "${URI_perl-Test2-Suite}"
SRC_URI[perl-Test2-Suite.sha256sum] = "d407092af2e0551d68c5322def158e0c2186de661b7d4ba55c200fff3d027efc"
RDEPENDS:perl-Test2-Suite = " \
 perl-constant \
 perl-threads \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-Test-Simple \
 perl-Test2-Suite \
 perl-B \
 perl-overload \
 perl-PathTools \
 perl-Time-HiRes \
 perl-Exporter \
 perl-Data-Dumper \
 perl-base \
 perl-File-Temp \
 perl-Term-Table \
"

URI_perl-Test2-Suite-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Test2-Suite-tests-0.000163-4.el10.noarch.rpm;name=perl-Test2-Suite-tests;unpack=0"
SRC_URI += "${URI_perl-Test2-Suite-tests}"
SRC_URI[perl-Test2-Suite-tests.sha256sum] = "2d818bc88967dc00c54ac26da08e78045a6f00f2938e623a4b978409d8c02010"
RDEPENDS:perl-Test2-Suite-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-vars \
 perl-IO \
 perl-ExtUtils-MakeMaker \
 perl-Scalar-List-Utils \
 perl-Test2-Suite \
 perl-File-Temp \
 perl-overload \
 bash \
 perl-PathTools \
 perl-Symbol \
 perl-interpreter \
 perl-Data-Dumper \
 perl-base \
 perl-lib \
"
