# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-SNMP_Session"
PE = "0"
PV = "1.16"
PR = "6.el10"
PACKAGES = "perl-SNMP_Session"
PROVIDES = "rpm/perl-SNMP_Session"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-SNMP_Session-1.16-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5d24511e3baa6001b2a0c83c2501e2b0556497a71f49387f8f78f3da465f9ae"

URI_perl-SNMP_Session = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-SNMP_Session-1.16-6.el10.noarch.rpm;name=perl-SNMP_Session;unpack=0"
SRC_URI += "${URI_perl-SNMP_Session}"
SRC_URI[perl-SNMP_Session.sha256sum] = "47082bb7f4995770d54da704185450c880a111ce6b70228bc7848bea1ecdfd18"
RDEPENDS:perl-SNMP_Session = " \
 perl-SNMP_Session \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-IO \
 perl-Socket \
 perl-Socket6 \
 perl-IO-Socket-INET6 \
 perl-Exporter \
 perl-Net-SNMP \
"
