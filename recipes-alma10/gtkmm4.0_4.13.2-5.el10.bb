# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gtkmm4.0"
PE = "0"
PV = "4.13.2"
PR = "5.el10"
PACKAGES = "gtkmm4.0 gtkmm4.0-devel gtkmm4.0-doc"
PROVIDES = "rpm/gtkmm4.0 rpm/gtkmm4.0-devel rpm/gtkmm4.0-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gtkmm4.0-4.13.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e642d0e34e284b8410df02f07d0c30e559ad6a792c58e7c50eadde8726916541"

URI_gtkmm4.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gtkmm4.0-4.13.2-5.el10.x86_64_v2.rpm;name=gtkmm4.0;unpack=0"
SRC_URI += "${URI_gtkmm4.0}"
SRC_URI[gtkmm4.0.sha256sum] = "765f53b5c32d26f0ceb7297de16d57f6534d52aa17929bd958b00b4667caf6dc"
RDEPENDS:gtkmm4.0 = " \
 libgcc \
 gdk-pixbuf2 \
 glibmm2.68 \
 pangomm2.48 \
 libstdc++ \
 glib2 \
 graphene \
 cairo-gobject \
 glibc \
 cairomm1.16 \
 gtk4 \
 libsigc++30 \
"

URI_gtkmm4.0-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gtkmm4.0-devel-4.13.2-5.el10.x86_64_v2.rpm;name=gtkmm4.0-devel;unpack=0"
SRC_URI += "${URI_gtkmm4.0-devel}"
SRC_URI[gtkmm4.0-devel.sha256sum] = "7c9f8b57a15060d6759f9e45e1e7c0dcd34fb26b2e9e23776e28c0986922ac8a"
RDEPENDS:gtkmm4.0-devel = " \
 pangomm2.48-devel \
 pkgconf-pkg-config \
 cairomm1.16-devel \
 glibmm2.68-devel \
 gdk-pixbuf2-devel \
 gtk4-devel \
 gtkmm4.0 \
"

URI_gtkmm4.0-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gtkmm4.0-doc-4.13.2-5.el10.noarch.rpm;name=gtkmm4.0-doc;unpack=0"
SRC_URI += "${URI_gtkmm4.0-doc}"
SRC_URI[gtkmm4.0-doc.sha256sum] = "72642e2997c1f8a2c02581c6495f5cb5cf662a40d8f9827763d6fa5c0846d989"
RDEPENDS:gtkmm4.0-doc = " \
 glibmm2.68-doc \
 gtkmm4.0 \
"
