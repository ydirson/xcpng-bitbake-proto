# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cups-pk-helper"
PE = "0"
PV = "0.2.7"
PR = "9.el10"
PACKAGES = "cups-pk-helper"
PROVIDES = "rpm/cups-pk-helper"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/cups-pk-helper-0.2.7-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba43ef2a616e2b3a5c807c5a9cb555ffa31f861caccf2ee144168e5d92d2ed76"

URI_cups-pk-helper = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cups-pk-helper-0.2.7-9.el10.x86_64_v2.rpm;name=cups-pk-helper;unpack=0"
SRC_URI += "${URI_cups-pk-helper}"
SRC_URI[cups-pk-helper.sha256sum] = "dc75e15a805d8b783a8982cd14a8e99053c8e4be6933607c3ef8729755bc9e1e"
RDEPENDS:cups-pk-helper = " \
 glibc \
 polkit-libs \
 cups-libs \
 glib2 \
"
