# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "almalinux-bookmarks"
PE = "0"
PV = "10"
PR = "1.el10"
PACKAGES = "almalinux-bookmarks"
PROVIDES = "rpm/almalinux-bookmarks"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/almalinux-bookmarks-10-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b88afb50201524696206cb6de4fa716f5149f02c9d4324d42ef6c4c9d7998e34"

URI_almalinux-bookmarks = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/almalinux-bookmarks-10-1.el10.noarch.rpm;name=almalinux-bookmarks;unpack=0"
SRC_URI += "${URI_almalinux-bookmarks}"
SRC_URI[almalinux-bookmarks.sha256sum] = "fc09dad87b38f82e23c8fc5a220ad28a6765560b6b1ec6e0f326c46d1ed53d5a"
RDEPENDS:almalinux-bookmarks = ""
