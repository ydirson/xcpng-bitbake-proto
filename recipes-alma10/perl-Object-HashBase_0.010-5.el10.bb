# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Object-HashBase"
PE = "0"
PV = "0.010"
PR = "5.el10"
PACKAGES = "perl-Object-HashBase perl-Object-HashBase-tests perl-Object-HashBase-tools"
PROVIDES = "rpm/perl-Object-HashBase rpm/perl-Object-HashBase-tests rpm/perl-Object-HashBase-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Object-HashBase-0.010-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1816aa74793b6cf51feb779bad8aa219bc0d859c194a8b8e976bb9e6a123e3ea"

URI_perl-Object-HashBase = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Object-HashBase-0.010-5.el10.noarch.rpm;name=perl-Object-HashBase;unpack=0"
SRC_URI += "${URI_perl-Object-HashBase}"
SRC_URI[perl-Object-HashBase.sha256sum] = "09db075de1e50ce7843fd268cfdf59a679fdcdefe399f27f2e58cf945dfe2101"
RDEPENDS:perl-Object-HashBase = " \
 perl-libs \
 perl-Carp \
"

URI_perl-Object-HashBase-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Object-HashBase-tests-0.010-5.el10.noarch.rpm;name=perl-Object-HashBase-tests;unpack=0"
SRC_URI += "${URI_perl-Object-HashBase-tests}"
SRC_URI[perl-Object-HashBase-tests.sha256sum] = "d6aa8a3eecadee7c8bf86eff382724dfdd8bf675a36a2ef638d925b920522866"
RDEPENDS:perl-Object-HashBase-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Object-HashBase \
 bash \
 perl-interpreter \
 perl-Object-HashBase-tools \
 perl-File-Temp \
"

URI_perl-Object-HashBase-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Object-HashBase-tools-0.010-5.el10.noarch.rpm;name=perl-Object-HashBase-tools;unpack=0"
SRC_URI += "${URI_perl-Object-HashBase-tools}"
SRC_URI[perl-Object-HashBase-tools.sha256sum] = "2af45a70313cfa019d2f1da46437cd789b023c101e81a6b2f944d1bf8853a6b5"
RDEPENDS:perl-Object-HashBase-tools = " \
 perl-Object-HashBase \
 perl-libs \
 perl-Test-Simple \
 perl-vars \
 perl-interpreter \
 perl-Object-HashBase-tools \
 perl-base \
"
