# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libspiro"
PE = "0"
PV = "20221101"
PR = "8.el10"
PACKAGES = "libspiro libspiro-devel"
PROVIDES = "rpm/libspiro rpm/libspiro-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libspiro-20221101-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b272a2e69cef6ca8baec083a05866f4a1ac25cacdc94e96665489a9591e7387b"

URI_libspiro = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libspiro-20221101-8.el10.x86_64_v2.rpm;name=libspiro;unpack=0"
SRC_URI += "${URI_libspiro}"
SRC_URI[libspiro.sha256sum] = "659a66b5775543256800ff4c3a94fd209378afa5a77dc205db7364b7c30ce8a6"
RDEPENDS:libspiro = " \
 glibc \
"

URI_libspiro-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libspiro-devel-20221101-8.el10.x86_64_v2.rpm;name=libspiro-devel;unpack=0"
SRC_URI += "${URI_libspiro-devel}"
SRC_URI[libspiro-devel.sha256sum] = "37c283685cb09e04b410f06d5062529da1247bfbdec7dbe23ce352ec93a76114"
RDEPENDS:libspiro-devel = " \
 libspiro \
 pkgconf-pkg-config \
"
