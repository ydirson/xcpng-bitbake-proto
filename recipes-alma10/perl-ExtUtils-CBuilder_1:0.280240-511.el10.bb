# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-CBuilder"
PE = "1"
PV = "0.280240"
PR = "511.el10"
PACKAGES = "perl-ExtUtils-CBuilder perl-ExtUtils-CBuilder-tests"
PROVIDES = "rpm/perl-ExtUtils-CBuilder rpm/perl-ExtUtils-CBuilder-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-ExtUtils-CBuilder-0.280240-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc7704fb79c66d9b4dad14427d8fa19e912f5f88290581f611d0c3f23519eaa6"

URI_perl-ExtUtils-CBuilder = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-ExtUtils-CBuilder-0.280240-511.el10.noarch.rpm;name=perl-ExtUtils-CBuilder;unpack=0"
SRC_URI += "${URI_perl-ExtUtils-CBuilder}"
SRC_URI[perl-ExtUtils-CBuilder.sha256sum] = "4fad62492a7d30e88767901a6098be78700d597e2700b503802a5427067ae418"
RDEPENDS:perl-ExtUtils-CBuilder = " \
 perl-libs \
 perl-ExtUtils-MakeMaker \
 perl-IO \
 perl-devel \
 perl-Text-ParseWords \
 perl-File-Basename \
 perl-DynaLoader \
 perl-IPC-Cmd \
 perl-PathTools \
 perl-Perl-OSType \
 gcc \
 gcc-c++ \
 perl-File-Path \
 perl-ExtUtils-CBuilder \
 perl-File-Temp \
"

URI_perl-ExtUtils-CBuilder-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-ExtUtils-CBuilder-tests-0.280240-511.el10.noarch.rpm;name=perl-ExtUtils-CBuilder-tests;unpack=0"
SRC_URI += "${URI_perl-ExtUtils-CBuilder-tests}"
SRC_URI[perl-ExtUtils-CBuilder-tests.sha256sum] = "8e9dd5cabb1ce1e3e1b5b12e4740749c95ebdfcde342efae78211168117c7408"
RDEPENDS:perl-ExtUtils-CBuilder-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 bash \
 perl-PathTools \
 perl-interpreter \
 perl-File-Path \
 perl-ExtUtils-CBuilder \
 perl-File-Temp \
"
