# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mpdecimal"
PE = "0"
PV = "2.5.1"
PR = "12.el10"
PACKAGES = "mpdecimal mpdecimal++ mpdecimal-devel mpdecimal-doc"
PROVIDES = "rpm/mpdecimal rpm/mpdecimal++ rpm/mpdecimal-devel rpm/mpdecimal-doc"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/mpdecimal-2.5.1-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1abd6c3e4105dff43e12d21f549ec4aff74088094370bb784dc926937b1e9da4"

URI_mpdecimal = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/mpdecimal-2.5.1-12.el10.x86_64_v2.rpm;name=mpdecimal;unpack=0"
SRC_URI += "${URI_mpdecimal}"
SRC_URI[mpdecimal.sha256sum] = "1e21e561aadc58c12e8382792f6273b8c86ebf43ccfca0216ef5866b6cf29398"
RDEPENDS:mpdecimal = " \
 glibc \
"

URI_mpdecimal++ = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mpdecimal++-2.5.1-12.el10.x86_64_v2.rpm;name=mpdecimal++;unpack=0"
SRC_URI += "${URI_mpdecimal++}"
SRC_URI[mpdecimal++.sha256sum] = "ae7ae17372877aed114cbdd2774d5c78374534f65e537834daee7e27bbab08e8"
RDEPENDS:mpdecimal++ = " \
 glibc \
 mpdecimal \
 libgcc \
 libstdc++ \
"

URI_mpdecimal-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mpdecimal-devel-2.5.1-12.el10.x86_64_v2.rpm;name=mpdecimal-devel;unpack=0"
SRC_URI += "${URI_mpdecimal-devel}"
SRC_URI[mpdecimal-devel.sha256sum] = "28246d169c0b1846569fceb4c0da7b334b8632db359607f80d08bb0fdf1d2ba9"
RDEPENDS:mpdecimal-devel = " \
 mpdecimal++ \
 mpdecimal \
"

URI_mpdecimal-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mpdecimal-doc-2.5.1-12.el10.noarch.rpm;name=mpdecimal-doc;unpack=0"
SRC_URI += "${URI_mpdecimal-doc}"
SRC_URI[mpdecimal-doc.sha256sum] = "34f65f4c3c1c6a0c4c74ff72de5a0fc896d51fb628dca9a94664b569b1c53b1b"
RDEPENDS:mpdecimal-doc = ""
