# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xorg-x11-xinit"
PE = "0"
PV = "1.4.2"
PR = "3.el10"
PACKAGES = "xorg-x11-xinit xorg-x11-xinit-session"
PROVIDES = "rpm/xorg-x11-xinit rpm/xorg-x11-xinit-session"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/xorg-x11-xinit-1.4.2-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57362c3d77fe602676cbad1b05a4ee8a043973897c6186a1fc1876d72560c5ca"

URI_xorg-x11-xinit = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/xorg-x11-xinit-1.4.2-3.el10.x86_64_v2.rpm;name=xorg-x11-xinit;unpack=0"
SRC_URI += "${URI_xorg-x11-xinit}"
SRC_URI[xorg-x11-xinit.sha256sum] = "d5b626827b891d8c4dd2fee98d08266d93db16dca5064484af122a0f8f00d03a"
RDEPENDS:xorg-x11-xinit = " \
 libX11 \
 xmodmap \
 xhost \
 bash \
 xorg-x11-xauth \
 xrdb \
 glibc \
 coreutils \
 setxkbmap \
"

URI_xorg-x11-xinit-session = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/xorg-x11-xinit-session-1.4.2-3.el10.x86_64_v2.rpm;name=xorg-x11-xinit-session;unpack=0"
SRC_URI += "${URI_xorg-x11-xinit-session}"
SRC_URI[xorg-x11-xinit-session.sha256sum] = "d12796f20d045de14a60433ce5778f859ba5b6aef595a2a1ce733a77d2e28e98"
RDEPENDS:xorg-x11-xinit-session = " \
 bash \
"
