# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rear"
PE = "0"
PV = "2.9"
PR = "2.el10"
PACKAGES = "rear"
PROVIDES = "rpm/rear"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/rear-2.9-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e61b7ba510954d5cb1c2e8de2a056c63a4f48c55ac8d9c77611999fcda84dbf"

URI_rear = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rear-2.9-2.el10.x86_64_v2.rpm;name=rear;unpack=0"
SRC_URI += "${URI_rear}"
SRC_URI[rear.sha256sum] = "017039d3cfd0804d8917407e194673db96927ea78b63fcd0b77ff2121c9184f3"
RDEPENDS:rear = " \
 syslinux-extlinux \
 iproute \
 tar \
 iputils \
 util-linux \
 dhcpcd \
 dosfstools \
 xorriso \
 attr \
 openssl \
 parted \
 bash \
 ethtool \
 bc \
 binutils \
 grub2-efi-x64-modules \
 file \
 gzip \
 gawk \
"
