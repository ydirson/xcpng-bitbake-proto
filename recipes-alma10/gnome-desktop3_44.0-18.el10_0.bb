# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-desktop3"
PE = "0"
PV = "44.0"
PR = "18.el10_0"
PACKAGES = "gnome-desktop3 gnome-desktop4 gnome-desktop3-devel gnome-desktop4-devel gnome-desktop3-tests"
PROVIDES = "rpm/gnome-desktop3 rpm/gnome-desktop4 rpm/gnome-desktop3-devel rpm/gnome-desktop4-devel rpm/gnome-desktop3-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-desktop3-44.0-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7f9102b6cf6fd8738566f1fd6abd3b9bc44c6653b629bc79c9bb52aaa8d9e41"

URI_gnome-desktop3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-desktop3-44.0-18.el10_0.x86_64_v2.rpm;name=gnome-desktop3;unpack=0"
SRC_URI += "${URI_gnome-desktop3}"
SRC_URI[gnome-desktop3.sha256sum] = "f46afaf9718ad81cca79b17ba902ad928bbb7ba5aee6e208cb2ab43ec8c05278"
RDEPENDS:gnome-desktop3 = " \
 bubblewrap \
 systemd-libs \
 shared-mime-info \
 libseccomp \
 gsettings-desktop-schemas \
 libgcc \
 gdk-pixbuf2 \
 cairo \
 glib2 \
 gtk3 \
 glibc \
 libxkbcommon \
"

URI_gnome-desktop4 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-desktop4-44.0-18.el10_0.x86_64_v2.rpm;name=gnome-desktop4;unpack=0"
SRC_URI += "${URI_gnome-desktop4}"
SRC_URI[gnome-desktop4.sha256sum] = "53280de8c1f71a52735297a40ef13efd3094c38408bc22a87fcc8a3f58118e1a"
RDEPENDS:gnome-desktop4 = " \
 systemd-libs \
 gnome-desktop3 \
 libgcc \
 gdk-pixbuf2 \
 cairo \
 glib2 \
 libseccomp \
 glibc \
 libxkbcommon \
 gtk4 \
"

URI_gnome-desktop3-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gnome-desktop3-devel-44.0-18.el10_0.x86_64_v2.rpm;name=gnome-desktop3-devel;unpack=0"
SRC_URI += "${URI_gnome-desktop3-devel}"
SRC_URI[gnome-desktop3-devel.sha256sum] = "ed8a31aa8094c4fa01d30a2756fa68243344e43fd058f10f95011557dc6412d4"
RDEPENDS:gnome-desktop3-devel = " \
 glib2-devel \
 gsettings-desktop-schemas-devel \
 systemd-devel \
 gnome-desktop3 \
 pkgconf-pkg-config \
 libseccomp-devel \
 gdk-pixbuf2-devel \
 xkeyboard-config-devel \
 gtk3-devel \
 libxkbcommon-devel \
 iso-codes-devel \
"

URI_gnome-desktop4-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gnome-desktop4-devel-44.0-18.el10_0.x86_64_v2.rpm;name=gnome-desktop4-devel;unpack=0"
SRC_URI += "${URI_gnome-desktop4-devel}"
SRC_URI[gnome-desktop4-devel.sha256sum] = "f24e04950bc0829d27a2659895ff3c28c68c3a3c623a05b0623cd046835e29d3"
RDEPENDS:gnome-desktop4-devel = " \
 glib2-devel \
 gsettings-desktop-schemas-devel \
 systemd-devel \
 gnome-desktop4 \
 pkgconf-pkg-config \
 libseccomp-devel \
 gdk-pixbuf2-devel \
 xkeyboard-config-devel \
 gnome-desktop4-devel \
 libxkbcommon-devel \
 gtk4-devel \
 iso-codes-devel \
"

URI_gnome-desktop3-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gnome-desktop3-tests-44.0-18.el10_0.x86_64_v2.rpm;name=gnome-desktop3-tests;unpack=0"
SRC_URI += "${URI_gnome-desktop3-tests}"
SRC_URI[gnome-desktop3-tests.sha256sum] = "5eaf4b458d5bc2e0287e1da48edf7e1b4c3be26f38ab04a0d250fcef63d8cd1a"
RDEPENDS:gnome-desktop3-tests = " \
 gnome-desktop3 \
 cairo \
 glib2 \
 gtk3 \
 glibc \
"
