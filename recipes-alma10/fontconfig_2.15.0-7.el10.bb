# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "fontconfig"
PE = "0"
PV = "2.15.0"
PR = "7.el10"
PACKAGES = "fontconfig fontconfig-devel fontconfig-devel-doc"
PROVIDES = "rpm/fontconfig rpm/fontconfig-devel rpm/fontconfig-devel-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/fontconfig-2.15.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a1946c95800505f2f63591a8cf468fdd2e6646b1179467185231afc313db229"

URI_fontconfig = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fontconfig-2.15.0-7.el10.x86_64_v2.rpm;name=fontconfig;unpack=0"
SRC_URI += "${URI_fontconfig}"
SRC_URI[fontconfig.sha256sum] = "fe6f01d0e4f7096a1aa4555c3ca13c0e61082b7b008b17f9c00b6cfa3407c45a"
RDEPENDS:fontconfig = " \
 fonts-filesystem \
 freetype \
 grep \
 libxml2 \
 bash \
 xml-common \
 glibc \
 coreutils \
 default-fonts-core-sans \
"

URI_fontconfig-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fontconfig-devel-2.15.0-7.el10.x86_64_v2.rpm;name=fontconfig-devel;unpack=0"
SRC_URI += "${URI_fontconfig-devel}"
SRC_URI[fontconfig-devel.sha256sum] = "19c24789768de0ff2ab8c7a958f17770193b486f7fdae6b136611f3bd2281c56"
RDEPENDS:fontconfig-devel = " \
 libxml2-devel \
 freetype-devel \
 pkgconf-pkg-config \
 fontconfig \
 gettext \
"

URI_fontconfig-devel-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/fontconfig-devel-doc-2.15.0-7.el10.noarch.rpm;name=fontconfig-devel-doc;unpack=0"
SRC_URI += "${URI_fontconfig-devel-doc}"
SRC_URI[fontconfig-devel-doc.sha256sum] = "530497c58b64913af4d1736dbce3d6ad7f31a0d6088a04721ba25edf15956e9e"
RDEPENDS:fontconfig-devel-doc = " \
 fontconfig-devel \
"
