# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xcb-util-keysyms"
PE = "0"
PV = "0.4.1"
PR = "7.el10"
PACKAGES = "xcb-util-keysyms xcb-util-keysyms-devel"
PROVIDES = "rpm/xcb-util-keysyms rpm/xcb-util-keysyms-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xcb-util-keysyms-0.4.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7bce79015d2e540e10f7297a303173a454b4274709f3439d73b48e33fa02d9d"

URI_xcb-util-keysyms = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xcb-util-keysyms-0.4.1-7.el10.x86_64_v2.rpm;name=xcb-util-keysyms;unpack=0"
SRC_URI += "${URI_xcb-util-keysyms}"
SRC_URI[xcb-util-keysyms.sha256sum] = "a10e993d1076830e0efa006cd704c72e3728f9ef028c124f627b46a06a58f8ab"
RDEPENDS:xcb-util-keysyms = " \
 glibc \
 libxcb \
"

URI_xcb-util-keysyms-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xcb-util-keysyms-devel-0.4.1-7.el10.x86_64_v2.rpm;name=xcb-util-keysyms-devel;unpack=0"
SRC_URI += "${URI_xcb-util-keysyms-devel}"
SRC_URI[xcb-util-keysyms-devel.sha256sum] = "ef075c6b81bc28bdc22301fc39777642c77bf751178f2f80d6559b8dba91ce52"
RDEPENDS:xcb-util-keysyms-devel = " \
 libxcb-devel \
 pkgconf-pkg-config \
 xcb-util-keysyms \
"
