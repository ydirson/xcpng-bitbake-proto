# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-zstd"
PE = "0"
PV = "1.5.5.1"
PR = "5.el10"
PACKAGES = "python3-zstd"
PROVIDES = "rpm/python3-zstd"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-zstd-1.5.5.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b99eb65db53ebd5f5f51283ce4e798f77a27dfc0ef4ba1516910ee31bb63e9c"

URI_python3-zstd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-zstd-1.5.5.1-5.el10.x86_64_v2.rpm;name=python3-zstd;unpack=0"
SRC_URI += "${URI_python3-zstd}"
SRC_URI[python3-zstd.sha256sum] = "4634cbc9770ac950e222ca53a72bcb2dca8a8634f2146359ff19f267409b22c7"
RDEPENDS:python3-zstd = " \
 glibc \
 python3 \
 libzstd \
"
