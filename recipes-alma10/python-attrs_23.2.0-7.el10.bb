# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-attrs"
PE = "0"
PV = "23.2.0"
PR = "7.el10"
PACKAGES = "python3-attrs"
PROVIDES = "rpm/python3-attrs"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/python-attrs-23.2.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eec75b57f0e7163bfa4e45492594af3b316a0fe7595694af466cc0a36446c64c"

URI_python3-attrs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-attrs-23.2.0-7.el10.noarch.rpm;name=python3-attrs;unpack=0"
SRC_URI += "${URI_python3-attrs}"
SRC_URI[python3-attrs.sha256sum] = "933038f53d7726dbc49700c9a4b76fb59d14a723d115d0fadb9acb69212c46e5"
RDEPENDS:python3-attrs = " \
 python3 \
"
