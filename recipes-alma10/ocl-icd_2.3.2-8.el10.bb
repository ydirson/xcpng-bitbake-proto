# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ocl-icd"
PE = "0"
PV = "2.3.2"
PR = "8.el10"
PACKAGES = "ocl-icd ocl-icd-devel"
PROVIDES = "rpm/ocl-icd rpm/ocl-icd-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/ocl-icd-2.3.2-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "948081d838fd9b77cb50035a508caeebe17c51b683c11c65b3451a911de31c3e"

URI_ocl-icd = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/ocl-icd-2.3.2-8.el10.x86_64_v2.rpm;name=ocl-icd;unpack=0"
SRC_URI += "${URI_ocl-icd}"
SRC_URI[ocl-icd.sha256sum] = "03892a33768d07db2f8e564650a0cc84aaa10ef1ffeb895fd5939cf579c86865"
RDEPENDS:ocl-icd = " \
 glibc \
"

URI_ocl-icd-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocl-icd-devel-2.3.2-8.el10.x86_64_v2.rpm;name=ocl-icd-devel;unpack=0"
SRC_URI += "${URI_ocl-icd-devel}"
SRC_URI[ocl-icd-devel.sha256sum] = "c25f6fe7162cfd22c494cbc8fd136bf27faf3dda2061b3345da757e256833a1a"
RDEPENDS:ocl-icd-devel = " \
 glibc \
 ocl-icd \
 pkgconf-pkg-config \
 opencl-headers \
"
