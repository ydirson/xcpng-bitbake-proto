# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "squashfs-tools"
PE = "0"
PV = "4.6.1"
PR = "6.el10"
PACKAGES = "squashfs-tools"
PROVIDES = "rpm/squashfs-tools"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/squashfs-tools-4.6.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1fc684ec2445edd4d02d584917d060967739141fb825229a79266fc70e37d19d"

URI_squashfs-tools = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/squashfs-tools-4.6.1-6.el10.x86_64_v2.rpm;name=squashfs-tools;unpack=0"
SRC_URI += "${URI_squashfs-tools}"
SRC_URI[squashfs-tools.sha256sum] = "97765c6f098d474049dacca13ce55f9f3cd6d54d0af83bf34632aadf13dfd4ea"
RDEPENDS:squashfs-tools = " \
 zlib-ng-compat \
 lz4-libs \
 lzo \
 libgcc \
 libzstd \
 glibc \
 xz-libs \
"
