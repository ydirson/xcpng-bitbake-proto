# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-requests-oauthlib"
PE = "0"
PV = "1.3.1"
PR = "11.el10"
PACKAGES = "python3-requests-oauthlib"
PROVIDES = "rpm/python3-requests-oauthlib"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-requests-oauthlib-1.3.1-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3adaa14aa1240b4c32a2fb08be8d1c416f38224d3a70dddd746a91451e8edb56"

URI_python3-requests-oauthlib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-requests-oauthlib-1.3.1-11.el10.noarch.rpm;name=python3-requests-oauthlib;unpack=0"
SRC_URI += "${URI_python3-requests-oauthlib}"
SRC_URI[python3-requests-oauthlib.sha256sum] = "05c3728e693c5cca8be5c50b039ea96a18f45bac4df9ceb7640d348fe9652fb6"
RDEPENDS:python3-requests-oauthlib = " \
 python3 \
 python3-oauthlib \
 python3-requests \
"
