# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-trove-classifiers"
PE = "0"
PV = "2023.10.18"
PR = "5.el10"
PACKAGES = "python3-trove-classifiers"
PROVIDES = "rpm/python3-trove-classifiers"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/python-trove-classifiers-2023.10.18-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e2cb4317212c14e461a0c2a1648fc2cba5f8ef4f63efcb72de79b8de14d58a0"

URI_python3-trove-classifiers = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-trove-classifiers-2023.10.18-5.el10.noarch.rpm;name=python3-trove-classifiers;unpack=0"
SRC_URI += "${URI_python3-trove-classifiers}"
SRC_URI[python3-trove-classifiers.sha256sum] = "5a11d96e11efe2ed6440c46f890e5b45a3ae0760281509609cf8380ce109adf9"
RDEPENDS:python3-trove-classifiers = " \
 python3 \
"
