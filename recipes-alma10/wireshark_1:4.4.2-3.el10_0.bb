# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "wireshark"
PE = "1"
PV = "4.4.2"
PR = "3.el10_0"
PACKAGES = "wireshark wireshark-cli wireshark-devel"
PROVIDES = "rpm/wireshark rpm/wireshark-cli rpm/wireshark-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/wireshark-4.4.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7db7d9281e2064843dcc3a725b93cf352466ff55dfdb0eebd65003ec0b31058"

URI_wireshark = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/wireshark-4.4.2-3.el10_0.x86_64_v2.rpm;name=wireshark;unpack=0"
SRC_URI += "${URI_wireshark}"
SRC_URI[wireshark.sha256sum] = "29dd4bc9374c41b59fae7d643668eb201518772b382bff4c31521d2ad45a937e"
RDEPENDS:wireshark = " \
 libpcap \
 qt6-qtmultimedia \
 libgcc \
 libnl3 \
 libgcrypt \
 qt6-qtbase \
 speexdsp \
 xdg-utils \
 qt6-qt5compat \
 wireshark-cli \
 libstdc++ \
 qt6-qtbase-gui \
 glib2 \
 glibc \
 hicolor-icon-theme \
"

URI_wireshark-cli = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/wireshark-cli-4.4.2-3.el10_0.x86_64_v2.rpm;name=wireshark-cli;unpack=0"
SRC_URI += "${URI_wireshark-cli}"
SRC_URI[wireshark-cli.sha256sum] = "8c8991726afee32f06230f68f6412c05a5985d220a7991a78cc537e3f97aea0a"
RDEPENDS:wireshark-cli = " \
 libpcap \
 systemd-libs \
 krb5-libs \
 libssh \
 libcap \
 shadow-utils \
 zlib-ng-compat \
 gnutls \
 libgcc \
 libgcrypt \
 libxml2 \
 speexdsp \
 libzstd \
 bash \
 pcre2 \
 libsmi \
 glibc \
 c-ares \
 glib2 \
 libnghttp2 \
 libnl3 \
"

URI_wireshark-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/wireshark-devel-4.4.2-3.el10_0.x86_64_v2.rpm;name=wireshark-devel;unpack=0"
SRC_URI += "${URI_wireshark-devel}"
SRC_URI[wireshark-devel.sha256sum] = "e69b4a8568c7ca2d3121a8a85a776ab27a3bc12457806b03560db4d0cd0ff5eb"
RDEPENDS:wireshark-devel = " \
 glib2-devel \
 glibc-devel \
 pkgconf-pkg-config \
 wireshark \
 wireshark-cli \
"
