# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "plotutils"
PE = "0"
PV = "2.6"
PR = "37.el10"
PACKAGES = "plotutils plotutils-devel"
PROVIDES = "rpm/plotutils rpm/plotutils-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/plotutils-2.6-37.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d35224387c4f6d60c09abafbc2fdf7ed33105426ca6228f17e38e4e02149ffac"

URI_plotutils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/plotutils-2.6-37.el10.x86_64_v2.rpm;name=plotutils;unpack=0"
SRC_URI += "${URI_plotutils}"
SRC_URI[plotutils.sha256sum] = "a3c5f58232f661879363d3ebf019652bde925cea3b7056c3f5c8232190c25635"
RDEPENDS:plotutils = " \
 zlib-ng-compat \
 libpng \
 libXmu \
 libgcc \
 libICE \
 libSM \
 libX11 \
 libstdc++ \
 libXt \
 libXaw \
 glibc \
 libXext \
"

URI_plotutils-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plotutils-devel-2.6-37.el10.x86_64_v2.rpm;name=plotutils-devel;unpack=0"
SRC_URI += "${URI_plotutils-devel}"
SRC_URI[plotutils-devel.sha256sum] = "b5b8f075853e73827cb2dd2616a18f63896f66c91dba587ea6fb48352a99301c"
RDEPENDS:plotutils-devel = " \
 plotutils \
"
