# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Types-Serialiser"
PE = "0"
PV = "1.01"
PR = "14.el10"
PACKAGES = "perl-Types-Serialiser perl-Types-Serialiser-tests"
PROVIDES = "rpm/perl-Types-Serialiser rpm/perl-Types-Serialiser-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Types-Serialiser-1.01-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23d88825c6a512c56022c89624b9192c676347486867ea59fba7f141d5d41e2b"

URI_perl-Types-Serialiser = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Types-Serialiser-1.01-14.el10.noarch.rpm;name=perl-Types-Serialiser;unpack=0"
SRC_URI += "${URI_perl-Types-Serialiser}"
SRC_URI[perl-Types-Serialiser.sha256sum] = "53df8a6210e8d02641bf1a2baf7e4e270ce112c2b1fe91c60e26212a66365583"
RDEPENDS:perl-Types-Serialiser = " \
 perl-libs \
 perl-Carp \
 perl-Types-Serialiser \
 perl-common-sense \
 perl-overload \
"

URI_perl-Types-Serialiser-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Types-Serialiser-tests-1.01-14.el10.noarch.rpm;name=perl-Types-Serialiser-tests;unpack=0"
SRC_URI += "${URI_perl-Types-Serialiser-tests}"
SRC_URI[perl-Types-Serialiser-tests.sha256sum] = "9c98652c50a0821b8ff1d68a78d0617cb0330d2277b714f9574fe4df13360e92"
RDEPENDS:perl-Types-Serialiser-tests = " \
 perl-Types-Serialiser \
 perl-interpreter \
 perl-Test-Harness \
 bash \
"
