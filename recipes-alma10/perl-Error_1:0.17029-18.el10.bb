# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Error"
PE = "1"
PV = "0.17029"
PR = "18.el10"
PACKAGES = "perl-Error perl-Error-tests"
PROVIDES = "rpm/perl-Error rpm/perl-Error-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Error-0.17029-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bffa29bb2a69fa2784a0a5683200a4cc8c2983460f2312559972ba175928d9a9"

URI_perl-Error = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Error-0.17029-18.el10.noarch.rpm;name=perl-Error;unpack=0"
SRC_URI += "${URI_perl-Error}"
SRC_URI[perl-Error.sha256sum] = "a9e4f3346a6e8f4ff9b023039a50321727d3d6c11136de389e154ef3ed817f39"
RDEPENDS:perl-Error = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-overload \
 perl-Error \
 perl-Exporter \
"

URI_perl-Error-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Error-tests-0.17029-18.el10.noarch.rpm;name=perl-Error-tests;unpack=0"
SRC_URI += "${URI_perl-Error-tests}"
SRC_URI[perl-Error-tests.sha256sum] = "09d733973f5b70ce4264a6bc54a10c1f50eca4173604f623de5748defd2a2040"
RDEPENDS:perl-Error-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-vars \
 perl-IO \
 perl-IPC-Open3 \
 bash \
 perl-PathTools \
 perl-Error \
 perl-interpreter \
 perl-base \
 perl-lib \
"
