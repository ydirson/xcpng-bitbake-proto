# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-alembic"
PE = "0"
PV = "1.13.1"
PR = "7.el10"
PACKAGES = "python3-alembic"
PROVIDES = "rpm/python3-alembic"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-alembic-1.13.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7775216b40910d805c38dc18111d8178b907d58d7f8dde4b23c7f2a2d911c405"

URI_python3-alembic = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-alembic-1.13.1-7.el10.noarch.rpm;name=python3-alembic;unpack=0"
SRC_URI += "${URI_python3-alembic}"
SRC_URI[python3-alembic.sha256sum] = "31dd61ea1ccf189e3a970207c54c9ddec5391531d01b4a0bc293f75e77a91450"
RDEPENDS:python3-alembic = " \
 python3 \
 python3-sqlalchemy \
 python3-mako \
 python3-typing-extensions \
"
