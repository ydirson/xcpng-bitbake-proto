# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-mos"
PE = "0"
PV = "0.20101130"
PR = "30.el10"
PACKAGES = "hunspell-mos"
PROVIDES = "rpm/hunspell-mos"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-mos-0.20101130-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de49fbaa2c9742d370c224e70fb6014dd1e25e6dd2688b4f3c937fdbd965c9b0"

URI_hunspell-mos = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-mos-0.20101130-30.el10.noarch.rpm;name=hunspell-mos;unpack=0"
SRC_URI += "${URI_hunspell-mos}"
SRC_URI[hunspell-mos.sha256sum] = "77644b02e928a25c8a474980dfef23c1859b9266dd336b71ec311db93121b458"
RDEPENDS:hunspell-mos = " \
 hunspell-filesystem \
"
