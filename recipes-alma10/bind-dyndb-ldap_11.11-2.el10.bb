# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "bind-dyndb-ldap"
PE = "0"
PV = "11.11"
PR = "2.el10"
PACKAGES = "bind-dyndb-ldap"
PROVIDES = "rpm/bind-dyndb-ldap"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/bind-dyndb-ldap-11.11-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bdab1462202d7716ddf0a5e736414c6d9edd52c43b973e5d2a1311d2bad734f7"

URI_bind-dyndb-ldap = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/bind-dyndb-ldap-11.11-2.el10.x86_64_v2.rpm;name=bind-dyndb-ldap;unpack=0"
SRC_URI += "${URI_bind-dyndb-ldap}"
SRC_URI[bind-dyndb-ldap.sha256sum] = "ccf9d58ddb191a0316c2c7ea54946c1535954b62c96055b5357e5c7bd0eaeacb"
RDEPENDS:bind-dyndb-ldap = " \
 softhsm \
 libuuid \
 bind-libs \
 pkcs11-provider \
 krb5-libs \
 bash \
 glibc \
 bind \
 openldap \
"
