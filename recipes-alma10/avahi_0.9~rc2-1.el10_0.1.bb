# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "avahi"
PE = "0"
PV = "0.9~rc2"
PR = "1.el10_0.1"
PACKAGES = "avahi avahi-libs avahi-devel avahi-glib avahi-gobject avahi-tools avahi-compat-howl avahi-compat-howl-devel avahi-compat-libdns_sd avahi-compat-libdns_sd-devel avahi-glib-devel avahi-autoipd avahi-dnsconfd avahi-gobject-devel avahi-ui-devel avahi-ui-gtk3 avahi-ui-tools"
PROVIDES = "rpm/avahi rpm/avahi-libs rpm/avahi-devel rpm/avahi-glib rpm/avahi-gobject rpm/avahi-tools rpm/avahi-compat-howl rpm/avahi-compat-howl-devel rpm/avahi-compat-libdns_sd rpm/avahi-compat-libdns_sd-devel rpm/avahi-glib-devel rpm/avahi-autoipd rpm/avahi-dnsconfd rpm/avahi-gobject-devel rpm/avahi-ui-devel rpm/avahi-ui-gtk3 rpm/avahi-ui-tools"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/avahi-0.9~rc2-1.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "013a456256ec5cf20ab90ec6462e61685795910f7d45fab56650ca634ec3a731"

URI_avahi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/avahi-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=avahi;unpack=0"
SRC_URI += "${URI_avahi}"
SRC_URI[avahi.sha256sum] = "eb3cdaec6e7370b9f8a56f127e694fd03370b1262734cc59c3c17fbf9e90fc1e"
RDEPENDS:avahi = " \
 shadow-utils \
 systemd-libs \
 libcap \
 libdaemon \
 avahi-libs \
 bash \
 dbus \
 expat \
 glibc \
 coreutils \
 dbus-libs \
"

URI_avahi-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/avahi-libs-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=avahi-libs;unpack=0"
SRC_URI += "${URI_avahi-libs}"
SRC_URI[avahi-libs.sha256sum] = "a4ffd2ecdadc429a95c986d82a14bfbca6334de6ddf976b3abe51ef0d7312423"
RDEPENDS:avahi-libs = " \
 glibc \
 dbus-libs \
 libevent \
"

URI_avahi-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/avahi-devel-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=avahi-devel;unpack=0"
SRC_URI += "${URI_avahi-devel}"
SRC_URI[avahi-devel.sha256sum] = "c6fec4a0b2574e9d841b77ad42fa71913d930419d836bdef503d3e8039d7509a"
RDEPENDS:avahi-devel = " \
 pkgconf-pkg-config \
 avahi \
 avahi-libs \
 dbus-devel \
 libevent-devel \
"

URI_avahi-glib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/avahi-glib-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=avahi-glib;unpack=0"
SRC_URI += "${URI_avahi-glib}"
SRC_URI[avahi-glib.sha256sum] = "d9b22fb865c0eabb171bb4bb5c8617d4b78bad29541ab89e56097afe0fa3016f"
RDEPENDS:avahi-glib = " \
 glibc \
 avahi-libs \
 glib2 \
"

URI_avahi-gobject = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/avahi-gobject-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=avahi-gobject;unpack=0"
SRC_URI += "${URI_avahi-gobject}"
SRC_URI[avahi-gobject.sha256sum] = "a87c9396a21b2a8462e2421e5d488a7a25a3a103603a9e925736260d3f60b536"
RDEPENDS:avahi-gobject = " \
 avahi-glib \
 avahi-libs \
 glib2 \
 glibc \
 dbus-libs \
"

URI_avahi-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/avahi-tools-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=avahi-tools;unpack=0"
SRC_URI += "${URI_avahi-tools}"
SRC_URI[avahi-tools.sha256sum] = "067b4448bb97871c165045c43fabd72e4d14378eb180fecba949e246527d4611"
RDEPENDS:avahi-tools = " \
 glibc \
 avahi-libs \
 avahi \
 gdbm-libs \
"

URI_avahi-compat-howl = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/avahi-compat-howl-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=avahi-compat-howl;unpack=0"
SRC_URI += "${URI_avahi-compat-howl}"
SRC_URI[avahi-compat-howl.sha256sum] = "10fce60c0b6ae288657261fe925e74aae45061e3ff61ed8ad5d09e8f7573bdf1"
RDEPENDS:avahi-compat-howl = " \
 glibc \
 avahi-libs \
 dbus-libs \
"

URI_avahi-compat-howl-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/avahi-compat-howl-devel-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=avahi-compat-howl-devel;unpack=0"
SRC_URI += "${URI_avahi-compat-howl-devel}"
SRC_URI[avahi-compat-howl-devel.sha256sum] = "61baa291d218458eb9e3ba5e04c6b539d58ccebeb45270e3cef6608a7888ea43"
RDEPENDS:avahi-compat-howl-devel = " \
 avahi-compat-howl \
 avahi-devel \
 pkgconf-pkg-config \
"

URI_avahi-compat-libdns_sd = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/avahi-compat-libdns_sd-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=avahi-compat-libdns_sd;unpack=0"
SRC_URI += "${URI_avahi-compat-libdns_sd}"
SRC_URI[avahi-compat-libdns_sd.sha256sum] = "16881fdbc8a2037bc2ae4cbfe73ecffe6aa6502167093770b7a440e98dd35f4a"
RDEPENDS:avahi-compat-libdns_sd = " \
 glibc \
 avahi-libs \
 dbus-libs \
"

URI_avahi-compat-libdns_sd-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/avahi-compat-libdns_sd-devel-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=avahi-compat-libdns_sd-devel;unpack=0"
SRC_URI += "${URI_avahi-compat-libdns_sd-devel}"
SRC_URI[avahi-compat-libdns_sd-devel.sha256sum] = "2a66518400b1310d598c7e3e0230da33b88c668f7e51d7cfb6759e1dfa024deb"
RDEPENDS:avahi-compat-libdns_sd-devel = " \
 avahi-devel \
 avahi-compat-libdns_sd \
 pkgconf-pkg-config \
"

URI_avahi-glib-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/avahi-glib-devel-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=avahi-glib-devel;unpack=0"
SRC_URI += "${URI_avahi-glib-devel}"
SRC_URI[avahi-glib-devel.sha256sum] = "233842aec68fb2b494c0ea2bf7f79755956a04847137cdbc2a33cbba6050adc2"
RDEPENDS:avahi-glib-devel = " \
 avahi-glib \
 glib2-devel \
 pkgconf-pkg-config \
 avahi-devel \
"

URI_avahi-autoipd = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/avahi-autoipd-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=avahi-autoipd;unpack=0"
SRC_URI += "${URI_avahi-autoipd}"
SRC_URI[avahi-autoipd.sha256sum] = "2ec428bb58f9201e28506837b2a784b962d72051cebfc106d669e41a922d7464"
RDEPENDS:avahi-autoipd = " \
 shadow-utils \
 avahi-libs \
 bash \
 glibc \
 libdaemon \
"

URI_avahi-dnsconfd = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/avahi-dnsconfd-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=avahi-dnsconfd;unpack=0"
SRC_URI += "${URI_avahi-dnsconfd}"
SRC_URI[avahi-dnsconfd.sha256sum] = "bde08713f8ca3ee9c4a27f4ee0c52d745327a0f42ec8af2fcb4f3059d0ffb631"
RDEPENDS:avahi-dnsconfd = " \
 avahi \
 avahi-libs \
 bash \
 glibc \
 libdaemon \
"

URI_avahi-gobject-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/avahi-gobject-devel-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=avahi-gobject-devel;unpack=0"
SRC_URI += "${URI_avahi-gobject-devel}"
SRC_URI[avahi-gobject-devel.sha256sum] = "9a76bc0f2641e141edecb1b8b51e67e8c49740de2dec9f4ba85621ada51fabeb"
RDEPENDS:avahi-gobject-devel = " \
 glib2-devel \
 avahi-devel \
 pkgconf-pkg-config \
 avahi-gobject \
 avahi-glib-devel \
"

URI_avahi-ui-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/avahi-ui-devel-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=avahi-ui-devel;unpack=0"
SRC_URI += "${URI_avahi-ui-devel}"
SRC_URI[avahi-ui-devel.sha256sum] = "2098b3cb7ebebe61bd2f332e42cd5ca57c2412628db12b05a4646b71edeee186"
RDEPENDS:avahi-ui-devel = " \
 avahi-devel \
 pkgconf-pkg-config \
 avahi-glib-devel \
 gtk3-devel \
 avahi-ui-gtk3 \
"

URI_avahi-ui-gtk3 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/avahi-ui-gtk3-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=avahi-ui-gtk3;unpack=0"
SRC_URI += "${URI_avahi-ui-gtk3}"
SRC_URI[avahi-ui-gtk3.sha256sum] = "390e74a9b0e1bad5980087ebe337da78216da816ff204c0c9d0d73435c0d91aa"
RDEPENDS:avahi-ui-gtk3 = " \
 atk \
 cairo-gobject \
 harfbuzz \
 avahi-glib \
 pango \
 gdk-pixbuf2 \
 gdbm-libs \
 avahi-libs \
 cairo \
 glib2 \
 gtk3 \
 glibc \
 dbus-libs \
"

URI_avahi-ui-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/avahi-ui-tools-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=avahi-ui-tools;unpack=0"
SRC_URI += "${URI_avahi-ui-tools}"
SRC_URI[avahi-ui-tools.sha256sum] = "1e33c44cdd5cf5d597479521556d3b89abf08e63e135cc4769b9fb2f0e4ea1a5"
RDEPENDS:avahi-ui-tools = " \
 openssh-clients \
 gnome-connections \
 avahi-glib \
 avahi \
 avahi-libs \
 glib2 \
 gtk3 \
 glibc \
 avahi-ui-gtk3 \
"
