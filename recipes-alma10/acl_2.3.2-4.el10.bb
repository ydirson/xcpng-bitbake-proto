# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "acl"
PE = "0"
PV = "2.3.2"
PR = "4.el10"
PACKAGES = "acl libacl libacl-devel"
PROVIDES = "rpm/acl rpm/libacl rpm/libacl-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/acl-2.3.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c509daedaece4fd86e18d60ba06567057db32f0a01414ef441af91d4c669ab0"

URI_acl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/acl-2.3.2-4.el10.x86_64_v2.rpm;name=acl;unpack=0"
SRC_URI += "${URI_acl}"
SRC_URI[acl.sha256sum] = "5099687b7f22987f762d21e1b07eeba2078535d8933ff97ee1eb3a2e112878f0"
RDEPENDS:acl = " \
 glibc \
 libacl \
"

URI_libacl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libacl-2.3.2-4.el10.x86_64_v2.rpm;name=libacl;unpack=0"
SRC_URI += "${URI_libacl}"
SRC_URI[libacl.sha256sum] = "a0b2714264b25a1382a5cb65c1e700debc17e2c3df1d59d9fe85efdee02ce9ed"
RDEPENDS:libacl = " \
 glibc \
 libattr \
"

URI_libacl-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libacl-devel-2.3.2-4.el10.x86_64_v2.rpm;name=libacl-devel;unpack=0"
SRC_URI += "${URI_libacl-devel}"
SRC_URI[libacl-devel.sha256sum] = "58493805d1f1d658b24b07ea834e7082ac4b7ca6211e5b3a787e854ce0d16b1a"
RDEPENDS:libacl-devel = " \
 libacl \
 pkgconf-pkg-config \
 libattr-devel \
"
