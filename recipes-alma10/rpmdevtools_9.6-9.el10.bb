# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rpmdevtools"
PE = "0"
PV = "9.6"
PR = "9.el10"
PACKAGES = "rpmdevtools"
PROVIDES = "rpm/rpmdevtools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/rpmdevtools-9.6-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1cde85978848f5f77ccf339e0e4cf0b4792b86a53fd3dea58c31bff4113e1ab3"

URI_rpmdevtools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rpmdevtools-9.6-9.el10.noarch.rpm;name=rpmdevtools;unpack=0"
SRC_URI += "${URI_rpmdevtools}"
SRC_URI[rpmdevtools.sha256sum] = "eec8370b135caabd3b4a01aa9c24fdd11549397bf4bf314aded905966b2b899e"
RDEPENDS:rpmdevtools = " \
 python3 \
 emacs-filesystem \
 python3-requests \
 python3-rpm \
 diffutils \
 gawk \
 grep \
 curl \
 python3-argcomplete \
 rpm-build \
 bash \
 sed \
 file \
 findutils \
"
