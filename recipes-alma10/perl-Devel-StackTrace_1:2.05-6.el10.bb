# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Devel-StackTrace"
PE = "1"
PV = "2.05"
PR = "6.el10"
PACKAGES = "perl-Devel-StackTrace perl-Devel-StackTrace-tests"
PROVIDES = "rpm/perl-Devel-StackTrace rpm/perl-Devel-StackTrace-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Devel-StackTrace-2.05-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18ab7663655ca9c51714d63ed3fa294c0ed57132921310f19e0005343f291875"

URI_perl-Devel-StackTrace = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Devel-StackTrace-2.05-6.el10.noarch.rpm;name=perl-Devel-StackTrace;unpack=0"
SRC_URI += "${URI_perl-Devel-StackTrace}"
SRC_URI[perl-Devel-StackTrace.sha256sum] = "4090588db2038c9173c4b8f48b52a3b7d89a4b5c8291710f89831677eb698542"
RDEPENDS:perl-Devel-StackTrace = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-overload \
 perl-PathTools \
 perl-Devel-StackTrace \
"

URI_perl-Devel-StackTrace-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Devel-StackTrace-tests-2.05-6.el10.noarch.rpm;name=perl-Devel-StackTrace-tests;unpack=0"
SRC_URI += "${URI_perl-Devel-StackTrace-tests}"
SRC_URI[perl-Devel-StackTrace-tests.sha256sum] = "d60ff2c04fc48806fd3fd9cfbd4d6cbe4747fcb4872837e8350505c06a989e40"
RDEPENDS:perl-Devel-StackTrace-tests = " \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 perl-ExtUtils-MakeMaker \
 perl-Test-Simple \
 perl-overload \
 perl-PathTools \
 bash \
 perl-Devel-StackTrace \
 perl-interpreter \
 perl-base \
"
