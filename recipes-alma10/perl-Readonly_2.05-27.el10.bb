# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Readonly"
PE = "0"
PV = "2.05"
PR = "27.el10"
PACKAGES = "perl-Readonly perl-Readonly-tests"
PROVIDES = "rpm/perl-Readonly rpm/perl-Readonly-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Readonly-2.05-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0c7af7b31c3ef9696551318efd97519270e4474c20d0d8f2f6322988bcba963"

URI_perl-Readonly = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Readonly-2.05-27.el10.noarch.rpm;name=perl-Readonly;unpack=0"
SRC_URI += "${URI_perl-Readonly}"
SRC_URI[perl-Readonly.sha256sum] = "a1f5d72b5fbe6be78c1d1da786191d504c911a5c4dbcba1a1932c088d057c5b3"
RDEPENDS:perl-Readonly = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-Storable \
 perl-Exporter \
"

URI_perl-Readonly-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Readonly-tests-2.05-27.el10.noarch.rpm;name=perl-Readonly-tests;unpack=0"
SRC_URI += "${URI_perl-Readonly-tests}"
SRC_URI[perl-Readonly-tests.sha256sum] = "77c14dd5f52bf3c4182f1dd345c49cb2fb098e466fe1d55b021eff0e53734634"
RDEPENDS:perl-Readonly-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-vars \
 perl-Readonly \
 bash \
 perl-interpreter \
 perl-lib \
"
