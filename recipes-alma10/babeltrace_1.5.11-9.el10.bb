# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "babeltrace"
PE = "0"
PV = "1.5.11"
PR = "9.el10"
PACKAGES = "libbabeltrace libbabeltrace-devel python3-babeltrace babeltrace"
PROVIDES = "rpm/libbabeltrace rpm/libbabeltrace-devel rpm/python3-babeltrace rpm/babeltrace"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/babeltrace-1.5.11-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d29bd14395a33b0bd082c4779a70de564947ea7c88babbe52270e72c0c5d79f0"

URI_libbabeltrace = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libbabeltrace-1.5.11-9.el10.x86_64_v2.rpm;name=libbabeltrace;unpack=0"
SRC_URI += "${URI_libbabeltrace}"
SRC_URI[libbabeltrace.sha256sum] = "9aa05d297ac2140ccd73c3fe4cd54546472a79616fe0c6b4c60a0ce0bcba2f5f"
RDEPENDS:libbabeltrace = " \
 libuuid \
 elfutils-libelf \
 elfutils-libs \
 glib2 \
 popt \
 glibc \
"

URI_libbabeltrace-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libbabeltrace-devel-1.5.11-9.el10.x86_64_v2.rpm;name=libbabeltrace-devel;unpack=0"
SRC_URI += "${URI_libbabeltrace-devel}"
SRC_URI[libbabeltrace-devel.sha256sum] = "eb4444709853a56f63010ecd61de5591992dbb88eb30e63fe6a94212daa42212"
RDEPENDS:libbabeltrace-devel = " \
 glib2-devel \
 libbabeltrace \
 pkgconf-pkg-config \
 libuuid-devel \
 popt-devel \
 libbabeltrace-devel \
"

URI_python3-babeltrace = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-babeltrace-1.5.11-9.el10.x86_64_v2.rpm;name=python3-babeltrace;unpack=0"
SRC_URI += "${URI_python3-babeltrace}"
SRC_URI[python3-babeltrace.sha256sum] = "b758c5f2fea9f42b4569be18e5b3a2734960132b005c0caa2fdfc371766db579"
RDEPENDS:python3-babeltrace = " \
 glibc \
 python3 \
 libbabeltrace \
"

URI_babeltrace = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/babeltrace-1.5.11-9.el10.x86_64_v2.rpm;name=babeltrace;unpack=0"
SRC_URI += "${URI_babeltrace}"
SRC_URI[babeltrace.sha256sum] = "4d47af1ce25b4b5dc8d261e8f875cb2632ccfbb45f401fe8ae0ba60c33ba87cf"
RDEPENDS:babeltrace = " \
 libuuid \
 libbabeltrace \
 popt \
 glib2 \
 glibc \
"
