# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-ia"
PE = "0"
PV = "0.20050226"
PR = "33.el10"
PACKAGES = "hunspell-ia"
PROVIDES = "rpm/hunspell-ia"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-ia-0.20050226-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "352f8dc53479a35e7f8d9c5362d9ada1512f11d6fa8b9213a30f5e66ba7d9703"

URI_hunspell-ia = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-ia-0.20050226-33.el10.noarch.rpm;name=hunspell-ia;unpack=0"
SRC_URI += "${URI_hunspell-ia}"
SRC_URI[hunspell-ia.sha256sum] = "2bb82e0c47771e8f0b3e6259c63bcff1585610b5e51b15477d88dfe3dcc1a83b"
RDEPENDS:hunspell-ia = " \
 hunspell-filesystem \
"
