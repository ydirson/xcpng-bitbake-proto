# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-urwid"
PE = "0"
PV = "2.5.3"
PR = "4.el10"
PACKAGES = "python3-urwid"
PROVIDES = "rpm/python3-urwid"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/python-urwid-2.5.3-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7282cdbef56472d123c5ceff770b818c268c260de37b3bbd562d9c5f36db7a3"

URI_python3-urwid = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-urwid-2.5.3-4.el10.x86_64_v2.rpm;name=python3-urwid;unpack=0"
SRC_URI += "${URI_python3-urwid}"
SRC_URI[python3-urwid.sha256sum] = "4859cbb0b5a96e5d93e77216941b749d8a2e8886e88c212f0fe605ef8c17ae3f"
RDEPENDS:python3-urwid = " \
 glibc \
 python3-wcwidth \
 python3 \
 python3-typing-extensions \
"
