# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "bubblewrap"
PE = "0"
PV = "0.10.0"
PR = "3.el10"
PACKAGES = "bubblewrap"
PROVIDES = "rpm/bubblewrap"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/bubblewrap-0.10.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84b21b8f7c98f19a85e0d6507671a07e8e5b892bef833328d3bb698e29e8cd61"

URI_bubblewrap = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/bubblewrap-0.10.0-3.el10.x86_64_v2.rpm;name=bubblewrap;unpack=0"
SRC_URI += "${URI_bubblewrap}"
SRC_URI[bubblewrap.sha256sum] = "51aec01bc88a9fe8162c0cda4979492cf53a8f392a8eee99828164a269011104"
RDEPENDS:bubblewrap = " \
 glibc \
 libselinux \
 libgcc \
 libcap \
"
