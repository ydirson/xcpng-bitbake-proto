# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "c2esp"
PE = "0"
PV = "2.7"
PR = "34.el10"
PACKAGES = "c2esp"
PROVIDES = "rpm/c2esp"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/c2esp-2.7-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95d6ceabcca718b0654664b7e07871a39101f2693762aba3a42eed31787ce476"

URI_c2esp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/c2esp-2.7-34.el10.x86_64_v2.rpm;name=c2esp;unpack=0"
SRC_URI += "${URI_c2esp}"
SRC_URI[c2esp.sha256sum] = "30dcaa46b25ba3abce17e821a8740fd5564f1df8d18a3df0a9c39e65a90b9abc"
RDEPENDS:c2esp = " \
 zlib-ng-compat \
 cups-filesystem \
 cups-libs \
 jbigkit-libs \
 libcupsfilters \
 glibc \
 libppd \
"
