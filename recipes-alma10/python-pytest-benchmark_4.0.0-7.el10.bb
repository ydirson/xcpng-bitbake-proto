# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-pytest-benchmark"
PE = "0"
PV = "4.0.0"
PR = "7.el10"
PACKAGES = "python3-pytest-benchmark"
PROVIDES = "rpm/python3-pytest-benchmark"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/python-pytest-benchmark-4.0.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5639c3a7611421fe4aa702f3b4a74338105883bc342631e20dcd41a91d76cb21"

URI_python3-pytest-benchmark = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-pytest-benchmark-4.0.0-7.el10.noarch.rpm;name=python3-pytest-benchmark;unpack=0"
SRC_URI += "${URI_python3-pytest-benchmark}"
SRC_URI[python3-pytest-benchmark.sha256sum] = "defba7fef53dadaff753d959a65d24f1075a1e9e034f9614cb3117fd8de38fca"
RDEPENDS:python3-pytest-benchmark = " \
 python3 \
 python3-cpuinfo \
 python3-pytest \
"
