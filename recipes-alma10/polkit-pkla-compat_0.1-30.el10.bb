# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "polkit-pkla-compat"
PE = "0"
PV = "0.1"
PR = "30.el10"
PACKAGES = "polkit-pkla-compat"
PROVIDES = "rpm/polkit-pkla-compat"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/polkit-pkla-compat-0.1-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1f31d63d5d6d67570a809a9d7537924ec7ce85862b29f7c474f3592b3ea96c1"

URI_polkit-pkla-compat = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/polkit-pkla-compat-0.1-30.el10.x86_64_v2.rpm;name=polkit-pkla-compat;unpack=0"
SRC_URI += "${URI_polkit-pkla-compat}"
SRC_URI[polkit-pkla-compat.sha256sum] = "a428797addc9848813c96db43ad26bf69e58b98a19ddb34c6955cf5a37b52140"
RDEPENDS:polkit-pkla-compat = " \
 glibc \
 polkit \
 polkit-libs \
 glib2 \
"
