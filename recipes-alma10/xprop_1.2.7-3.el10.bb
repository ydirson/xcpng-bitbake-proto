# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xprop"
PE = "0"
PV = "1.2.7"
PR = "3.el10"
PACKAGES = "xprop"
PROVIDES = "rpm/xprop"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xprop-1.2.7-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85dd471c03c6c746fcb5086140116ef5f7935a4cdd3931bc936b2100e03d33ed"

URI_xprop = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xprop-1.2.7-3.el10.x86_64_v2.rpm;name=xprop;unpack=0"
SRC_URI += "${URI_xprop}"
SRC_URI[xprop.sha256sum] = "7100995bfba294290ca0693cf74a049d29fb3de065908ea0af40d4a57102d16c"
RDEPENDS:xprop = " \
 glibc \
 libX11 \
"
