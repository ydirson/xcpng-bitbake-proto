# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "icu"
PE = "0"
PV = "74.2"
PR = "5.el10_0"
PACKAGES = "libicu icu libicu-devel libicu-doc"
PROVIDES = "rpm/libicu rpm/icu rpm/libicu-devel rpm/libicu-doc"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/icu-74.2-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "918141828861cac1cf6e3a171a33f984b6f1928b52553bf2d548ba0d7b28822c"

URI_libicu = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libicu-74.2-5.el10_0.x86_64_v2.rpm;name=libicu;unpack=0"
SRC_URI += "${URI_libicu}"
SRC_URI[libicu.sha256sum] = "9cfd087e77da931ea76af6a825dcb0e29a36bbe11295ad8a8994b121242f5fc8"
RDEPENDS:libicu = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_icu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/icu-74.2-5.el10_0.x86_64_v2.rpm;name=icu;unpack=0"
SRC_URI += "${URI_icu}"
SRC_URI[icu.sha256sum] = "14dd672cbca744c06e47607a3ce95089f05d4cc8aebeb45bd8ed58af1f0ce8a3"
RDEPENDS:icu = " \
 glibc \
 libicu \
 libgcc \
 libstdc++ \
"

URI_libicu-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libicu-devel-74.2-5.el10_0.x86_64_v2.rpm;name=libicu-devel;unpack=0"
SRC_URI += "${URI_libicu-devel}"
SRC_URI[libicu-devel.sha256sum] = "fab8ed71b550ef77f5ceb5c4f3017b6720c98548d5e287b1a0c90c8950ae0636"
RDEPENDS:libicu-devel = " \
 libicu-devel \
 pkgconf-pkg-config \
 bash \
 glibc \
 libicu \
"

URI_libicu-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libicu-doc-74.2-5.el10_0.noarch.rpm;name=libicu-doc;unpack=0"
SRC_URI += "${URI_libicu-doc}"
SRC_URI[libicu-doc.sha256sum] = "b0b2f358413387777db351a1b63b8a2a0dcd86dd1cf193042c0dddf55b01b8ef"
RDEPENDS:libicu-doc = ""
