# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "psutils"
PE = "0"
PV = "2.10"
PR = "7.el10"
PACKAGES = "psutils psutils-tests"
PROVIDES = "rpm/psutils rpm/psutils-tests"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/psutils-2.10-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7e19298c9e12873046c19aa2168d8f16acda74f5b056645adf65f5fb715c00d"

URI_psutils = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/psutils-2.10-7.el10.noarch.rpm;name=psutils;unpack=0"
SRC_URI += "${URI_psutils}"
SRC_URI[psutils.sha256sum] = "c8b358b4e087066a44096a633234129307c861f0bbc54a293ef272bb73279ce0"
RDEPENDS:psutils = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-IPC-Run3 \
 perl-Fcntl \
 perl-Getopt-Long \
 perl-File-Basename \
 perl-POSIX \
 paper \
 perl-File-Copy \
 perl-PathTools \
 perl-Exporter \
 perl-interpreter \
 perl-base \
 perl-File-Temp \
"

URI_psutils-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/psutils-tests-2.10-7.el10.noarch.rpm;name=psutils-tests;unpack=0"
SRC_URI += "${URI_psutils-tests}"
SRC_URI[psutils-tests.sha256sum] = "c2f7c2b71612603b5117bc06056ce88c45fd8ec79de55fd1ad59e4d7da596c11"
RDEPENDS:psutils-tests = " \
 diffutils \
 make \
 bash \
 coreutils \
 psutils \
"
