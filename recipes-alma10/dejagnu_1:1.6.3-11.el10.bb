# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dejagnu"
PE = "1"
PV = "1.6.3"
PR = "11.el10"
PACKAGES = "dejagnu"
PROVIDES = "rpm/dejagnu"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/dejagnu-1.6.3-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "89d0bbd44087ab32c2c653e8e4b73d0f5b53c05410eda2317755849954b60c37"

URI_dejagnu = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/dejagnu-1.6.3-11.el10.noarch.rpm;name=dejagnu;unpack=0"
SRC_URI += "${URI_dejagnu}"
SRC_URI[dejagnu.sha256sum] = "969730168b90e214c2fdc761f771fcfd0627feed53898df026e30884b7db54a2"
RDEPENDS:dejagnu = " \
 expect \
 bash \
"
