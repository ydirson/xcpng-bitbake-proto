# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-kn"
PE = "0"
PV = "1.0.3"
PR = "33.el10"
PACKAGES = "hunspell-kn"
PROVIDES = "rpm/hunspell-kn"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-kn-1.0.3-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8eeaca26cc88c4494124740b50ee00841fffcecfc6cd822c1f80ef7f026c008f"

URI_hunspell-kn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-kn-1.0.3-33.el10.noarch.rpm;name=hunspell-kn;unpack=0"
SRC_URI += "${URI_hunspell-kn}"
SRC_URI[hunspell-kn.sha256sum] = "d03b40f8b05c81f53ede38d39171e0724f8422d36aaf6ce150c09983eeec3bbe"
RDEPENDS:hunspell-kn = " \
 hunspell-filesystem \
"
