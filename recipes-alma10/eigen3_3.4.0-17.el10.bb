# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "eigen3"
PE = "0"
PV = "3.4.0"
PR = "17.el10"
PACKAGES = "eigen3-devel eigen3-doc"
PROVIDES = "rpm/eigen3-devel rpm/eigen3-doc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/eigen3-3.4.0-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f0ad2b555dd8c6ff0646a92098fff49d148d66b0225d2e5d87cae371c91161d"

URI_eigen3-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/eigen3-devel-3.4.0-17.el10.noarch.rpm;name=eigen3-devel;unpack=0"
SRC_URI += "${URI_eigen3-devel}"
SRC_URI[eigen3-devel.sha256sum] = "91ede5f5f43dbb74a98a4aeb6027bb80cc835c2b2254760cda5f451362588449"
RDEPENDS:eigen3-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
"

URI_eigen3-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/eigen3-doc-3.4.0-17.el10.noarch.rpm;name=eigen3-doc;unpack=0"
SRC_URI += "${URI_eigen3-doc}"
SRC_URI[eigen3-doc.sha256sum] = "460813d059215e116cf3e0d42bebfd0e26ea549b912e12b750d55299629c5c8f"
RDEPENDS:eigen3-doc = " \
 eigen3-devel \
"
