# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libpanel"
PE = "0"
PV = "1.8.1"
PR = "1.el10"
PACKAGES = "libpanel libpanel-devel"
PROVIDES = "rpm/libpanel rpm/libpanel-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libpanel-1.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e7e3c1d9bf144389813ed762e4fbf3e782a5b73c518ed261bbcc50307dadfa1"

URI_libpanel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libpanel-1.8.1-1.el10.x86_64_v2.rpm;name=libpanel;unpack=0"
SRC_URI += "${URI_libpanel}"
SRC_URI[libpanel.sha256sum] = "03b89e849f1f648185af689ee95f784382ece958d99bf8aef2e778cd33d1c93a"
RDEPENDS:libpanel = " \
 cairo \
 glib2 \
 graphene \
 glibc \
 gtk4 \
 hicolor-icon-theme \
 libadwaita \
"

URI_libpanel-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libpanel-devel-1.8.1-1.el10.x86_64_v2.rpm;name=libpanel-devel;unpack=0"
SRC_URI += "${URI_libpanel-devel}"
SRC_URI[libpanel-devel.sha256sum] = "a3bd77b865f3e162fb64d7b823c086a43bf7b22d9b5f67b55c875748fcc178d9"
RDEPENDS:libpanel-devel = " \
 glib2-devel \
 libpanel \
 pkgconf-pkg-config \
 libadwaita-devel \
 gtk4-devel \
"
