# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rpcbind"
PE = "0"
PV = "1.2.7"
PR = "3.el10"
PACKAGES = "rpcbind"
PROVIDES = "rpm/rpcbind"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/rpcbind-1.2.7-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ba30818cf49aa930175a845975a5b7d4dcda12234523db8b6f710c3aa918455"

URI_rpcbind = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/rpcbind-1.2.7-3.el10.x86_64_v2.rpm;name=rpcbind;unpack=0"
SRC_URI += "${URI_rpcbind}"
SRC_URI[rpcbind.sha256sum] = "c18911716f741ff3c2dace229791088c7cfa39e8628668c491185804fcba717a"
RDEPENDS:rpcbind = " \
 glibc-common \
 setup \
 shadow-utils \
 systemd \
 systemd-libs \
 libtirpc \
 bash \
 glibc \
 coreutils \
"
