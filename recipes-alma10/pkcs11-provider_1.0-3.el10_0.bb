# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pkcs11-provider"
PE = "0"
PV = "1.0"
PR = "3.el10_0"
PACKAGES = "pkcs11-provider"
PROVIDES = "rpm/pkcs11-provider"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/pkcs11-provider-1.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca9bac1c55fd915cd44daa63bb19ee7a0380b7069a7f5214fa396b6c11169cc4"

URI_pkcs11-provider = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/pkcs11-provider-1.0-3.el10_0.x86_64_v2.rpm;name=pkcs11-provider;unpack=0"
SRC_URI += "${URI_pkcs11-provider}"
SRC_URI[pkcs11-provider.sha256sum] = "20b93681ff6577a4fc2897d507a72724b01c351ae0b36831db8a0a1331c4c07b"
RDEPENDS:pkcs11-provider = " \
 glibc \
 openssl-libs \
"
