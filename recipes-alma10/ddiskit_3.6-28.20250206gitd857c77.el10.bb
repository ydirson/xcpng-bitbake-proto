# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ddiskit"
PE = "0"
PV = "3.6"
PR = "28.20250206gitd857c77.el10"
PACKAGES = "ddiskit"
PROVIDES = "rpm/ddiskit"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ddiskit-3.6-28.20250206gitd857c77.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "346aaa63d4089c1141bcc3a38744c7f471cbd159dd56ed781c61f46ffcb7ced8"

URI_ddiskit = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ddiskit-3.6-28.20250206gitd857c77.el10.noarch.rpm;name=ddiskit;unpack=0"
SRC_URI += "${URI_ddiskit}"
SRC_URI[ddiskit.sha256sum] = "85dfea9243035deed19e9dfc5d79929a0f5bb5f39e3112b86b4a2ced29af6644"
RDEPENDS:ddiskit = " \
 python3 \
 rpm \
 createrepo_c \
 xorriso \
"
