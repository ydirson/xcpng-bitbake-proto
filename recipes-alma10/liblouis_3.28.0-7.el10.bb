# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "liblouis"
PE = "0"
PV = "3.28.0"
PR = "7.el10"
PACKAGES = "liblouis liblouis-tables python3-louis liblouis-devel liblouis-doc liblouis-utils"
PROVIDES = "rpm/liblouis rpm/liblouis-tables rpm/python3-louis rpm/liblouis-devel rpm/liblouis-doc rpm/liblouis-utils"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/liblouis-3.28.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb40774060c14f864118fe4a02c993839501ea9b7f269294721450b483637977"

URI_liblouis = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/liblouis-3.28.0-7.el10.x86_64_v2.rpm;name=liblouis;unpack=0"
SRC_URI += "${URI_liblouis}"
SRC_URI[liblouis.sha256sum] = "52aa1c5f5fddee767dfbd86e848fbaaae025ddce6e8c7c7e03e02b736c0423ae"
RDEPENDS:liblouis = " \
 glibc \
 liblouis-tables \
"

URI_liblouis-tables = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/liblouis-tables-3.28.0-7.el10.noarch.rpm;name=liblouis-tables;unpack=0"
SRC_URI += "${URI_liblouis-tables}"
SRC_URI[liblouis-tables.sha256sum] = "288666c6d4e832748c50f2b37ad36624ee319015b1e46af0854da6b27baf56f3"
RDEPENDS:liblouis-tables = ""

URI_python3-louis = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-louis-3.28.0-7.el10.noarch.rpm;name=python3-louis;unpack=0"
SRC_URI += "${URI_python3-louis}"
SRC_URI[python3-louis.sha256sum] = "7da2984cf966aeeb99bf8be177aca1e8ebcfa60f6a7fca3e46fb06dc66de31e1"
RDEPENDS:python3-louis = " \
 python3 \
 liblouis \
"

URI_liblouis-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/liblouis-devel-3.28.0-7.el10.x86_64_v2.rpm;name=liblouis-devel;unpack=0"
SRC_URI += "${URI_liblouis-devel}"
SRC_URI[liblouis-devel.sha256sum] = "40b9cef899a58b2e268a2a9e912cb263c73c81f62d5f9af427144af8636d0b02"
RDEPENDS:liblouis-devel = " \
 pkgconf-pkg-config \
 liblouis \
"

URI_liblouis-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/liblouis-doc-3.28.0-7.el10.noarch.rpm;name=liblouis-doc;unpack=0"
SRC_URI += "${URI_liblouis-doc}"
SRC_URI[liblouis-doc.sha256sum] = "09950809f5d81489f82e33ed0482cfd5eb8f054e62929d3b22cdb0874e37032c"
RDEPENDS:liblouis-doc = " \
 liblouis \
"

URI_liblouis-utils = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/liblouis-utils-3.28.0-7.el10.x86_64_v2.rpm;name=liblouis-utils;unpack=0"
SRC_URI += "${URI_liblouis-utils}"
SRC_URI[liblouis-utils.sha256sum] = "2c5a16ef2683407d44b1f11339015ad97b948341c85aff07bf91b577060a8d0d"
RDEPENDS:liblouis-utils = " \
 glibc \
 libyaml \
 liblouis \
"
