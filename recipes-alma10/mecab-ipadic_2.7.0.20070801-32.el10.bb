# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mecab-ipadic"
PE = "0"
PV = "2.7.0.20070801"
PR = "32.el10"
PACKAGES = "mecab-ipadic mecab-ipadic-EUCJP"
PROVIDES = "rpm/mecab-ipadic rpm/mecab-ipadic-EUCJP"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mecab-ipadic-2.7.0.20070801-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a18df1c9f5a83bd6b8382df46ef8ded7cb931114716127c08c7161ce3a2c7453"

URI_mecab-ipadic = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mecab-ipadic-2.7.0.20070801-32.el10.x86_64_v2.rpm;name=mecab-ipadic;unpack=0"
SRC_URI += "${URI_mecab-ipadic}"
SRC_URI[mecab-ipadic.sha256sum] = "686ab4406266700d15ac7785465b84534a30fc977bdee59533d1b88e44abc769"
RDEPENDS:mecab-ipadic = " \
 bash \
 mecab \
"

URI_mecab-ipadic-EUCJP = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mecab-ipadic-EUCJP-2.7.0.20070801-32.el10.x86_64_v2.rpm;name=mecab-ipadic-EUCJP;unpack=0"
SRC_URI += "${URI_mecab-ipadic-EUCJP}"
SRC_URI[mecab-ipadic-EUCJP.sha256sum] = "06c70ad5d24603757fb80937ae061efa4119b231f52a66e06116cdcedbee1931"
RDEPENDS:mecab-ipadic-EUCJP = " \
 bash \
 mecab \
"
