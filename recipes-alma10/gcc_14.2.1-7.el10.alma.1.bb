# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gcc"
PE = "0"
PV = "14.2.1"
PR = "7.el10.alma.1"
PACKAGES = "libatomic libgcc libgfortran libgomp libquadmath libstdc++ cpp gcc gcc-c++ gcc-gfortran gcc-offload-amdgcn gcc-offload-nvptx gcc-plugin-annobin libasan libgccjit libgccjit-devel libgomp-offload-amdgcn libgomp-offload-nvptx libhwasan libitm libitm-devel liblsan libquadmath-devel libstdc++-devel libstdc++-docs libtsan libubsan gcc-plugin-devel libgfortran-static libquadmath-static libstdc++-static gcc-gdb-plugin libasan-static libatomic-static libhwasan-static libitm-static liblsan-static libtsan-static libubsan-static"
PROVIDES = "rpm/libatomic rpm/libgcc rpm/libgfortran rpm/libgomp rpm/libquadmath rpm/libstdc++ rpm/cpp rpm/gcc rpm/gcc-c++ rpm/gcc-gfortran rpm/gcc-offload-amdgcn rpm/gcc-offload-nvptx rpm/gcc-plugin-annobin rpm/libasan rpm/libgccjit rpm/libgccjit-devel rpm/libgomp-offload-amdgcn rpm/libgomp-offload-nvptx rpm/libhwasan rpm/libitm rpm/libitm-devel rpm/liblsan rpm/libquadmath-devel rpm/libstdc++-devel rpm/libstdc++-docs rpm/libtsan rpm/libubsan rpm/gcc-plugin-devel rpm/libgfortran-static rpm/libquadmath-static rpm/libstdc++-static rpm/gcc-gdb-plugin rpm/libasan-static rpm/libatomic-static rpm/libhwasan-static rpm/libitm-static rpm/liblsan-static rpm/libtsan-static rpm/libubsan-static"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/gcc-14.2.1-7.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e87913c821707393bebc144d6667d1cb9097785a200668428766eef9a6dc0d56"

URI_libatomic = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libatomic-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libatomic;unpack=0"
SRC_URI += "${URI_libatomic}"
SRC_URI[libatomic.sha256sum] = "f7209408de7d4e5c04699ce4ee5501b9bc4641c3257882870bbdb808812a6077"
RDEPENDS:libatomic = " \
 glibc \
"

URI_libgcc = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libgcc-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libgcc;unpack=0"
SRC_URI += "${URI_libgcc}"
SRC_URI[libgcc.sha256sum] = "4946f476ee4ac5432da625bd0c91341b348db6843b55cbac3e3f4996d532deed"
RDEPENDS:libgcc = ""

URI_libgfortran = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libgfortran-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libgfortran;unpack=0"
SRC_URI += "${URI_libgfortran}"
SRC_URI[libgfortran.sha256sum] = "89ff209b8febd1e73e57588f4bc83c15ba7f8f48d67bf8a867a806f7e4a0c37b"
RDEPENDS:libgfortran = " \
 glibc \
 libgcc \
"

URI_libgomp = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libgomp-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libgomp;unpack=0"
SRC_URI += "${URI_libgomp}"
SRC_URI[libgomp.sha256sum] = "998c5c0b550e7990bb1ce543450ca1b40741d4b51c850e9f1f991f05bfdcd782"
RDEPENDS:libgomp = " \
 glibc \
"

URI_libquadmath = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libquadmath-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libquadmath;unpack=0"
SRC_URI += "${URI_libquadmath}"
SRC_URI[libquadmath.sha256sum] = "5ba9e554822cc931db91f00dcec7bc2b72b23cea9e36815136bc9199b86fbbaf"
RDEPENDS:libquadmath = " \
 glibc \
 libgcc \
"

URI_libstdc++ = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libstdc++-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libstdc++;unpack=0"
SRC_URI += "${URI_libstdc++}"
SRC_URI[libstdc++.sha256sum] = "dedbb1adca6d08569f33535bcf9a8f28f6c36d2865136e7d120fc97f03a85779"
RDEPENDS:libstdc++ = " \
 glibc \
 libgcc \
"

URI_cpp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cpp-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=cpp;unpack=0"
SRC_URI += "${URI_cpp}"
SRC_URI[cpp.sha256sum] = "9a435faf811bbd6e83073d62c18a0fdf11f6aae65dfaaf323ccd7a042e73e512"
RDEPENDS:cpp = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 libzstd \
 libmpc \
 glibc \
 filesystem \
"

URI_gcc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gcc-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=gcc;unpack=0"
SRC_URI += "${URI_gcc}"
SRC_URI[gcc.sha256sum] = "74562c6c601c33de954c6582efe50830a8d3d5253cd82b09b05395c589141f93"
RDEPENDS:gcc = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 cpp \
 glibc-devel \
 libgcc \
 make \
 libgomp \
 libzstd \
 libmpc \
 bash \
 binutils \
 glibc \
"

URI_gcc-c++ = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gcc-c++-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=gcc-c++;unpack=0"
SRC_URI += "${URI_gcc-c++}"
SRC_URI[gcc-c++.sha256sum] = "6683bb181b2c954c7838060ab709238d17831b2e4764b212917f7423275aced1"
RDEPENDS:gcc-c++ = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 libstdc++-devel \
 libzstd \
 libmpc \
 libstdc++ \
 gcc \
 glibc \
"

URI_gcc-gfortran = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gcc-gfortran-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=gcc-gfortran;unpack=0"
SRC_URI += "${URI_gcc-gfortran}"
SRC_URI[gcc-gfortran.sha256sum] = "940d23341a855e5344d3de29d821bcbf8d7684d756cc29d9ba19fb7da7b37308"
RDEPENDS:gcc-gfortran = " \
 libquadmath-devel \
 gmp \
 zlib-ng-compat \
 mpfr \
 libgfortran \
 libquadmath \
 libzstd \
 libmpc \
 gcc \
 glibc \
"

URI_gcc-offload-amdgcn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gcc-offload-amdgcn-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=gcc-offload-amdgcn;unpack=0"
SRC_URI += "${URI_gcc-offload-amdgcn}"
SRC_URI[gcc-offload-amdgcn.sha256sum] = "3c3d1e5466e2b33c6deb523d6ddf7b05e1b5acd04df03656a3fda5435bcf70f5"
RDEPENDS:gcc-offload-amdgcn = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 libgcc \
 libgomp-offload-amdgcn \
 libzstd \
 libmpc \
 lld \
 libstdc++ \
 gcc \
 glibc \
 llvm \
"

URI_gcc-offload-nvptx = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gcc-offload-nvptx-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=gcc-offload-nvptx;unpack=0"
SRC_URI += "${URI_gcc-offload-nvptx}"
SRC_URI[gcc-offload-nvptx.sha256sum] = "8b6a0433ba08ab813ab9822de28e399e9ebd1d50a3379ae5a3c9f2039a7b6894"
RDEPENDS:gcc-offload-nvptx = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 libgcc \
 libgomp-offload-nvptx \
 libzstd \
 libmpc \
 libstdc++ \
 gcc \
 glibc \
"

URI_gcc-plugin-annobin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gcc-plugin-annobin-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=gcc-plugin-annobin;unpack=0"
SRC_URI += "${URI_gcc-plugin-annobin}"
SRC_URI[gcc-plugin-annobin.sha256sum] = "050467f0c0aa4f90d9ae6e160335eb80eddbb20c71b13796df82be25f1e3a509"
RDEPENDS:gcc-plugin-annobin = " \
 glibc \
 libgcc \
 libstdc++ \
 gcc \
"

URI_libasan = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libasan-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libasan;unpack=0"
SRC_URI += "${URI_libasan}"
SRC_URI[libasan.sha256sum] = "d861ff6606c8447e671b4826662dc62416bb7266d1089d93c9d5646264aa612d"
RDEPENDS:libasan = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_libgccjit = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libgccjit-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libgccjit;unpack=0"
SRC_URI += "${URI_libgccjit}"
SRC_URI[libgccjit.sha256sum] = "52e5d30c889c64b72f9dc4abb4b8df7bddbf4564101366a328c5cfed70df9623"
RDEPENDS:libgccjit = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 libzstd \
 libmpc \
 gcc \
 glibc \
"

URI_libgccjit-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libgccjit-devel-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libgccjit-devel;unpack=0"
SRC_URI += "${URI_libgccjit-devel}"
SRC_URI[libgccjit-devel.sha256sum] = "bb6331db28b91f3152fd65925b6c3f30ae72ecf0f0bce5f73ddb375c4ff49258"
RDEPENDS:libgccjit-devel = " \
 libgccjit \
"

URI_libgomp-offload-amdgcn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libgomp-offload-amdgcn-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libgomp-offload-amdgcn;unpack=0"
SRC_URI += "${URI_libgomp-offload-amdgcn}"
SRC_URI[libgomp-offload-amdgcn.sha256sum] = "d770a9bcc5ea65948c9ed77b0b5bfedef453c638f5d498fbc2bae67313658827"
RDEPENDS:libgomp-offload-amdgcn = " \
 glibc \
 libgomp \
"

URI_libgomp-offload-nvptx = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libgomp-offload-nvptx-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libgomp-offload-nvptx;unpack=0"
SRC_URI += "${URI_libgomp-offload-nvptx}"
SRC_URI[libgomp-offload-nvptx.sha256sum] = "b6b5e2a80af31963fa7671c40647178158add0380307ed5e8a2e3caf5284a599"
RDEPENDS:libgomp-offload-nvptx = " \
 glibc \
 libgcc \
 libgomp \
"

URI_libhwasan = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libhwasan-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libhwasan;unpack=0"
SRC_URI += "${URI_libhwasan}"
SRC_URI[libhwasan.sha256sum] = "b0f230236cd7847a2e372f03f20824456ce090ca7982856bc8a7505519ff4092"
RDEPENDS:libhwasan = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_libitm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libitm-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libitm;unpack=0"
SRC_URI += "${URI_libitm}"
SRC_URI[libitm.sha256sum] = "4a934416fb4cb2bf5b3c58479994b2f6b956e9d356b95a5437d655c717d7f6b7"
RDEPENDS:libitm = " \
 glibc \
"

URI_libitm-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libitm-devel-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libitm-devel;unpack=0"
SRC_URI += "${URI_libitm-devel}"
SRC_URI[libitm-devel.sha256sum] = "792692e48af4c11f23ff4427c6152bfb00c6c741260f0f22c1054405d5c94ec4"
RDEPENDS:libitm-devel = " \
 libitm \
 gcc \
"

URI_liblsan = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/liblsan-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=liblsan;unpack=0"
SRC_URI += "${URI_liblsan}"
SRC_URI[liblsan.sha256sum] = "138060cfbde27532159701cdfc2d35969dafa291e6a0303bd37948237ce3cf0d"
RDEPENDS:liblsan = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_libquadmath-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libquadmath-devel-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libquadmath-devel;unpack=0"
SRC_URI += "${URI_libquadmath-devel}"
SRC_URI[libquadmath-devel.sha256sum] = "379dce553253b59a27009ae2c3a95b05b5a57f9e23da6b13468338344eba355f"
RDEPENDS:libquadmath-devel = " \
 libquadmath \
 gcc \
"

URI_libstdc++-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libstdc++-devel-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libstdc++-devel;unpack=0"
SRC_URI += "${URI_libstdc++-devel}"
SRC_URI[libstdc++-devel.sha256sum] = "b79fd9f04f684d7ab6f6b46e7b92c326399b994e41fc4002b511f8e2df696deb"
RDEPENDS:libstdc++-devel = " \
 libstdc++ \
"

URI_libstdc++-docs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libstdc++-docs-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libstdc++-docs;unpack=0"
SRC_URI += "${URI_libstdc++-docs}"
SRC_URI[libstdc++-docs.sha256sum] = "7036986294693395fe77474b5ad890a75d5522b99216cea8b3db87a883b99402"
RDEPENDS:libstdc++-docs = ""

URI_libtsan = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libtsan-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libtsan;unpack=0"
SRC_URI += "${URI_libtsan}"
SRC_URI[libtsan.sha256sum] = "fdbf39af12eaa150fc21de2564b8b79c3ffa239e50a3861f7b1b186415c414e1"
RDEPENDS:libtsan = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_libubsan = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libubsan-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libubsan;unpack=0"
SRC_URI += "${URI_libubsan}"
SRC_URI[libubsan.sha256sum] = "ebd184d7821ad9af31d8dae5994b332d1377ac778a6677a9232cf8b1d42ecb81"
RDEPENDS:libubsan = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_gcc-plugin-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gcc-plugin-devel-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=gcc-plugin-devel;unpack=0"
SRC_URI += "${URI_gcc-plugin-devel}"
SRC_URI[gcc-plugin-devel.sha256sum] = "120a018988db34841c6cc7df24697ae9d726b34ed27e842fcafa93b76b0e40d7"
RDEPENDS:gcc-plugin-devel = " \
 libmpc-devel \
 gcc \
 glibc \
 mpfr-devel \
 gmp-devel \
"

URI_libgfortran-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libgfortran-static-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libgfortran-static;unpack=0"
SRC_URI += "${URI_libgfortran-static}"
SRC_URI[libgfortran-static.sha256sum] = "69afecc4dc278310c477ce07e9e27debb5540d5f0eda9532051cece4502460b0"
RDEPENDS:libgfortran-static = " \
 libquadmath-static \
 libgfortran \
 gcc \
"

URI_libquadmath-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libquadmath-static-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libquadmath-static;unpack=0"
SRC_URI += "${URI_libquadmath-static}"
SRC_URI[libquadmath-static.sha256sum] = "b83f0c10549b710186e08f9662af219776b2595fa108d3d2836b1f450fadfc81"
RDEPENDS:libquadmath-static = " \
 libquadmath-devel \
"

URI_libstdc++-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libstdc++-static-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libstdc++-static;unpack=0"
SRC_URI += "${URI_libstdc++-static}"
SRC_URI[libstdc++-static.sha256sum] = "3eec98603ea43e6142d7d1983c7963e4ffe0cdd41814ad2facac97f82a2f2ab6"
RDEPENDS:libstdc++-static = " \
 libstdc++-devel \
"

URI_gcc-gdb-plugin = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gcc-gdb-plugin-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=gcc-gdb-plugin;unpack=0"
SRC_URI += "${URI_gcc-gdb-plugin}"
SRC_URI[gcc-gdb-plugin.sha256sum] = "e76a5323cf646c556745f896fa7720b322eedfaadae2bce27b5bed2d96f4cb45"
RDEPENDS:gcc-gdb-plugin = " \
 glibc \
 libgcc \
 libstdc++ \
 gcc \
"

URI_libasan-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libasan-static-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libasan-static;unpack=0"
SRC_URI += "${URI_libasan-static}"
SRC_URI[libasan-static.sha256sum] = "12af9a8f5cc3243b5dc1994e89b15690b30ca4dde50e8b82906d3c524c39dfa0"
RDEPENDS:libasan-static = " \
 libasan \
"

URI_libatomic-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libatomic-static-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libatomic-static;unpack=0"
SRC_URI += "${URI_libatomic-static}"
SRC_URI[libatomic-static.sha256sum] = "df3e3916313b471a812e95290f987e574e2661c5373ae558a0fcab1836ef7202"
RDEPENDS:libatomic-static = " \
 libatomic \
"

URI_libhwasan-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libhwasan-static-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libhwasan-static;unpack=0"
SRC_URI += "${URI_libhwasan-static}"
SRC_URI[libhwasan-static.sha256sum] = "bf24aecfc3827bdcfc6ab0cabd42516bc89c9ed84ad03a5a331da0d947a51eca"
RDEPENDS:libhwasan-static = " \
 libhwasan \
"

URI_libitm-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libitm-static-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libitm-static;unpack=0"
SRC_URI += "${URI_libitm-static}"
SRC_URI[libitm-static.sha256sum] = "b5ca08b0bfdf1a4d32dbbab8a4f4acbf2135d0de7479f64778f94fc835372382"
RDEPENDS:libitm-static = " \
 libitm-devel \
"

URI_liblsan-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/liblsan-static-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=liblsan-static;unpack=0"
SRC_URI += "${URI_liblsan-static}"
SRC_URI[liblsan-static.sha256sum] = "f4091a2ebf2648accd3387e82837b68195b10d7e3f151ac9421872f60036f85e"
RDEPENDS:liblsan-static = " \
 liblsan \
"

URI_libtsan-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libtsan-static-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libtsan-static;unpack=0"
SRC_URI += "${URI_libtsan-static}"
SRC_URI[libtsan-static.sha256sum] = "34f933cafe694e647c3459a6670e4332387ee2b5fe260d57c736a2c2fcc3816d"
RDEPENDS:libtsan-static = " \
 libtsan \
"

URI_libubsan-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libubsan-static-14.2.1-7.el10.alma.1.x86_64_v2.rpm;name=libubsan-static;unpack=0"
SRC_URI += "${URI_libubsan-static}"
SRC_URI[libubsan-static.sha256sum] = "60b5a7ebe24ec516dcfecf11469ea8b4f5f2e9b6d34bda5963f7d02a0f69e5ed"
RDEPENDS:libubsan-static = " \
 libubsan \
"
