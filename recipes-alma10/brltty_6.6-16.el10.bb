# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "brltty"
PE = "0"
PV = "6.6"
PR = "16.el10"
PACKAGES = "brlapi brltty brltty-at-spi2 brltty-docs brltty-dracut brltty-espeak-ng brltty-xw python3-brlapi brlapi-devel ocaml-brlapi brlapi-java brltty-minimal tcl-brlapi"
PROVIDES = "rpm/brlapi rpm/brltty rpm/brltty-at-spi2 rpm/brltty-docs rpm/brltty-dracut rpm/brltty-espeak-ng rpm/brltty-xw rpm/python3-brlapi rpm/brlapi-devel rpm/ocaml-brlapi rpm/brlapi-java rpm/brltty-minimal rpm/tcl-brlapi"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/brltty-6.6-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3acbb387f4ddd0b259bd18d647bf97c416ab1cd8682f68c21703a47b99267bd"

URI_brlapi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/brlapi-0.8.5-16.el10.x86_64_v2.rpm;name=brlapi;unpack=0"
SRC_URI += "${URI_brlapi}"
SRC_URI[brlapi.sha256sum] = "7d0b24837c266bd3cc2214130203d76c3f6bec1c45e6978f363049187b560323"
RDEPENDS:brlapi = " \
 glibc-common \
 libXfixes \
 shadow-utils \
 lua-libs \
 util-linux \
 libX11 \
 libicu \
 bash \
 libXtst \
 glibc \
 coreutils \
"

URI_brltty = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/brltty-6.6-16.el10.x86_64_v2.rpm;name=brltty;unpack=0"
SRC_URI += "${URI_brltty}"
SRC_URI[brltty.sha256sum] = "631f6ddc6c43d220b21383fbdbb971e62aedbe5901b6463a4f4d0fe08ef4d6c1"
RDEPENDS:brltty = " \
 python3 \
 alsa-lib \
 shadow-utils \
 systemd \
 brlapi \
 libicu \
 polkit-libs \
 bash \
 glib2 \
 pcre2-utf32 \
 glibc \
 coreutils \
 bluez-libs \
 dbus-libs \
"

URI_brltty-at-spi2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/brltty-at-spi2-6.6-16.el10.x86_64_v2.rpm;name=brltty-at-spi2;unpack=0"
SRC_URI += "${URI_brltty-at-spi2}"
SRC_URI[brltty-at-spi2.sha256sum] = "658acb5ba2ac939178b77be62df5a30d784b48e9f44c756571cfcdd768e744da"
RDEPENDS:brltty-at-spi2 = " \
 libXfixes \
 libX11 \
 glibc \
 brltty \
 dbus-libs \
 at-spi2-core \
"

URI_brltty-docs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/brltty-docs-6.6-16.el10.noarch.rpm;name=brltty-docs;unpack=0"
SRC_URI += "${URI_brltty-docs}"
SRC_URI[brltty-docs.sha256sum] = "e1bc4a341b20d051ab285f38c0e71f3a9e06ac9a76facd061badab46ce8b7b65"
RDEPENDS:brltty-docs = " \
 brltty \
"

URI_brltty-dracut = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/brltty-dracut-6.6-16.el10.x86_64_v2.rpm;name=brltty-dracut;unpack=0"
SRC_URI += "${URI_brltty-dracut}"
SRC_URI[brltty-dracut.sha256sum] = "14a3367498fa24afbe9d881f259901229996515d93d2e42ea7dca9e47a733a35"
RDEPENDS:brltty-dracut = " \
 brltty \
 bash \
 dracut \
"

URI_brltty-espeak-ng = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/brltty-espeak-ng-6.6-16.el10.x86_64_v2.rpm;name=brltty-espeak-ng;unpack=0"
SRC_URI += "${URI_brltty-espeak-ng}"
SRC_URI[brltty-espeak-ng.sha256sum] = "58f0fb4127665a5bab11289542e2278a5630bb1edaf3a5c644d35b2e0bfd63cf"
RDEPENDS:brltty-espeak-ng = " \
 glibc \
 espeak-ng \
 brltty \
"

URI_brltty-xw = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/brltty-xw-6.6-16.el10.x86_64_v2.rpm;name=brltty-xw;unpack=0"
SRC_URI += "${URI_brltty-xw}"
SRC_URI[brltty-xw.sha256sum] = "06162b1cf86f808d4a38bd99a399c64471a626d1c572d9930f2d920d7ffe366c"
RDEPENDS:brltty-xw = " \
 libX11 \
 xorg-x11-fonts-misc \
 libXt \
 libXaw \
 glibc \
 brltty \
"

URI_python3-brlapi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-brlapi-0.8.5-16.el10.x86_64_v2.rpm;name=python3-brlapi;unpack=0"
SRC_URI += "${URI_python3-brlapi}"
SRC_URI[python3-brlapi.sha256sum] = "dc1544399129de51fcbe89de1f45f3b37edda401a96c1aa02eb2f13d65eb0504"
RDEPENDS:python3-brlapi = " \
 glibc \
 brlapi \
 python3 \
"

URI_brlapi-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/brlapi-devel-0.8.5-16.el10.x86_64_v2.rpm;name=brlapi-devel;unpack=0"
SRC_URI += "${URI_brlapi-devel}"
SRC_URI[brlapi-devel.sha256sum] = "cb80a0e14a53b0ba675a6b3562f333b7e23b549054fdd71ab7db7b5defd49622"
RDEPENDS:brlapi-devel = " \
 brlapi \
 pkgconf-pkg-config \
"

URI_ocaml-brlapi = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-brlapi-0.8.5-16.el10.x86_64_v2.rpm;name=ocaml-brlapi;unpack=0"
SRC_URI += "${URI_ocaml-brlapi}"
SRC_URI[ocaml-brlapi.sha256sum] = "09bd2bec88a76a670f7570f7e0b0055e11abb45b59ffd5c05ee4d77c60bcc4f5"
RDEPENDS:ocaml-brlapi = " \
 glibc \
 ocaml-runtime \
 brlapi \
 ocaml \
"

URI_brlapi-java = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/brlapi-java-0.8.5-16.el10.x86_64_v2.rpm;name=brlapi-java;unpack=0"
SRC_URI += "${URI_brlapi-java}"
SRC_URI[brlapi-java.sha256sum] = "b00bc9997ee720ec8dc7aa972046bcda895af5fe7146d0d5d3e9f33d2be808eb"
RDEPENDS:brlapi-java = " \
 glibc \
 brlapi \
"

URI_brltty-minimal = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/brltty-minimal-6.6-16.el10.x86_64_v2.rpm;name=brltty-minimal;unpack=0"
SRC_URI += "${URI_brltty-minimal}"
SRC_URI[brltty-minimal.sha256sum] = "0e11582d43e49a82851b76c3d9cb57579ddaeb384cf8a6156be4d59ffe648203"
RDEPENDS:brltty-minimal = " \
 python3 \
 pcre2-utf32 \
 glibc \
 bluez-libs \
 dbus-libs \
"

URI_tcl-brlapi = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/tcl-brlapi-0.8.5-16.el10.x86_64_v2.rpm;name=tcl-brlapi;unpack=0"
SRC_URI += "${URI_tcl-brlapi}"
SRC_URI[tcl-brlapi.sha256sum] = "01f326ce6eeec660b012630c30be7955470d3fbe6f7508c4e6af908205165262"
RDEPENDS:tcl-brlapi = " \
 glibc \
 brlapi \
 tcl \
"
