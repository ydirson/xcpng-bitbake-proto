# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pyproject-rpm-macros"
PE = "0"
PV = "1.16.2"
PR = "1.el10"
PACKAGES = "pyproject-srpm-macros pyproject-rpm-macros"
PROVIDES = "rpm/pyproject-srpm-macros rpm/pyproject-rpm-macros"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/pyproject-rpm-macros-1.16.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ed84b98c5a7d3edfd4cf6fcf073834aee303b31d47b50e74b9948087c29b2ee"

URI_pyproject-srpm-macros = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pyproject-srpm-macros-1.16.2-1.el10.noarch.rpm;name=pyproject-srpm-macros;unpack=0"
SRC_URI += "${URI_pyproject-srpm-macros}"
SRC_URI[pyproject-srpm-macros.sha256sum] = "21a9d616192ee3486d7101534402caf72972790236bf0eb0e6f043e27f65187c"
RDEPENDS:pyproject-srpm-macros = " \
 rpm-build \
 pyproject-rpm-macros \
"

URI_pyproject-rpm-macros = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/pyproject-rpm-macros-1.16.2-1.el10.noarch.rpm;name=pyproject-rpm-macros;unpack=0"
SRC_URI += "${URI_pyproject-rpm-macros}"
SRC_URI[pyproject-rpm-macros.sha256sum] = "9746adffd96a99139f6a21d1f6cff7ee1099d32498cf8e39ac70ef5713fd41ed"
RDEPENDS:pyproject-rpm-macros = " \
 pyproject-srpm-macros \
 python-rpm-macros \
 python-srpm-macros \
 rpm-build \
 sed \
 findutils \
 python3-rpm-macros \
"
