# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-zu"
PE = "0"
PV = "0.20100126"
PR = "33.el10"
PACKAGES = "hunspell-zu"
PROVIDES = "rpm/hunspell-zu"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-zu-0.20100126-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "782221e0b341d2154d338b9519b344bcb224db32ac4bab3a7f66c93c5a793e5f"

URI_hunspell-zu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-zu-0.20100126-33.el10.noarch.rpm;name=hunspell-zu;unpack=0"
SRC_URI += "${URI_hunspell-zu}"
SRC_URI[hunspell-zu.sha256sum] = "d345dd06088ad200361c1316ceeaf3b666d16048c0975b9d9310f7cdece09f1e"
RDEPENDS:hunspell-zu = " \
 hunspell-filesystem \
"
