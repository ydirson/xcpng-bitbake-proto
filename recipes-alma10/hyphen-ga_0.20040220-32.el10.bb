# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-ga"
PE = "0"
PV = "0.20040220"
PR = "32.el10"
PACKAGES = "hyphen-ga"
PROVIDES = "rpm/hyphen-ga"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-ga-0.20040220-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c50ba60fb282b4239f0219f4aadadd5c553d6050482f09d332a3afb4c08f1ef4"

URI_hyphen-ga = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-ga-0.20040220-32.el10.noarch.rpm;name=hyphen-ga;unpack=0"
SRC_URI += "${URI_hyphen-ga}"
SRC_URI[hyphen-ga.sha256sum] = "d10667fa9f1d50a43898d792363712655df017a4b0a1880858014b709307fc30"
RDEPENDS:hyphen-ga = " \
 hyphen \
"
