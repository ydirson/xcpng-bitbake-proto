# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-pdm-backend"
PE = "0"
PV = "2.1.8"
PR = "1.el10"
PACKAGES = "python3-pdm-backend"
PROVIDES = "rpm/python3-pdm-backend"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/python-pdm-backend-2.1.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4797d2c3fee90c930a24ac7daa9ddeb37dcb9b0a2cf20e15bc0cd78154663826"

URI_python3-pdm-backend = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-pdm-backend-2.1.8-1.el10.noarch.rpm;name=python3-pdm-backend;unpack=0"
SRC_URI += "${URI_python3-pdm-backend}"
SRC_URI[python3-pdm-backend.sha256sum] = "b8df5c0bd57edfcd3ce10d36dcc224ec78081a24c6c864223260deec50ec4e18"
RDEPENDS:python3-pdm-backend = " \
 python3 \
 python3-packaging \
 python3-tomli-w \
 python3-pyproject-metadata \
"
