# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-XS-Parse-Keyword"
PE = "0"
PV = "0.39"
PR = "7.el10"
PACKAGES = "perl-XS-Parse-Keyword perl-XS-Parse-Keyword-Builder perl-XS-Parse-Keyword-tests"
PROVIDES = "rpm/perl-XS-Parse-Keyword rpm/perl-XS-Parse-Keyword-Builder rpm/perl-XS-Parse-Keyword-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-XS-Parse-Keyword-0.39-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cbf0d157054eb4f5a57b873ab8a2599e76b7bd3beb145d8eea7d22bdbaa8b63f"

URI_perl-XS-Parse-Keyword = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-XS-Parse-Keyword-0.39-7.el10.x86_64_v2.rpm;name=perl-XS-Parse-Keyword;unpack=0"
SRC_URI += "${URI_perl-XS-Parse-Keyword}"
SRC_URI[perl-XS-Parse-Keyword.sha256sum] = "5d01f0479e80cbbf6b3a2a7bbbb0a176404367b4c019b5a43c7ef66aa30376c3"
RDEPENDS:perl-XS-Parse-Keyword = " \
 glibc \
 perl-XS-Parse-Keyword \
 perl-libs \
"

URI_perl-XS-Parse-Keyword-Builder = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-XS-Parse-Keyword-Builder-0.39-7.el10.x86_64_v2.rpm;name=perl-XS-Parse-Keyword-Builder;unpack=0"
SRC_URI += "${URI_perl-XS-Parse-Keyword-Builder}"
SRC_URI[perl-XS-Parse-Keyword-Builder.sha256sum] = "7e7d2435f688a53ec28f7e905ad0f60035c59b94a37767f12d8f707fcc49895e"
RDEPENDS:perl-XS-Parse-Keyword-Builder = " \
 perl-constant \
 perl-libs \
 perl-XS-Parse-Keyword \
 perl-interpreter \
 perl-XS-Parse-Keyword-Builder \
"

URI_perl-XS-Parse-Keyword-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-XS-Parse-Keyword-tests-0.39-7.el10.x86_64_v2.rpm;name=perl-XS-Parse-Keyword-tests;unpack=0"
SRC_URI += "${URI_perl-XS-Parse-Keyword-tests}"
SRC_URI[perl-XS-Parse-Keyword-tests.sha256sum] = "245226e6b76128f1aa7544fb983e55e0ae3910358d225adfac75800c0cdbf108"
RDEPENDS:perl-XS-Parse-Keyword-tests = " \
 perl-constant \
 perl-Test-Harness \
 perl-libs \
 perl-Test2-Suite \
 perl-XS-Parse-Keyword \
 perl-B \
 perl-overload \
 bash \
 glibc \
 perl-interpreter \
 perl-lib \
"
