# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "man-pages"
PE = "0"
PV = "6.06"
PR = "8.el10_0"
PACKAGES = "man-pages"
PROVIDES = "rpm/man-pages"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/man-pages-6.06-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87dc5505a510486a3c9ab7e5465afbeb36b637617d4a9ec568c9864b520f49ea"

URI_man-pages = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/man-pages-6.06-8.el10_0.noarch.rpm;name=man-pages;unpack=0"
SRC_URI += "${URI_man-pages}"
SRC_URI[man-pages.sha256sum] = "a308406301ddf53854decf02f713ec69f5a7a831f6e2981b68286ddcbbf59d65"
RDEPENDS:man-pages = " \
 alternatives \
 bash \
"
