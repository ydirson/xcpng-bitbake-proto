# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "389-ds-base"
PE = "0"
PV = "3.0.6"
PR = "13.el10_0"
PACKAGES = "389-ds-base 389-ds-base-libs 389-ds-base-snmp python3-lib389 389-ds-base-bdb 389-ds-base-devel"
PROVIDES = "rpm/389-ds-base rpm/389-ds-base-libs rpm/389-ds-base-snmp rpm/python3-lib389 rpm/389-ds-base-bdb rpm/389-ds-base-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/389-ds-base-3.0.6-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0bf665bb84316f30e9c8fe5f78e08f42dedd735f04c9efca253f1578ff56d068"

URI_389-ds-base = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/389-ds-base-3.0.6-13.el10_0.x86_64_v2.rpm;name=389-ds-base;unpack=0"
SRC_URI += "${URI_389-ds-base}"
SRC_URI[389-ds-base.sha256sum] = "f953b39d658fb56aaa84dbe147bbaa78aea1a5a07a25efb7ed8bea7b3b12d658"
RDEPENDS:389-ds-base = " \
 python3 \
 systemd \
 nss \
 systemd-libs \
 policycoreutils-python-utils \
 perl-Archive-Tar \
 cyrus-sasl-gssapi \
 krb5-libs \
 cyrus-sasl-lib \
 nss-tools \
 nss-util \
 cyrus-sasl-plain \
 perl-sigtrap \
 python3-lib389 \
 json-c \
 acl \
 cyrus-sasl-md5 \
 python3-libsemanage \
 libstdc++ \
 libcom_err \
 openldap \
 openldap-clients \
 shadow-utils \
 zlib-ng-compat \
 python3-file-magic \
 libxcrypt \
 zlib-ng-compat-devel \
 libgcc \
 openssl-libs \
 pam-libs \
 bash \
 pcre2 \
 libicu \
 lmdb-libs \
 perl-debugger \
 389-ds-base-libs \
 glibc \
 perl-interpreter \
 cracklib \
 cracklib-dicts \
 nspr \
"

URI_389-ds-base-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/389-ds-base-libs-3.0.6-13.el10_0.x86_64_v2.rpm;name=389-ds-base-libs;unpack=0"
SRC_URI += "${URI_389-ds-base-libs}"
SRC_URI[389-ds-base-libs.sha256sum] = "a9bff5c6a3c22a978d0c015b00e8033067535ee7c4adcc93226e26d10b1f031f"
RDEPENDS:389-ds-base-libs = " \
 zlib-ng-compat \
 nss \
 systemd-libs \
 openssl-libs \
 libgcc \
 json-c \
 krb5-libs \
 cyrus-sasl-lib \
 libstdc++ \
 nss-util \
 pcre2 \
 libcom_err \
 cracklib \
 glibc \
 openldap \
 nspr \
"

URI_389-ds-base-snmp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/389-ds-base-snmp-3.0.6-13.el10_0.x86_64_v2.rpm;name=389-ds-base-snmp;unpack=0"
SRC_URI += "${URI_389-ds-base-snmp}"
SRC_URI[389-ds-base-snmp.sha256sum] = "c4dd3b166d941d34c2348d3d3b6450b48223606a9b0692cfd4d83e58405c5055"
RDEPENDS:389-ds-base-snmp = " \
 net-snmp-agent-libs \
 net-snmp-libs \
 389-ds-base \
 bash \
 glibc \
 openldap \
 nspr \
"

URI_python3-lib389 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-lib389-3.0.6-13.el10_0.noarch.rpm;name=python3-lib389;unpack=0"
SRC_URI += "${URI_python3-lib389}"
SRC_URI[python3-lib389.sha256sum] = "11ebf5d56fec6cba8957c0c79fb018a7576e5a7e876dd8c175ba94a4678f938b"
RDEPENDS:python3-lib389 = " \
 python3 \
 python3-ldap \
 python3-psutil \
 python3-cryptography \
 openssl \
 iproute \
 python3-pyasn1 \
 python3-dateutil \
 python3-pyasn1-modules \
 python3-libselinux \
 python3-setuptools \
 389-ds-base \
 openssl-perl \
 python3-distro \
 python3-argcomplete \
"

URI_389-ds-base-bdb = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/389-ds-base-bdb-3.0.6-13.el10_0.x86_64_v2.rpm;name=389-ds-base-bdb;unpack=0"
SRC_URI += "${URI_389-ds-base-bdb}"
SRC_URI[389-ds-base-bdb.sha256sum] = "b28746622b9b76dc69352f7a721aabd7bb74975d3b3abf30408ee544d2ed4751"
RDEPENDS:389-ds-base-bdb = " \
 zlib-ng-compat \
 nss \
 systemd-libs \
 openssl-libs \
 libgcc \
 json-c \
 openldap \
 krb5-libs \
 cyrus-sasl-lib \
 libcom_err \
 pcre2 \
 389-ds-base-libs \
 cracklib \
 389-ds-base \
 glibc \
 nss-util \
 lmdb-libs \
 nspr \
"

URI_389-ds-base-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/389-ds-base-devel-3.0.6-13.el10_0.x86_64_v2.rpm;name=389-ds-base-devel;unpack=0"
SRC_URI += "${URI_389-ds-base-devel}"
SRC_URI[389-ds-base-devel.sha256sum] = "0bb95dc97ad911610e19a4e8213be1dd97978cb7a73b713e240375f0dc19c717"
RDEPENDS:389-ds-base-devel = " \
 nspr-devel \
 systemd-libs \
 nss-devel \
 openldap-devel \
 pkgconf-pkg-config \
 389-ds-base-libs \
"
