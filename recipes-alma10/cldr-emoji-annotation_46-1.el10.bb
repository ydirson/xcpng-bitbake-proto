# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cldr-emoji-annotation"
PE = "0"
PV = "46"
PR = "1.el10"
PACKAGES = "cldr-emoji-annotation cldr-emoji-annotation-dtd cldr-emoji-annotation-devel"
PROVIDES = "rpm/cldr-emoji-annotation rpm/cldr-emoji-annotation-dtd rpm/cldr-emoji-annotation-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/cldr-emoji-annotation-46-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7738f713202f999eb9d87b8365dd7d1aa88d9ca435ee716b2d5acb6398ebdb17"

URI_cldr-emoji-annotation = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cldr-emoji-annotation-46-1.el10.noarch.rpm;name=cldr-emoji-annotation;unpack=0"
SRC_URI += "${URI_cldr-emoji-annotation}"
SRC_URI[cldr-emoji-annotation.sha256sum] = "42ce66d2c769ee686ee40835d96c2313e33b0f11e46c291586db9864f464036d"
RDEPENDS:cldr-emoji-annotation = " \
 cldr-emoji-annotation-dtd \
"

URI_cldr-emoji-annotation-dtd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cldr-emoji-annotation-dtd-46-1.el10.noarch.rpm;name=cldr-emoji-annotation-dtd;unpack=0"
SRC_URI += "${URI_cldr-emoji-annotation-dtd}"
SRC_URI[cldr-emoji-annotation-dtd.sha256sum] = "37ab860e7f17a6b52092be8f5ed85cffe7ec97a05a58edb8d1b307838f446370"
RDEPENDS:cldr-emoji-annotation-dtd = " \
 cldr-emoji-annotation \
"

URI_cldr-emoji-annotation-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/cldr-emoji-annotation-devel-46-1.el10.noarch.rpm;name=cldr-emoji-annotation-devel;unpack=0"
SRC_URI += "${URI_cldr-emoji-annotation-devel}"
SRC_URI[cldr-emoji-annotation-devel.sha256sum] = "be95e433cc7ccccc1a5ba5d29e96f6fd753a370c301e257b22d647ec925829db"
RDEPENDS:cldr-emoji-annotation-devel = " \
 cldr-emoji-annotation \
 pkgconf-pkg-config \
"
