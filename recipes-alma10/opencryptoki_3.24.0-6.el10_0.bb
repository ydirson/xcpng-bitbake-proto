# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "opencryptoki"
PE = "0"
PV = "3.24.0"
PR = "6.el10_0"
PACKAGES = "opencryptoki opencryptoki-ccatok opencryptoki-icsftok opencryptoki-libs opencryptoki-swtok opencryptoki-devel"
PROVIDES = "rpm/opencryptoki rpm/opencryptoki-ccatok rpm/opencryptoki-icsftok rpm/opencryptoki-libs rpm/opencryptoki-swtok rpm/opencryptoki-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/opencryptoki-3.24.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9e75f77fecc6d2a43b1821a07295b0cb4efcb0c0151df6e72e33f26bf23e864"

URI_opencryptoki = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/opencryptoki-3.24.0-6.el10_0.x86_64_v2.rpm;name=opencryptoki;unpack=0"
SRC_URI += "${URI_opencryptoki}"
SRC_URI[opencryptoki.sha256sum] = "38f92ba230f0026195cc82c044a3806f3baceb8cb4cd64b8b9e01a8de77767be"
RDEPENDS:opencryptoki = " \
 systemd \
 diffutils \
 openssl-libs \
 libcap \
 bash \
 glibc \
 coreutils \
 opencryptoki-libs \
 opencryptoki-swtok \
 selinux-policy \
"

URI_opencryptoki-ccatok = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/opencryptoki-ccatok-3.24.0-6.el10_0.x86_64_v2.rpm;name=opencryptoki-ccatok;unpack=0"
SRC_URI += "${URI_opencryptoki-ccatok}"
SRC_URI[opencryptoki-ccatok.sha256sum] = "4c240513f7d38f0f234a586ea9d9b3f20dc9ab0775843db637477d4249c2cfee"
RDEPENDS:opencryptoki-ccatok = " \
 glibc \
 opencryptoki-libs \
 openssl-libs \
 openldap \
"

URI_opencryptoki-icsftok = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/opencryptoki-icsftok-3.24.0-6.el10_0.x86_64_v2.rpm;name=opencryptoki-icsftok;unpack=0"
SRC_URI += "${URI_opencryptoki-icsftok}"
SRC_URI[opencryptoki-icsftok.sha256sum] = "e717e774c0d30db4838c3b0c5e26e92223964b669e239bc10db39d1ccb6d945b"
RDEPENDS:opencryptoki-icsftok = " \
 glibc \
 opencryptoki-libs \
 openssl-libs \
 openldap \
"

URI_opencryptoki-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/opencryptoki-libs-3.24.0-6.el10_0.x86_64_v2.rpm;name=opencryptoki-libs;unpack=0"
SRC_URI += "${URI_opencryptoki-libs}"
SRC_URI[opencryptoki-libs.sha256sum] = "074feb6e2578e5b7fe14ba2bf198f31dfc67eeef3d4eef7c4e72b26610238609"
RDEPENDS:opencryptoki-libs = " \
 shadow-utils \
 libgcc \
 openssl-libs \
 bash \
 glibc \
"

URI_opencryptoki-swtok = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/opencryptoki-swtok-3.24.0-6.el10_0.x86_64_v2.rpm;name=opencryptoki-swtok;unpack=0"
SRC_URI += "${URI_opencryptoki-swtok}"
SRC_URI[opencryptoki-swtok.sha256sum] = "761e19dcfbb9994b062d4ed81f1a115e1ab54d0e6ab68426c1e202e95b3a2ac2"
RDEPENDS:opencryptoki-swtok = " \
 glibc \
 opencryptoki-libs \
 openssl-libs \
 openldap \
"

URI_opencryptoki-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/opencryptoki-devel-3.24.0-6.el10_0.x86_64_v2.rpm;name=opencryptoki-devel;unpack=0"
SRC_URI += "${URI_opencryptoki-devel}"
SRC_URI[opencryptoki-devel.sha256sum] = "82ffb58e5383e63bc3e0861b90e08e868f2adde537ba527ca8494dea08a39ff7"
RDEPENDS:opencryptoki-devel = " \
 opencryptoki-libs \
 pkgconf-pkg-config \
"
