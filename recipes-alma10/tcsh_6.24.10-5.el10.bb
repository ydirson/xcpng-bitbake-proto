# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tcsh"
PE = "0"
PV = "6.24.10"
PR = "5.el10"
PACKAGES = "tcsh"
PROVIDES = "rpm/tcsh"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tcsh-6.24.10-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a99ccf5f6e597a80560fb97f0db4adb1302079bf9c67a9f085d663ddc4805a6"

URI_tcsh = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tcsh-6.24.10-5.el10.x86_64_v2.rpm;name=tcsh;unpack=0"
SRC_URI += "${URI_tcsh}"
SRC_URI[tcsh.sha256sum] = "52c5f14d3441ba2fb5660e43a79e65a898d81ba6b96ec81eced5da8278693e19"
RDEPENDS:tcsh = " \
 libxcrypt \
 grep \
 bash \
 ncurses-libs \
 glibc \
 coreutils \
 sed \
"
