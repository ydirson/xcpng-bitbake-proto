# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Clone"
PE = "0"
PV = "0.46"
PR = "10.el10"
PACKAGES = "perl-Clone perl-Clone-tests"
PROVIDES = "rpm/perl-Clone rpm/perl-Clone-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Clone-0.46-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "98adfcf702c601c5daa6f26b977c7b895c9c1b463b95c0d6e7fac0719d3293ba"

URI_perl-Clone = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Clone-0.46-10.el10.x86_64_v2.rpm;name=perl-Clone;unpack=0"
SRC_URI += "${URI_perl-Clone}"
SRC_URI[perl-Clone.sha256sum] = "0031f4eaebdec1500d629a2541a99fb63013814d75d2bc7542f22011248cdeb4"
RDEPENDS:perl-Clone = " \
 glibc \
 perl-Exporter \
 perl-libs \
 perl-AutoLoader \
"

URI_perl-Clone-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Clone-tests-0.46-10.el10.noarch.rpm;name=perl-Clone-tests;unpack=0"
SRC_URI += "${URI_perl-Clone-tests}"
SRC_URI[perl-Clone-tests.sha256sum] = "14168a81a3f643ac9e51f99357235eae5a5ecbeae44acd8c9b2dd3c4a0977b8a"
RDEPENDS:perl-Clone-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-vars \
 perl-B-COW \
 perl-Clone \
 bash \
 perl-B \
 perl-interpreter \
"
