# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-iso639"
PE = "0"
PV = "0.1.4"
PR = "27.el10"
PACKAGES = "python3-iso639"
PROVIDES = "rpm/python3-iso639"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-iso639-0.1.4-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c0ced74485c19ae70a6e10a694e2764d4a7865edc956f2b55c174b7a2b93a21"

URI_python3-iso639 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-iso639-0.1.4-27.el10.noarch.rpm;name=python3-iso639;unpack=0"
SRC_URI += "${URI_python3-iso639}"
SRC_URI[python3-iso639.sha256sum] = "353064852ca91b427753088149d41ce69359845d1404ac4b7b38e4383837689b"
RDEPENDS:python3-iso639 = " \
 python3 \
"
