# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "network-manager-applet"
PE = "0"
PV = "1.36.0"
PR = "4.el10"
PACKAGES = "network-manager-applet nm-connection-editor nm-connection-editor-desktop"
PROVIDES = "rpm/network-manager-applet rpm/nm-connection-editor rpm/nm-connection-editor-desktop"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/network-manager-applet-1.36.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7c3b7618745b5a56aca836b86288f7c19cb6ae60851d0e56842650b627c06c0"

URI_network-manager-applet = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/network-manager-applet-1.36.0-4.el10.x86_64_v2.rpm;name=network-manager-applet;unpack=0"
SRC_URI += "${URI_network-manager-applet}"
SRC_URI[network-manager-applet.sha256sum] = "c64fbd1ead7a486135164026859c9cf793e3f3ceac8f68f286d26083961d72fe"
RDEPENDS:network-manager-applet = " \
 NetworkManager \
 nm-connection-editor \
 libnma \
"

URI_nm-connection-editor = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nm-connection-editor-1.36.0-4.el10.x86_64_v2.rpm;name=nm-connection-editor;unpack=0"
SRC_URI += "${URI_nm-connection-editor}"
SRC_URI[nm-connection-editor.sha256sum] = "c12bad29e3f8d1cb560a70af8d94db6c155cb9cbc283cff5129c037b6c25da0d"
RDEPENDS:nm-connection-editor = " \
 jansson \
 libgcc \
 glib2 \
 gtk3 \
 glibc \
 libselinux \
 NetworkManager-libnm \
 libnma \
"

URI_nm-connection-editor-desktop = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/nm-connection-editor-desktop-1.36.0-4.el10.x86_64_v2.rpm;name=nm-connection-editor-desktop;unpack=0"
SRC_URI += "${URI_nm-connection-editor-desktop}"
SRC_URI[nm-connection-editor-desktop.sha256sum] = "6fd7b9a68da095f9d81aa1332f5c52b946a885d83c13af1ef935d20a8f5123c4"
RDEPENDS:nm-connection-editor-desktop = " \
 nm-connection-editor \
"
