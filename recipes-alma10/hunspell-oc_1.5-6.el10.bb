# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-oc"
PE = "0"
PV = "1.5"
PR = "6.el10"
PACKAGES = "hunspell-oc"
PROVIDES = "rpm/hunspell-oc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-oc-1.5-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ebd3c2d0d9c6684bdf130839d9bb3f26e535cfd929e4b9ecc1bacefbed0ed15e"

URI_hunspell-oc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-oc-1.5-6.el10.noarch.rpm;name=hunspell-oc;unpack=0"
SRC_URI += "${URI_hunspell-oc}"
SRC_URI[hunspell-oc.sha256sum] = "80a45f6ef40a7a2a30691b7c1cbf4216efc5790b6dc87b1a405b8a4ea84a9f9b"
RDEPENDS:hunspell-oc = " \
 hunspell \
"
