# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "openjade"
PE = "0"
PV = "1.3.2"
PR = "82.el10"
PACKAGES = "openjade"
PROVIDES = "rpm/openjade"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/openjade-1.3.2-82.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52600c10fe1e1d525c9e0b0671bf767ddf722809d620e3fe4f7474059b8e7673"

URI_openjade = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/openjade-1.3.2-82.el10.x86_64_v2.rpm;name=openjade;unpack=0"
SRC_URI += "${URI_openjade}"
SRC_URI[openjade.sha256sum] = "bd6f94f73cd6a853e760a89fb2e750e97d0603c1abf6bc4e14d650223c989e8c"
RDEPENDS:openjade = " \
 sgml-common \
 libgcc \
 libstdc++ \
 bash \
 opensp \
 glibc \
"
