# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-shell"
PE = "0"
PV = "47.4"
PR = "2.el10.alma.2"
PACKAGES = "gnome-shell"
PROVIDES = "rpm/gnome-shell"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-shell-47.4-2.el10.alma.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c368bc366d34c9b9eeb80fd88094930e893691721b7925c38fcc3424123c7a2"

URI_gnome-shell = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-47.4-2.el10.alma.2.x86_64_v2.rpm;name=gnome-shell;unpack=0"
SRC_URI += "${URI_gnome-shell}"
SRC_URI[gnome-shell.sha256sum] = "39baf881c8389472ca0677e5dafaf7b50ab4932e5cfcec056f1241bd515102a3"
RDEPENDS:gnome-shell = " \
 python3 \
 gjs \
 systemd-libs \
 xdg-desktop-portal-gnome \
 xdg-desktop-portal-gtk \
 xdg-user-dirs-gtk \
 pango \
 mutter \
 libX11 \
 ibus \
 upower \
 NetworkManager-libnm \
 gnome-autoar \
 libnma-gtk4 \
 libXfixes \
 tecla \
 accountsservice-libs \
 gnome-control-center \
 evolution-data-server \
 gnome-desktop4 \
 gnome-desktop3 \
 json-glib \
 cairo \
 switcheroo-control \
 libadwaita \
 at-spi2-atk \
 gcr \
 gcr-libs \
 gnome-settings-daemon \
 atk \
 gobject-introspection \
 libglvnd-gles \
 pulseaudio-libs \
 librsvg2 \
 libgcc \
 pulseaudio-libs-glib2 \
 gdk-pixbuf2 \
 libsecret \
 gdm \
 graphene \
 geoclue2-libs \
 pipewire-gstreamer \
 pipewire-libs \
 libgweather \
 gstreamer1 \
 libical-glib \
 gsettings-desktop-schemas \
 gettext \
 gstreamer1-plugins-good \
 polkit \
 polkit-libs \
 glib2 \
 glibc \
 gtk4 \
"
