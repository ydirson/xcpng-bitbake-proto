# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-meh"
PE = "0"
PV = "0.52"
PR = "3.el10"
PACKAGES = "python3-meh python3-meh-gui"
PROVIDES = "rpm/python3-meh rpm/python3-meh-gui"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-meh-0.52-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "276a2bc62673c2a800452558335ec456be1ebd272af95a1d9bd16b45de557ea0"

URI_python3-meh = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-meh-0.52-3.el10.noarch.rpm;name=python3-meh;unpack=0"
SRC_URI += "${URI_python3-meh}"
SRC_URI[python3-meh.sha256sum] = "a8ae45cac2058fcc29943409a0703caf165e5f7f8224ccfd0fe01be83d3356bb"
RDEPENDS:python3-meh = " \
 python3 \
 python3-dbus \
 python3-rpm \
"

URI_python3-meh-gui = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-meh-gui-0.52-3.el10.noarch.rpm;name=python3-meh-gui;unpack=0"
SRC_URI += "${URI_python3-meh-gui}"
SRC_URI[python3-meh-gui.sha256sum] = "c1bbfa97f256c25b2f2715d5201b7a19cc13f0264877ac318f7c20a27f6cec48"
RDEPENDS:python3-meh-gui = " \
 python3 \
 python3-gobject \
 python3-meh \
 gtk3 \
"
