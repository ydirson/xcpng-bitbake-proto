# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-characters"
PE = "0"
PV = "46.0"
PR = "3.el10"
PACKAGES = "gnome-characters"
PROVIDES = "rpm/gnome-characters"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-characters-46.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0233206e32bc021273a4487bb8bfb39a029df29d0646f56ff4e40f7a758f43ce"

URI_gnome-characters = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-characters-46.0-3.el10.x86_64_v2.rpm;name=gnome-characters;unpack=0"
SRC_URI += "${URI_gnome-characters}"
SRC_URI[gnome-characters.sha256sum] = "aa2205eb23fbff44f5879663143dd69b89975c5460150d5a35f71c214fab9ebb"
RDEPENDS:gnome-characters = " \
 gjs \
 gnome-desktop4 \
 glib2 \
 glibc \
 gtk4 \
 libadwaita \
"
