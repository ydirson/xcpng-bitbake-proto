# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-ro"
PE = "0"
PV = "3.3.6"
PR = "29.el10"
PACKAGES = "hyphen-ro"
PROVIDES = "rpm/hyphen-ro"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-ro-3.3.6-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f105152f8055f4417dbf9d22c9e6165d6fddf6734a2cac2d428e8cf8232e6693"

URI_hyphen-ro = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-ro-3.3.6-29.el10.noarch.rpm;name=hyphen-ro;unpack=0"
SRC_URI += "${URI_hyphen-ro}"
SRC_URI[hyphen-ro.sha256sum] = "da7cc008803f2a7d1b2d830e209ce7cd7f7d33f74f23545febfa443f89b375bd"
RDEPENDS:hyphen-ro = " \
 hyphen \
"
