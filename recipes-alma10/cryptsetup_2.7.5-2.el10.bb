# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cryptsetup"
PE = "0"
PV = "2.7.5"
PR = "2.el10"
PACKAGES = "cryptsetup cryptsetup-libs integritysetup veritysetup cryptsetup-devel"
PROVIDES = "rpm/cryptsetup rpm/cryptsetup-libs rpm/integritysetup rpm/veritysetup rpm/cryptsetup-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/cryptsetup-2.7.5-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b181f0a6b22caedcd09250d9dcd648ba013ebd5129fc59cdcb8adf7094c9dc8f"

URI_cryptsetup = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cryptsetup-2.7.5-2.el10.x86_64_v2.rpm;name=cryptsetup;unpack=0"
SRC_URI += "${URI_cryptsetup}"
SRC_URI[cryptsetup.sha256sum] = "6c1aaf898f356f35075c6d01e6c0ec7f9d8825e36961fa369f7de0eef2424374"
RDEPENDS:cryptsetup = " \
 libuuid \
 cryptsetup-libs \
 libpwquality \
 libblkid \
 popt \
 glibc \
"

URI_cryptsetup-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cryptsetup-libs-2.7.5-2.el10.x86_64_v2.rpm;name=cryptsetup-libs;unpack=0"
SRC_URI += "${URI_cryptsetup-libs}"
SRC_URI[cryptsetup-libs.sha256sum] = "5d1e8f853b4d9d646204c59ca68d2a51c83db21bf0db6c48948b7e12b3fdd73a"
RDEPENDS:cryptsetup-libs = " \
 libuuid \
 device-mapper-libs \
 libblkid \
 openssl-libs \
 json-c \
 glibc \
"

URI_integritysetup = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/integritysetup-2.7.5-2.el10.x86_64_v2.rpm;name=integritysetup;unpack=0"
SRC_URI += "${URI_integritysetup}"
SRC_URI[integritysetup.sha256sum] = "bf5fde57e03500395350d72ff05b3388c69b3a06638b48d05f8ec8b8015ac255"
RDEPENDS:integritysetup = " \
 libuuid \
 cryptsetup-libs \
 libblkid \
 popt \
 glibc \
"

URI_veritysetup = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/veritysetup-2.7.5-2.el10.x86_64_v2.rpm;name=veritysetup;unpack=0"
SRC_URI += "${URI_veritysetup}"
SRC_URI[veritysetup.sha256sum] = "cb6aa267092da67ca2a9c4881a208d0abbf52fc8d0ff865ffd887b6a6168f758"
RDEPENDS:veritysetup = " \
 glibc \
 cryptsetup-libs \
 popt \
"

URI_cryptsetup-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/cryptsetup-devel-2.7.5-2.el10.x86_64_v2.rpm;name=cryptsetup-devel;unpack=0"
SRC_URI += "${URI_cryptsetup-devel}"
SRC_URI[cryptsetup-devel.sha256sum] = "e30f23c2790b6989f994e727b8ae15da31a9a33fdd4c268902765b070b1d4d46"
RDEPENDS:cryptsetup-devel = " \
 libblkid-devel \
 cryptsetup-libs \
 pkgconf-pkg-config \
 libuuid-devel \
 openssl-devel \
 device-mapper-devel \
 json-c-devel \
"
