# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tpm2-abrmd"
PE = "0"
PV = "3.0.0"
PR = "7.el10"
PACKAGES = "tpm2-abrmd tpm2-abrmd-devel"
PROVIDES = "rpm/tpm2-abrmd rpm/tpm2-abrmd-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tpm2-abrmd-3.0.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "13646ed0b7ae3189e2283473d629b63ca38f1fc5fef153b20600bcd0d23e97c9"

URI_tpm2-abrmd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tpm2-abrmd-3.0.0-7.el10.x86_64_v2.rpm;name=tpm2-abrmd;unpack=0"
SRC_URI += "${URI_tpm2-abrmd}"
SRC_URI[tpm2-abrmd.sha256sum] = "f9a72236323bf39f02d23aafcc9a0ce83e3326d3bde9ae973210f79db1a1dd71"
RDEPENDS:tpm2-abrmd = " \
 systemd \
 bash \
 glib2 \
 tpm2-tss \
 glibc \
 tpm2-abrmd-selinux \
"

URI_tpm2-abrmd-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/tpm2-abrmd-devel-3.0.0-7.el10.x86_64_v2.rpm;name=tpm2-abrmd-devel;unpack=0"
SRC_URI += "${URI_tpm2-abrmd-devel}"
SRC_URI[tpm2-abrmd-devel.sha256sum] = "18b190da5797e84dac160dd8d46eb5ff150a367ce3b504ebc33520ec66da7ed4"
RDEPENDS:tpm2-abrmd-devel = " \
 tpm2-abrmd \
 glib2-devel \
 tpm2-tss-devel \
 pkgconf-pkg-config \
"
