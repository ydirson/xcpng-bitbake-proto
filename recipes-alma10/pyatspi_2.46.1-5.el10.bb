# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pyatspi"
PE = "0"
PV = "2.46.1"
PR = "5.el10"
PACKAGES = "python3-pyatspi"
PROVIDES = "rpm/python3-pyatspi"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/pyatspi-2.46.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd55cadf022b49996e985c89d0392170c12d5fca37adde1aef4ce36a62360fa6"

URI_python3-pyatspi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-pyatspi-2.46.1-5.el10.noarch.rpm;name=python3-pyatspi;unpack=0"
SRC_URI += "${URI_python3-pyatspi}"
SRC_URI[python3-pyatspi.sha256sum] = "add4bfe3cd3f200b17bfb8b1567af3849d7471c34a155ae3cbebfbd465f74705"
RDEPENDS:python3-pyatspi = " \
 python3 \
 python3-gobject \
 at-spi2-core \
"
