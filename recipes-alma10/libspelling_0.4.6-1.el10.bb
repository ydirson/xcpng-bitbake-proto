# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libspelling"
PE = "0"
PV = "0.4.6"
PR = "1.el10"
PACKAGES = "libspelling libspelling-devel"
PROVIDES = "rpm/libspelling rpm/libspelling-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libspelling-0.4.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbc80ae1d938fb3fc7486a3c56539e2b7a2612fb359eabddd2847acc1c5e2b9d"

URI_libspelling = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libspelling-0.4.6-1.el10.x86_64_v2.rpm;name=libspelling;unpack=0"
SRC_URI += "${URI_libspelling}"
SRC_URI[libspelling.sha256sum] = "39575479577906f33f51cea8ce5dc0f798c6c5176410a607ad4c6f0bfaabfa26"
RDEPENDS:libspelling = " \
 enchant2 \
 libgcc \
 pango \
 glib2 \
 glibc \
 libicu \
 gtk4 \
 gtksourceview5 \
"

URI_libspelling-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libspelling-devel-0.4.6-1.el10.x86_64_v2.rpm;name=libspelling-devel;unpack=0"
SRC_URI += "${URI_libspelling-devel}"
SRC_URI[libspelling-devel.sha256sum] = "1f8d6030d097954544594f148a2d85947a328aa80f9118afb42eb375903eb501"
RDEPENDS:libspelling-devel = " \
 glib2-devel \
 libspelling \
 pkgconf-pkg-config \
 gtksourceview5-devel \
 gtk4-devel \
"
