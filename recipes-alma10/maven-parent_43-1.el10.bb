# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "maven-parent"
PE = "0"
PV = "43"
PR = "1.el10"
PACKAGES = "maven-parent"
PROVIDES = "rpm/maven-parent"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/maven-parent-43-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62bd050274a0d45a52bef33ed9a29c38752bad8846fdaa9490ea76af7a456904"

URI_maven-parent = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-parent-43-1.el10.noarch.rpm;name=maven-parent;unpack=0"
SRC_URI += "${URI_maven-parent}"
SRC_URI[maven-parent.sha256sum] = "c7faf0ea25f3483ed76c3f0501b547261305338a3f1370f7a413ce4549c9b703"
RDEPENDS:maven-parent = " \
 maven-plugin-plugin \
 maven-enforcer-plugin \
 javapackages-filesystem \
 apache-parent \
"
