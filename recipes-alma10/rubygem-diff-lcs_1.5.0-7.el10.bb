# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rubygem-diff-lcs"
PE = "0"
PV = "1.5.0"
PR = "7.el10"
PACKAGES = "rubygem-diff-lcs rubygem-diff-lcs-doc"
PROVIDES = "rpm/rubygem-diff-lcs rpm/rubygem-diff-lcs-doc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/rubygem-diff-lcs-1.5.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51e99df6e08a72db91ef260c5ea08d928e53d6a834dcf77381c471835d8572bb"

URI_rubygem-diff-lcs = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/rubygem-diff-lcs-1.5.0-7.el10.noarch.rpm;name=rubygem-diff-lcs;unpack=0"
SRC_URI += "${URI_rubygem-diff-lcs}"
SRC_URI[rubygem-diff-lcs.sha256sum] = "49cc2ce2d1976f88f23aa57130e624221fede91aff8f163986d1e378f9005d79"
RDEPENDS:rubygem-diff-lcs = " \
 rubygems \
 ruby \
"

URI_rubygem-diff-lcs-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-diff-lcs-doc-1.5.0-7.el10.noarch.rpm;name=rubygem-diff-lcs-doc;unpack=0"
SRC_URI += "${URI_rubygem-diff-lcs-doc}"
SRC_URI[rubygem-diff-lcs-doc.sha256sum] = "4afb82e0470a28c83b4b1b3b8e59beeb1532d02a81dbc12870a500a7d08bfffe"
RDEPENDS:rubygem-diff-lcs-doc = " \
 rubygem-diff-lcs \
"
