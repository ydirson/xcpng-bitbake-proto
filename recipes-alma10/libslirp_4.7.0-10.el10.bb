# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libslirp"
PE = "0"
PV = "4.7.0"
PR = "10.el10"
PACKAGES = "libslirp libslirp-devel"
PROVIDES = "rpm/libslirp rpm/libslirp-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libslirp-4.7.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "899e605ffc1cf2fa926a8d52c2cdffd88a86aab7e8809c09466e0e996543cddb"

URI_libslirp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libslirp-4.7.0-10.el10.x86_64_v2.rpm;name=libslirp;unpack=0"
SRC_URI += "${URI_libslirp}"
SRC_URI[libslirp.sha256sum] = "67881b5dc8505dc8b25edacc18a7c88f6579042774dd4f8aceb6a824f918cfa0"
RDEPENDS:libslirp = " \
 glibc \
 glib2 \
"

URI_libslirp-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libslirp-devel-4.7.0-10.el10.x86_64_v2.rpm;name=libslirp-devel;unpack=0"
SRC_URI += "${URI_libslirp-devel}"
SRC_URI[libslirp-devel.sha256sum] = "ba30262d4e1530f070df426ff55849bebb65d4ef69b7b5ee3f66360d2fdaa007"
RDEPENDS:libslirp-devel = " \
 libslirp \
 glib2-devel \
 pkgconf-pkg-config \
"
