# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-PyMySQL"
PE = "0"
PV = "1.1.1"
PR = "3.el10"
PACKAGES = "python3-PyMySQL python3-PyMySQL+rsa"
PROVIDES = "rpm/python3-PyMySQL rpm/python3-PyMySQL+rsa"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-PyMySQL-1.1.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a93424a8f136c4e6909b2207cd5172e337426177e8e83fb5c8af75a2957f3a43"

URI_python3-PyMySQL = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-PyMySQL-1.1.1-3.el10.noarch.rpm;name=python3-PyMySQL;unpack=0"
SRC_URI += "${URI_python3-PyMySQL}"
SRC_URI[python3-PyMySQL.sha256sum] = "fdc5d9bc099b40e787a8491371573db3b2e5315a0bcaea60a7fd216eb57591dc"
RDEPENDS:python3-PyMySQL = " \
 python3 \
"

URI_python3-PyMySQL+rsa = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-PyMySQL+rsa-1.1.1-3.el10.noarch.rpm;name=python3-PyMySQL+rsa;unpack=0"
SRC_URI += "${URI_python3-PyMySQL+rsa}"
SRC_URI[python3-PyMySQL+rsa.sha256sum] = "0c7d986f4d6be0c1d64f815a6a7796268a12f768d34a25c24ad98f6d977f563b"
RDEPENDS:python3-PyMySQL+rsa = " \
 python3-cryptography \
 python3 \
 python3-PyMySQL \
"
