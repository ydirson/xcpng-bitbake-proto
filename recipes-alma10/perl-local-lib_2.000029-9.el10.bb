# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-local-lib"
PE = "0"
PV = "2.000029"
PR = "9.el10"
PACKAGES = "perl-local-lib perl-homedir perl-local-lib-tests"
PROVIDES = "rpm/perl-local-lib rpm/perl-homedir rpm/perl-local-lib-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-local-lib-2.000029-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e2812b3e5e86506129ce570f1c969f0d9ecaa13b9377a72c2a9a51d7a9b5b07"

URI_perl-local-lib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-local-lib-2.000029-9.el10.noarch.rpm;name=perl-local-lib;unpack=0"
SRC_URI += "${URI_perl-local-lib}"
SRC_URI[perl-local-lib.sha256sum] = "e69645d8c4e0b66033073578e788b58478e21260a6e3509e2ab8b06429b43d6c"
RDEPENDS:perl-local-lib = " \
 perl-PathTools \
 perl-libs \
 perl-Carp \
 perl-File-Basename \
"

URI_perl-homedir = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-homedir-2.000029-9.el10.noarch.rpm;name=perl-homedir;unpack=0"
SRC_URI += "${URI_perl-homedir}"
SRC_URI[perl-homedir.sha256sum] = "37a7c69064552f6212299e5aff6578410e0d11863744b83bed1347193ea2a1fb"
RDEPENDS:perl-homedir = " \
 sed \
 perl-local-lib \
"

URI_perl-local-lib-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-local-lib-tests-2.000029-9.el10.noarch.rpm;name=perl-local-lib-tests;unpack=0"
SRC_URI += "${URI_perl-local-lib-tests}"
SRC_URI[perl-local-lib-tests.sha256sum] = "41f02ca4a8b85f8216e0ac77f707bb8d5d4845248e2afefa63c69609f296a591"
RDEPENDS:perl-local-lib-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-local-lib \
 perl-File-Basename \
 perl-File-Temp \
 perl-IPC-Open3 \
 bash \
 perl-PathTools \
 perl-base \
 perl-interpreter \
 perl-File-Path \
 perl-Exporter \
 perl-lib \
"
