# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cockpit-composer"
PE = "0"
PV = "53"
PR = "1.el10"
PACKAGES = "cockpit-composer"
PROVIDES = "rpm/cockpit-composer"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/cockpit-composer-53-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4600de38557d13f8238bbaec4bbc189d3f5469ac6e0b1a07fc7e5632d690c699"

URI_cockpit-composer = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/cockpit-composer-53-1.el10.noarch.rpm;name=cockpit-composer;unpack=0"
SRC_URI += "${URI_cockpit-composer}"
SRC_URI[cockpit-composer.sha256sum] = "032ad8ee5c64fb4f98af8370e49be2fe9d40e4378abb4966565af03240bc7ab5"
RDEPENDS:cockpit-composer = " \
 cockpit \
 osbuild-composer \
"
