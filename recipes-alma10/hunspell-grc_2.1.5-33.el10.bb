# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-grc"
PE = "0"
PV = "2.1.5"
PR = "33.el10"
PACKAGES = "hunspell-grc"
PROVIDES = "rpm/hunspell-grc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-grc-2.1.5-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe24c0aabdd4a765abf8ee87b064a5e6feeb45eccdeddbc7f142d7ccfe9c1b2e"

URI_hunspell-grc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-grc-2.1.5-33.el10.noarch.rpm;name=hunspell-grc;unpack=0"
SRC_URI += "${URI_hunspell-grc}"
SRC_URI[hunspell-grc.sha256sum] = "72f7718ffac6afbc2125009ea29e89c4baf58517c5b57c5eae402a833959658f"
RDEPENDS:hunspell-grc = " \
 hunspell-filesystem \
"
