# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-sphinx_rtd_theme"
PE = "0"
PV = "2.0.0"
PR = "5.el10"
PACKAGES = "python-sphinx_rtd_theme-doc python3-sphinx_rtd_theme"
PROVIDES = "rpm/python-sphinx_rtd_theme-doc rpm/python3-sphinx_rtd_theme"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/python-sphinx_rtd_theme-2.0.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b50039523a73b7154862aa3239bb24636a164467d739fa84e1f28ed0690961fc"

URI_python-sphinx_rtd_theme-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python-sphinx_rtd_theme-doc-2.0.0-5.el10.noarch.rpm;name=python-sphinx_rtd_theme-doc;unpack=0"
SRC_URI += "${URI_python-sphinx_rtd_theme-doc}"
SRC_URI[python-sphinx_rtd_theme-doc.sha256sum] = "674ee1386b6eb1ddc7a06c0c5e901677e390f278e2b5a5d2a8aebc8baa187822"
RDEPENDS:python-sphinx_rtd_theme-doc = " \
 lato-fonts \
 fontawesome4-fonts \
 google-roboto-slab-fonts \
"

URI_python3-sphinx_rtd_theme = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-sphinx_rtd_theme-2.0.0-5.el10.noarch.rpm;name=python3-sphinx_rtd_theme;unpack=0"
SRC_URI += "${URI_python3-sphinx_rtd_theme}"
SRC_URI[python3-sphinx_rtd_theme.sha256sum] = "fd1647475b3a67ae00a59b6fa0931151470c3d745218309a051172e52fdf6fb3"
RDEPENDS:python3-sphinx_rtd_theme = " \
 python3 \
 python3-sphinx \
 lato-fonts \
 python3-sphinxcontrib-jquery \
 google-roboto-slab-fonts \
 fontawesome4-fonts \
 python3-docutils \
"
