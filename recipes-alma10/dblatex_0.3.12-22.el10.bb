# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dblatex"
PE = "0"
PV = "0.3.12"
PR = "22.el10"
PACKAGES = "dblatex"
PROVIDES = "rpm/dblatex"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/dblatex-0.3.12-22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36e0ef2e21fddb9c7054b6949c0e78fc95b0744a2fcf1bbc5cf53ee52f380998"

URI_dblatex = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/dblatex-0.3.12-22.el10.noarch.rpm;name=dblatex;unpack=0"
SRC_URI += "${URI_dblatex}"
SRC_URI[dblatex.sha256sum] = "57d01dd14b10f86d271da99997c2ebb8ff705cefece15750d7afbbc68281a7d6"
RDEPENDS:dblatex = " \
 python3 \
 texlive-multirow \
 texlive-wasysym \
 texlive-fancybox \
 docbook-dtds \
 texlive-overpic \
 texlive-passivetex \
 texlive-xmltex \
 texlive-pdfpages \
 texlive-anysize \
 texlive-appendix \
 texlive-base \
 texlive-jknapltx \
 texlive-bibtopic \
 texlive-kpathsea \
 texlive-changebar \
 texlive-stmaryrd \
 texlive-subfigure \
 texlive-collection-fontsrecommended \
 texlive-collection-latex \
 texlive-collection-xetex \
 libxslt \
 texlive-ec \
"
