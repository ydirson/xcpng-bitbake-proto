# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-shell-extension-no-overview"
PE = "0"
PV = "47"
PR = "1.el10"
PACKAGES = "gnome-shell-extension-no-overview"
PROVIDES = "rpm/gnome-shell-extension-no-overview"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/gnome-shell-extension-no-overview-47-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57460b8a17c3c4b9bd3d1abfa4a7f662dee3c6fb18bb98a8f8332fa9df8f5163"

URI_gnome-shell-extension-no-overview = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gnome-shell-extension-no-overview-47-1.el10.noarch.rpm;name=gnome-shell-extension-no-overview;unpack=0"
SRC_URI += "${URI_gnome-shell-extension-no-overview}"
SRC_URI[gnome-shell-extension-no-overview.sha256sum] = "73cc22f69b4cfe607b9f185385302f10ddc9be8a725a5bef7670058eecf7705a"
RDEPENDS:gnome-shell-extension-no-overview = ""
