# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Module-Load-Conditional"
PE = "0"
PV = "0.74"
PR = "511.el10"
PACKAGES = "perl-Module-Load-Conditional perl-Module-Load-Conditional-tests"
PROVIDES = "rpm/perl-Module-Load-Conditional rpm/perl-Module-Load-Conditional-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Module-Load-Conditional-0.74-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66bd371b83ce85020d19c768d607657c23c99ac84e6ea53ae608934964ac7e39"

URI_perl-Module-Load-Conditional = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Module-Load-Conditional-0.74-511.el10.noarch.rpm;name=perl-Module-Load-Conditional;unpack=0"
SRC_URI += "${URI_perl-Module-Load-Conditional}"
SRC_URI[perl-Module-Load-Conditional.sha256sum] = "ae72e90cfed7b2e8245b59bc59615e1eaadb238415ac3222403dd50f4633b2c2"
RDEPENDS:perl-Module-Load-Conditional = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-FileHandle \
 perl-version \
 perl-Module-CoreList \
 perl-Module-Load \
 perl-Params-Check \
 perl-Module-Metadata \
 perl-PathTools \
 perl-Exporter \
 perl-Locale-Maketext-Simple \
"

URI_perl-Module-Load-Conditional-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Module-Load-Conditional-tests-0.74-511.el10.noarch.rpm;name=perl-Module-Load-Conditional-tests;unpack=0"
SRC_URI += "${URI_perl-Module-Load-Conditional-tests}"
SRC_URI[perl-Module-Load-Conditional-tests.sha256sum] = "445571d54b6a7932be09c96aeae45435da4ea56e822fbe41e05868321fff0de7"
RDEPENDS:perl-Module-Load-Conditional-tests = " \
 perl-constant \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-FindBin \
 perl-Module-Load-Conditional \
 bash \
 perl-PathTools \
 perl-interpreter \
 perl-Exporter \
 perl-lib \
"
