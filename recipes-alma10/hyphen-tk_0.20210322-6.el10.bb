# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-tk"
PE = "0"
PV = "0.20210322"
PR = "6.el10"
PACKAGES = "hyphen-tk"
PROVIDES = "rpm/hyphen-tk"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-tk-0.20210322-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de6fda5ad0a6dacc136744f37490fd6dfc980fc39f129ebdb5f6a431b57c2b6b"

URI_hyphen-tk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-tk-0.20210322-6.el10.noarch.rpm;name=hyphen-tk;unpack=0"
SRC_URI += "${URI_hyphen-tk}"
SRC_URI[hyphen-tk.sha256sum] = "800bb35cf87014117b84f31af534abc139bb433b54f799f0fcd19ad0e7040bed"
RDEPENDS:hyphen-tk = " \
 hyphen \
"
