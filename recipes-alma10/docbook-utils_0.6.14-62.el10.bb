# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "docbook-utils"
PE = "0"
PV = "0.6.14"
PR = "62.el10"
PACKAGES = "docbook-utils docbook-utils-pdf"
PROVIDES = "rpm/docbook-utils rpm/docbook-utils-pdf"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/docbook-utils-0.6.14-62.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04058dbf367080e7ee8433b833adb2f741325dcac386c63817e87d6f11d2c340"

URI_docbook-utils = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/docbook-utils-0.6.14-62.el10.noarch.rpm;name=docbook-utils;unpack=0"
SRC_URI += "${URI_docbook-utils}"
SRC_URI[docbook-utils.sha256sum] = "6266dd3520c14c0164f14965a56a59d988c55192c45681d8ebba6dc7a9460f55"
RDEPENDS:docbook-utils = " \
 docbook-style-dsssl \
 perl-libs \
 perl-vars \
 gawk \
 grep \
 elinks \
 docbook-dtds \
 perl-Getopt-Long \
 bash \
 which \
 perl-SGMLSpm \
 perl-interpreter \
"

URI_docbook-utils-pdf = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/docbook-utils-pdf-0.6.14-62.el10.noarch.rpm;name=docbook-utils-pdf;unpack=0"
SRC_URI += "${URI_docbook-utils-pdf}"
SRC_URI[docbook-utils-pdf.sha256sum] = "33fe3f4e64c801cbdb41217a17f6b8a41f6b7871139da34991bacb61cf4340bd"
RDEPENDS:docbook-utils-pdf = " \
 texlive-collection-htmlxml \
 docbook-utils \
 texlive-jadetex \
 texlive-dvips \
 bash \
 texlive-collection-fontsrecommended \
"
