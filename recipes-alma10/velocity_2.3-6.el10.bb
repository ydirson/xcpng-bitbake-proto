# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "velocity"
PE = "0"
PV = "2.3"
PR = "6.el10"
PACKAGES = "velocity velocity-javadoc"
PROVIDES = "rpm/velocity rpm/velocity-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/velocity-2.3-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46f13de7c5c9448d133b4bcc740f5a8c69f111a5145c6951175cf5a27ae44785"

URI_velocity = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/velocity-2.3-6.el10.noarch.rpm;name=velocity;unpack=0"
SRC_URI += "${URI_velocity}"
SRC_URI[velocity.sha256sum] = "226d43c6de137b825b09891a25b6953b5d9ad2e84ffc1e5ce3624e0410d62cb9"
RDEPENDS:velocity = " \
 apache-commons-io \
 javapackages-filesystem \
 apache-commons-lang3 \
 slf4j \
"

URI_velocity-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/velocity-javadoc-2.3-6.el10.noarch.rpm;name=velocity-javadoc;unpack=0"
SRC_URI += "${URI_velocity-javadoc}"
SRC_URI[velocity-javadoc.sha256sum] = "d68dfc633dbf3f03d7f148fb609fe96753171dd3c4f7e2f9faa64fb80eb765cf"
RDEPENDS:velocity-javadoc = " \
 javapackages-filesystem \
"
