# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "subversion"
PE = "0"
PV = "1.14.3"
PR = "8.el10"
PACKAGES = "mod_dav_svn python3-subversion subversion subversion-devel subversion-gnome subversion-libs subversion-perl subversion-tools"
PROVIDES = "rpm/mod_dav_svn rpm/python3-subversion rpm/subversion rpm/subversion-devel rpm/subversion-gnome rpm/subversion-libs rpm/subversion-perl rpm/subversion-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/subversion-1.14.3-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7dbea22b423e7739370b8bff4f8a08fe6d729c7ae8693360939aa5d1c9a8fd1"

URI_mod_dav_svn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mod_dav_svn-1.14.3-8.el10.x86_64_v2.rpm;name=mod_dav_svn;unpack=0"
SRC_URI += "${URI_mod_dav_svn}"
SRC_URI[mod_dav_svn.sha256sum] = "f32ef891469163b01ab1a51af37fc2e7701099586967308c3d38bc41bb3e46de"
RDEPENDS:mod_dav_svn = " \
 zlib-ng-compat \
 httpd-core \
 libxcrypt \
 lz4-libs \
 apr \
 utf8proc \
 apr-util \
 sqlite-libs \
 subversion-libs \
 expat \
 glibc \
 file-libs \
"

URI_python3-subversion = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-subversion-1.14.3-8.el10.x86_64_v2.rpm;name=python3-subversion;unpack=0"
SRC_URI += "${URI_python3-subversion}"
SRC_URI[python3-subversion.sha256sum] = "1b4afc7f198a4a833682010bb9b4bc6ec31c2799ab62fd67356f9548df931a37"
RDEPENDS:python3-subversion = " \
 python3 \
 zlib-ng-compat \
 libxcrypt \
 lz4-libs \
 apr \
 utf8proc \
 apr-util \
 sqlite-libs \
 cyrus-sasl-lib \
 subversion-libs \
 expat \
 glibc \
 libserf \
 file-libs \
"

URI_subversion = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/subversion-1.14.3-8.el10.x86_64_v2.rpm;name=subversion;unpack=0"
SRC_URI += "${URI_subversion}"
SRC_URI[subversion.sha256sum] = "d62009331ab16730e3025a3e6b1966fc589d876cca41c1ae20b444f88ad012df"
RDEPENDS:subversion = " \
 systemd \
 apr \
 apr-util \
 subversion-libs \
 bash \
 glibc \
"

URI_subversion-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/subversion-devel-1.14.3-8.el10.x86_64_v2.rpm;name=subversion-devel;unpack=0"
SRC_URI += "${URI_subversion-devel}"
SRC_URI[subversion-devel.sha256sum] = "28fc5535b58e002d20697018e57d921d9df446b43f6b3f9a922437913ac87b21"
RDEPENDS:subversion-devel = " \
 apr-devel \
 pkgconf-pkg-config \
 apr-util-devel \
 subversion-devel \
 subversion-libs \
 libsecret-devel \
 sqlite-devel \
"

URI_subversion-gnome = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/subversion-gnome-1.14.3-8.el10.x86_64_v2.rpm;name=subversion-gnome;unpack=0"
SRC_URI += "${URI_subversion-gnome}"
SRC_URI[subversion-gnome.sha256sum] = "ffd2c72bfc16bf32c7520fd336b8cf6220f8f8daa79b11565d83988e803b369c"
RDEPENDS:subversion-gnome = " \
 zlib-ng-compat \
 libxcrypt \
 lz4-libs \
 apr \
 utf8proc \
 apr-util \
 sqlite-libs \
 libsecret \
 subversion-libs \
 glib2 \
 expat \
 glibc \
 file-libs \
"

URI_subversion-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/subversion-libs-1.14.3-8.el10.x86_64_v2.rpm;name=subversion-libs;unpack=0"
SRC_URI += "${URI_subversion-libs}"
SRC_URI[subversion-libs.sha256sum] = "203e0f418259a73fc7b02dbf33dd255d6bc434903e21a4067caaff41da00fb92"
RDEPENDS:subversion-libs = " \
 zlib-ng-compat \
 libxcrypt \
 lz4-libs \
 apr \
 utf8proc \
 apr-util \
 sqlite-libs \
 cyrus-sasl-lib \
 expat \
 glibc \
 libserf \
 file-libs \
"

URI_subversion-perl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/subversion-perl-1.14.3-8.el10.x86_64_v2.rpm;name=subversion-perl;unpack=0"
SRC_URI += "${URI_subversion-perl}"
SRC_URI[subversion-perl.sha256sum] = "93787a15375bbb99d93ee2dd33662e1cd0e5172274f205f395a54a1bc2d64cf1"
RDEPENDS:subversion-perl = " \
 perl-Scalar-List-Utils \
 perl-libs \
 apr \
 apr-util \
 perl-overload \
 perl-Symbol \
 perl-Carp \
 perl-IO \
 utf8proc \
 zlib-ng-compat \
 libxcrypt \
 perl-DynaLoader \
 sqlite-libs \
 expat \
 file-libs \
 lz4-libs \
 subversion-libs \
 glibc \
 perl-File-Temp \
"

URI_subversion-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/subversion-tools-1.14.3-8.el10.x86_64_v2.rpm;name=subversion-tools;unpack=0"
SRC_URI += "${URI_subversion-tools}"
SRC_URI[subversion-tools.sha256sum] = "edefd91b6b0b7908bbf85c0f74f64e186465ce26b2c76cf4a30bab46c729fbe9"
RDEPENDS:subversion-tools = " \
 glibc \
 apr \
 subversion-libs \
 bash \
"
