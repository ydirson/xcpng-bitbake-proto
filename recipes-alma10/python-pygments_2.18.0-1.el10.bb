# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-pygments"
PE = "0"
PV = "2.18.0"
PR = "1.el10"
PACKAGES = "python3-pygments"
PROVIDES = "rpm/python3-pygments"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/python-pygments-2.18.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e19ad2c946257227c2f803e8c079e679507ae727ae7ff4d91ee24566ebd4ba1"

URI_python3-pygments = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-pygments-2.18.0-1.el10.noarch.rpm;name=python3-pygments;unpack=0"
SRC_URI += "${URI_python3-pygments}"
SRC_URI[python3-pygments.sha256sum] = "0aa5135cbcd64ca51b1db4c3a093720490c54e5ce0f02ef249356855f1b9133a"
RDEPENDS:python3-pygments = " \
 python3 \
"
