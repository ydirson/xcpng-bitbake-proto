# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "javapackages-bootstrap"
PE = "0"
PV = "1.17.0"
PR = "2.el10"
PACKAGES = "javapackages-bootstrap"
PROVIDES = "rpm/javapackages-bootstrap"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/javapackages-bootstrap-1.17.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7307cc4ae358152e97010913b738a5b99a31ba949dce05a8afa05b04e201379f"

URI_javapackages-bootstrap = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/javapackages-bootstrap-1.17.0-2.el10.x86_64_v2.rpm;name=javapackages-bootstrap;unpack=0"
SRC_URI += "${URI_javapackages-bootstrap}"
SRC_URI[javapackages-bootstrap.sha256sum] = "ad74397c676fad37150cc466a3f8e2796422fbb5e4219c9488d2f09c5a39cdbc"
RDEPENDS:javapackages-bootstrap = " \
 javapackages-common \
 java-21-openjdk-devel \
 bash \
 procps-ng \
 coreutils \
 lujavrite \
"
