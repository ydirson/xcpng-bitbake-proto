# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Mozilla-PublicSuffix"
PE = "0"
PV = "1.0.6"
PR = "8.el10"
PACKAGES = "perl-Mozilla-PublicSuffix"
PROVIDES = "rpm/perl-Mozilla-PublicSuffix"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-Mozilla-PublicSuffix-1.0.6-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e27838ae664e26a7cda5efa6a0e4fab333a4939757410ab260556fde7c3df6a5"

URI_perl-Mozilla-PublicSuffix = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Mozilla-PublicSuffix-1.0.6-8.el10.noarch.rpm;name=perl-Mozilla-PublicSuffix;unpack=0"
SRC_URI += "${URI_perl-Mozilla-PublicSuffix}"
SRC_URI[perl-Mozilla-PublicSuffix.sha256sum] = "41ba8acffbb56d41e29d890e7b22e7f403a5b196c3cb3437a93e7bfd65dfed6f"
RDEPENDS:perl-Mozilla-PublicSuffix = " \
 perl-libs \
 perl-URI \
 publicsuffix-list \
 perl-open \
 perl-Exporter \
"
