# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "po4a"
PE = "0"
PV = "0.69"
PR = "7.el10"
PACKAGES = "po4a"
PROVIDES = "rpm/po4a"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/po4a-0.69-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d89cf7183fa23e48d416033504eed96674ff1c6f77d49777f254add60c6f9fe"

URI_po4a = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/po4a-0.69-7.el10.noarch.rpm;name=po4a;unpack=0"
SRC_URI += "${URI_po4a}"
SRC_URI[po4a.sha256sum] = "8ac6b8799221e5fc85c3c801276f19025aa0ce6326761421b9e1e1ef0cece2d3"
RDEPENDS:po4a = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Locale-gettext \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-Pod-Parser \
 perl-Syntax-Keyword-Try \
 perl-subs \
 perl-TermReadKey \
 perl-Carp \
 perl-Text-WrapI18N \
 perl-vars \
 perl-IO \
 perl-I18N-Langinfo \
 perl-YAML-Tiny \
 perl-Time-Local \
 perl-Unicode-LineBreak \
 texlive-kpathsea \
 po4a \
 perl-DynaLoader \
 perl-Encode \
 bash \
 opensp \
 perl-Exporter \
 libxslt \
 perl-Fcntl \
 gettext \
 perl-File-Basename \
 perl-POSIX \
 perl-File-Copy \
 perl-PathTools \
 perl-interpreter \
 perl-File-Path \
 perl-File-Temp \
 perl-Pod-Usage \
"
