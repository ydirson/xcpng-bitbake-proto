# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "maven-dependency-tree"
PE = "0"
PV = "3.2.1"
PR = "7.el10"
PACKAGES = "maven-dependency-tree maven-dependency-tree-javadoc"
PROVIDES = "rpm/maven-dependency-tree rpm/maven-dependency-tree-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/maven-dependency-tree-3.2.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc17f3e7f2df5e4e0e876972f0ea1490d47598edb62108dcccbc1c1f246b13a3"

URI_maven-dependency-tree = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-dependency-tree-3.2.1-7.el10.noarch.rpm;name=maven-dependency-tree;unpack=0"
SRC_URI += "${URI_maven-dependency-tree}"
SRC_URI[maven-dependency-tree.sha256sum] = "6d1f9745dafe4ec2d8ba94b91d98f78dbd1ec2a14a1624375ebfb471c5157d4a"
RDEPENDS:maven-dependency-tree = " \
 maven-resolver \
 javapackages-filesystem \
 slf4j \
"

URI_maven-dependency-tree-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-dependency-tree-javadoc-3.2.1-7.el10.noarch.rpm;name=maven-dependency-tree-javadoc;unpack=0"
SRC_URI += "${URI_maven-dependency-tree-javadoc}"
SRC_URI[maven-dependency-tree-javadoc.sha256sum] = "9403d23d064145d9b6f68120e7527b8396e219fd91039e89f1636fbc7b765580"
RDEPENDS:maven-dependency-tree-javadoc = " \
 javapackages-filesystem \
"
