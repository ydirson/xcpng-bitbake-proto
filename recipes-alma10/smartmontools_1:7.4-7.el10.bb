# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "smartmontools"
PE = "1"
PV = "7.4"
PR = "7.el10"
PACKAGES = "smartmontools smartmontools-selinux"
PROVIDES = "rpm/smartmontools rpm/smartmontools-selinux"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/smartmontools-7.4-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2cb483b4557c36a40ca25491479d882ef71d6e2469193c39858100cc6852ab69"

URI_smartmontools = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/smartmontools-7.4-7.el10.x86_64_v2.rpm;name=smartmontools;unpack=0"
SRC_URI += "${URI_smartmontools}"
SRC_URI[smartmontools.sha256sum] = "14c44bfca8c0b07cd008929a025215ca337def997eeea26f604e3f106a8686fb"
RDEPENDS:smartmontools = " \
 systemd-libs \
 smartmontools-selinux \
 libgcc \
 libcap-ng \
 libstdc++ \
 bash \
 glibc \
 libselinux \
"

URI_smartmontools-selinux = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/smartmontools-selinux-7.4-7.el10.noarch.rpm;name=smartmontools-selinux;unpack=0"
SRC_URI += "${URI_smartmontools-selinux}"
SRC_URI[smartmontools-selinux.sha256sum] = "9c945242f455b8bf79d75ee4e761aa7f53cf780b4e366a66c05a92dfec797844"
RDEPENDS:smartmontools-selinux = " \
 policycoreutils \
 bash \
 selinux-policy \
 libselinux-utils \
 selinux-policy-targeted \
"
