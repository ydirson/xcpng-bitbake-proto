# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "maven-surefire"
PE = "0"
PV = "3.2.2"
PR = "6.el10"
PACKAGES = "maven-failsafe-plugin maven-surefire maven-surefire-javadoc maven-surefire-plugin maven-surefire-provider-junit maven-surefire-provider-junit5 maven-surefire-provider-testng"
PROVIDES = "rpm/maven-failsafe-plugin rpm/maven-surefire rpm/maven-surefire-javadoc rpm/maven-surefire-plugin rpm/maven-surefire-provider-junit rpm/maven-surefire-provider-junit5 rpm/maven-surefire-provider-testng"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/maven-surefire-3.2.2-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4153b4261c2cd9ca509c6ef65aafba01886d7be7413431dc99f049af0cebc9d0"

URI_maven-failsafe-plugin = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-failsafe-plugin-3.2.2-6.el10.noarch.rpm;name=maven-failsafe-plugin;unpack=0"
SRC_URI += "${URI_maven-failsafe-plugin}"
SRC_URI[maven-failsafe-plugin.sha256sum] = "6bc4ae9069da52ca99110fd8c535aee58fe3c3b74d9c68685e5cb13be70339b4"
RDEPENDS:maven-failsafe-plugin = " \
 javapackages-filesystem \
 maven-surefire \
"

URI_maven-surefire = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-surefire-3.2.2-6.el10.noarch.rpm;name=maven-surefire;unpack=0"
SRC_URI += "${URI_maven-surefire}"
SRC_URI[maven-surefire.sha256sum] = "a1f3e00a7aa6565cb43de073afd1c4aa66e1b647206421b3980a5d605ab13f6d"
RDEPENDS:maven-surefire = " \
 apache-commons-compress \
 apache-commons-io \
 javapackages-filesystem \
 apache-commons-lang3 \
 maven-common-artifact-filters \
 procps-ng \
 maven-resolver \
 maven-shared-utils \
 plexus-languages \
"

URI_maven-surefire-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-surefire-javadoc-3.2.2-6.el10.noarch.rpm;name=maven-surefire-javadoc;unpack=0"
SRC_URI += "${URI_maven-surefire-javadoc}"
SRC_URI[maven-surefire-javadoc.sha256sum] = "25715927aa8862be3e44fd9b80f4113b4037363b85eaa006564f79b11830beab"
RDEPENDS:maven-surefire-javadoc = " \
 javapackages-filesystem \
"

URI_maven-surefire-plugin = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-surefire-plugin-3.2.2-6.el10.noarch.rpm;name=maven-surefire-plugin;unpack=0"
SRC_URI += "${URI_maven-surefire-plugin}"
SRC_URI[maven-surefire-plugin.sha256sum] = "25cf1e0911e637251330fb0c44d05d7b7a485da364b178d1a22d0e3227476a43"
RDEPENDS:maven-surefire-plugin = " \
 maven-surefire-provider-junit \
 maven-surefire-provider-junit5 \
 maven-surefire-provider-testng \
 javapackages-filesystem \
 maven-surefire \
"

URI_maven-surefire-provider-junit = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-surefire-provider-junit-3.2.2-6.el10.noarch.rpm;name=maven-surefire-provider-junit;unpack=0"
SRC_URI += "${URI_maven-surefire-provider-junit}"
SRC_URI[maven-surefire-provider-junit.sha256sum] = "77e77a420b13ca33f160d7dcd66e559c6606d18326708e8e9231a52f1513fd5f"
RDEPENDS:maven-surefire-provider-junit = " \
 javapackages-filesystem \
 maven-surefire \
"

URI_maven-surefire-provider-junit5 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-surefire-provider-junit5-3.2.2-6.el10.noarch.rpm;name=maven-surefire-provider-junit5;unpack=0"
SRC_URI += "${URI_maven-surefire-provider-junit5}"
SRC_URI[maven-surefire-provider-junit5.sha256sum] = "ed075f11f73218cd4f61819d2ad203ae1525ae13dd008067aa55348656959d46"
RDEPENDS:maven-surefire-provider-junit5 = " \
 junit5 \
 javapackages-filesystem \
 maven-surefire \
"

URI_maven-surefire-provider-testng = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-surefire-provider-testng-3.2.2-6.el10.noarch.rpm;name=maven-surefire-provider-testng;unpack=0"
SRC_URI += "${URI_maven-surefire-provider-testng}"
SRC_URI[maven-surefire-provider-testng.sha256sum] = "aa9d4e19c51dc3db226abac9086c07647d3acc6b5446450f20d90b77cc1cfb20"
RDEPENDS:maven-surefire-provider-testng = " \
 javapackages-filesystem \
 maven-surefire \
"
