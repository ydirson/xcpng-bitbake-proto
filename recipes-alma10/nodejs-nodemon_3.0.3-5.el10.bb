# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "nodejs-nodemon"
PE = "0"
PV = "3.0.3"
PR = "5.el10"
PACKAGES = "nodejs-nodemon"
PROVIDES = "rpm/nodejs-nodemon"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/nodejs-nodemon-3.0.3-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92c8b6e5e93554e02605ff09f747e521d5e097fb1a8c038c3429173672dc2d8f"

URI_nodejs-nodemon = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nodejs-nodemon-3.0.3-5.el10.noarch.rpm;name=nodejs-nodemon;unpack=0"
SRC_URI += "${URI_nodejs-nodemon}"
SRC_URI[nodejs-nodemon.sha256sum] = "f0067da1d5d70c4974031fa9d58791313dcd07abec90625a6cb1d8c4602a53ae"
RDEPENDS:nodejs-nodemon = " \
 nodejs \
"
