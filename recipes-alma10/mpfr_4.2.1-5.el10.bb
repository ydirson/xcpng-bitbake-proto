# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mpfr"
PE = "0"
PV = "4.2.1"
PR = "5.el10"
PACKAGES = "mpfr mpfr-devel mpfr-doc"
PROVIDES = "rpm/mpfr rpm/mpfr-devel rpm/mpfr-doc"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/mpfr-4.2.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "513a7c3f0fc0dfd0fd54bd9a13aba2207bab4f6a7aec20c6de513efaf96eb437"

URI_mpfr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/mpfr-4.2.1-5.el10.x86_64_v2.rpm;name=mpfr;unpack=0"
SRC_URI += "${URI_mpfr}"
SRC_URI[mpfr.sha256sum] = "4aba1c9d70985c0bf3dfb238bb83231ffd96cf17c593c2e33def3b61e206df1b"
RDEPENDS:mpfr = " \
 glibc \
 gmp \
"

URI_mpfr-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mpfr-devel-4.2.1-5.el10.x86_64_v2.rpm;name=mpfr-devel;unpack=0"
SRC_URI += "${URI_mpfr-devel}"
SRC_URI[mpfr-devel.sha256sum] = "ac23f0268bf528f80504a60fd35bef4d656bc9b516614882079df0e21f204339"
RDEPENDS:mpfr-devel = " \
 gmp-devel \
 mpfr \
 pkgconf-pkg-config \
"

URI_mpfr-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mpfr-doc-4.2.1-5.el10.noarch.rpm;name=mpfr-doc;unpack=0"
SRC_URI += "${URI_mpfr-doc}"
SRC_URI[mpfr-doc.sha256sum] = "b6b9dd0611cc2039740572f83011d92933cfa1813c70faf99690e300fa7c1934"
RDEPENDS:mpfr-doc = ""
