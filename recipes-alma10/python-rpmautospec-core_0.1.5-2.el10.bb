# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-rpmautospec-core"
PE = "0"
PV = "0.1.5"
PR = "2.el10"
PACKAGES = "python3-rpmautospec-core"
PROVIDES = "rpm/python3-rpmautospec-core"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/python-rpmautospec-core-0.1.5-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee19eae39ce252452f384ac71a7ab405dc241f2af5a1382de6343affba5e1607"

URI_python3-rpmautospec-core = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-rpmautospec-core-0.1.5-2.el10.noarch.rpm;name=python3-rpmautospec-core;unpack=0"
SRC_URI += "${URI_python3-rpmautospec-core}"
SRC_URI[python3-rpmautospec-core.sha256sum] = "77677d071fc7850739fb4dfea869ebd65a03d1077a28e1c6231eafda866dc6d6"
RDEPENDS:python3-rpmautospec-core = " \
 python3 \
"
