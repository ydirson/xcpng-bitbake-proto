# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "synce4l"
PE = "0"
PV = "1.1.0"
PR = "5.el10"
PACKAGES = "synce4l"
PROVIDES = "rpm/synce4l"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/synce4l-1.1.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2225733b8450121e809bf4d2d9988bdae0849838a02c962b69830cc0a57a12f8"

URI_synce4l = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/synce4l-1.1.0-5.el10.x86_64_v2.rpm;name=synce4l;unpack=0"
SRC_URI += "${URI_synce4l}"
SRC_URI[synce4l.sha256sum] = "216c09027acade9e973e776903ed1cab1b73ac73a7fa5bd1b9d809ca6ceddf4b"
RDEPENDS:synce4l = " \
 glibc \
 systemd \
 bash \
 libnl3 \
"
