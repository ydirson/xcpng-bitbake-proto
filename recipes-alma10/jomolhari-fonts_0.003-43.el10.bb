# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jomolhari-fonts"
PE = "0"
PV = "0.003"
PR = "43.el10"
PACKAGES = "jomolhari-fonts"
PROVIDES = "rpm/jomolhari-fonts"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/jomolhari-fonts-0.003-43.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b69a58977dc43799c7dcf77ece8de0a5feb1bd439a2cde47564a53ec169bef7"

URI_jomolhari-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jomolhari-fonts-0.003-43.el10.noarch.rpm;name=jomolhari-fonts;unpack=0"
SRC_URI += "${URI_jomolhari-fonts}"
SRC_URI[jomolhari-fonts.sha256sum] = "5c5edabf9aac058ba1f63ca9597ee8e0e39e012122fcf20b96e1bb91ac421ec7"
RDEPENDS:jomolhari-fonts = " \
 fonts-filesystem \
"
