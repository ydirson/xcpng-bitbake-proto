# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Text-Diff"
PE = "0"
PV = "1.45"
PR = "24.el10"
PACKAGES = "perl-Text-Diff perl-Text-Diff-tests"
PROVIDES = "rpm/perl-Text-Diff rpm/perl-Text-Diff-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Text-Diff-1.45-24.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4df264cb25a2e71d52d80b8defc47977ebe71edf5cef1d79a483704ac18e7090"

URI_perl-Text-Diff = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Text-Diff-1.45-24.el10.noarch.rpm;name=perl-Text-Diff;unpack=0"
SRC_URI += "${URI_perl-Text-Diff}"
SRC_URI[perl-Text-Diff.sha256sum] = "f6a26df2078138be4b3d30e5ca9b04fd5b179d993efe953a77031aa1213d4a3c"
RDEPENDS:perl-Text-Diff = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-Text-Diff \
 perl-Algorithm-Diff \
 perl-Exporter \
"

URI_perl-Text-Diff-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Text-Diff-tests-1.45-24.el10.noarch.rpm;name=perl-Text-Diff-tests;unpack=0"
SRC_URI += "${URI_perl-Text-Diff-tests}"
SRC_URI[perl-Text-Diff-tests.sha256sum] = "d8d2a69839341c9d5b8d40257ccd3422d38d81f49d36f270b6d5ba9561d63dc2"
RDEPENDS:perl-Text-Diff-tests = " \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Text-Diff \
 bash \
 perl-interpreter \
 perl-Data-Dumper \
"
