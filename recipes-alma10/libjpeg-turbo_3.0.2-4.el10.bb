# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libjpeg-turbo"
PE = "0"
PV = "3.0.2"
PR = "4.el10"
PACKAGES = "libjpeg-turbo libjpeg-turbo-devel libjpeg-turbo-utils turbojpeg turbojpeg-devel"
PROVIDES = "rpm/libjpeg-turbo rpm/libjpeg-turbo-devel rpm/libjpeg-turbo-utils rpm/turbojpeg rpm/turbojpeg-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libjpeg-turbo-3.0.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5b86c33d06259116ccf3e39d365ad98320f93fe4b7f3cd051fe5accbefcfb9c"

URI_libjpeg-turbo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libjpeg-turbo-3.0.2-4.el10.x86_64_v2.rpm;name=libjpeg-turbo;unpack=0"
SRC_URI += "${URI_libjpeg-turbo}"
SRC_URI[libjpeg-turbo.sha256sum] = "728508ad184277169cd63265cdcbf67bbe0f5bde3b0965172eae70edb4d5917e"
RDEPENDS:libjpeg-turbo = " \
 glibc \
"

URI_libjpeg-turbo-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libjpeg-turbo-devel-3.0.2-4.el10.x86_64_v2.rpm;name=libjpeg-turbo-devel;unpack=0"
SRC_URI += "${URI_libjpeg-turbo-devel}"
SRC_URI[libjpeg-turbo-devel.sha256sum] = "357d103110c330c358a6840620e61e1352f54aff7007025d4ae4ad12f421c872"
RDEPENDS:libjpeg-turbo-devel = " \
 libjpeg-turbo \
 cmake-filesystem \
 pkgconf-pkg-config \
"

URI_libjpeg-turbo-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libjpeg-turbo-utils-3.0.2-4.el10.x86_64_v2.rpm;name=libjpeg-turbo-utils;unpack=0"
SRC_URI += "${URI_libjpeg-turbo-utils}"
SRC_URI[libjpeg-turbo-utils.sha256sum] = "f6e61cd3995c7a30269705527cc3b901b509c192af4fc5135d84fa14a12b3e99"
RDEPENDS:libjpeg-turbo-utils = " \
 glibc \
 libjpeg-turbo \
"

URI_turbojpeg = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/turbojpeg-3.0.2-4.el10.x86_64_v2.rpm;name=turbojpeg;unpack=0"
SRC_URI += "${URI_turbojpeg}"
SRC_URI[turbojpeg.sha256sum] = "57757803c80e56f744c5e5035f861c6f906bc1e431d795f4fa010bbbecec6de6"
RDEPENDS:turbojpeg = " \
 glibc \
"

URI_turbojpeg-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/turbojpeg-devel-3.0.2-4.el10.x86_64_v2.rpm;name=turbojpeg-devel;unpack=0"
SRC_URI += "${URI_turbojpeg-devel}"
SRC_URI[turbojpeg-devel.sha256sum] = "b47c738218b01bc45927b882d6ced19a5f9247ffe49475347a738479e0cbf4f8"
RDEPENDS:turbojpeg-devel = " \
 turbojpeg \
 pkgconf-pkg-config \
"
