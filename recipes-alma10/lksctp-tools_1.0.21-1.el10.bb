# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lksctp-tools"
PE = "0"
PV = "1.0.21"
PR = "1.el10"
PACKAGES = "lksctp-tools lksctp-tools-devel lksctp-tools-doc"
PROVIDES = "rpm/lksctp-tools rpm/lksctp-tools-devel rpm/lksctp-tools-doc"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/lksctp-tools-1.0.21-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "437c28b80141a242016644093cd263499f575b9eb34b3be3ed186f3215c60684"

URI_lksctp-tools = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/lksctp-tools-1.0.21-1.el10.x86_64_v2.rpm;name=lksctp-tools;unpack=0"
SRC_URI += "${URI_lksctp-tools}"
SRC_URI[lksctp-tools.sha256sum] = "21254d6ebf7586fe11e92a01564e3fedf8a6565a2645344067fa1b144a074d01"
RDEPENDS:lksctp-tools = " \
 glibc \
 bash \
"

URI_lksctp-tools-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lksctp-tools-devel-1.0.21-1.el10.x86_64_v2.rpm;name=lksctp-tools-devel;unpack=0"
SRC_URI += "${URI_lksctp-tools-devel}"
SRC_URI[lksctp-tools-devel.sha256sum] = "db8f269f3a6fcf029a8293ec16888faa9791acc9d29b70d0d080429a48d7be8c"
RDEPENDS:lksctp-tools-devel = " \
 lksctp-tools \
 pkgconf-pkg-config \
"

URI_lksctp-tools-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lksctp-tools-doc-1.0.21-1.el10.x86_64_v2.rpm;name=lksctp-tools-doc;unpack=0"
SRC_URI += "${URI_lksctp-tools-doc}"
SRC_URI[lksctp-tools-doc.sha256sum] = "4c1f5c9521fc62df054f2a24d6d1078224ec75b8ff15dd51978d35cb0a4a9cfe"
RDEPENDS:lksctp-tools-doc = " \
 lksctp-tools \
"
