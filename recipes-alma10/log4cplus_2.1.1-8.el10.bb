# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "log4cplus"
PE = "0"
PV = "2.1.1"
PR = "8.el10"
PACKAGES = "log4cplus log4cplus-devel log4cplus-static"
PROVIDES = "rpm/log4cplus rpm/log4cplus-devel rpm/log4cplus-static"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/log4cplus-2.1.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "955656cb984e4e2b3f7fd1810c4a846733c90207639ad7cdbde825415cc2731b"

URI_log4cplus = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/log4cplus-2.1.1-8.el10.x86_64_v2.rpm;name=log4cplus;unpack=0"
SRC_URI += "${URI_log4cplus}"
SRC_URI[log4cplus.sha256sum] = "92aa93f69480df9d0bb13e1818b0b41e08f42212e9886370e5aeee79824afc55"
RDEPENDS:log4cplus = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_log4cplus-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/log4cplus-devel-2.1.1-8.el10.x86_64_v2.rpm;name=log4cplus-devel;unpack=0"
SRC_URI += "${URI_log4cplus-devel}"
SRC_URI[log4cplus-devel.sha256sum] = "fec1e4c3442d852e92a2ada9d9c6443afc6bd85fe616c2f1cd0dfb6b04574834"
RDEPENDS:log4cplus-devel = " \
 pkgconf-pkg-config \
 log4cplus \
"

URI_log4cplus-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/log4cplus-static-2.1.1-8.el10.x86_64_v2.rpm;name=log4cplus-static;unpack=0"
SRC_URI += "${URI_log4cplus-static}"
SRC_URI[log4cplus-static.sha256sum] = "baa4ab77561e1484f6641d17dea522a64d7ff93bf1e3564e22ae9e262582ecc4"
RDEPENDS:log4cplus-static = " \
 log4cplus-devel \
"
