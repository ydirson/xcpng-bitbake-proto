# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xhtml1-dtds"
PE = "0"
PV = "1.0"
PR = "20020801.22.el10"
PACKAGES = "xhtml1-dtds"
PROVIDES = "rpm/xhtml1-dtds"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xhtml1-dtds-1.0-20020801.22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d18cc81c1ca6b91a0c7d2c1ef328e49fe2a9683c1cb72782cec6b521efe8cc94"

URI_xhtml1-dtds = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xhtml1-dtds-1.0-20020801.22.el10.noarch.rpm;name=xhtml1-dtds;unpack=0"
SRC_URI += "${URI_xhtml1-dtds}"
SRC_URI[xhtml1-dtds.sha256sum] = "dff53a5351125b1693672839d0f8e16878a80e80998e057fbb449a44b4ddf614"
RDEPENDS:xhtml1-dtds = " \
 sgml-common \
 bash \
 libxml2 \
 xml-common \
"
