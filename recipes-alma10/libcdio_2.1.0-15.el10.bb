# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libcdio"
PE = "0"
PV = "2.1.0"
PR = "15.el10"
PACKAGES = "libcdio libcdio-devel"
PROVIDES = "rpm/libcdio rpm/libcdio-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libcdio-2.1.0-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a373348fbb7b0d9ebaa1c3573232884b661c49088dd32f68280532049bf2f19e"

URI_libcdio = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libcdio-2.1.0-15.el10.x86_64_v2.rpm;name=libcdio;unpack=0"
SRC_URI += "${URI_libcdio}"
SRC_URI[libcdio.sha256sum] = "cf09d95ef92fd80b8ef0d74157e8cc65e3bc505d6d303478ccb8beed8ce7add9"
RDEPENDS:libcdio = " \
 glibc \
 libgcc \
 ncurses-libs \
 libstdc++ \
"

URI_libcdio-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libcdio-devel-2.1.0-15.el10.x86_64_v2.rpm;name=libcdio-devel;unpack=0"
SRC_URI += "${URI_libcdio-devel}"
SRC_URI[libcdio-devel.sha256sum] = "14014a3fbb0f65192d4dc6f9124240a789f5e0b5b413c9915ad5ab599928be63"
RDEPENDS:libcdio-devel = " \
 libcdio-devel \
 pkgconf-pkg-config \
 libcdio \
"
