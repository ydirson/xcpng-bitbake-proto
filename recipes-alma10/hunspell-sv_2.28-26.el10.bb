# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-sv"
PE = "0"
PV = "2.28"
PR = "26.el10"
PACKAGES = "hunspell-sv"
PROVIDES = "rpm/hunspell-sv"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-sv-2.28-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83d476ae926ed9a59b6f5a530dfe49031d849ee2240a0d4948d5e1b7b7be7020"

URI_hunspell-sv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-sv-2.28-26.el10.noarch.rpm;name=hunspell-sv;unpack=0"
SRC_URI += "${URI_hunspell-sv}"
SRC_URI[hunspell-sv.sha256sum] = "f2ac738bb9381550efa07f4008e45bfe298c152ffd5383a21103e0ac5c112398"
RDEPENDS:hunspell-sv = " \
 hunspell \
"
