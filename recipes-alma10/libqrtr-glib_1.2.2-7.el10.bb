# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libqrtr-glib"
PE = "0"
PV = "1.2.2"
PR = "7.el10"
PACKAGES = "libqrtr-glib libqrtr-glib-devel"
PROVIDES = "rpm/libqrtr-glib rpm/libqrtr-glib-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libqrtr-glib-1.2.2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "719ffcf8a514ceda2b5c13b71790dfcaffde62793ec21d6988162b9051542e7f"

URI_libqrtr-glib = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libqrtr-glib-1.2.2-7.el10.x86_64_v2.rpm;name=libqrtr-glib;unpack=0"
SRC_URI += "${URI_libqrtr-glib}"
SRC_URI[libqrtr-glib.sha256sum] = "a1d4739d2bf41a3be62a0266197db9ce35e390365eca95379e7a259b6822be2c"
RDEPENDS:libqrtr-glib = " \
 glibc \
 libgcc \
 glib2 \
"

URI_libqrtr-glib-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libqrtr-glib-devel-1.2.2-7.el10.x86_64_v2.rpm;name=libqrtr-glib-devel;unpack=0"
SRC_URI += "${URI_libqrtr-glib-devel}"
SRC_URI[libqrtr-glib-devel.sha256sum] = "1f27afe31a813abe7361889a84a659dc1988a752dd1b94abd02805cd8452e132"
RDEPENDS:libqrtr-glib-devel = " \
 glib2-devel \
 libqrtr-glib \
 pkgconf-pkg-config \
"
