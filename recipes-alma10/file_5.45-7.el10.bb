# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "file"
PE = "0"
PV = "5.45"
PR = "7.el10"
PACKAGES = "file file-libs python3-file-magic file-devel file-static"
PROVIDES = "rpm/file rpm/file-libs rpm/python3-file-magic rpm/file-devel rpm/file-static"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/file-5.45-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "121672e865a8e772d321a37433169104c42de4b3f3494f6631631d3afab59adf"

URI_file = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/file-5.45-7.el10.x86_64_v2.rpm;name=file;unpack=0"
SRC_URI += "${URI_file}"
SRC_URI[file.sha256sum] = "c00e7f4b04b233284704d655338192df3a7a994807504eb6369907ca36972ae9"
RDEPENDS:file = " \
 glibc \
 file-libs \
"

URI_file-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/file-libs-5.45-7.el10.x86_64_v2.rpm;name=file-libs;unpack=0"
SRC_URI += "${URI_file-libs}"
SRC_URI[file-libs.sha256sum] = "a64d0e67bbb7e9153e27fdd0dad3977a16d1a9ea8bd15395fed018d18f63be42"
RDEPENDS:file-libs = " \
 glibc \
 zlib-ng-compat \
"

URI_python3-file-magic = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-file-magic-5.45-7.el10.noarch.rpm;name=python3-file-magic;unpack=0"
SRC_URI += "${URI_python3-file-magic}"
SRC_URI[python3-file-magic.sha256sum] = "24ab3ec5362d1767fe0156f009c9f503eb6a5a86e73c1e2b0672d6451cf259fd"
RDEPENDS:python3-file-magic = " \
 python3 \
 file-libs \
"

URI_file-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/file-devel-5.45-7.el10.x86_64_v2.rpm;name=file-devel;unpack=0"
SRC_URI += "${URI_file-devel}"
SRC_URI[file-devel.sha256sum] = "8935d8cc834d5deb3bb33d813b2d0fa7dd7441f083a674f21b7f3ce43d22ece5"
RDEPENDS:file-devel = " \
 file-libs \
 pkgconf-pkg-config \
"

URI_file-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/file-static-5.45-7.el10.x86_64_v2.rpm;name=file-static;unpack=0"
SRC_URI += "${URI_file-static}"
SRC_URI[file-static.sha256sum] = "ebce0c4f4c5416fcda39360663e8a12672159dc1713ad4fdc189aa29be3f6622"
RDEPENDS:file-static = " \
 file-devel \
"
