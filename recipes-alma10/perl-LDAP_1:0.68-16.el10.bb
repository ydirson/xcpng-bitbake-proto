# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-LDAP"
PE = "1"
PV = "0.68"
PR = "16.el10"
PACKAGES = "perl-LDAP perl-LDAP-tests"
PROVIDES = "rpm/perl-LDAP rpm/perl-LDAP-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-LDAP-0.68-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6621bcddba1e3e4b5328de88d2f35cbcc324c2c6b919cbaf9a7b8cd346f6243"

URI_perl-LDAP = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-LDAP-0.68-16.el10.noarch.rpm;name=perl-LDAP;unpack=0"
SRC_URI += "${URI_perl-LDAP}"
SRC_URI[perl-LDAP.sha256sum] = "84d58baa55e5ed317dd474f4fd014d9c2e2fffb8a5c0d29b4b1fb5e4d2038b05"
RDEPENDS:perl-LDAP = " \
 perl-libs \
 perl-libwww-perl \
 perl-Socket \
 perl-Authen-SASL \
 perl-HTTP-Message \
 perl-HTTP-Negotiate \
 perl-Carp \
 perl-IO \
 perl-Text-Soundex \
 perl-IO-Socket-SSL \
 perl-Convert-ASN1 \
 perl-JSON \
 perl-LDAP \
 perl-LWP-MediaTypes \
 perl-Time-Local \
 perl-MIME-Base64 \
 perl-Encode \
 perl-Exporter \
 perl-base \
 perl-constant \
"

URI_perl-LDAP-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-LDAP-tests-0.68-16.el10.noarch.rpm;name=perl-LDAP-tests;unpack=0"
SRC_URI += "${URI_perl-LDAP-tests}"
SRC_URI[perl-LDAP-tests.sha256sum] = "b8fdfc12d3e06d05815ec13cd052cca70d86d7ebe2df0aabf0dd42bc6a059aaa"
RDEPENDS:perl-LDAP-tests = " \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-IO \
 perl-Text-Soundex \
 perl-File-Basename \
 perl-File-Compare \
 perl-Convert-ASN1 \
 perl-PathTools \
 bash \
 perl-LDAP \
 coreutils \
 perl-interpreter \
 perl-File-Path \
"
