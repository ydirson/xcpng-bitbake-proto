# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtsvg"
PE = "0"
PV = "6.8.1"
PR = "1.el10_0.1"
PACKAGES = "qt6-qtsvg qt6-qtsvg-devel qt6-qtsvg-examples qt6-qtsvg-tests"
PROVIDES = "rpm/qt6-qtsvg rpm/qt6-qtsvg-devel rpm/qt6-qtsvg-examples rpm/qt6-qtsvg-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtsvg-6.8.1-1.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b4098d9f873b07cdd24ea87bb28b665e612db720dffb47a843ca4bd27aaea34"

URI_qt6-qtsvg = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtsvg-6.8.1-1.el10_0.1.x86_64_v2.rpm;name=qt6-qtsvg;unpack=0"
SRC_URI += "${URI_qt6-qtsvg}"
SRC_URI[qt6-qtsvg.sha256sum] = "156ba71f7852f7705910fa56e2bff7cb0090422a5c64ea2cce0a42dcaeb8fdf5"
RDEPENDS:qt6-qtsvg = " \
 zlib-ng-compat \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qtsvg-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtsvg-devel-6.8.1-1.el10_0.1.x86_64_v2.rpm;name=qt6-qtsvg-devel;unpack=0"
SRC_URI += "${URI_qt6-qtsvg-devel}"
SRC_URI[qt6-qtsvg-devel.sha256sum] = "296fb4e6290e0b6202e011c041a7f94fc5b884bfbeeec94b77d29428634daef8"
RDEPENDS:qt6-qtsvg-devel = " \
 qt6-qtsvg \
 cmake-filesystem \
 qt6-qtsvg-devel \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
"

URI_qt6-qtsvg-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtsvg-examples-6.8.1-1.el10_0.1.x86_64_v2.rpm;name=qt6-qtsvg-examples;unpack=0"
SRC_URI += "${URI_qt6-qtsvg-examples}"
SRC_URI[qt6-qtsvg-examples.sha256sum] = "18c9dd6cd2ff47cf2b5b8e9de44f4d54ecadb00446e30daccf78c5652311b22e"
RDEPENDS:qt6-qtsvg-examples = " \
 qt6-qtsvg \
"

URI_qt6-qtsvg-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtsvg-tests-6.8.1-1.el10_0.1.x86_64_v2.rpm;name=qt6-qtsvg-tests;unpack=0"
SRC_URI += "${URI_qt6-qtsvg-tests}"
SRC_URI[qt6-qtsvg-tests.sha256sum] = "fa99ff5b4fc51fe4d2620982c2bfd61c34ee9c4d484faccbdee0267f12e11212"
RDEPENDS:qt6-qtsvg-tests = " \
 qt6-qtsvg \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"
