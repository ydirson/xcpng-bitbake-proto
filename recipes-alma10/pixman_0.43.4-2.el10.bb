# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pixman"
PE = "0"
PV = "0.43.4"
PR = "2.el10"
PACKAGES = "pixman pixman-devel"
PROVIDES = "rpm/pixman rpm/pixman-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/pixman-0.43.4-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10d81f5c9438a5b1d68e2968ec6a7a32ad427f8133f73f07425d899661b55ac9"

URI_pixman = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pixman-0.43.4-2.el10.x86_64_v2.rpm;name=pixman;unpack=0"
SRC_URI += "${URI_pixman}"
SRC_URI[pixman.sha256sum] = "dd8f71b80dd5f5d995fe3082ff82bf24b1e621f4613b2bccab949294a1d58a25"
RDEPENDS:pixman = " \
 glibc \
"

URI_pixman-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pixman-devel-0.43.4-2.el10.x86_64_v2.rpm;name=pixman-devel;unpack=0"
SRC_URI += "${URI_pixman-devel}"
SRC_URI[pixman-devel.sha256sum] = "91f17b9bc7d9701a196ec95a1e10f3a30f77387fa54e08914433122c54e10777"
RDEPENDS:pixman-devel = " \
 pkgconf-pkg-config \
 pixman \
"
