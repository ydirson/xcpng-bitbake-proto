# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "asciidoc"
PE = "0"
PV = "10.2.0"
PR = "12.el10"
PACKAGES = "asciidoc asciidoc-doc asciidoc-latex"
PROVIDES = "rpm/asciidoc rpm/asciidoc-doc rpm/asciidoc-latex"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/asciidoc-10.2.0-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca24731128209e04cfc4e6b124b2b59160e7d605df5084bdb868bb97cc21f768"

URI_asciidoc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/asciidoc-10.2.0-12.el10.noarch.rpm;name=asciidoc;unpack=0"
SRC_URI += "${URI_asciidoc}"
SRC_URI[asciidoc.sha256sum] = "bb34a342421805e3df245b074ee2787ca5d2f0134e2fecbefafad3285a14a74c"
RDEPENDS:asciidoc = " \
 python3 \
 source-highlight \
 libxslt \
 docbook-style-xsl \
 graphviz \
"

URI_asciidoc-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/asciidoc-doc-10.2.0-12.el10.noarch.rpm;name=asciidoc-doc;unpack=0"
SRC_URI += "${URI_asciidoc-doc}"
SRC_URI[asciidoc-doc.sha256sum] = "abb36792a2c65932c7ed09eaba144a2bbc52eb5f346449876cff1d7f531ce69e"
RDEPENDS:asciidoc-doc = " \
 asciidoc \
"

URI_asciidoc-latex = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/asciidoc-latex-10.2.0-12.el10.noarch.rpm;name=asciidoc-latex;unpack=0"
SRC_URI += "${URI_asciidoc-latex}"
SRC_URI[asciidoc-latex.sha256sum] = "f9065e2c29954db57c17c20da80e64b5e02ee8484405e1a092f7203ab54a7f0b"
RDEPENDS:asciidoc-latex = " \
 texlive-dvipng \
 dblatex \
 asciidoc \
"
