# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-hsb"
PE = "0"
PV = "0.20060327.3"
PR = "29.el10"
PACKAGES = "hunspell-hsb"
PROVIDES = "rpm/hunspell-hsb"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-hsb-0.20060327.3-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f26b18e8c5ced72305cd924de92241c97e24c2d6d13cb54c3d6a2c7fc601b44"

URI_hunspell-hsb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-hsb-0.20060327.3-29.el10.noarch.rpm;name=hunspell-hsb;unpack=0"
SRC_URI += "${URI_hunspell-hsb}"
SRC_URI[hunspell-hsb.sha256sum] = "e6625b39e2fa099e73ed97d3950cdc1670e82b8080f341769241a040e8b655e6"
RDEPENDS:hunspell-hsb = " \
 hunspell-filesystem \
"
