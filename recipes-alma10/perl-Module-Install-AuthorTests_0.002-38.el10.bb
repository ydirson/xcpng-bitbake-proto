# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Module-Install-AuthorTests"
PE = "0"
PV = "0.002"
PR = "38.el10"
PACKAGES = "perl-Module-Install-AuthorTests perl-Module-Install-AuthorTests-tests"
PROVIDES = "rpm/perl-Module-Install-AuthorTests rpm/perl-Module-Install-AuthorTests-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Module-Install-AuthorTests-0.002-38.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6b221bc4facd0917601035a7cf28a5d353f804a0cdd15b6881ad7da46e3ed45"

URI_perl-Module-Install-AuthorTests = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Module-Install-AuthorTests-0.002-38.el10.noarch.rpm;name=perl-Module-Install-AuthorTests;unpack=0"
SRC_URI += "${URI_perl-Module-Install-AuthorTests}"
SRC_URI[perl-Module-Install-AuthorTests.sha256sum] = "d64c628e2044b6eaa98fcefc2b4ef2bbbe2c3d47081a49b04035c049de17672d"
RDEPENDS:perl-Module-Install-AuthorTests = " \
 perl-Module-Install \
 perl-vars \
 perl-libs \
 perl-Carp \
"

URI_perl-Module-Install-AuthorTests-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Module-Install-AuthorTests-tests-0.002-38.el10.noarch.rpm;name=perl-Module-Install-AuthorTests-tests;unpack=0"
SRC_URI += "${URI_perl-Module-Install-AuthorTests-tests}"
SRC_URI[perl-Module-Install-AuthorTests-tests.sha256sum] = "e2abe9bf181a26a66424dada33d0d1bee0ae1f711d038bf662fc2db914af4d46"
RDEPENDS:perl-Module-Install-AuthorTests-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Module-Install-AuthorTests \
 bash \
 perl-interpreter \
"
