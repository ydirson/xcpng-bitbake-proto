# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pytest"
PE = "0"
PV = "7.4.3"
PR = "5.el10"
PACKAGES = "python3-pytest"
PROVIDES = "rpm/python3-pytest"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/pytest-7.4.3-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7300f24b1da408639f8e3a6b2e4f310a41e175b3c530cb6e347f15f4a9843577"

URI_python3-pytest = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-pytest-7.4.3-5.el10.noarch.rpm;name=python3-pytest;unpack=0"
SRC_URI += "${URI_python3-pytest}"
SRC_URI[python3-pytest.sha256sum] = "d7e57906e49568cf0eb09c667e913e807fccaeec9ebbde7825569e14488da0f4"
RDEPENDS:python3-pytest = " \
 python3 \
 python3-packaging \
 python3-iniconfig \
 python3-pluggy \
"
