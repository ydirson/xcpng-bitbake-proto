# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "voikko-fi"
PE = "0"
PV = "2.5"
PR = "8.el10"
PACKAGES = "voikko-fi"
PROVIDES = "rpm/voikko-fi"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/voikko-fi-2.5-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd27fab21b6148c141441eebad765428ccb78bc96b527bc15d756ccf41ea5d79"

URI_voikko-fi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/voikko-fi-2.5-8.el10.noarch.rpm;name=voikko-fi;unpack=0"
SRC_URI += "${URI_voikko-fi}"
SRC_URI[voikko-fi.sha256sum] = "83742a62b569619988d055d4372035330f0f42e16e30aa7aa9daf766094b1a9e"
RDEPENDS:voikko-fi = " \
 libvoikko \
"
