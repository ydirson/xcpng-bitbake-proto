# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rteval-loads"
PE = "0"
PV = "1.6"
PR = "14.el10"
PACKAGES = ""
PROVIDES = ""


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/rteval-loads-1.6-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d41bb5738c7bde5f916d5558173ece919ce2365bfe432459b6068b00db46d75a"
