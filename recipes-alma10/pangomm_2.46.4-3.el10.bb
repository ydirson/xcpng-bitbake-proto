# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pangomm"
PE = "0"
PV = "2.46.4"
PR = "3.el10"
PACKAGES = "pangomm pangomm-devel pangomm-doc"
PROVIDES = "rpm/pangomm rpm/pangomm-devel rpm/pangomm-doc"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/pangomm-2.46.4-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52dd41f746050f6b681d269a5801b7c0d4825890a869e0c408523b4a2f091c05"

URI_pangomm = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/pangomm-2.46.4-3.el10.x86_64_v2.rpm;name=pangomm;unpack=0"
SRC_URI += "${URI_pangomm}"
SRC_URI[pangomm.sha256sum] = "fb0bcf14891c01d43b23a485aebeda1405e4615d0b48a431e349771f08f5ef56"
RDEPENDS:pangomm = " \
 cairomm \
 libgcc \
 pango \
 libsigc++20 \
 libstdc++ \
 glib2 \
 glibc \
 glibmm2.4 \
"

URI_pangomm-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/pangomm-devel-2.46.4-3.el10.x86_64_v2.rpm;name=pangomm-devel;unpack=0"
SRC_URI += "${URI_pangomm-devel}"
SRC_URI[pangomm-devel.sha256sum] = "6e524e15956a21d7bc2e61840602d5b015a1d08d5cba2f40fab89693430e7fd0"
RDEPENDS:pangomm-devel = " \
 cairomm-devel \
 pangomm \
 pkgconf-pkg-config \
 pango-devel \
 glibmm2.4-devel \
"

URI_pangomm-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/pangomm-doc-2.46.4-3.el10.noarch.rpm;name=pangomm-doc;unpack=0"
SRC_URI += "${URI_pangomm-doc}"
SRC_URI[pangomm-doc.sha256sum] = "45101ee7ab94883fc5e41cbcfad8fe4d51755ac1687bae032f6e660827b383d0"
RDEPENDS:pangomm-doc = " \
 libsigc++20-doc \
 pangomm \
 glibmm2.4-doc \
"
