# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-ParseXS"
PE = "1"
PV = "3.51"
PR = "512.el10"
PACKAGES = "perl-ExtUtils-ParseXS perl-ExtUtils-ParseXS-tests"
PROVIDES = "rpm/perl-ExtUtils-ParseXS rpm/perl-ExtUtils-ParseXS-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-ExtUtils-ParseXS-3.51-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f04b4cdcc87a8f6fbe03b2f7aae97040c8ad4027e0548e3304fcab48e8d6a946"

URI_perl-ExtUtils-ParseXS = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-ExtUtils-ParseXS-3.51-512.el10.noarch.rpm;name=perl-ExtUtils-ParseXS;unpack=0"
SRC_URI += "${URI_perl-ExtUtils-ParseXS}"
SRC_URI[perl-ExtUtils-ParseXS.sha256sum] = "08653f50841f2c5ac8a07edbf93665304cae988b6fbf6e7ce680d07803ca0322"
RDEPENDS:perl-ExtUtils-ParseXS = " \
 perl-libs \
 perl-ExtUtils-ParseXS \
 perl-Getopt-Long \
 perl-File-Basename \
 perl-Symbol \
 perl-PathTools \
 perl-interpreter \
 perl-Exporter \
"

URI_perl-ExtUtils-ParseXS-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-ExtUtils-ParseXS-tests-3.51-512.el10.noarch.rpm;name=perl-ExtUtils-ParseXS-tests;unpack=0"
SRC_URI += "${URI_perl-ExtUtils-ParseXS-tests}"
SRC_URI[perl-ExtUtils-ParseXS-tests.sha256sum] = "90b2c07759a6498f0dbdc620fd3cb751759833b3e2a618e6d07913ba77cc96b6"
RDEPENDS:perl-ExtUtils-ParseXS-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-ExtUtils-ParseXS \
 perl-DynaLoader \
 perl-File-Temp \
 perl-overload \
 bash \
 perl-PathTools \
 perl-interpreter \
 perl-ExtUtils-CBuilder \
 perl-lib \
"
