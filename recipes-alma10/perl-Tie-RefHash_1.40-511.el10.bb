# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Tie-RefHash"
PE = "0"
PV = "1.40"
PR = "511.el10"
PACKAGES = "perl-Tie-RefHash perl-Tie-RefHash-tests"
PROVIDES = "rpm/perl-Tie-RefHash rpm/perl-Tie-RefHash-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Tie-RefHash-1.40-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c344e035703da2117c587aa7dd3382b4b7be8809b0c592b145e3b65a90c59a56"

URI_perl-Tie-RefHash = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Tie-RefHash-1.40-511.el10.noarch.rpm;name=perl-Tie-RefHash;unpack=0"
SRC_URI += "${URI_perl-Tie-RefHash}"
SRC_URI[perl-Tie-RefHash.sha256sum] = "7f6c20d84ee7b8ab89a05c23d3933a20671230751af20162b0cf55c53b1f0534"
RDEPENDS:perl-Tie-RefHash = " \
 perl-overload \
 perl-libs \
 perl-Carp \
"

URI_perl-Tie-RefHash-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Tie-RefHash-tests-1.40-511.el10.noarch.rpm;name=perl-Tie-RefHash-tests;unpack=0"
SRC_URI += "${URI_perl-Tie-RefHash-tests}"
SRC_URI[perl-Tie-RefHash-tests.sha256sum] = "e49e60494deef92768d8ad76033fd0f56dacd0b7d6d7ea3dc019b4604b7e974e"
RDEPENDS:perl-Tie-RefHash-tests = " \
 perl-threads \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-ExtUtils-MakeMaker \
 perl-Storable \
 perl-overload \
 bash \
 perl-PathTools \
 perl-interpreter \
 perl-Tie-RefHash \
 perl-Data-Dumper \
"
