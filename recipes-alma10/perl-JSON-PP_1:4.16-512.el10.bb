# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-JSON-PP"
PE = "1"
PV = "4.16"
PR = "512.el10"
PACKAGES = "perl-JSON-PP perl-JSON-PP-tests"
PROVIDES = "rpm/perl-JSON-PP rpm/perl-JSON-PP-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-JSON-PP-4.16-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f146501e41c7f5e0abad9de05c5aaff7ea0ba43af24832fd595344765cf118f"

URI_perl-JSON-PP = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-JSON-PP-4.16-512.el10.noarch.rpm;name=perl-JSON-PP;unpack=0"
SRC_URI += "${URI_perl-JSON-PP}"
SRC_URI[perl-JSON-PP.sha256sum] = "878851743ef985607359b574f527076df27ae928b21ecb775959470b5495e19b"
RDEPENDS:perl-JSON-PP = " \
 perl-constant \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-interpreter \
 perl-Math-BigInt \
 perl-Getopt-Long \
 perl-Encode \
 perl-overload \
 perl-JSON-PP \
 perl-Exporter \
 perl-Data-Dumper \
"

URI_perl-JSON-PP-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-JSON-PP-tests-4.16-512.el10.noarch.rpm;name=perl-JSON-PP-tests;unpack=0"
SRC_URI += "${URI_perl-JSON-PP-tests}"
SRC_URI[perl-JSON-PP-tests.sha256sum] = "14cf1b84d83d8624377b71a5b387ec985278174db70e885135a766577826351d"
RDEPENDS:perl-JSON-PP-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-vars \
 perl-Encode \
 perl-overload \
 bash \
 perl-Tie \
 perl-JSON-PP \
 perl-interpreter \
 perl-Data-Dumper \
"
