# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "x3270"
PE = "0"
PV = "4.3ga8"
PR = "8.el10"
PACKAGES = "x3270 x3270-text x3270-x11"
PROVIDES = "rpm/x3270 rpm/x3270-text rpm/x3270-x11"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/x3270-4.3ga8-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05e479ccb5365e6d5b39f518ee9d7936355c2d55aa3e0dd19e4e094f1cfb6676"

URI_x3270 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/x3270-4.3ga8-8.el10.x86_64_v2.rpm;name=x3270;unpack=0"
SRC_URI += "${URI_x3270}"
SRC_URI[x3270.sha256sum] = "bd5d3c539cacd42a31306bb0c956c839eeb264d32e615acca9b40480c18f6700"
RDEPENDS:x3270 = " \
 openssl-libs \
 readline \
 bash \
 ncurses-libs \
 glibc \
"

URI_x3270-text = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/x3270-text-4.3ga8-8.el10.x86_64_v2.rpm;name=x3270-text;unpack=0"
SRC_URI += "${URI_x3270-text}"
SRC_URI[x3270-text.sha256sum] = "387c299169577c859698b7812c4ce0e2632a84214a034a8817dd7303f87782b6"
RDEPENDS:x3270-text = " \
 openssl-libs \
 readline \
 ncurses-libs \
 glibc \
 x3270 \
"

URI_x3270-x11 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/x3270-x11-4.3ga8-8.el10.x86_64_v2.rpm;name=x3270-x11;unpack=0"
SRC_URI += "${URI_x3270-x11}"
SRC_URI[x3270-x11.sha256sum] = "df69001a2c4314c44cf4bae0398c6b56f667d5492f13109862dede49d6dff01f"
RDEPENDS:x3270-x11 = " \
 x3270 \
 libXmu \
 openssl-libs \
 libX11 \
 libXt \
 bash \
 libXaw \
 glibc \
 xrdb \
"
