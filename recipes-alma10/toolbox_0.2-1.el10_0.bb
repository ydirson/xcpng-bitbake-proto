# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "toolbox"
PE = "0"
PV = "0.2"
PR = "1.el10_0"
PACKAGES = "toolbox toolbox-tests"
PROVIDES = "rpm/toolbox rpm/toolbox-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/toolbox-0.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39dce054d3172cdf41dd9432840e97c9dc3f5d6d283c730c63ec9bfe25994258"

URI_toolbox = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/toolbox-0.2-1.el10_0.x86_64_v2.rpm;name=toolbox;unpack=0"
SRC_URI += "${URI_toolbox}"
SRC_URI[toolbox.sha256sum] = "4f7a782a9c5312efb1439530b9f67da040a7466736c4a2959dbb2308c5f7dcdb"
RDEPENDS:toolbox = " \
 containers-common \
 flatpak-session-helper \
 shadow-utils-subid \
 glibc \
 podman \
"

URI_toolbox-tests = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/toolbox-tests-0.2-1.el10_0.x86_64_v2.rpm;name=toolbox-tests;unpack=0"
SRC_URI += "${URI_toolbox-tests}"
SRC_URI[toolbox-tests.sha256sum] = "1d659c8eeac440ee5b70fddd887f6e0d4dab684f94e02541c7757e0d54b9d57b"
RDEPENDS:toolbox-tests = " \
 python3 \
 openssl \
 diffutils \
 grep \
 httpd-tools \
 skopeo \
 glib2 \
 toolbox \
 coreutils \
"
