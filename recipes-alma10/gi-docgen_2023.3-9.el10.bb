# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gi-docgen"
PE = "0"
PV = "2023.3"
PR = "9.el10"
PACKAGES = "gi-docgen gi-docgen-doc gi-docgen-fonts"
PROVIDES = "rpm/gi-docgen rpm/gi-docgen-doc rpm/gi-docgen-fonts"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/gi-docgen-2023.3-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26b7f9c42cfb69174e3068047930d6a75e5ab62567fc012f65cb766cbae124cd"

URI_gi-docgen = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gi-docgen-2023.3-9.el10.noarch.rpm;name=gi-docgen;unpack=0"
SRC_URI += "${URI_gi-docgen}"
SRC_URI[gi-docgen.sha256sum] = "7605452703ef2eb395663d9aa0de85f401b6fe21818607ff6ef93b2da398e63a"
RDEPENDS:gi-docgen = " \
 python3 \
 python3-typogrify \
 pkgconf-pkg-config \
 python3-pygments \
 python3-markdown \
 python3-jinja2 \
 gi-docgen-fonts \
 python3-markupsafe \
 python3-packaging \
"

URI_gi-docgen-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gi-docgen-doc-2023.3-9.el10.noarch.rpm;name=gi-docgen-doc;unpack=0"
SRC_URI += "${URI_gi-docgen-doc}"
SRC_URI[gi-docgen-doc.sha256sum] = "1c6c48286f1efdf820e955bd7276a824c4fbf60a58080cf4cbea6d18db88a535"
RDEPENDS:gi-docgen-doc = ""

URI_gi-docgen-fonts = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gi-docgen-fonts-2023.3-9.el10.noarch.rpm;name=gi-docgen-fonts;unpack=0"
SRC_URI += "${URI_gi-docgen-fonts}"
SRC_URI[gi-docgen-fonts.sha256sum] = "1c9ad6d0d8f1b5acc2a703b3809eada719730d98d905c91aff93d58dc9c7240a"
RDEPENDS:gi-docgen-fonts = " \
 redhat-text-fonts \
 redhat-display-fonts \
 redhat-mono-vf-fonts \
"
