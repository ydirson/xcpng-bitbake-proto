# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-tomli-w"
PE = "0"
PV = "1.0.0"
PR = "12.el10"
PACKAGES = "python3-tomli-w"
PROVIDES = "rpm/python3-tomli-w"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/python-tomli-w-1.0.0-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "686482f8b3b72697595bf725fd3b8b8ac2ed78aadfc11f1c7275477c9995e5ad"

URI_python3-tomli-w = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-tomli-w-1.0.0-12.el10.noarch.rpm;name=python3-tomli-w;unpack=0"
SRC_URI += "${URI_python3-tomli-w}"
SRC_URI[python3-tomli-w.sha256sum] = "ed48456c4fa73b893cafbfb10ba8d48709c0c5a3a0c851c8b374e5e15a1fdf8c"
RDEPENDS:python3-tomli-w = " \
 python3 \
"
