# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "trace-cmd"
PE = "0"
PV = "3.3.1"
PR = "2.el10"
PACKAGES = "trace-cmd trace-cmd-python3"
PROVIDES = "rpm/trace-cmd rpm/trace-cmd-python3"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/trace-cmd-3.3.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3cb239cc7368bbdc7138b6dcdfd6a9beacb85498ac17d2d0bcb09835717802c4"

URI_trace-cmd = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/trace-cmd-3.3.1-2.el10.x86_64_v2.rpm;name=trace-cmd;unpack=0"
SRC_URI += "${URI_trace-cmd}"
SRC_URI[trace-cmd.sha256sum] = "66dca80b1edccb4d895e555d684f5baf2b30baf023292ea843da47525ed31db6"
RDEPENDS:trace-cmd = " \
 audit-libs \
 libzstd \
 bash \
 glibc \
 libtraceevent \
 libtracefs \
"

URI_trace-cmd-python3 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/trace-cmd-python3-3.3.1-2.el10.x86_64_v2.rpm;name=trace-cmd-python3;unpack=0"
SRC_URI += "${URI_trace-cmd-python3}"
SRC_URI[trace-cmd-python3.sha256sum] = "ab6f1d5421a8800c628a632ad7f26655b88f6f724d6b66145b8fc66741b47974"
RDEPENDS:trace-cmd-python3 = " \
 python3 \
 glibc \
 trace-cmd \
 libtraceevent \
 libtracefs \
"
