# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gstreamer1-plugins-good"
PE = "0"
PV = "1.24.11"
PR = "1.el10"
PACKAGES = "gstreamer1-plugins-good gstreamer1-plugins-good-gtk gstreamer1-plugins-good-qt6"
PROVIDES = "rpm/gstreamer1-plugins-good rpm/gstreamer1-plugins-good-gtk rpm/gstreamer1-plugins-good-qt6"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gstreamer1-plugins-good-1.24.11-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5044c866248ea4836873362eb47d6dedee7b80aa8b7cfad61219a6f77676af41"

URI_gstreamer1-plugins-good = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-good-1.24.11-1.el10.x86_64_v2.rpm;name=gstreamer1-plugins-good;unpack=0"
SRC_URI += "${URI_gstreamer1-plugins-good}"
SRC_URI[gstreamer1-plugins-good.sha256sum] = "1c998be6349c471760365b31870f98d29538be9f751fcb92ebc3e7f5364d6832"
RDEPENDS:gstreamer1-plugins-good = " \
 libpng \
 libX11 \
 libv4l \
 taglib \
 libXdamage \
 libXext \
 libXfixes \
 libstdc++ \
 cairo \
 libXtst \
 cairo-gobject \
 libvpx \
 zlib-ng-compat \
 pulseaudio-libs \
 speex \
 libgcc \
 openssl-libs \
 libxml2 \
 gdk-pixbuf2 \
 libgudev \
 flac-libs \
 libshout \
 orc \
 wavpack \
 lame-libs \
 bzip2-libs \
 gstreamer1 \
 gstreamer1-plugins-base \
 twolame-libs \
 glib2 \
 glibc \
 libjpeg-turbo \
 mpg123-libs \
"

URI_gstreamer1-plugins-good-gtk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-good-gtk-1.24.11-1.el10.x86_64_v2.rpm;name=gstreamer1-plugins-good-gtk;unpack=0"
SRC_URI += "${URI_gstreamer1-plugins-good-gtk}"
SRC_URI[gstreamer1-plugins-good-gtk.sha256sum] = "18fd45284d6f62728ab2c68818623760832afa0bad7c9159a18242d71a20b460"
RDEPENDS:gstreamer1-plugins-good-gtk = " \
 gstreamer1 \
 gstreamer1-plugins-base \
 gstreamer1-plugins-good \
 cairo \
 glib2 \
 gtk3 \
 glibc \
"

URI_gstreamer1-plugins-good-qt6 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gstreamer1-plugins-good-qt6-1.24.11-1.el10.x86_64_v2.rpm;name=gstreamer1-plugins-good-qt6;unpack=0"
SRC_URI += "${URI_gstreamer1-plugins-good-qt6}"
SRC_URI[gstreamer1-plugins-good-qt6.sha256sum] = "97bb335c773de218d6ef3bda7480e63ba4739ae58fb7f2cc18e0e5dcb01462dc"
RDEPENDS:gstreamer1-plugins-good-qt6 = " \
 qt6-qtdeclarative \
 gstreamer1 \
 libglvnd-gles \
 libgcc \
 gstreamer1-plugins-base \
 qt6-qtbase \
 qt6-qtwayland \
 gstreamer1-plugins-good \
 libstdc++ \
 qt6-qtbase-gui \
 glib2 \
 glibc \
"
