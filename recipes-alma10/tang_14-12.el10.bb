# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tang"
PE = "0"
PV = "14"
PR = "12.el10"
PACKAGES = "tang"
PROVIDES = "rpm/tang"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tang-14-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39c9dc3005b3a5731cdb3a8ceed0cb6b2aaaa6b0fbc354c1f82ac4ec5d8d3772"

URI_tang = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tang-14-12.el10.x86_64_v2.rpm;name=tang;unpack=0"
SRC_URI += "${URI_tang}"
SRC_URI[tang.sha256sum] = "a23067dff641c8b645a07a3bdb6dd0d748a357c1c25bfd28090e91eb823d7b3e"
RDEPENDS:tang = " \
 shadow-utils \
 jansson \
 libgcc \
 grep \
 bash \
 llhttp \
 glibc \
 coreutils \
 sed \
 libjose \
 jose \
"
