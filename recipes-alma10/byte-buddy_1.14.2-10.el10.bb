# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "byte-buddy"
PE = "0"
PV = "1.14.2"
PR = "10.el10"
PACKAGES = "byte-buddy byte-buddy-agent byte-buddy-javadoc byte-buddy-maven-plugin"
PROVIDES = "rpm/byte-buddy rpm/byte-buddy-agent rpm/byte-buddy-javadoc rpm/byte-buddy-maven-plugin"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/byte-buddy-1.14.2-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "94a7b17ae653fd8690d78bf3cf30eb3f973da3b98db3d0c2875e33ed087e4f20"

URI_byte-buddy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/byte-buddy-1.14.2-10.el10.noarch.rpm;name=byte-buddy;unpack=0"
SRC_URI += "${URI_byte-buddy}"
SRC_URI[byte-buddy.sha256sum] = "181e43f434eb62a3775b177988641f68ff95d0bd6c479e0d64a774b77b2cb488"
RDEPENDS:byte-buddy = " \
 objectweb-asm \
 javapackages-filesystem \
"

URI_byte-buddy-agent = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/byte-buddy-agent-1.14.2-10.el10.noarch.rpm;name=byte-buddy-agent;unpack=0"
SRC_URI += "${URI_byte-buddy-agent}"
SRC_URI[byte-buddy-agent.sha256sum] = "3c618fa9502901e63d2a3827be0b71218975542638322f729229ad0ec80dffb6"
RDEPENDS:byte-buddy-agent = " \
 javapackages-filesystem \
"

URI_byte-buddy-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/byte-buddy-javadoc-1.14.2-10.el10.noarch.rpm;name=byte-buddy-javadoc;unpack=0"
SRC_URI += "${URI_byte-buddy-javadoc}"
SRC_URI[byte-buddy-javadoc.sha256sum] = "8d4bd79bbfd03c90340ae81adbad0c4f9ad0d4329f1bca480bae0e1cac1abb43"
RDEPENDS:byte-buddy-javadoc = " \
 javapackages-filesystem \
"

URI_byte-buddy-maven-plugin = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/byte-buddy-maven-plugin-1.14.2-10.el10.noarch.rpm;name=byte-buddy-maven-plugin;unpack=0"
SRC_URI += "${URI_byte-buddy-maven-plugin}"
SRC_URI[byte-buddy-maven-plugin.sha256sum] = "804fddcd337f0e4269ecac29921b04055b5b79c5aff177ec34341a885c18afa1"
RDEPENDS:byte-buddy-maven-plugin = " \
 maven-resolver \
 plexus-build-api0 \
 javapackages-filesystem \
 byte-buddy \
"
