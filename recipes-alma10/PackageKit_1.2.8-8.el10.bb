# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "PackageKit"
PE = "0"
PV = "1.2.8"
PR = "8.el10"
PACKAGES = "PackageKit PackageKit-command-not-found PackageKit-glib PackageKit-gstreamer-plugin PackageKit-gtk3-module PackageKit-glib-devel PackageKit-cron"
PROVIDES = "rpm/PackageKit rpm/PackageKit-command-not-found rpm/PackageKit-glib rpm/PackageKit-gstreamer-plugin rpm/PackageKit-gtk3-module rpm/PackageKit-glib-devel rpm/PackageKit-cron"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/PackageKit-1.2.8-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d14e23b2a4b99c1e7b8a74f31c66fe02d3a07ec473220fb0838e8dbd07cdcca8"

URI_PackageKit = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/PackageKit-1.2.8-8.el10.x86_64_v2.rpm;name=PackageKit;unpack=0"
SRC_URI += "${URI_PackageKit}"
SRC_URI[PackageKit.sha256sum] = "85e774a13c7739689e9b29fac4a87567f9fe3f4ee274d6d6bfb46584641b1b39"
RDEPENDS:PackageKit = " \
 python3 \
 systemd \
 systemd-libs \
 shared-mime-info \
 appstream \
 libgcc \
 sqlite-libs \
 polkit-libs \
 bash \
 glib2 \
 glibc \
 PackageKit-glib \
 libdnf \
 rpm-libs \
"

URI_PackageKit-command-not-found = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/PackageKit-command-not-found-1.2.8-8.el10.x86_64_v2.rpm;name=PackageKit-command-not-found;unpack=0"
SRC_URI += "${URI_PackageKit-command-not-found}"
SRC_URI[PackageKit-command-not-found.sha256sum] = "a4b5a86162d7935a29a246cb3c2a7898612d9c7dbe2ed4a06808b6ad1efb5dcb"
RDEPENDS:PackageKit-command-not-found = " \
 libgcc \
 bash \
 glib2 \
 PackageKit \
 glibc \
 PackageKit-glib \
"

URI_PackageKit-glib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/PackageKit-glib-1.2.8-8.el10.x86_64_v2.rpm;name=PackageKit-glib;unpack=0"
SRC_URI += "${URI_PackageKit-glib}"
SRC_URI[PackageKit-glib.sha256sum] = "d02bec87760d868d12cecc7f365f996eec8e951a2e18d1244a9d8396ac5709c8"
RDEPENDS:PackageKit-glib = " \
 gobject-introspection \
 libgcc \
 glib2 \
 dbus \
 glibc \
"

URI_PackageKit-gstreamer-plugin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/PackageKit-gstreamer-plugin-1.2.8-8.el10.x86_64_v2.rpm;name=PackageKit-gstreamer-plugin;unpack=0"
SRC_URI += "${URI_PackageKit-gstreamer-plugin}"
SRC_URI[PackageKit-gstreamer-plugin.sha256sum] = "ebd3cb9fd835b03050e7a5f9bbe1ec59384b21ab3552e95000b7397bfb51bf8f"
RDEPENDS:PackageKit-gstreamer-plugin = " \
 gstreamer1 \
 libgcc \
 glib2 \
 glibc \
 PackageKit-glib \
"

URI_PackageKit-gtk3-module = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/PackageKit-gtk3-module-1.2.8-8.el10.x86_64_v2.rpm;name=PackageKit-gtk3-module;unpack=0"
SRC_URI += "${URI_PackageKit-gtk3-module}"
SRC_URI[PackageKit-gtk3-module.sha256sum] = "db7cc84354d9aad1f46bcb7d3697c04a64ce02f20abafba7b045cea220f4844b"
RDEPENDS:PackageKit-gtk3-module = " \
 libgcc \
 fontconfig \
 pango \
 glib2 \
 glibc \
 PackageKit-glib \
"

URI_PackageKit-glib-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/PackageKit-glib-devel-1.2.8-8.el10.x86_64_v2.rpm;name=PackageKit-glib-devel;unpack=0"
SRC_URI += "${URI_PackageKit-glib-devel}"
SRC_URI[PackageKit-glib-devel.sha256sum] = "ba0ddc689ce73be115786f9b5e44a05a36177751ca26bb7395d32144647bc374"
RDEPENDS:PackageKit-glib-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 dbus-devel \
 PackageKit-glib \
 sqlite-devel \
"

URI_PackageKit-cron = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/PackageKit-cron-1.2.8-8.el10.x86_64_v2.rpm;name=PackageKit-cron;unpack=0"
SRC_URI += "${URI_PackageKit-cron}"
SRC_URI[PackageKit-cron.sha256sum] = "13ab27c25868b11a0077a12706eb58ee5f43f969e1c60febf489253471629e66"
RDEPENDS:PackageKit-cron = " \
 crontabs \
 bash \
 PackageKit \
"
