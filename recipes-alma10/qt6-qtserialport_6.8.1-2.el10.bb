# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtserialport"
PE = "0"
PV = "6.8.1"
PR = "2.el10"
PACKAGES = "qt6-qtserialport qt6-qtserialport-devel qt6-qtserialport-examples qt6-qtserialport-tests"
PROVIDES = "rpm/qt6-qtserialport rpm/qt6-qtserialport-devel rpm/qt6-qtserialport-examples rpm/qt6-qtserialport-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtserialport-6.8.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16766148c0d29059525fab776b054e848a8bc0945c39bbf8ed58a2de05d90e05"

URI_qt6-qtserialport = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtserialport-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtserialport;unpack=0"
SRC_URI += "${URI_qt6-qtserialport}"
SRC_URI[qt6-qtserialport.sha256sum] = "bc7c0c940acb28293e22327127d0f8e4096ae496f119af771258904ebdc945a2"
RDEPENDS:qt6-qtserialport = " \
 glibc \
 libstdc++ \
 systemd-libs \
 qt6-qtbase \
"

URI_qt6-qtserialport-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtserialport-devel-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtserialport-devel;unpack=0"
SRC_URI += "${URI_qt6-qtserialport-devel}"
SRC_URI[qt6-qtserialport-devel.sha256sum] = "b688b9d236cedb90d9cf844cea5b3cc2dc9d81999f0b098ade81b45099ac64ba"
RDEPENDS:qt6-qtserialport-devel = " \
 qt6-qtserialport \
 qt6-qtbase-devel \
 cmake-filesystem \
 pkgconf-pkg-config \
"

URI_qt6-qtserialport-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtserialport-examples-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtserialport-examples;unpack=0"
SRC_URI += "${URI_qt6-qtserialport-examples}"
SRC_URI[qt6-qtserialport-examples.sha256sum] = "813e1a90e04247eb53b62e582dfaed6cf932843be0ada8d5692478b54fb3fc88"
RDEPENDS:qt6-qtserialport-examples = " \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
 qt6-qtserialport \
"

URI_qt6-qtserialport-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtserialport-tests-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtserialport-tests;unpack=0"
SRC_URI += "${URI_qt6-qtserialport-tests}"
SRC_URI[qt6-qtserialport-tests.sha256sum] = "10a4f2ed5413de48ac0b4929d8e6518a13ac16bda8b98688d3423a19f3fcdbde"
RDEPENDS:qt6-qtserialport-tests = " \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 glibc \
 qt6-qtserialport \
"
