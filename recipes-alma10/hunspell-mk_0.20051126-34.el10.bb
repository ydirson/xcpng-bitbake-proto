# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-mk"
PE = "0"
PV = "0.20051126"
PR = "34.el10"
PACKAGES = "hunspell-mk"
PROVIDES = "rpm/hunspell-mk"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-mk-0.20051126-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6becbffdd0c954980fc3ab4dc02e21d23e6292ae9d7af18ed43a3cc6d37d6f29"

URI_hunspell-mk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-mk-0.20051126-34.el10.noarch.rpm;name=hunspell-mk;unpack=0"
SRC_URI += "${URI_hunspell-mk}"
SRC_URI[hunspell-mk.sha256sum] = "d791dd1b3c4f5ca8571a499f48f7255fa15677fb6c997b395e288ce351407ceb"
RDEPENDS:hunspell-mk = " \
 hunspell-filesystem \
"
