# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sed"
PE = "0"
PV = "4.9"
PR = "3.el10"
PACKAGES = "sed"
PROVIDES = "rpm/sed"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/sed-4.9-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c8a5e61a79ee0cec6f2f5c1d82b97127fd76b9c29dbc75844ae465e02488cf9"

URI_sed = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/sed-4.9-3.el10.x86_64_v2.rpm;name=sed;unpack=0"
SRC_URI += "${URI_sed}"
SRC_URI[sed.sha256sum] = "44456b015140e03f094f48530d7d4432def05c5dfc30facb935d1384f9892b5e"
RDEPENDS:sed = " \
 glibc \
 libselinux \
 libacl \
"
