# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "argparse-manpage"
PE = "0"
PV = "4.5"
PR = "4.el10"
PACKAGES = "argparse-manpage python3-argparse-manpage+setuptools python3-argparse-manpage"
PROVIDES = "rpm/argparse-manpage rpm/python3-argparse-manpage+setuptools rpm/python3-argparse-manpage"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/argparse-manpage-4.5-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "348d1f4f7cdb6887d3841eb9c4c8eb93b9042f965d6def8a6933c70945ee85d4"

URI_argparse-manpage = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/argparse-manpage-4.5-4.el10.noarch.rpm;name=argparse-manpage;unpack=0"
SRC_URI += "${URI_argparse-manpage}"
SRC_URI[argparse-manpage.sha256sum] = "d89dd573a79f879bfc74cbf5c31deb6dd9ff808986f2e750909920803fba537d"
RDEPENDS:argparse-manpage = " \
 python3 \
 python3-argparse-manpage \
"

URI_python3-argparse-manpage+setuptools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-argparse-manpage+setuptools-4.5-4.el10.noarch.rpm;name=python3-argparse-manpage+setuptools;unpack=0"
SRC_URI += "${URI_python3-argparse-manpage+setuptools}"
SRC_URI[python3-argparse-manpage+setuptools.sha256sum] = "53d925974188d09377dad86d231c479b071ef25c15887eb68ea19af323d79c38"
RDEPENDS:python3-argparse-manpage+setuptools = " \
 python3-setuptools \
 python3 \
 python3-argparse-manpage \
"

URI_python3-argparse-manpage = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-argparse-manpage-4.5-4.el10.noarch.rpm;name=python3-argparse-manpage;unpack=0"
SRC_URI += "${URI_python3-argparse-manpage}"
SRC_URI[python3-argparse-manpage.sha256sum] = "c3270472933098b99c9816b7ad5bcc37d9be378d7dcfaf74750a978e27f7c497"
RDEPENDS:python3-argparse-manpage = " \
 python3 \
"
