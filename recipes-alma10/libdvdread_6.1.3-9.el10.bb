# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libdvdread"
PE = "0"
PV = "6.1.3"
PR = "9.el10"
PACKAGES = "libdvdread libdvdread-devel"
PROVIDES = "rpm/libdvdread rpm/libdvdread-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libdvdread-6.1.3-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e40d16c45f1c53ba9d241f869f12b30465f6f636341a1d46a83fb0016439324"

URI_libdvdread = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libdvdread-6.1.3-9.el10.x86_64_v2.rpm;name=libdvdread;unpack=0"
SRC_URI += "${URI_libdvdread}"
SRC_URI[libdvdread.sha256sum] = "64b1da9ae281dfe530d46ff5564095567ace386fe63c4b525676f1d5e6b16689"
RDEPENDS:libdvdread = " \
 glibc \
"

URI_libdvdread-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libdvdread-devel-6.1.3-9.el10.x86_64_v2.rpm;name=libdvdread-devel;unpack=0"
SRC_URI += "${URI_libdvdread-devel}"
SRC_URI[libdvdread-devel.sha256sum] = "c2d0775803dd1baf090bdf24a98fc8bb5f872871462ca7142789af8060e3290b"
RDEPENDS:libdvdread-devel = " \
 libdvdread \
 pkgconf-pkg-config \
"
