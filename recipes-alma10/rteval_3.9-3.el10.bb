# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rteval"
PE = "0"
PV = "3.9"
PR = "3.el10"
PACKAGES = ""
PROVIDES = ""


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/rteval-3.9-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bffae9c0414d3c37fe8ae79ef9660c8037665d343d38ebfac8ad78fb888f29ef"
