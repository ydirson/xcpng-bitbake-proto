# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Term-Size-Any"
PE = "0"
PV = "0.002"
PR = "45.el10"
PACKAGES = "perl-Term-Size-Any perl-Term-Size-Any-tests"
PROVIDES = "rpm/perl-Term-Size-Any rpm/perl-Term-Size-Any-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Term-Size-Any-0.002-45.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c176b4cbaeae3aa98f3a74efc92737e670456e5ebacfec2c1f1dece9827baea"

URI_perl-Term-Size-Any = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Term-Size-Any-0.002-45.el10.noarch.rpm;name=perl-Term-Size-Any;unpack=0"
SRC_URI += "${URI_perl-Term-Size-Any}"
SRC_URI[perl-Term-Size-Any.sha256sum] = "64117b34781488da7872adb50d6c4922eaf2eb4c1c0361d0545530e7258955b5"
RDEPENDS:perl-Term-Size-Any = " \
 perl-libs \
 perl-vars \
 perl-Term-Size-Perl \
"

URI_perl-Term-Size-Any-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Term-Size-Any-tests-0.002-45.el10.noarch.rpm;name=perl-Term-Size-Any-tests;unpack=0"
SRC_URI += "${URI_perl-Term-Size-Any-tests}"
SRC_URI[perl-Term-Size-Any-tests.sha256sum] = "e3a302e222446164e9e78efb9ef6fe7737b0c07a3af4ae2869346c39de7deb04"
RDEPENDS:perl-Term-Size-Any-tests = " \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Module-Load-Conditional \
 bash \
 perl-interpreter \
 perl-Term-Size-Any \
"
