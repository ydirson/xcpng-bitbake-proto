# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ldapjdk"
PE = "0"
PV = "5.6.0"
PR = "1.el10"
PACKAGES = "idm-ldapjdk idm-ldapjdk-javadoc"
PROVIDES = "rpm/idm-ldapjdk rpm/idm-ldapjdk-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ldapjdk-5.6.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "955be772d27dc392d5fd96aee28b4c65498f2b25267a0e716a198c7b16be26b9"

URI_idm-ldapjdk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/idm-ldapjdk-5.6.0-1.el10.noarch.rpm;name=idm-ldapjdk;unpack=0"
SRC_URI += "${URI_idm-ldapjdk}"
SRC_URI[idm-ldapjdk.sha256sum] = "f07e9c3936f447f299361e8f8fb499fbebe5dfa764bcdb1405896bd7ac60477f"
RDEPENDS:idm-ldapjdk = " \
 javapackages-filesystem \
 idm-jss \
 java-21-openjdk-headless \
 slf4j-jdk14 \
 slf4j \
"

URI_idm-ldapjdk-javadoc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/idm-ldapjdk-javadoc-5.6.0-1.el10.noarch.rpm;name=idm-ldapjdk-javadoc;unpack=0"
SRC_URI += "${URI_idm-ldapjdk-javadoc}"
SRC_URI[idm-ldapjdk-javadoc.sha256sum] = "05d4c77510bbb3f1172d6fdf8e11285476fd84424f7177fc9c754996bfddaa03"
RDEPENDS:idm-ldapjdk-javadoc = " \
 javapackages-filesystem \
"
