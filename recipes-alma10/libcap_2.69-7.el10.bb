# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libcap"
PE = "0"
PV = "2.69"
PR = "7.el10"
PACKAGES = "libcap libcap-devel libcap-static"
PROVIDES = "rpm/libcap rpm/libcap-devel rpm/libcap-static"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libcap-2.69-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f8e599d088aab4ff7c52cd7041beed62eb9bc2d20d50cb8e6e4502fb60e1bd4"

URI_libcap = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libcap-2.69-7.el10.x86_64_v2.rpm;name=libcap;unpack=0"
SRC_URI += "${URI_libcap}"
SRC_URI[libcap.sha256sum] = "2cfb6f79c225b9175a7d2c696dcbd00fef9fe4a9881cf407d2beaeeca1da94d2"
RDEPENDS:libcap = " \
 glibc \
 pam-libs \
 libgcc \
"

URI_libcap-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libcap-devel-2.69-7.el10.x86_64_v2.rpm;name=libcap-devel;unpack=0"
SRC_URI += "${URI_libcap-devel}"
SRC_URI[libcap-devel.sha256sum] = "080505f6f87c079cc91451594041969dcd712cb9ee2cef77adccfa2188bf0f65"
RDEPENDS:libcap-devel = " \
 pkgconf-pkg-config \
 libcap \
"

URI_libcap-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libcap-static-2.69-7.el10.x86_64_v2.rpm;name=libcap-static;unpack=0"
SRC_URI += "${URI_libcap-static}"
SRC_URI[libcap-static.sha256sum] = "0753d7b86e3d8e84d0360b8038e0556f73821b70e2b9962e44ba28cfb05c57bd"
RDEPENDS:libcap-static = " \
 libcap \
"
