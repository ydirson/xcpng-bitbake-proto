# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Filter"
PE = "2"
PV = "1.64"
PR = "512.el10"
PACKAGES = "perl-Filter perl-Filter-tests"
PROVIDES = "rpm/perl-Filter rpm/perl-Filter-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Filter-1.64-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ac9529411ae68946f6e217e1d9d442c6621aa5f4cb1f740bc13247560a35aa6"

URI_perl-Filter = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Filter-1.64-512.el10.x86_64_v2.rpm;name=perl-Filter;unpack=0"
SRC_URI += "${URI_perl-Filter}"
SRC_URI[perl-Filter.sha256sum] = "00f923cefe98f515a9a26cb9d55b11c33c081c2247d6d0102dfefe719fc8e764"
RDEPENDS:perl-Filter = " \
 perl-libs \
 perl-Carp \
 perl-Filter \
 glibc \
 perl-Exporter \
"

URI_perl-Filter-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Filter-tests-1.64-512.el10.x86_64_v2.rpm;name=perl-Filter-tests;unpack=0"
SRC_URI += "${URI_perl-Filter-tests}"
SRC_URI[perl-Filter-tests.sha256sum] = "1c87ac809e4e932539bd5ff263251ab8628486b1c2092df742ea0974a53ea589"
RDEPENDS:perl-Filter-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-debugger \
 perl-vars \
 perl-Filter \
 perl-FindBin \
 bash \
 perl-PathTools \
 perl-interpreter \
 perl-lib \
"
