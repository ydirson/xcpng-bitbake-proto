# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-es"
PE = "0"
PV = "2.3"
PR = "19.el10"
PACKAGES = "hyphen-es"
PROVIDES = "rpm/hyphen-es"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-es-2.3-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2dc8fb0eb6349deb77502021b3425fa2136f4817a28b1545b4a999abddf283f3"

URI_hyphen-es = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-es-2.3-19.el10.noarch.rpm;name=hyphen-es;unpack=0"
SRC_URI += "${URI_hyphen-es}"
SRC_URI[hyphen-es.sha256sum] = "9a9c67b9e849d4a94d19f122de37b7a0a214765a1284cf01c439a953a3a8efa5"
RDEPENDS:hyphen-es = " \
 hyphen \
"
