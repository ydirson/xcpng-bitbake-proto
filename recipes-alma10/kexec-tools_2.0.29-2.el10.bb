# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "kexec-tools"
PE = "0"
PV = "2.0.29"
PR = "2.el10"
PACKAGES = "kexec-tools"
PROVIDES = "rpm/kexec-tools"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/kexec-tools-2.0.29-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7805a1b0c916de7fd619edd12e4c43b9935ba095771f7c1cfc5770e3a2fd1d4b"

URI_kexec-tools = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kexec-tools-2.0.29-2.el10.x86_64_v2.rpm;name=kexec-tools;unpack=0"
SRC_URI += "${URI_kexec-tools}"
SRC_URI[kexec-tools.sha256sum] = "5b2bde80bd54de4cdc649b39625cd505c9bbaa00d9b531c114ef519708ca53f5"
RDEPENDS:kexec-tools = " \
 glibc \
 zlib-ng-compat \
 xz-libs \
"
