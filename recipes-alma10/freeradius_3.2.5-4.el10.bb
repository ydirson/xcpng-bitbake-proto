# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "freeradius"
PE = "0"
PV = "3.2.5"
PR = "4.el10"
PACKAGES = "freeradius freeradius-devel freeradius-doc freeradius-krb5 freeradius-ldap freeradius-utils python3-freeradius freeradius-mysql freeradius-perl freeradius-postgresql freeradius-rest freeradius-sqlite freeradius-unixODBC"
PROVIDES = "rpm/freeradius rpm/freeradius-devel rpm/freeradius-doc rpm/freeradius-krb5 rpm/freeradius-ldap rpm/freeradius-utils rpm/python3-freeradius rpm/freeradius-mysql rpm/freeradius-perl rpm/freeradius-postgresql rpm/freeradius-rest rpm/freeradius-sqlite rpm/freeradius-unixODBC"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/freeradius-3.2.5-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3f11fc7ccfdbf52fae1182c3880b19da95591990c1ef8ca50080fbcfe555f10"

URI_freeradius = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/freeradius-3.2.5-4.el10.x86_64_v2.rpm;name=freeradius;unpack=0"
SRC_URI += "${URI_freeradius}"
SRC_URI[freeradius.sha256sum] = "99cf9ef913b212faaa9931483dd2889b65d3951b4a6b6ddf21f00750341fb55b"
RDEPENDS:freeradius = " \
 glibc-common \
 libpcap \
 shadow-utils \
 systemd \
 libxcrypt \
 openssl \
 openssl-libs \
 readline \
 make \
 json-c \
 gdbm-libs \
 pam-libs \
 bash \
 libtalloc \
 glibc \
 perl-interpreter \
"

URI_freeradius-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/freeradius-devel-3.2.5-4.el10.x86_64_v2.rpm;name=freeradius-devel;unpack=0"
SRC_URI += "${URI_freeradius-devel}"
SRC_URI[freeradius-devel.sha256sum] = "084a2d443912411f52ce32c71698e85002b977aac313a3f4d3361aaf8fc318be"
RDEPENDS:freeradius-devel = " \
 freeradius \
"

URI_freeradius-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/freeradius-doc-3.2.5-4.el10.x86_64_v2.rpm;name=freeradius-doc;unpack=0"
SRC_URI += "${URI_freeradius-doc}"
SRC_URI[freeradius-doc.sha256sum] = "394e1edb6301616cff688eb86658fd7f57206f39b7b17e7e727a47b6d2737db4"
RDEPENDS:freeradius-doc = ""

URI_freeradius-krb5 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/freeradius-krb5-3.2.5-4.el10.x86_64_v2.rpm;name=freeradius-krb5;unpack=0"
SRC_URI += "${URI_freeradius-krb5}"
SRC_URI[freeradius-krb5.sha256sum] = "c69936f8998f11bbfc07f290c309fc079697f2822929302279665f785e78ad2e"
RDEPENDS:freeradius-krb5 = " \
 glibc \
 krb5-libs \
 libcom_err \
 freeradius \
"

URI_freeradius-ldap = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/freeradius-ldap-3.2.5-4.el10.x86_64_v2.rpm;name=freeradius-ldap;unpack=0"
SRC_URI += "${URI_freeradius-ldap}"
SRC_URI[freeradius-ldap.sha256sum] = "23ec3050013a6896f0230a3b5090b06be803d57f6abdae7d6a17561ceef2a099"
RDEPENDS:freeradius-ldap = " \
 glibc \
 openldap \
 freeradius \
"

URI_freeradius-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/freeradius-utils-3.2.5-4.el10.x86_64_v2.rpm;name=freeradius-utils;unpack=0"
SRC_URI += "${URI_freeradius-utils}"
SRC_URI[freeradius-utils.sha256sum] = "050e87a6a595d50a8a8ba3301132e5d4b78cecdb5b007d1983f124d5c449ec19"
RDEPENDS:freeradius-utils = " \
 libpcap \
 freeradius \
 perl-libs \
 openssl-libs \
 perl-Fcntl \
 gdbm-libs \
 perl-Getopt-Long \
 perl-POSIX \
 perl-File-Basename \
 perl-Getopt-Std \
 perl-DBI \
 perl-GDBM_File \
 bash \
 libtalloc \
 glibc \
 perl-interpreter \
 perl-Time-HiRes \
"

URI_python3-freeradius = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-freeradius-3.2.5-4.el10.x86_64_v2.rpm;name=python3-freeradius;unpack=0"
SRC_URI += "${URI_python3-freeradius}"
SRC_URI[python3-freeradius.sha256sum] = "7295c5db275dbcb72633464bba79caf856444997fc88848b1d82699ddcacbcb8"
RDEPENDS:python3-freeradius = " \
 glibc \
 freeradius \
 python3 \
 python3-libs \
"

URI_freeradius-mysql = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/freeradius-mysql-3.2.5-4.el10.x86_64_v2.rpm;name=freeradius-mysql;unpack=0"
SRC_URI += "${URI_freeradius-mysql}"
SRC_URI[freeradius-mysql.sha256sum] = "045b17837793855972785be3c15481f8c72144ee05e194d3620d7ebc05a0b818"
RDEPENDS:freeradius-mysql = " \
 glibc \
 mariadb-connector-c \
 freeradius \
"

URI_freeradius-perl = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/freeradius-perl-3.2.5-4.el10.x86_64_v2.rpm;name=freeradius-perl;unpack=0"
SRC_URI += "${URI_freeradius-perl}"
SRC_URI[freeradius-perl.sha256sum] = "01e7d6498cea2bb22d34fa32f4edec5a3c4e0d373f2bdd83213ae6d05d3aac29"
RDEPENDS:freeradius-perl = " \
 glibc \
 perl-libs \
 freeradius \
"

URI_freeradius-postgresql = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/freeradius-postgresql-3.2.5-4.el10.x86_64_v2.rpm;name=freeradius-postgresql;unpack=0"
SRC_URI += "${URI_freeradius-postgresql}"
SRC_URI[freeradius-postgresql.sha256sum] = "26a5699dd322c1c3b52966ee12594c7f4a45534792b037d1dd397e939613eb0f"
RDEPENDS:freeradius-postgresql = " \
 glibc \
 freeradius \
 libpq \
"

URI_freeradius-rest = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/freeradius-rest-3.2.5-4.el10.x86_64_v2.rpm;name=freeradius-rest;unpack=0"
SRC_URI += "${URI_freeradius-rest}"
SRC_URI[freeradius-rest.sha256sum] = "57a09ca849641ba1faea7e7acc2f9d9f050cf6eedb8b467ee437ab2f349a6097"
RDEPENDS:freeradius-rest = " \
 glibc \
 json-c \
 freeradius \
 libcurl \
"

URI_freeradius-sqlite = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/freeradius-sqlite-3.2.5-4.el10.x86_64_v2.rpm;name=freeradius-sqlite;unpack=0"
SRC_URI += "${URI_freeradius-sqlite}"
SRC_URI[freeradius-sqlite.sha256sum] = "de639a474d3e11e60a765f97e5ed7a0fb921cfeede6b969e0e314eb3723a1e06"
RDEPENDS:freeradius-sqlite = " \
 glibc \
 sqlite-libs \
 freeradius \
"

URI_freeradius-unixODBC = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/freeradius-unixODBC-3.2.5-4.el10.x86_64_v2.rpm;name=freeradius-unixODBC;unpack=0"
SRC_URI += "${URI_freeradius-unixODBC}"
SRC_URI[freeradius-unixODBC.sha256sum] = "6d6760eb52564588d1d23c077ce61924aee91e0e76fa70f43f96ba7577255914"
RDEPENDS:freeradius-unixODBC = " \
 glibc \
 unixODBC \
 freeradius \
"
