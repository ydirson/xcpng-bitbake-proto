# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "volume_key"
PE = "0"
PV = "0.3.12"
PR = "24.el10"
PACKAGES = "python3-volume_key volume_key volume_key-libs volume_key-devel"
PROVIDES = "rpm/python3-volume_key rpm/volume_key rpm/volume_key-libs rpm/volume_key-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/volume_key-0.3.12-24.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28cb16b8a0951770d0bb13cb4e262d2a766d289c205b9b269090f752d2145922"

URI_python3-volume_key = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-volume_key-0.3.12-24.el10.x86_64_v2.rpm;name=python3-volume_key;unpack=0"
SRC_URI += "${URI_python3-volume_key}"
SRC_URI[python3-volume_key.sha256sum] = "2fa3d38c45815508eba9358ee7b0405a9aba0e49f3c5d2cec9bdb2235f188cce"
RDEPENDS:python3-volume_key = " \
 python3 \
 nss \
 cryptsetup-libs \
 libblkid \
 gpgme \
 nss-util \
 glib2 \
 volume_key-libs \
 glibc \
 nspr \
"

URI_volume_key = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/volume_key-0.3.12-24.el10.x86_64_v2.rpm;name=volume_key;unpack=0"
SRC_URI += "${URI_volume_key}"
SRC_URI[volume_key.sha256sum] = "423fcae18833b5823959fea3ca5a460ab934913b12b83fd8dd983ed09ae65dc5"
RDEPENDS:volume_key = " \
 nss \
 volume_key-libs \
 glib2 \
 glibc \
 nspr \
"

URI_volume_key-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/volume_key-libs-0.3.12-24.el10.x86_64_v2.rpm;name=volume_key-libs;unpack=0"
SRC_URI += "${URI_volume_key-libs}"
SRC_URI[volume_key-libs.sha256sum] = "f7dd562c6e48f1eaa980e1e603038022c9d6e508cbcaf2da79a99e1ccfda4637"
RDEPENDS:volume_key-libs = " \
 nss \
 gnupg2 \
 cryptsetup-libs \
 libblkid \
 gpgme \
 nss-util \
 glib2 \
 glibc \
 nspr \
"

URI_volume_key-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/volume_key-devel-0.3.12-24.el10.x86_64_v2.rpm;name=volume_key-devel;unpack=0"
SRC_URI += "${URI_volume_key-devel}"
SRC_URI[volume_key-devel.sha256sum] = "d07e8886d5e05b53c73dff1df8b5aaa40032618adcfc43d022732ace8d6eefb2"
RDEPENDS:volume_key-devel = " \
 volume_key-libs \
"
