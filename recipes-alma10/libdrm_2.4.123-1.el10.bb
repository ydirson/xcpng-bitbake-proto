# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libdrm"
PE = "0"
PV = "2.4.123"
PR = "1.el10"
PACKAGES = "libdrm libdrm-devel drm-utils"
PROVIDES = "rpm/libdrm rpm/libdrm-devel rpm/drm-utils"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libdrm-2.4.123-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7129e2d7b66814abb0076c0f1903d00740d9ac98dac0f32384f3bb396c518b5e"

URI_libdrm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libdrm-2.4.123-1.el10.x86_64_v2.rpm;name=libdrm;unpack=0"
SRC_URI += "${URI_libdrm}"
SRC_URI[libdrm.sha256sum] = "7bfe34a751539df2ca1fbd84175549383ca5e9b09485ffa813e5fbf95c05f00b"
RDEPENDS:libdrm = " \
 glibc \
 libpciaccess \
"

URI_libdrm-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libdrm-devel-2.4.123-1.el10.x86_64_v2.rpm;name=libdrm-devel;unpack=0"
SRC_URI += "${URI_libdrm-devel}"
SRC_URI[libdrm-devel.sha256sum] = "43fbf578d39632cff063e7932b7bece399c0e9637cc70a0160a176927ffd6b31"
RDEPENDS:libdrm-devel = " \
 kernel-headers \
 libpciaccess-devel \
 pkgconf-pkg-config \
 libdrm \
 libdrm-devel \
"

URI_drm-utils = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/drm-utils-2.4.123-1.el10.x86_64_v2.rpm;name=drm-utils;unpack=0"
SRC_URI += "${URI_drm-utils}"
SRC_URI[drm-utils.sha256sum] = "767693e0885a6ac7d8f4f2c01b229d97a29ecd62e370a44ab8e0ae2b547c8890"
RDEPENDS:drm-utils = " \
 glibc \
 libdrm \
"
