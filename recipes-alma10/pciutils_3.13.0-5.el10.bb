# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pciutils"
PE = "0"
PV = "3.13.0"
PR = "5.el10"
PACKAGES = "pciutils pciutils-libs pciutils-devel pciutils-devel-static"
PROVIDES = "rpm/pciutils rpm/pciutils-libs rpm/pciutils-devel rpm/pciutils-devel-static"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/pciutils-3.13.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3332b67a9f9319687851292cd5e837027a8eb6ea4ea4fab921efbffd350eda11"

URI_pciutils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/pciutils-3.13.0-5.el10.x86_64_v2.rpm;name=pciutils;unpack=0"
SRC_URI += "${URI_pciutils}"
SRC_URI[pciutils.sha256sum] = "8945c9504fd11b96a1cac9917e9a904cff39ee810a6f9459729f04d0ade51ee4"
RDEPENDS:pciutils = " \
 kmod-libs \
 hwdata \
 pciutils-libs \
 bash \
 glibc \
"

URI_pciutils-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/pciutils-libs-3.13.0-5.el10.x86_64_v2.rpm;name=pciutils-libs;unpack=0"
SRC_URI += "${URI_pciutils-libs}"
SRC_URI[pciutils-libs.sha256sum] = "909a58590011b0e647643983831462a881717d92bd7172d1ba1bec3f47ca77e3"
RDEPENDS:pciutils-libs = " \
 glibc \
"

URI_pciutils-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pciutils-devel-3.13.0-5.el10.x86_64_v2.rpm;name=pciutils-devel;unpack=0"
SRC_URI += "${URI_pciutils-devel}"
SRC_URI[pciutils-devel.sha256sum] = "2e4b3d9d36b0d4a80d788d5199b50bb72a95d40d69015e0e686645bc25d60d95"
RDEPENDS:pciutils-devel = " \
 pciutils \
 zlib-ng-compat-devel \
 pciutils-libs \
 pkgconf-pkg-config \
"

URI_pciutils-devel-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/pciutils-devel-static-3.13.0-5.el10.x86_64_v2.rpm;name=pciutils-devel-static;unpack=0"
SRC_URI += "${URI_pciutils-devel-static}"
SRC_URI[pciutils-devel-static.sha256sum] = "241056760d051d132883793ee326aa426d9295f216c827fc81683df06a45ace9"
RDEPENDS:pciutils-devel-static = " \
 pciutils-devel \
"
