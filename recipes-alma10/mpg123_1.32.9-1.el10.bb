# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mpg123"
PE = "0"
PV = "1.32.9"
PR = "1.el10"
PACKAGES = "mpg123 mpg123-libs mpg123-plugins-pulseaudio mpg123-devel"
PROVIDES = "rpm/mpg123 rpm/mpg123-libs rpm/mpg123-plugins-pulseaudio rpm/mpg123-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mpg123-1.32.9-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f8cb6a6cf890bf206d4e18c08d1646181c7ecc51d8f6a77ea7381aeb652809b"

URI_mpg123 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mpg123-1.32.9-1.el10.x86_64_v2.rpm;name=mpg123;unpack=0"
SRC_URI += "${URI_mpg123}"
SRC_URI[mpg123.sha256sum] = "3c7aa463f51b9b728234f3dd7e3b1948f234015a2fd2d96327f5c957dc2fe34c"
RDEPENDS:mpg123 = " \
 glibc \
 alsa-lib \
 mpg123-libs \
"

URI_mpg123-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mpg123-libs-1.32.9-1.el10.x86_64_v2.rpm;name=mpg123-libs;unpack=0"
SRC_URI += "${URI_mpg123-libs}"
SRC_URI[mpg123-libs.sha256sum] = "43042b8398b124eeb4ac113315079a1522de458673c72a2df067b79b8932effb"
RDEPENDS:mpg123-libs = " \
 glibc \
"

URI_mpg123-plugins-pulseaudio = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mpg123-plugins-pulseaudio-1.32.9-1.el10.x86_64_v2.rpm;name=mpg123-plugins-pulseaudio;unpack=0"
SRC_URI += "${URI_mpg123-plugins-pulseaudio}"
SRC_URI[mpg123-plugins-pulseaudio.sha256sum] = "fa4ed16c579c966bddae5b38acb476f9861fede2d2636aa1f92daa2aeda4da46"
RDEPENDS:mpg123-plugins-pulseaudio = " \
 glibc \
 pulseaudio-libs \
 mpg123 \
"

URI_mpg123-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mpg123-devel-1.32.9-1.el10.x86_64_v2.rpm;name=mpg123-devel;unpack=0"
SRC_URI += "${URI_mpg123-devel}"
SRC_URI[mpg123-devel.sha256sum] = "2acf827dddd9211f0702d37ec2902e880abf792940d9fd468f048e4c1d01a83e"
RDEPENDS:mpg123-devel = " \
 mpg123-libs \
 pkgconf-pkg-config \
"
