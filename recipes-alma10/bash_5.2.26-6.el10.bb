# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "bash"
PE = "0"
PV = "5.2.26"
PR = "6.el10"
PACKAGES = "bash bash-devel bash-doc"
PROVIDES = "rpm/bash rpm/bash-devel rpm/bash-doc"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/bash-5.2.26-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8bdbc70bc9a03158c9475057371317096df355a734106612f8d1585f6e24941"

URI_bash = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/bash-5.2.26-6.el10.x86_64_v2.rpm;name=bash;unpack=0"
SRC_URI += "${URI_bash}"
SRC_URI[bash.sha256sum] = "06674be4185048638c884c43e5cc458d1d092d013252df9b87fd872aa6860c6c"
RDEPENDS:bash = " \
 glibc \
 filesystem \
 ncurses-libs \
"

URI_bash-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/bash-devel-5.2.26-6.el10.x86_64_v2.rpm;name=bash-devel;unpack=0"
SRC_URI += "${URI_bash-devel}"
SRC_URI[bash-devel.sha256sum] = "e1fd331aa3bbd3eeea369985a26710ec2b5c3fe191bfefafe8ed20088032fcd9"
RDEPENDS:bash-devel = " \
 bash \
 pkgconf-pkg-config \
"

URI_bash-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/bash-doc-5.2.26-6.el10.x86_64_v2.rpm;name=bash-doc;unpack=0"
SRC_URI += "${URI_bash-doc}"
SRC_URI[bash-doc.sha256sum] = "9b73f2eadf28a6a465eb82af1fee5f3d274811a5674485a3db32bfe3c21caaa3"
RDEPENDS:bash-doc = " \
 bash \
"
