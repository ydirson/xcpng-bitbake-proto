# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gcab"
PE = "0"
PV = "1.6"
PR = "7.el10"
PACKAGES = "libgcab1 libgcab1-devel gcab"
PROVIDES = "rpm/libgcab1 rpm/libgcab1-devel rpm/gcab"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/gcab-1.6-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "966602a4aeb2b2e837a7d8476239ab05d6b4b0a706bda13cbb24927a74e7b6c7"

URI_libgcab1 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libgcab1-1.6-7.el10.x86_64_v2.rpm;name=libgcab1;unpack=0"
SRC_URI += "${URI_libgcab1}"
SRC_URI[libgcab1.sha256sum] = "e299c703082959203c738e3ebd1ad96549b4bc4e96afaaf123b5c90d09abede6"
RDEPENDS:libgcab1 = " \
 glibc \
 libgcc \
 glib2 \
 zlib-ng-compat \
"

URI_libgcab1-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libgcab1-devel-1.6-7.el10.x86_64_v2.rpm;name=libgcab1-devel;unpack=0"
SRC_URI += "${URI_libgcab1-devel}"
SRC_URI[libgcab1-devel.sha256sum] = "1dd8a65b29a4316afc91cbae80695ab786357008bf8b8a563d4a7ac5d988fe07"
RDEPENDS:libgcab1-devel = " \
 libgcab1 \
 glib2-devel \
 pkgconf-pkg-config \
"

URI_gcab = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gcab-1.6-7.el10.x86_64_v2.rpm;name=gcab;unpack=0"
SRC_URI += "${URI_gcab}"
SRC_URI[gcab.sha256sum] = "9489000b0819b3e35e7ee25869d3b8e3e00efe40f44df2800b78d39c32fe2768"
RDEPENDS:gcab = " \
 glibc \
 libgcab1 \
 libgcc \
 glib2 \
"
