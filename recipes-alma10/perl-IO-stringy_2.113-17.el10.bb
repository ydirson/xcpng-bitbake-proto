# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-IO-stringy"
PE = "0"
PV = "2.113"
PR = "17.el10"
PACKAGES = "perl-IO-stringy perl-IO-stringy-tests"
PROVIDES = "rpm/perl-IO-stringy rpm/perl-IO-stringy-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-IO-stringy-2.113-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "755b117242a1dadbf55b1ca4db43846f95cb3daba02961cc658f27352c6b8970"

URI_perl-IO-stringy = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-IO-stringy-2.113-17.el10.noarch.rpm;name=perl-IO-stringy;unpack=0"
SRC_URI += "${URI_perl-IO-stringy}"
SRC_URI[perl-IO-stringy.sha256sum] = "b8a57808ace94c261130fac5cefdb13c5a2115200d9b96eab9867e769e38c0ea"
RDEPENDS:perl-IO-stringy = " \
 perl-IO-stringy \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-IO \
 perl-FileHandle \
 perl-overload \
 perl-Symbol \
 perl-parent \
 perl-Exporter \
"

URI_perl-IO-stringy-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-IO-stringy-tests-2.113-17.el10.noarch.rpm;name=perl-IO-stringy-tests;unpack=0"
SRC_URI += "${URI_perl-IO-stringy-tests}"
SRC_URI[perl-IO-stringy-tests.sha256sum] = "4653648cea14b3ef769a39e9b7497cacb53c679fca9302f06f82c09d40b6aefe"
RDEPENDS:perl-IO-stringy-tests = " \
 perl-IO-stringy \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-ExtUtils-MakeMaker \
 perl-IO \
 perl-Symbol \
 bash \
 perl-PathTools \
 perl-interpreter \
 perl-File-Temp \
"
