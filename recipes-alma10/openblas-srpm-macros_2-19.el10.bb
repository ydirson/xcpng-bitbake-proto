# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "openblas-srpm-macros"
PE = "0"
PV = "2"
PR = "19.el10"
PACKAGES = "openblas-srpm-macros"
PROVIDES = "rpm/openblas-srpm-macros"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/openblas-srpm-macros-2-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e2e50dd9cb052e4cfb31301e9c6f89a76a888724d07ce89782769addaaa0dd2"

URI_openblas-srpm-macros = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/openblas-srpm-macros-2-19.el10.noarch.rpm;name=openblas-srpm-macros;unpack=0"
SRC_URI += "${URI_openblas-srpm-macros}"
SRC_URI[openblas-srpm-macros.sha256sum] = "aaab4436f0b991293a491f72e8704906c2c2608032c3490c3dc05c68cff9b0ce"
RDEPENDS:openblas-srpm-macros = ""
