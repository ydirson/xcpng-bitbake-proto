# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rit-rachana-fonts"
PE = "0"
PV = "1.4.7"
PR = "5.el10"
PACKAGES = "rit-rachana-fonts"
PROVIDES = "rpm/rit-rachana-fonts"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/rit-rachana-fonts-1.4.7-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e9e6308facf464427c128bf1c40e0c3762666604ef6614fd64fdddb15f6f95d"

URI_rit-rachana-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rit-rachana-fonts-1.4.7-5.el10.noarch.rpm;name=rit-rachana-fonts;unpack=0"
SRC_URI += "${URI_rit-rachana-fonts}"
SRC_URI[rit-rachana-fonts.sha256sum] = "353db04b6ee0ce668708bdf092d2d607baef0fd35871d182598bcdce818fc435"
RDEPENDS:rit-rachana-fonts = " \
 fonts-filesystem \
"
