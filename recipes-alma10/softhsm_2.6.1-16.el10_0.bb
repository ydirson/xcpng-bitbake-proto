# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "softhsm"
PE = "0"
PV = "2.6.1"
PR = "16.el10_0"
PACKAGES = "softhsm softhsm-devel"
PROVIDES = "rpm/softhsm rpm/softhsm-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/softhsm-2.6.1-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "725403def9ac613c729489fa3e7b54ee6a6948040ee7b1c1fc3140a81925a535"

URI_softhsm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/softhsm-2.6.1-16.el10_0.x86_64_v2.rpm;name=softhsm;unpack=0"
SRC_URI += "${URI_softhsm}"
SRC_URI[softhsm.sha256sum] = "1dc7523b2d468080e6d5dc525a42e6931c64134d6a47417f72a1cdbba2aa31e3"
RDEPENDS:softhsm = " \
 shadow-utils \
 libgcc \
 openssl-libs \
 p11-kit \
 sqlite-libs \
 libstdc++ \
 bash \
 glibc \
"

URI_softhsm-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/softhsm-devel-2.6.1-16.el10_0.x86_64_v2.rpm;name=softhsm-devel;unpack=0"
SRC_URI += "${URI_softhsm-devel}"
SRC_URI[softhsm-devel.sha256sum] = "c3a2bb92c67bc5ddc54978dd4de3f4cc10127d46a5aacac91c7cfdf17c94749f"
RDEPENDS:softhsm-devel = " \
 softhsm \
 openssl-devel \
 sqlite-devel \
"
