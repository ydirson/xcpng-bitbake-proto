# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xorg-x11-xauth"
PE = "1"
PV = "1.1.2"
PR = "8.el10"
PACKAGES = "xorg-x11-xauth"
PROVIDES = "rpm/xorg-x11-xauth"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xorg-x11-xauth-1.1.2-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de29acde2c99d9f583f7a909560f64f5a8f7bd0374532388712d194617b7aecb"

URI_xorg-x11-xauth = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xorg-x11-xauth-1.1.2-8.el10.x86_64_v2.rpm;name=xorg-x11-xauth;unpack=0"
SRC_URI += "${URI_xorg-x11-xauth}"
SRC_URI[xorg-x11-xauth.sha256sum] = "c777b6b73d7b0676eabebe7b2da3cadf908ebca79a011cf4494507dcb1f9c969"
RDEPENDS:xorg-x11-xauth = " \
 libXmu \
 libX11 \
 libXau \
 glibc \
 libXext \
"
