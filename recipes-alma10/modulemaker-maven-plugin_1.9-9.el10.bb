# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "modulemaker-maven-plugin"
PE = "0"
PV = "1.9"
PR = "9.el10"
PACKAGES = "modulemaker-maven-plugin modulemaker-maven-plugin-javadoc"
PROVIDES = "rpm/modulemaker-maven-plugin rpm/modulemaker-maven-plugin-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/modulemaker-maven-plugin-1.9-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b82595117e006d1db0b3ae3a0dd75f6503606d1ae4c176bad28b1626285e4dfe"

URI_modulemaker-maven-plugin = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/modulemaker-maven-plugin-1.9-9.el10.noarch.rpm;name=modulemaker-maven-plugin;unpack=0"
SRC_URI += "${URI_modulemaker-maven-plugin}"
SRC_URI[modulemaker-maven-plugin.sha256sum] = "de7dea623dfc8e904d6e1d3a210a1c14572d3e9a33a74f73be07be6a490942bd"
RDEPENDS:modulemaker-maven-plugin = " \
 objectweb-asm \
 javapackages-filesystem \
"

URI_modulemaker-maven-plugin-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/modulemaker-maven-plugin-javadoc-1.9-9.el10.noarch.rpm;name=modulemaker-maven-plugin-javadoc;unpack=0"
SRC_URI += "${URI_modulemaker-maven-plugin-javadoc}"
SRC_URI[modulemaker-maven-plugin-javadoc.sha256sum] = "256085e7c7a2a5bca1cf1b66e312d7a9324b6793bde5310461b52c1aacc0c1a0"
RDEPENDS:modulemaker-maven-plugin-javadoc = " \
 javapackages-filesystem \
"
