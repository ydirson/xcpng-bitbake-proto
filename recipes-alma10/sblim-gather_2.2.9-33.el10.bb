# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sblim-gather"
PE = "0"
PV = "2.2.9"
PR = "33.el10"
PACKAGES = "sblim-gather sblim-gather-devel sblim-gather-provider sblim-gather-test"
PROVIDES = "rpm/sblim-gather rpm/sblim-gather-devel rpm/sblim-gather-provider rpm/sblim-gather-test"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/sblim-gather-2.2.9-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0af7f4710556e440c58db62b3ba4be551c239ab0491fd603bef9fea60fddc1ea"

URI_sblim-gather = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sblim-gather-2.2.9-33.el10.x86_64_v2.rpm;name=sblim-gather;unpack=0"
SRC_URI += "${URI_sblim-gather}"
SRC_URI[sblim-gather.sha256sum] = "98d7d32b8c0c9b8521bd818b4003c8411841d01b7a6c83497f553a398139574f"
RDEPENDS:sblim-gather = " \
 systemd \
 libgcc \
 sblim-sfcb \
 bash \
 glibc \
 libvirt-libs \
"

URI_sblim-gather-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sblim-gather-devel-2.2.9-33.el10.x86_64_v2.rpm;name=sblim-gather-devel;unpack=0"
SRC_URI += "${URI_sblim-gather-devel}"
SRC_URI[sblim-gather-devel.sha256sum] = "d9a90df96eed464d99e8c883be7e6b1b62a1ee0bb3bf3201fe03ea8874ce9afc"
RDEPENDS:sblim-gather-devel = " \
 sblim-sfcb \
 sblim-gather \
"

URI_sblim-gather-provider = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sblim-gather-provider-2.2.9-33.el10.x86_64_v2.rpm;name=sblim-gather-provider;unpack=0"
SRC_URI += "${URI_sblim-gather-provider}"
SRC_URI[sblim-gather-provider.sha256sum] = "ee491324847ecfc0a76ae5973022875a844857bce143093177a4f19618abe0fb"
RDEPENDS:sblim-gather-provider = " \
 sblim-cmpi-base \
 sblim-sfcb \
 sblim-gather \
 bash \
 glibc \
"

URI_sblim-gather-test = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sblim-gather-test-2.2.9-33.el10.x86_64_v2.rpm;name=sblim-gather-test;unpack=0"
SRC_URI += "${URI_sblim-gather-test}"
SRC_URI[sblim-gather-test.sha256sum] = "1a70c7c0d312926ed4e2451018c7abce6a63b68746c775a9805bd91d08d8163f"
RDEPENDS:sblim-gather-test = " \
 sblim-sfcb \
 bash \
 sblim-gather-provider \
"
