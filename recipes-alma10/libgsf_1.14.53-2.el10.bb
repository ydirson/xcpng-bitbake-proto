# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libgsf"
PE = "0"
PV = "1.14.53"
PR = "2.el10"
PACKAGES = "libgsf libgsf-devel"
PROVIDES = "rpm/libgsf rpm/libgsf-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libgsf-1.14.53-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2c704d214b4cb4f1c64f68ec02e6211131bedab18eacdb3f3f240a7ba42a977"

URI_libgsf = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libgsf-1.14.53-2.el10.x86_64_v2.rpm;name=libgsf;unpack=0"
SRC_URI += "${URI_libgsf}"
SRC_URI[libgsf.sha256sum] = "ff7c47b0f225c34114e942187da176bc94f4b23475a61885fa31587f9e96cdcd"
RDEPENDS:libgsf = " \
 zlib-ng-compat \
 bzip2-libs \
 libxml2 \
 gdk-pixbuf2 \
 glib2 \
 glibc \
"

URI_libgsf-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libgsf-devel-1.14.53-2.el10.x86_64_v2.rpm;name=libgsf-devel;unpack=0"
SRC_URI += "${URI_libgsf-devel}"
SRC_URI[libgsf-devel.sha256sum] = "b7f4d43375a4a7ca7c7618750cbaa3ace758c30694641c7d6e79d72328b8a5d1"
RDEPENDS:libgsf-devel = " \
 libxml2-devel \
 glib2-devel \
 pkgconf-pkg-config \
 libgsf \
 glib2 \
 glibc \
"
