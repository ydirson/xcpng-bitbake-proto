# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Authen-SASL"
PE = "0"
PV = "2.1700"
PR = "5.el10"
PACKAGES = "perl-Authen-SASL perl-Authen-SASL-tests"
PROVIDES = "rpm/perl-Authen-SASL rpm/perl-Authen-SASL-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Authen-SASL-2.1700-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4328b2a932fb3a413755acde69feed2eaa7b225c6f8d52d2efc32b9137eff093"

URI_perl-Authen-SASL = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Authen-SASL-2.1700-5.el10.noarch.rpm;name=perl-Authen-SASL;unpack=0"
SRC_URI += "${URI_perl-Authen-SASL}"
SRC_URI[perl-Authen-SASL.sha256sum] = "c859cc9585221cb13fae6ae9030807b324e7ba6588a9f990410d7eac3ab2dea3"
RDEPENDS:perl-Authen-SASL = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-Digest-HMAC \
 perl-Digest-MD5 \
 perl-GSSAPI \
 perl-Tie \
"

URI_perl-Authen-SASL-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Authen-SASL-tests-2.1700-5.el10.noarch.rpm;name=perl-Authen-SASL-tests;unpack=0"
SRC_URI += "${URI_perl-Authen-SASL-tests}"
SRC_URI[perl-Authen-SASL-tests.sha256sum] = "5ca0f757c489678b21a6042b8a786725f4eb4e70f5d0f919071b2d913d558936"
RDEPENDS:perl-Authen-SASL-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-Digest-HMAC \
 perl-Digest-MD5 \
 perl-FindBin \
 perl-Authen-SASL \
 bash \
 perl-interpreter \
"
