# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "startup-notification"
PE = "0"
PV = "0.12"
PR = "31.el10"
PACKAGES = "startup-notification startup-notification-devel"
PROVIDES = "rpm/startup-notification rpm/startup-notification-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/startup-notification-0.12-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f15cbc6235aad8704bbed604d775ba6eb99aed8f77b1b401192419fc4262ae58"

URI_startup-notification = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/startup-notification-0.12-31.el10.x86_64_v2.rpm;name=startup-notification;unpack=0"
SRC_URI += "${URI_startup-notification}"
SRC_URI[startup-notification.sha256sum] = "75eb985e6dc20eae5d4ea51a239ec9968270cde395a71202076cd41cd8f0d088"
RDEPENDS:startup-notification = " \
 libX11 \
 libxcb \
 libX11-xcb \
 glibc \
 xcb-util \
"

URI_startup-notification-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/startup-notification-devel-0.12-31.el10.x86_64_v2.rpm;name=startup-notification-devel;unpack=0"
SRC_URI += "${URI_startup-notification-devel}"
SRC_URI[startup-notification-devel.sha256sum] = "70ed0c4b5478d24b60d78653c35207c491b04b6dcb1ccc98ea68e83ea4476cfc"
RDEPENDS:startup-notification-devel = " \
 libX11-devel \
 pkgconf-pkg-config \
 startup-notification \
"
