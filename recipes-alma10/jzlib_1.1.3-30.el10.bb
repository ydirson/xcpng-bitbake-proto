# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jzlib"
PE = "0"
PV = "1.1.3"
PR = "30.el10"
PACKAGES = "jzlib jzlib-demo jzlib-javadoc"
PROVIDES = "rpm/jzlib rpm/jzlib-demo rpm/jzlib-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/jzlib-1.1.3-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "783fd0efcf3f8d0089066d23611d9752f9013ff70adc36b3f42893074398f6f0"

URI_jzlib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jzlib-1.1.3-30.el10.noarch.rpm;name=jzlib;unpack=0"
SRC_URI += "${URI_jzlib}"
SRC_URI[jzlib.sha256sum] = "f023faa26b4a70c8db0dfb9feb7bd2f23d1296160c764379992c45f395e7aece"
RDEPENDS:jzlib = " \
 javapackages-filesystem \
"

URI_jzlib-demo = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jzlib-demo-1.1.3-30.el10.noarch.rpm;name=jzlib-demo;unpack=0"
SRC_URI += "${URI_jzlib-demo}"
SRC_URI[jzlib-demo.sha256sum] = "7befec9856b9e3349a5379f3ee5fab4db979dc23f5671d049f8a9a5cbc987822"
RDEPENDS:jzlib-demo = " \
 jzlib \
"

URI_jzlib-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jzlib-javadoc-1.1.3-30.el10.noarch.rpm;name=jzlib-javadoc;unpack=0"
SRC_URI += "${URI_jzlib-javadoc}"
SRC_URI[jzlib-javadoc.sha256sum] = "4faeb582a9fcf7ed00bb72c1e89daa8c76b6f8a3714f0cc22a2d66414fcc3898"
RDEPENDS:jzlib-javadoc = " \
 javapackages-filesystem \
"
