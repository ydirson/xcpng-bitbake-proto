# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "boost"
PE = "0"
PV = "1.83.0"
PR = "5.el10"
PACKAGES = "boost-system boost boost-atomic boost-chrono boost-container boost-context boost-contract boost-coroutine boost-date-time boost-devel boost-fiber boost-filesystem boost-graph boost-iostreams boost-json boost-locale boost-log boost-math boost-nowide boost-numpy3 boost-program-options boost-python3 boost-random boost-regex boost-serialization boost-stacktrace boost-test boost-thread boost-timer boost-type_erasure boost-wave boost-b2 boost-build boost-doc boost-doctools boost-examples boost-graph-mpich boost-graph-openmpi boost-mpich boost-mpich-devel boost-mpich-python3 boost-openmpi boost-openmpi-devel boost-openmpi-python3 boost-static boost-mpich-python3-devel boost-openmpi-python3-devel boost-url"
PROVIDES = "rpm/boost-system rpm/boost rpm/boost-atomic rpm/boost-chrono rpm/boost-container rpm/boost-context rpm/boost-contract rpm/boost-coroutine rpm/boost-date-time rpm/boost-devel rpm/boost-fiber rpm/boost-filesystem rpm/boost-graph rpm/boost-iostreams rpm/boost-json rpm/boost-locale rpm/boost-log rpm/boost-math rpm/boost-nowide rpm/boost-numpy3 rpm/boost-program-options rpm/boost-python3 rpm/boost-random rpm/boost-regex rpm/boost-serialization rpm/boost-stacktrace rpm/boost-test rpm/boost-thread rpm/boost-timer rpm/boost-type_erasure rpm/boost-wave rpm/boost-b2 rpm/boost-build rpm/boost-doc rpm/boost-doctools rpm/boost-examples rpm/boost-graph-mpich rpm/boost-graph-openmpi rpm/boost-mpich rpm/boost-mpich-devel rpm/boost-mpich-python3 rpm/boost-openmpi rpm/boost-openmpi-devel rpm/boost-openmpi-python3 rpm/boost-static rpm/boost-mpich-python3-devel rpm/boost-openmpi-python3-devel rpm/boost-url"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/boost-1.83.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "544d76f20ac6c4d3e4cb3a785ff631a640b506d2f409bc239da2a80bf2733d8c"

URI_boost-system = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/boost-system-1.83.0-5.el10.x86_64_v2.rpm;name=boost-system;unpack=0"
SRC_URI += "${URI_boost-system}"
SRC_URI[boost-system.sha256sum] = "d67a0f420212d1b8c0d95a85752558b97933e4e9ba2f9db761b230bf9a3bce49"
RDEPENDS:boost-system = " \
 glibc \
"

URI_boost = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-1.83.0-5.el10.x86_64_v2.rpm;name=boost;unpack=0"
SRC_URI += "${URI_boost}"
SRC_URI[boost.sha256sum] = "3f2fccf305080d32d4b3b8e488ec6018386538da810b031915441fe95472af90"
RDEPENDS:boost = " \
 boost-fiber \
 boost-filesystem \
 boost-graph \
 boost-iostreams \
 boost-json \
 boost-locale \
 boost-log \
 boost-math \
 boost-nowide \
 boost-program-options \
 boost-python3 \
 boost-random \
 boost-regex \
 boost-serialization \
 boost-stacktrace \
 boost-test \
 boost-thread \
 boost-timer \
 boost-type_erasure \
 boost-wave \
 boost-system \
 boost-atomic \
 boost-chrono \
 boost-container \
 boost-context \
 boost-contract \
 boost-coroutine \
 boost-date-time \
"

URI_boost-atomic = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-atomic-1.83.0-5.el10.x86_64_v2.rpm;name=boost-atomic;unpack=0"
SRC_URI += "${URI_boost-atomic}"
SRC_URI[boost-atomic.sha256sum] = "b881a7e871679376b4af88daec7a00d9e5df8c06b8d40bf032948c6928f84170"
RDEPENDS:boost-atomic = " \
 glibc \
 libstdc++ \
"

URI_boost-chrono = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-chrono-1.83.0-5.el10.x86_64_v2.rpm;name=boost-chrono;unpack=0"
SRC_URI += "${URI_boost-chrono}"
SRC_URI[boost-chrono.sha256sum] = "2514b4882459d9651bbb0cc6aad6f189287957f5ffe0b15420c89981e5e5156d"
RDEPENDS:boost-chrono = " \
 glibc \
 libgcc \
 boost-system \
 libstdc++ \
"

URI_boost-container = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-container-1.83.0-5.el10.x86_64_v2.rpm;name=boost-container;unpack=0"
SRC_URI += "${URI_boost-container}"
SRC_URI[boost-container.sha256sum] = "9d54f99adb6cf7a70d7f8a4a605cafb8a594afed2d73c7d8b0f0d8d6ceb26c12"
RDEPENDS:boost-container = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_boost-context = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-context-1.83.0-5.el10.x86_64_v2.rpm;name=boost-context;unpack=0"
SRC_URI += "${URI_boost-context}"
SRC_URI[boost-context.sha256sum] = "ffeb29c5d7d6cb3cde117a2045d70cfbb8cc297d470e82882c7cc2ec31882976"
RDEPENDS:boost-context = " \
 glibc \
 libstdc++ \
"

URI_boost-contract = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-contract-1.83.0-5.el10.x86_64_v2.rpm;name=boost-contract;unpack=0"
SRC_URI += "${URI_boost-contract}"
SRC_URI[boost-contract.sha256sum] = "2838ad1c291210e905e6baad1d79cb699b3ab65da287a1f1a9527bae36e1215a"
RDEPENDS:boost-contract = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_boost-coroutine = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-coroutine-1.83.0-5.el10.x86_64_v2.rpm;name=boost-coroutine;unpack=0"
SRC_URI += "${URI_boost-coroutine}"
SRC_URI[boost-coroutine.sha256sum] = "b0e694e7362f3b3b07c6d56e38ffb508fe99fc49a21960070cf64dc74c16067b"
RDEPENDS:boost-coroutine = " \
 glibc \
 libstdc++ \
 boost-context \
"

URI_boost-date-time = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-date-time-1.83.0-5.el10.x86_64_v2.rpm;name=boost-date-time;unpack=0"
SRC_URI += "${URI_boost-date-time}"
SRC_URI[boost-date-time.sha256sum] = "0cadf394666c8886cdd0504dd128865a1941ab221504a3c2131e1f10ee494cb3"
RDEPENDS:boost-date-time = " \
 glibc \
"

URI_boost-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-devel-1.83.0-5.el10.x86_64_v2.rpm;name=boost-devel;unpack=0"
SRC_URI += "${URI_boost-devel}"
SRC_URI[boost-devel.sha256sum] = "23097f333447163909baadc295303f839b8c8d8ef0f407dd56bf8e4c483a0122"
RDEPENDS:boost-devel = " \
 libquadmath-devel \
 libicu-devel \
 boost-numpy3 \
 boost \
"

URI_boost-fiber = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-fiber-1.83.0-5.el10.x86_64_v2.rpm;name=boost-fiber;unpack=0"
SRC_URI += "${URI_boost-fiber}"
SRC_URI[boost-fiber.sha256sum] = "b299c4fbca9f46b5f9ec9433bd06d62a6c5c82c83045f518366cb8f62580ae2b"
RDEPENDS:boost-fiber = " \
 boost-filesystem \
 libgcc \
 libstdc++ \
 glibc \
 boost-context \
"

URI_boost-filesystem = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-filesystem-1.83.0-5.el10.x86_64_v2.rpm;name=boost-filesystem;unpack=0"
SRC_URI += "${URI_boost-filesystem}"
SRC_URI[boost-filesystem.sha256sum] = "d39ca3e645c63c74eb7197db7f383c951eefdb1cd1039f6a3f10ef3a5b0277f0"
RDEPENDS:boost-filesystem = " \
 boost-atomic \
 libgcc \
 libstdc++ \
 glibc \
 boost-system \
"

URI_boost-graph = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-graph-1.83.0-5.el10.x86_64_v2.rpm;name=boost-graph;unpack=0"
SRC_URI += "${URI_boost-graph}"
SRC_URI[boost-graph.sha256sum] = "3576b512c1fd42bdb0005ab69af8cf5ea81e6c20e476980017ae497e18fb8674"
RDEPENDS:boost-graph = " \
 libgcc \
 boost-regex \
 libstdc++ \
 glibc \
 libicu \
"

URI_boost-iostreams = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-iostreams-1.83.0-5.el10.x86_64_v2.rpm;name=boost-iostreams;unpack=0"
SRC_URI += "${URI_boost-iostreams}"
SRC_URI[boost-iostreams.sha256sum] = "f130b0096b5de0d5b9e6608dc18d2ed18962d37a79c695d40def5e9ef8047908"
RDEPENDS:boost-iostreams = " \
 zlib-ng-compat \
 bzip2-libs \
 libgcc \
 libzstd \
 libstdc++ \
 glibc \
 xz-libs \
"

URI_boost-json = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-json-1.83.0-5.el10.x86_64_v2.rpm;name=boost-json;unpack=0"
SRC_URI += "${URI_boost-json}"
SRC_URI[boost-json.sha256sum] = "5b844fbd2434f1dc28447457c111c79f73087f5f3069e44d2bfb6209aac03542"
RDEPENDS:boost-json = " \
 glibc \
 boost-container \
 libgcc \
 libstdc++ \
"

URI_boost-locale = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-locale-1.83.0-5.el10.x86_64_v2.rpm;name=boost-locale;unpack=0"
SRC_URI += "${URI_boost-locale}"
SRC_URI[boost-locale.sha256sum] = "7ef52ceb41f0f1185ebe09423bbd6e58e8a198968d4f838fa722ff6d06551c1b"
RDEPENDS:boost-locale = " \
 libgcc \
 boost-chrono \
 boost-thread \
 libstdc++ \
 glibc \
 libicu \
 boost-system \
"

URI_boost-log = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-log-1.83.0-5.el10.x86_64_v2.rpm;name=boost-log;unpack=0"
SRC_URI += "${URI_boost-log}"
SRC_URI[boost-log.sha256sum] = "6e0bb89be533eed4c243c49e8aa7f2f686dc572f0d50b327a14364cd95258c84"
RDEPENDS:boost-log = " \
 boost-filesystem \
 boost-atomic \
 libgcc \
 boost-chrono \
 boost-regex \
 boost-thread \
 libstdc++ \
 glibc \
 libicu \
"

URI_boost-math = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-math-1.83.0-5.el10.x86_64_v2.rpm;name=boost-math;unpack=0"
SRC_URI += "${URI_boost-math}"
SRC_URI[boost-math.sha256sum] = "dd24b60512c9d6fe3685b87bd42bacfa70b0f7b8b0a1a07e2053b959636570d8"
RDEPENDS:boost-math = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_boost-nowide = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-nowide-1.83.0-5.el10.x86_64_v2.rpm;name=boost-nowide;unpack=0"
SRC_URI += "${URI_boost-nowide}"
SRC_URI[boost-nowide.sha256sum] = "34e3c7a0d91f6d523d6a1bc74246794d0cacc61426167e2cca66404c04959b6b"
RDEPENDS:boost-nowide = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_boost-numpy3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-numpy3-1.83.0-5.el10.x86_64_v2.rpm;name=boost-numpy3;unpack=0"
SRC_URI += "${URI_boost-numpy3}"
SRC_URI[boost-numpy3.sha256sum] = "12b5c2fca8a5408d85d91f0bc0a6aa28b77a3062aef35b72bc5cc257cc1e5f21"
RDEPENDS:boost-numpy3 = " \
 boost-python3 \
 libgcc \
 libstdc++ \
 glibc \
 python3-numpy \
"

URI_boost-program-options = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-program-options-1.83.0-5.el10.x86_64_v2.rpm;name=boost-program-options;unpack=0"
SRC_URI += "${URI_boost-program-options}"
SRC_URI[boost-program-options.sha256sum] = "6ea3a5157c7ab3611b1afa4794f76c69043ce29f668ed8f155cc904a7de8d722"
RDEPENDS:boost-program-options = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_boost-python3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-python3-1.83.0-5.el10.x86_64_v2.rpm;name=boost-python3;unpack=0"
SRC_URI += "${URI_boost-python3}"
SRC_URI[boost-python3.sha256sum] = "030f680be399fc9d8de487e8df8d3ca9c7c0318795282185634e0610209c7c59"
RDEPENDS:boost-python3 = " \
 glibc \
 python3 \
 libgcc \
 libstdc++ \
"

URI_boost-random = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-random-1.83.0-5.el10.x86_64_v2.rpm;name=boost-random;unpack=0"
SRC_URI += "${URI_boost-random}"
SRC_URI[boost-random.sha256sum] = "5a21e19f823ff9c60e0632be4ddca97737fe93b72e0ca441df60bd3816f37116"
RDEPENDS:boost-random = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_boost-regex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-regex-1.83.0-5.el10.x86_64_v2.rpm;name=boost-regex;unpack=0"
SRC_URI += "${URI_boost-regex}"
SRC_URI[boost-regex.sha256sum] = "72b7ace0a88b7bc4af8b1f86870ecdee0ad9ebc0fbe4c15e1eb7109f9803f28b"
RDEPENDS:boost-regex = " \
 glibc \
 libicu \
 libgcc \
 libstdc++ \
"

URI_boost-serialization = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-serialization-1.83.0-5.el10.x86_64_v2.rpm;name=boost-serialization;unpack=0"
SRC_URI += "${URI_boost-serialization}"
SRC_URI[boost-serialization.sha256sum] = "313c0228949e7fac5513a99132d299d9745dcaba90b70adb39a65f34cee68343"
RDEPENDS:boost-serialization = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_boost-stacktrace = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-stacktrace-1.83.0-5.el10.x86_64_v2.rpm;name=boost-stacktrace;unpack=0"
SRC_URI += "${URI_boost-stacktrace}"
SRC_URI[boost-stacktrace.sha256sum] = "e283154fb361ad346492eea84d88dc9ec9573fc3d3647450f6449e7cc0676272"
RDEPENDS:boost-stacktrace = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_boost-test = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-test-1.83.0-5.el10.x86_64_v2.rpm;name=boost-test;unpack=0"
SRC_URI += "${URI_boost-test}"
SRC_URI[boost-test.sha256sum] = "a0fabafc708aa133e9bfe08d9b2b2f00cee54e9e5421cfedb9fffc74ef1c763b"
RDEPENDS:boost-test = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_boost-thread = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-thread-1.83.0-5.el10.x86_64_v2.rpm;name=boost-thread;unpack=0"
SRC_URI += "${URI_boost-thread}"
SRC_URI[boost-thread.sha256sum] = "66a761734fad97232183e59894e6fd5bb42a58e066629d92f2be82bc989526c3"
RDEPENDS:boost-thread = " \
 glibc \
 libgcc \
 boost-system \
 libstdc++ \
"

URI_boost-timer = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-timer-1.83.0-5.el10.x86_64_v2.rpm;name=boost-timer;unpack=0"
SRC_URI += "${URI_boost-timer}"
SRC_URI[boost-timer.sha256sum] = "0c30a0719406c04570df5d19123e6c2f080ba4196cc95724bedecc5c3cca366d"
RDEPENDS:boost-timer = " \
 libgcc \
 libstdc++ \
 glibc \
 boost-chrono \
 boost-system \
"

URI_boost-type_erasure = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-type_erasure-1.83.0-5.el10.x86_64_v2.rpm;name=boost-type_erasure;unpack=0"
SRC_URI += "${URI_boost-type_erasure}"
SRC_URI[boost-type_erasure.sha256sum] = "8ba2d06ab29cbd376cf9f96bbd23bafba8e6eef676eaec76b31798ab6209c094"
RDEPENDS:boost-type_erasure = " \
 libgcc \
 boost-thread \
 libstdc++ \
 glibc \
 boost-chrono \
 boost-system \
"

URI_boost-wave = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boost-wave-1.83.0-5.el10.x86_64_v2.rpm;name=boost-wave;unpack=0"
SRC_URI += "${URI_boost-wave}"
SRC_URI[boost-wave.sha256sum] = "5582f362a9b54ce47bf0e568de52f56dc1edad8338724adecdeafdae4b035c3a"
RDEPENDS:boost-wave = " \
 boost-filesystem \
 libgcc \
 boost-thread \
 libstdc++ \
 glibc \
 boost-chrono \
 boost-system \
 boost-date-time \
"

URI_boost-b2 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/boost-b2-1.83.0-5.el10.x86_64_v2.rpm;name=boost-b2;unpack=0"
SRC_URI += "${URI_boost-b2}"
SRC_URI[boost-b2.sha256sum] = "da23a31b4af45a759b288d396077c8c0c320547184317503767f3c0041925776"
RDEPENDS:boost-b2 = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_boost-build = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/boost-build-1.83.0-5.el10.noarch.rpm;name=boost-build;unpack=0"
SRC_URI += "${URI_boost-build}"
SRC_URI[boost-build.sha256sum] = "215c8352ca171d8fab43323c2bdbe1c81b3ffa5b150996da707a36dacbe1f8c3"
RDEPENDS:boost-build = " \
 python3 \
 boost-b2 \
"

URI_boost-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/boost-doc-1.83.0-5.el10.noarch.rpm;name=boost-doc;unpack=0"
SRC_URI += "${URI_boost-doc}"
SRC_URI[boost-doc.sha256sum] = "114bcbe588d75f01cb108a2c4f41b2de81530234fc88ac28deabb8e031aa9930"
RDEPENDS:boost-doc = ""

URI_boost-doctools = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/boost-doctools-1.83.0-5.el10.x86_64_v2.rpm;name=boost-doctools;unpack=0"
SRC_URI += "${URI_boost-doctools}"
SRC_URI[boost-doctools.sha256sum] = "3b77fc924c08013c36172eef7a164e7b54729203baa5d15b9be8c9a510dfd4e7"
RDEPENDS:boost-doctools = " \
 libgcc \
 docbook-dtds \
 docbook-style-xsl \
 libstdc++ \
 bash \
 glibc \
"

URI_boost-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/boost-examples-1.83.0-5.el10.noarch.rpm;name=boost-examples;unpack=0"
SRC_URI += "${URI_boost-examples}"
SRC_URI[boost-examples.sha256sum] = "31ce38d7432c449a531fd9eb4dfbba6c12842da0db66b8b8b2ed804941e6fe84"
RDEPENDS:boost-examples = " \
 boost-devel \
"

URI_boost-graph-mpich = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/boost-graph-mpich-1.83.0-5.el10.x86_64_v2.rpm;name=boost-graph-mpich;unpack=0"
SRC_URI += "${URI_boost-graph-mpich}"
SRC_URI[boost-graph-mpich.sha256sum] = "3507d05d3344017d42fb64c1010475d7b0ce92d0829c331fd61e079710bb4f9b"
RDEPENDS:boost-graph-mpich = " \
 boost-mpich \
 libgcc \
 boost-serialization \
 libstdc++ \
 glibc \
 mpich \
"

URI_boost-graph-openmpi = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/boost-graph-openmpi-1.83.0-5.el10.x86_64_v2.rpm;name=boost-graph-openmpi;unpack=0"
SRC_URI += "${URI_boost-graph-openmpi}"
SRC_URI[boost-graph-openmpi.sha256sum] = "7fec08a9863be59f7bfc1be262676f3d2dc76f06225e0b640744280879fad6eb"
RDEPENDS:boost-graph-openmpi = " \
 openmpi \
 libgcc \
 boost-openmpi \
 boost-serialization \
 libstdc++ \
 glibc \
"

URI_boost-mpich = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/boost-mpich-1.83.0-5.el10.x86_64_v2.rpm;name=boost-mpich;unpack=0"
SRC_URI += "${URI_boost-mpich}"
SRC_URI[boost-mpich.sha256sum] = "d45c153f8df234201c3aa0f39387a685aa471e1ce95dfc690fb89ffc6e0e716b"
RDEPENDS:boost-mpich = " \
 libgcc \
 boost-serialization \
 libstdc++ \
 glibc \
 mpich \
"

URI_boost-mpich-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/boost-mpich-devel-1.83.0-5.el10.x86_64_v2.rpm;name=boost-mpich-devel;unpack=0"
SRC_URI += "${URI_boost-mpich-devel}"
SRC_URI[boost-mpich-devel.sha256sum] = "85a3e47bf5a15802ac5113cd0d62d2d39a8813db60f0175a8bec624bd2e33608"
RDEPENDS:boost-mpich-devel = " \
 boost-graph-mpich \
 boost-mpich \
 boost-devel \
"

URI_boost-mpich-python3 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/boost-mpich-python3-1.83.0-5.el10.x86_64_v2.rpm;name=boost-mpich-python3;unpack=0"
SRC_URI += "${URI_boost-mpich-python3}"
SRC_URI[boost-mpich-python3.sha256sum] = "ae3d93fc5feb952bcf713928825c86b975fda7dcff42ffe12f55feab0cbb26b9"
RDEPENDS:boost-mpich-python3 = " \
 python3 \
 python3-mpich \
 boost-mpich \
 libgcc \
 boost-python3 \
 boost-serialization \
 libstdc++ \
 glibc \
 mpich \
"

URI_boost-openmpi = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/boost-openmpi-1.83.0-5.el10.x86_64_v2.rpm;name=boost-openmpi;unpack=0"
SRC_URI += "${URI_boost-openmpi}"
SRC_URI[boost-openmpi.sha256sum] = "a4c6c5f08cebaa67c340433ddff701ce9c2f9a48e38974d363f4fa1b314db882"
RDEPENDS:boost-openmpi = " \
 openmpi \
 libgcc \
 boost-serialization \
 libstdc++ \
 glibc \
"

URI_boost-openmpi-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/boost-openmpi-devel-1.83.0-5.el10.x86_64_v2.rpm;name=boost-openmpi-devel;unpack=0"
SRC_URI += "${URI_boost-openmpi-devel}"
SRC_URI[boost-openmpi-devel.sha256sum] = "7bea1e7103bdd81bb45886adcf27bbb773c3886fb829a53f99206c900e786ab9"
RDEPENDS:boost-openmpi-devel = " \
 boost-graph-openmpi \
 boost-openmpi \
 boost-devel \
"

URI_boost-openmpi-python3 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/boost-openmpi-python3-1.83.0-5.el10.x86_64_v2.rpm;name=boost-openmpi-python3;unpack=0"
SRC_URI += "${URI_boost-openmpi-python3}"
SRC_URI[boost-openmpi-python3.sha256sum] = "7de24de4bb756019aa809ee375146e86226d75bddf8a94b95171fdd59269fa6a"
RDEPENDS:boost-openmpi-python3 = " \
 python3 \
 openmpi \
 libgcc \
 boost-python3 \
 python3-openmpi \
 boost-openmpi \
 boost-serialization \
 libstdc++ \
 glibc \
"

URI_boost-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/boost-static-1.83.0-5.el10.x86_64_v2.rpm;name=boost-static;unpack=0"
SRC_URI += "${URI_boost-static}"
SRC_URI[boost-static.sha256sum] = "8525bb65dea18755d3454017d4c7d02ffdfc788158e0de8f71cc1323a28fd690"
RDEPENDS:boost-static = " \
 boost-devel \
"

URI_boost-mpich-python3-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/boost-mpich-python3-devel-1.83.0-5.el10.x86_64_v2.rpm;name=boost-mpich-python3-devel;unpack=0"
SRC_URI += "${URI_boost-mpich-python3-devel}"
SRC_URI[boost-mpich-python3-devel.sha256sum] = "835db283c951ef7e2085c6e7f5e8afdfa7c42ece505f8fe45b36a80c0520eb9a"
RDEPENDS:boost-mpich-python3-devel = " \
 boost-mpich-devel \
 boost-mpich-python3 \
 boost-devel \
"

URI_boost-openmpi-python3-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/boost-openmpi-python3-devel-1.83.0-5.el10.x86_64_v2.rpm;name=boost-openmpi-python3-devel;unpack=0"
SRC_URI += "${URI_boost-openmpi-python3-devel}"
SRC_URI[boost-openmpi-python3-devel.sha256sum] = "96ed1c3ddc79219a6aafd1aee93446db3829ddc74209d414449e774ecc2a616d"
RDEPENDS:boost-openmpi-python3-devel = " \
 boost-openmpi-python3 \
 boost-openmpi-devel \
 boost-devel \
"

URI_boost-url = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/boost-url-1.83.0-5.el10.x86_64_v2.rpm;name=boost-url;unpack=0"
SRC_URI += "${URI_boost-url}"
SRC_URI[boost-url.sha256sum] = "e04f5e152db6aec032abf48373f1818239e0213f500ec91dd3956d542793a4fd"
RDEPENDS:boost-url = " \
 glibc \
 libgcc \
 libstdc++ \
"
