# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "delve"
PE = "0"
PV = "1.24.1"
PR = "2.el10_0"
PACKAGES = "delve"
PROVIDES = "rpm/delve"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/delve-1.24.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1479fe808ef116d07a6c96d721765aa744d163d7e2e6cbab8d54040fd7a91900"

URI_delve = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/delve-1.24.1-2.el10_0.x86_64_v2.rpm;name=delve;unpack=0"
SRC_URI += "${URI_delve}"
SRC_URI[delve.sha256sum] = "6e29b2cfbb2e17e86d5663e6983d4c8538bdcdea97fa78ee0358ddfb16b23c13"
RDEPENDS:delve = " \
 glibc \
"
