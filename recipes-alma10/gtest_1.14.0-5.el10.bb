# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gtest"
PE = "0"
PV = "1.14.0"
PR = "5.el10"
PACKAGES = "gmock gmock-devel gtest gtest-devel"
PROVIDES = "rpm/gmock rpm/gmock-devel rpm/gtest rpm/gtest-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/gtest-1.14.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7e2acd8c2b57e4458695c9486d78182301e9853b037a9d5c9cd00cdedbc8060"

URI_gmock = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gmock-1.14.0-5.el10.x86_64_v2.rpm;name=gmock;unpack=0"
SRC_URI += "${URI_gmock}"
SRC_URI[gmock.sha256sum] = "57c5a49a5a84c00a3a8f23afa5121ffa0dc5f83642aeeee90bff9dbf0a4671f0"
RDEPENDS:gmock = " \
 glibc \
 libgcc \
 libstdc++ \
 gtest \
"

URI_gmock-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gmock-devel-1.14.0-5.el10.x86_64_v2.rpm;name=gmock-devel;unpack=0"
SRC_URI += "${URI_gmock-devel}"
SRC_URI[gmock-devel.sha256sum] = "37f6b147088def99f21845c9753aba8967de35b40a950f985f2a19e3291acae3"
RDEPENDS:gmock-devel = " \
 gmock \
 pkgconf-pkg-config \
 gtest-devel \
"

URI_gtest = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gtest-1.14.0-5.el10.x86_64_v2.rpm;name=gtest;unpack=0"
SRC_URI += "${URI_gtest}"
SRC_URI[gtest.sha256sum] = "cbc5e68410bad0621744411e03bc9e19cc9d5e250bce47ddcfeb5ebaeb37419c"
RDEPENDS:gtest = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_gtest-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gtest-devel-1.14.0-5.el10.x86_64_v2.rpm;name=gtest-devel;unpack=0"
SRC_URI += "${URI_gtest-devel}"
SRC_URI[gtest-devel.sha256sum] = "6c9c5e1e6f24d6f4644ace803cb3ba81778ad5692f5ecd172f804e2db0d6ec0f"
RDEPENDS:gtest-devel = " \
 gmock \
 cmake-filesystem \
 pkgconf-pkg-config \
 gtest \
"
