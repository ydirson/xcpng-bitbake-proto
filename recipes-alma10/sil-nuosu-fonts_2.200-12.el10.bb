# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sil-nuosu-fonts"
PE = "0"
PV = "2.200"
PR = "12.el10"
PACKAGES = "sil-nuosu-fonts"
PROVIDES = "rpm/sil-nuosu-fonts"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/sil-nuosu-fonts-2.200-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7fcf39eb170174470e67a842e8beacf2f0f9b67cc460ff2749202089e83b9cd3"

URI_sil-nuosu-fonts = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/sil-nuosu-fonts-2.200-12.el10.noarch.rpm;name=sil-nuosu-fonts;unpack=0"
SRC_URI += "${URI_sil-nuosu-fonts}"
SRC_URI[sil-nuosu-fonts.sha256sum] = "e53205b3de6832e83cdb1b56a740fd9c6af3dcc7311d2d094ecac9810bdfd1f7"
RDEPENDS:sil-nuosu-fonts = " \
 fonts-filesystem \
"
