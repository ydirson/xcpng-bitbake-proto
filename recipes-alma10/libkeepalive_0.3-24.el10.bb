# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libkeepalive"
PE = "0"
PV = "0.3"
PR = "24.el10"
PACKAGES = "libkeepalive"
PROVIDES = "rpm/libkeepalive"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libkeepalive-0.3-24.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1dfd2c34fec8509e25da31f78c4054fef7a3366f05b43945d432c21d8e63045e"

URI_libkeepalive = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libkeepalive-0.3-24.el10.x86_64_v2.rpm;name=libkeepalive;unpack=0"
SRC_URI += "${URI_libkeepalive}"
SRC_URI[libkeepalive.sha256sum] = "7b6a807c4c16c69acace6329595973cc9426c985570edd142e8a8d2bf4aa18d1"
RDEPENDS:libkeepalive = " \
 glibc \
"
