# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libXdmcp"
PE = "0"
PV = "1.1.4"
PR = "5.el10"
PACKAGES = "libXdmcp libXdmcp-devel"
PROVIDES = "rpm/libXdmcp rpm/libXdmcp-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libXdmcp-1.1.4-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2edcc987e0893db6862872ee5e115f52c242d2649630909e9110865b208383da"

URI_libXdmcp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXdmcp-1.1.4-5.el10.x86_64_v2.rpm;name=libXdmcp;unpack=0"
SRC_URI += "${URI_libXdmcp}"
SRC_URI[libXdmcp.sha256sum] = "4ecea5792827c4512c99ae88173ae8e750aa36d4937ca776d80c12236411f68d"
RDEPENDS:libXdmcp = " \
 glibc \
"

URI_libXdmcp-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libXdmcp-devel-1.1.4-5.el10.x86_64_v2.rpm;name=libXdmcp-devel;unpack=0"
SRC_URI += "${URI_libXdmcp-devel}"
SRC_URI[libXdmcp-devel.sha256sum] = "a0cac1564b710e100d6319c9d8c9fd7fc090a21ad21e591a04f59a252c85962a"
RDEPENDS:libXdmcp-devel = " \
 xorg-x11-proto-devel \
 pkgconf-pkg-config \
 libXdmcp \
"
