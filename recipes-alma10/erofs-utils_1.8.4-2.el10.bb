# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "erofs-utils"
PE = "0"
PV = "1.8.4"
PR = "2.el10"
PACKAGES = "erofs-fuse erofs-utils"
PROVIDES = "rpm/erofs-fuse rpm/erofs-utils"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/erofs-utils-1.8.4-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "387130416b5d98261beb22bf4e90f313fa7af27dc10e1b98c506e6c82412f1e2"

URI_erofs-fuse = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/erofs-fuse-1.8.4-2.el10.x86_64_v2.rpm;name=erofs-fuse;unpack=0"
SRC_URI += "${URI_erofs-fuse}"
SRC_URI[erofs-fuse.sha256sum] = "0f6ab08daf2d5aab9ab151319f95d56fa83a0957bc9bf877c3b17eb267b3c16d"
RDEPENDS:erofs-fuse = " \
 zlib-ng-compat \
 fuse3 \
 fuse3-libs \
 lz4-libs \
 libzstd \
 glibc \
 libselinux \
 xz-libs \
"

URI_erofs-utils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/erofs-utils-1.8.4-2.el10.x86_64_v2.rpm;name=erofs-utils;unpack=0"
SRC_URI += "${URI_erofs-utils}"
SRC_URI[erofs-utils.sha256sum] = "8359fafed278822af7c806fb186e342c27331dbf4c896e34ae8cc764c96e552b"
RDEPENDS:erofs-utils = " \
 libuuid \
 zlib-ng-compat \
 lz4-libs \
 libzstd \
 glibc \
 libselinux \
 xz-libs \
"
