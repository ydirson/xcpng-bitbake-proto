# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-sw"
PE = "0"
PV = "0.20050819"
PR = "34.el10"
PACKAGES = "hunspell-sw"
PROVIDES = "rpm/hunspell-sw"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-sw-0.20050819-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71f84b5a20a29a378a3387a8c22edbc0783c71f316edd44ea3f84ff680f711b5"

URI_hunspell-sw = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-sw-0.20050819-34.el10.noarch.rpm;name=hunspell-sw;unpack=0"
SRC_URI += "${URI_hunspell-sw}"
SRC_URI[hunspell-sw.sha256sum] = "383bb24c47f1bebfa11b5ab93c452320a4edc9466ff5c11ca5f06782e49cd982"
RDEPENDS:hunspell-sw = " \
 hunspell-filesystem \
"
