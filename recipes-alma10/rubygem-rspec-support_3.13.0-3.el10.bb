# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rubygem-rspec-support"
PE = "0"
PV = "3.13.0"
PR = "3.el10"
PACKAGES = "rubygem-rspec-support rubygem-rspec-support-doc"
PROVIDES = "rpm/rubygem-rspec-support rpm/rubygem-rspec-support-doc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/rubygem-rspec-support-3.13.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4594fbc5f87c179341b9c4bcf2886cf2e06b388bcea33fedf14aa5c5f7899e73"

URI_rubygem-rspec-support = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/rubygem-rspec-support-3.13.0-3.el10.noarch.rpm;name=rubygem-rspec-support;unpack=0"
SRC_URI += "${URI_rubygem-rspec-support}"
SRC_URI[rubygem-rspec-support.sha256sum] = "57b9591484d04aaf37d52e2c4ef4d9f42ca20db7aa68c4b60244702b3263ae2b"
RDEPENDS:rubygem-rspec-support = " \
 rubygems \
"

URI_rubygem-rspec-support-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-rspec-support-doc-3.13.0-3.el10.noarch.rpm;name=rubygem-rspec-support-doc;unpack=0"
SRC_URI += "${URI_rubygem-rspec-support-doc}"
SRC_URI[rubygem-rspec-support-doc.sha256sum] = "513798a4fae26c49007cfa8f9de8d04fd916189485fa921c1343cbedfef09d2b"
RDEPENDS:rubygem-rspec-support-doc = " \
 rubygem-rspec-support \
"
