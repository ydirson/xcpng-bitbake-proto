# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "evince"
PE = "0"
PV = "46.1"
PR = "2.el10"
PACKAGES = "evince evince-devel evince-dvi evince-libs evince-previewer evince-thumbnailer"
PROVIDES = "rpm/evince rpm/evince-devel rpm/evince-dvi rpm/evince-libs rpm/evince-previewer rpm/evince-thumbnailer"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/evince-46.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5fda182aad2cc587d9ed9bf74a2347500afefaa2bd93a1be2e9d27507f81b6d"

URI_evince = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/evince-46.1-2.el10.x86_64_v2.rpm;name=evince;unpack=0"
SRC_URI += "${URI_evince}"
SRC_URI[evince.sha256sum] = "359c64848ecbee4d9c3854787834ea6354b8ff54d15a9f04128306b7aebb6333"
RDEPENDS:evince = " \
 libhandy \
 atk \
 cairo-gobject \
 gnome-desktop3 \
 libgcc \
 pango \
 gdk-pixbuf2 \
 libsecret \
 cairo \
 glib2 \
 gtk3 \
 glibc \
 evince-libs \
 evince-previewer \
 evince-thumbnailer \
"

URI_evince-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/evince-devel-46.1-2.el10.x86_64_v2.rpm;name=evince-devel;unpack=0"
SRC_URI += "${URI_evince-devel}"
SRC_URI[evince-devel.sha256sum] = "08317b5e33f0dfb9beeeb5b8e1c0ab83c65f237e412d5e41af3e299e0fbd92d8"
RDEPENDS:evince-devel = " \
 glib2-devel \
 evince-libs \
 pkgconf-pkg-config \
 gtk3-devel \
"

URI_evince-dvi = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/evince-dvi-46.1-2.el10.x86_64_v2.rpm;name=evince-dvi;unpack=0"
SRC_URI += "${URI_evince-dvi}"
SRC_URI[evince-dvi.sha256sum] = "07253073302572e5aec1e173419a90a4997410cf82146e473e019236dbdda042"
RDEPENDS:evince-dvi = " \
 texlive-lib \
 libspectre \
 cairo \
 glib2 \
 gtk3 \
 glibc \
 evince-libs \
 texlive-collection-fontsrecommended \
"

URI_evince-libs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/evince-libs-46.1-2.el10.x86_64_v2.rpm;name=evince-libs;unpack=0"
SRC_URI += "${URI_evince-libs}"
SRC_URI[evince-libs.sha256sum] = "5473cf19ba568e7dcee8c1df0b45b8ff7975d1eda05d174c2fa09a8f924166cd"
RDEPENDS:evince-libs = " \
 libgxps \
 atk \
 texlive-lib \
 libarchive \
 gstreamer1 \
 libspectre \
 libgcc \
 libxml2 \
 pango \
 gdk-pixbuf2 \
 gstreamer1-plugins-base \
 poppler-glib \
 cairo \
 glib2 \
 gtk3 \
 glibc \
 libtiff \
"

URI_evince-previewer = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/evince-previewer-46.1-2.el10.x86_64_v2.rpm;name=evince-previewer;unpack=0"
SRC_URI += "${URI_evince-previewer}"
SRC_URI[evince-previewer.sha256sum] = "76c83a652807fc2fdc9a67b9180fccd9ac79c315dceb9bc171820cf1c536fac4"
RDEPENDS:evince-previewer = " \
 libhandy \
 atk \
 glib2 \
 gtk3 \
 glibc \
 evince-libs \
"

URI_evince-thumbnailer = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/evince-thumbnailer-46.1-2.el10.x86_64_v2.rpm;name=evince-thumbnailer;unpack=0"
SRC_URI += "${URI_evince-thumbnailer}"
SRC_URI[evince-thumbnailer.sha256sum] = "1b4040cd7b41d9223df855a4a59d35256eb7b8d2a02eb7e2e7d43bb02fa204b4"
RDEPENDS:evince-thumbnailer = " \
 gdk-pixbuf2 \
 glib2 \
 gtk3 \
 glibc \
 evince-libs \
"
