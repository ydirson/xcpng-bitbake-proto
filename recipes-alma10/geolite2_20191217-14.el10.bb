# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "geolite2"
PE = "0"
PV = "20191217"
PR = "14.el10"
PACKAGES = "geolite2-city geolite2-country geolite2-asn"
PROVIDES = "rpm/geolite2-city rpm/geolite2-country rpm/geolite2-asn"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/geolite2-20191217-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "98e6b1eab8218c180f5e69d6f3388cbff21f556ff9a5cf4422ebf24d92e76eae"

URI_geolite2-city = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/geolite2-city-20191217-14.el10.noarch.rpm;name=geolite2-city;unpack=0"
SRC_URI += "${URI_geolite2-city}"
SRC_URI[geolite2-city.sha256sum] = "769f7806429d7ef18c5a5bd97fd93c9ccd3c2512cb154f6529a26016d5a66b67"
RDEPENDS:geolite2-city = ""

URI_geolite2-country = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/geolite2-country-20191217-14.el10.noarch.rpm;name=geolite2-country;unpack=0"
SRC_URI += "${URI_geolite2-country}"
SRC_URI[geolite2-country.sha256sum] = "a19503a6bf26b243aa926c7648d670654b3e3e0f6d4d9930c9fe208a5d9a6d99"
RDEPENDS:geolite2-country = ""

URI_geolite2-asn = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/geolite2-asn-20191217-14.el10.noarch.rpm;name=geolite2-asn;unpack=0"
SRC_URI += "${URI_geolite2-asn}"
SRC_URI[geolite2-asn.sha256sum] = "751049f0fd9063d802db423310a8ca7998b9bb9587174ee3d78e2a0a6ee37556"
RDEPENDS:geolite2-asn = ""
