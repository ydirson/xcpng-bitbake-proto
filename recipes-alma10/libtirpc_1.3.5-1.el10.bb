# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libtirpc"
PE = "0"
PV = "1.3.5"
PR = "1.el10"
PACKAGES = "libtirpc libtirpc-devel"
PROVIDES = "rpm/libtirpc rpm/libtirpc-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libtirpc-1.3.5-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8941dc468defdc14a77ae3eb6fb0339c4f36278815d958e505914bd2a05d5e48"

URI_libtirpc = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libtirpc-1.3.5-1.el10.x86_64_v2.rpm;name=libtirpc;unpack=0"
SRC_URI += "${URI_libtirpc}"
SRC_URI[libtirpc.sha256sum] = "9f2b051efd3d299bfe9fb2646d1fcc7ff7eac96a71bdb2e7b1c75f702e00371d"
RDEPENDS:libtirpc = " \
 glibc \
 krb5-libs \
 libcom_err \
"

URI_libtirpc-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libtirpc-devel-1.3.5-1.el10.x86_64_v2.rpm;name=libtirpc-devel;unpack=0"
SRC_URI += "${URI_libtirpc-devel}"
SRC_URI[libtirpc-devel.sha256sum] = "d5060ef88477266237e163472b42b9bbf7333eb5b9e528c143fa8525a1d1f3eb"
RDEPENDS:libtirpc-devel = " \
 libtirpc \
 pkgconf-pkg-config \
"
