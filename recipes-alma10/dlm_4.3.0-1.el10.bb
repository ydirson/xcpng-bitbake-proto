# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dlm"
PE = "0"
PV = "4.3.0"
PR = "1.el10"
PACKAGES = "dlm dlm-devel dlm-lib"
PROVIDES = "rpm/dlm rpm/dlm-devel rpm/dlm-lib"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/dlm-4.3.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "41cb3effe672a7573bf42bab0a56bc956d943fb893d35d69c591dfdee18f7e13"

URI_dlm = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/dlm-4.3.0-1.el10.x86_64_v2.rpm;name=dlm;unpack=0"
SRC_URI += "${URI_dlm}"
SRC_URI[dlm.sha256sum] = "203e90214de9135262bd2c714d366dea708dd8b3c84be455246eb29cb6dd0e9d"
RDEPENDS:dlm = " \
 libuuid \
 systemd \
 systemd-libs \
 corosynclib \
 bash \
 glibc \
 dlm-lib \
"

URI_dlm-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/dlm-devel-4.3.0-1.el10.x86_64_v2.rpm;name=dlm-devel;unpack=0"
SRC_URI += "${URI_dlm-devel}"
SRC_URI[dlm-devel.sha256sum] = "6ddd3e3afbd5c5836c04fb60cf25e447b9f82da5abe21c2e22d501a6d7b15e6f"
RDEPENDS:dlm-devel = " \
 pkgconf-pkg-config \
 dlm-lib \
"

URI_dlm-lib = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/dlm-lib-4.3.0-1.el10.x86_64_v2.rpm;name=dlm-lib;unpack=0"
SRC_URI += "${URI_dlm-lib}"
SRC_URI[dlm-lib.sha256sum] = "c0c7ba88e211b1a75d40369168ee70bb3d6a47cbe1ea60da1c1919f698c23bc2"
RDEPENDS:dlm-lib = " \
 glibc \
"
