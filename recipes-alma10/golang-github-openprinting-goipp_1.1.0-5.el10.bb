# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "golang-github-openprinting-goipp"
PE = "0"
PV = "1.1.0"
PR = "5.el10"
PACKAGES = "golang-github-openprinting-goipp-devel"
PROVIDES = "rpm/golang-github-openprinting-goipp-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/golang-github-openprinting-goipp-1.1.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e01cdd8018524981fd4ebfa70d7ef921ce62753404dbc2c5a1a05b6677480b1"

URI_golang-github-openprinting-goipp-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/golang-github-openprinting-goipp-devel-1.1.0-5.el10.noarch.rpm;name=golang-github-openprinting-goipp-devel;unpack=0"
SRC_URI += "${URI_golang-github-openprinting-goipp-devel}"
SRC_URI[golang-github-openprinting-goipp-devel.sha256sum] = "c4c17c1afea7518e6a362accaedfcfd6cbd5329e6352a72501206e571a3936ed"
RDEPENDS:golang-github-openprinting-goipp-devel = " \
 go-filesystem \
"
