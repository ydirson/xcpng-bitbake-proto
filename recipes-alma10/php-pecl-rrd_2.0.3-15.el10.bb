# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "php-pecl-rrd"
PE = "0"
PV = "2.0.3"
PR = "15.el10"
PACKAGES = "php-pecl-rrd"
PROVIDES = "rpm/php-pecl-rrd"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/php-pecl-rrd-2.0.3-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b257b30c28b816c90c3e1f199e6685906caf056e61badf1db5a1fe28b12a49cb"

URI_php-pecl-rrd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-pecl-rrd-2.0.3-15.el10.x86_64_v2.rpm;name=php-pecl-rrd;unpack=0"
SRC_URI += "${URI_php-pecl-rrd}"
SRC_URI[php-pecl-rrd.sha256sum] = "da06dfd412c2aa77b4f1abd2cecb96b9a72fd31959593310374942ef8cf0388c"
RDEPENDS:php-pecl-rrd = " \
 glibc \
 php-common \
 rrdtool \
"
