# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "openjpeg2"
PE = "0"
PV = "2.5.2"
PR = "4.el10_0.1"
PACKAGES = "openjpeg2 openjpeg2-devel openjpeg2-tools openjpeg2-devel-docs"
PROVIDES = "rpm/openjpeg2 rpm/openjpeg2-devel rpm/openjpeg2-tools rpm/openjpeg2-devel-docs"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/openjpeg2-2.5.2-4.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ffa6d29ab5619237487e2695aad828c4b596b050c5cdb7f56fb377c0ba0c88d"

URI_openjpeg2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/openjpeg2-2.5.2-4.el10_0.1.x86_64_v2.rpm;name=openjpeg2;unpack=0"
SRC_URI += "${URI_openjpeg2}"
SRC_URI[openjpeg2.sha256sum] = "bd4ea67949cb60f74b9e5e919199c431d8e2338133492881120d37f1d547b554"
RDEPENDS:openjpeg2 = " \
 glibc \
"

URI_openjpeg2-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/openjpeg2-devel-2.5.2-4.el10_0.1.x86_64_v2.rpm;name=openjpeg2-devel;unpack=0"
SRC_URI += "${URI_openjpeg2-devel}"
SRC_URI[openjpeg2-devel.sha256sum] = "61cbc71494f3a4d01660a3c7c212d937f477b7ef36d577cb50745bc6e8a9bd75"
RDEPENDS:openjpeg2-devel = " \
 openjpeg2 \
 openjpeg2-tools \
 cmake-filesystem \
 pkgconf-pkg-config \
"

URI_openjpeg2-tools = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/openjpeg2-tools-2.5.2-4.el10_0.1.x86_64_v2.rpm;name=openjpeg2-tools;unpack=0"
SRC_URI += "${URI_openjpeg2-tools}"
SRC_URI[openjpeg2-tools.sha256sum] = "12b3346b28261d1c929bc4f1607e78a0e203c61f23de0419a9527d52cab60712"
RDEPENDS:openjpeg2-tools = " \
 lcms2 \
 libpng \
 openjpeg2 \
 glibc \
 libtiff \
"

URI_openjpeg2-devel-docs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/openjpeg2-devel-docs-2.5.2-4.el10_0.1.noarch.rpm;name=openjpeg2-devel-docs;unpack=0"
SRC_URI += "${URI_openjpeg2-devel-docs}"
SRC_URI[openjpeg2-devel-docs.sha256sum] = "359893eb6857c545d09bd090e70b5985e74c34878a1fe48d8c3866af7acc8294"
RDEPENDS:openjpeg2-devel-docs = ""
