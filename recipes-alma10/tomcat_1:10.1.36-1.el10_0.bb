# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tomcat"
PE = "1"
PV = "10.1.36"
PR = "1.el10_0"
PACKAGES = "tomcat tomcat-admin-webapps tomcat-docs-webapp tomcat-el-5.0-api tomcat-jsp-3.1-api tomcat-lib tomcat-servlet-6.0-api tomcat-webapps"
PROVIDES = "rpm/tomcat rpm/tomcat-admin-webapps rpm/tomcat-docs-webapp rpm/tomcat-el-5.0-api rpm/tomcat-jsp-3.1-api rpm/tomcat-lib rpm/tomcat-servlet-6.0-api rpm/tomcat-webapps"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tomcat-10.1.36-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66496723621dc4daa1d4754597934a47bd75e2984eaa68f982ef3b1c21fe0c57"

URI_tomcat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tomcat-10.1.36-1.el10_0.noarch.rpm;name=tomcat;unpack=0"
SRC_URI += "${URI_tomcat}"
SRC_URI[tomcat.sha256sum] = "c537f204e675fb99f007abe17e83de5cdfff94e2aa39ac4c96218794a1c9487f"
RDEPENDS:tomcat = " \
 shadow-utils \
 systemd \
 javapackages-tools \
 bash \
 java-21-openjdk-headless \
 tomcat-lib \
"

URI_tomcat-admin-webapps = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tomcat-admin-webapps-10.1.36-1.el10_0.noarch.rpm;name=tomcat-admin-webapps;unpack=0"
SRC_URI += "${URI_tomcat-admin-webapps}"
SRC_URI[tomcat-admin-webapps.sha256sum] = "81fb1786c342a295dc1658ad036603afc58f45207b9f8fa70331434990e2547a"
RDEPENDS:tomcat-admin-webapps = " \
 tomcat \
"

URI_tomcat-docs-webapp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tomcat-docs-webapp-10.1.36-1.el10_0.noarch.rpm;name=tomcat-docs-webapp;unpack=0"
SRC_URI += "${URI_tomcat-docs-webapp}"
SRC_URI[tomcat-docs-webapp.sha256sum] = "aa2e8940747c61d410b95fa290e739d92f12bb8355f75cbc728b7fe0bc07a37a"
RDEPENDS:tomcat-docs-webapp = " \
 tomcat \
"

URI_tomcat-el-5.0-api = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tomcat-el-5.0-api-10.1.36-1.el10_0.noarch.rpm;name=tomcat-el-5.0-api;unpack=0"
SRC_URI += "${URI_tomcat-el-5.0-api}"
SRC_URI[tomcat-el-5.0-api.sha256sum] = "9a1faab42410519a576de15d8fd0e7ee811e637bc4ef7a9680696cffe37d0a2e"
RDEPENDS:tomcat-el-5.0-api = " \
 javapackages-filesystem \
"

URI_tomcat-jsp-3.1-api = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tomcat-jsp-3.1-api-10.1.36-1.el10_0.noarch.rpm;name=tomcat-jsp-3.1-api;unpack=0"
SRC_URI += "${URI_tomcat-jsp-3.1-api}"
SRC_URI[tomcat-jsp-3.1-api.sha256sum] = "d274238c3adfe7b418bfaa6b5f9c672bb2116e388e0804063bb76ef5b75507b7"
RDEPENDS:tomcat-jsp-3.1-api = " \
 tomcat-servlet-6.0-api \
 javapackages-filesystem \
 tomcat-el-5.0-api \
"

URI_tomcat-lib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tomcat-lib-10.1.36-1.el10_0.noarch.rpm;name=tomcat-lib;unpack=0"
SRC_URI += "${URI_tomcat-lib}"
SRC_URI[tomcat-lib.sha256sum] = "7f26a0dd4e3b27353200bb5fceb97a24589de854d2b6487703652a54fc2762a8"
RDEPENDS:tomcat-lib = " \
 javapackages-filesystem \
 tomcat-jsp-3.1-api \
 ecj \
 tomcat-el-5.0-api \
 coreutils \
 tomcat-servlet-6.0-api \
"

URI_tomcat-servlet-6.0-api = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tomcat-servlet-6.0-api-10.1.36-1.el10_0.noarch.rpm;name=tomcat-servlet-6.0-api;unpack=0"
SRC_URI += "${URI_tomcat-servlet-6.0-api}"
SRC_URI[tomcat-servlet-6.0-api.sha256sum] = "b061109bc255ff0bcf7fb962103896ed71afbbf5354f445fec6dabd962cafb9f"
RDEPENDS:tomcat-servlet-6.0-api = " \
 javapackages-filesystem \
"

URI_tomcat-webapps = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tomcat-webapps-10.1.36-1.el10_0.noarch.rpm;name=tomcat-webapps;unpack=0"
SRC_URI += "${URI_tomcat-webapps}"
SRC_URI[tomcat-webapps.sha256sum] = "682605cafa9b7e186e4df4817f9a73e5a5cdeee241b4d37a6c2a05931ec063c9"
RDEPENDS:tomcat-webapps = " \
 tomcat \
"
