# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-IO-String"
PE = "0"
PV = "1.08"
PR = "53.el10"
PACKAGES = "perl-IO-String perl-IO-String-tests"
PROVIDES = "rpm/perl-IO-String rpm/perl-IO-String-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-IO-String-1.08-53.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68bda380844b5ff8c23938cc6f1e8c95576d69c6cda5fdc15941c50b95522b47"

URI_perl-IO-String = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-IO-String-1.08-53.el10.noarch.rpm;name=perl-IO-String;unpack=0"
SRC_URI += "${URI_perl-IO-String}"
SRC_URI[perl-IO-String.sha256sum] = "26eb10e95745934dedd2355a77e0eea89d67d55936cc7fa4f10ef00c51b37ef8"
RDEPENDS:perl-IO-String = " \
 perl-libs \
 perl-vars \
 perl-IO \
 perl-Symbol \
 perl-Data-Dumper \
"

URI_perl-IO-String-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-IO-String-tests-1.08-53.el10.noarch.rpm;name=perl-IO-String-tests;unpack=0"
SRC_URI += "${URI_perl-IO-String-tests}"
SRC_URI[perl-IO-String-tests.sha256sum] = "14d5b728f50d6bb388760281b4e1e1781cfc315a0bb3e38bed8900438276d6ca"
RDEPENDS:perl-IO-String-tests = " \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 perl-vars \
 bash \
 perl-interpreter \
 perl-IO-String \
"
