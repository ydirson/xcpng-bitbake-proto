# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtdatavis3d"
PE = "0"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = "qt6-qtdatavis3d qt6-qtdatavis3d-devel qt6-qtdatavis3d-examples qt6-qtdatavis3d-tests"
PROVIDES = "rpm/qt6-qtdatavis3d rpm/qt6-qtdatavis3d-devel rpm/qt6-qtdatavis3d-examples rpm/qt6-qtdatavis3d-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtdatavis3d-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa53d89f06742aa4dbec76798228ef2f793d49d30c45b6cf80354fcfcd6cd8ec"

URI_qt6-qtdatavis3d = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtdatavis3d-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtdatavis3d;unpack=0"
SRC_URI += "${URI_qt6-qtdatavis3d}"
SRC_URI[qt6-qtdatavis3d.sha256sum] = "9968761fe0764150c0e1b8d455fabf2fc67df9c487f50df95e1cc31755968230"
RDEPENDS:qt6-qtdatavis3d = " \
 qt6-qtdeclarative \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qtdatavis3d-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtdatavis3d-devel-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtdatavis3d-devel;unpack=0"
SRC_URI += "${URI_qt6-qtdatavis3d-devel}"
SRC_URI[qt6-qtdatavis3d-devel.sha256sum] = "e0f3fff9398ec2210f8f8bfdb01172bb60a3288cad26d3f11954d9f792698dfc"
RDEPENDS:qt6-qtdatavis3d-devel = " \
 qt6-qtdeclarative-devel \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdatavis3d \
"

URI_qt6-qtdatavis3d-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtdatavis3d-examples-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtdatavis3d-examples;unpack=0"
SRC_URI += "${URI_qt6-qtdatavis3d-examples}"
SRC_URI[qt6-qtdatavis3d-examples.sha256sum] = "ae5a3b698e530685157b25e5f41744e3d01b27bdcde6982e6b25494a948ef2cd"
RDEPENDS:qt6-qtdatavis3d-examples = " \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
 qt6-qtdatavis3d \
"

URI_qt6-qtdatavis3d-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtdatavis3d-tests-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtdatavis3d-tests;unpack=0"
SRC_URI += "${URI_qt6-qtdatavis3d-tests}"
SRC_URI[qt6-qtdatavis3d-tests.sha256sum] = "0ab3e8afa45d832125428075a6dd14fc2ae0dbba00ea8d9a931914fb9c723477"
RDEPENDS:qt6-qtdatavis3d-tests = " \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
 qt6-qtdatavis3d \
"
