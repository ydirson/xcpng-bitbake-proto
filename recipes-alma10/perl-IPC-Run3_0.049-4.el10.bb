# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-IPC-Run3"
PE = "0"
PV = "0.049"
PR = "4.el10"
PACKAGES = "perl-IPC-Run3 perl-IPC-Run3-tests"
PROVIDES = "rpm/perl-IPC-Run3 rpm/perl-IPC-Run3-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-IPC-Run3-0.049-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5439306576fa54a4a45c04e3da5e1ab62d3a6bd3cb5cb2d0f4d8469ec60c951"

URI_perl-IPC-Run3 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-IPC-Run3-0.049-4.el10.noarch.rpm;name=perl-IPC-Run3;unpack=0"
SRC_URI += "${URI_perl-IPC-Run3}"
SRC_URI[perl-IPC-Run3.sha256sum] = "389f41a26b69f40b08a7eb56ebb53e6b80e4543caa54fd9711b5c3188020d388"
RDEPENDS:perl-IPC-Run3 = " \
 perl-constant \
 perl-IPC-Run3 \
 perl-libs \
 perl-Carp \
 perl-POSIX \
 perl-Exporter \
 perl-File-Temp \
"

URI_perl-IPC-Run3-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-IPC-Run3-tests-0.049-4.el10.noarch.rpm;name=perl-IPC-Run3-tests;unpack=0"
SRC_URI += "${URI_perl-IPC-Run3-tests}"
SRC_URI[perl-IPC-Run3-tests.sha256sum] = "60db816c8e125c99158499006cb1b1ff04441ce78facb8fd7390866b8ee21106"
RDEPENDS:perl-IPC-Run3-tests = " \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-IPC-Run3 \
 bash \
 perl-interpreter \
"
