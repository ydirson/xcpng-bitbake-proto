# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-pycotap"
PE = "0"
PV = "1.1.0"
PR = "22.el10"
PACKAGES = "python3-pycotap"
PROVIDES = "rpm/python3-pycotap"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/python-pycotap-1.1.0-22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3c0bdd0e12c429898cacf7393a0079f6a72a36909a76a29910acbd331ca003a"

URI_python3-pycotap = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-pycotap-1.1.0-22.el10.noarch.rpm;name=python3-pycotap;unpack=0"
SRC_URI += "${URI_python3-pycotap}"
SRC_URI[python3-pycotap.sha256sum] = "82d1f94baf2217a4d02e95b62ecbf40ee8cdbe89de89e75af6287d0b89604427"
RDEPENDS:python3-pycotap = " \
 python3 \
"
