# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-pt"
PE = "0"
PV = "0.20140727"
PR = "11.el10"
PACKAGES = "hyphen-pt hyphen-pt-BR"
PROVIDES = "rpm/hyphen-pt rpm/hyphen-pt-BR"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-pt-0.20140727-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3e253650f6922d17059470651dad396cffa27bcde1c6765bc46bab2e4aec5dc"

URI_hyphen-pt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-pt-0.20140727-11.el10.noarch.rpm;name=hyphen-pt;unpack=0"
SRC_URI += "${URI_hyphen-pt}"
SRC_URI[hyphen-pt.sha256sum] = "857ba84bf33ba55551b10c57985a8ab068556dcefdb6d533d6216be976d951f8"
RDEPENDS:hyphen-pt = " \
 hyphen \
"

URI_hyphen-pt-BR = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-pt-BR-0.20140727-11.el10.noarch.rpm;name=hyphen-pt-BR;unpack=0"
SRC_URI += "${URI_hyphen-pt-BR}"
SRC_URI[hyphen-pt-BR.sha256sum] = "8310094c3174070a1dbe9fb4862dec9d37cd1f1b49e190b2662c4a0e10900060"
RDEPENDS:hyphen-pt-BR = " \
 hyphen \
"
