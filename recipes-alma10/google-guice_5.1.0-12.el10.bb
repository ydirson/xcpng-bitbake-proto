# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "google-guice"
PE = "0"
PV = "5.1.0"
PR = "12.el10"
PACKAGES = "google-guice google-guice-javadoc guice-assistedinject guice-bom guice-extensions guice-grapher guice-jmx guice-jndi guice-parent guice-servlet guice-throwingproviders"
PROVIDES = "rpm/google-guice rpm/google-guice-javadoc rpm/guice-assistedinject rpm/guice-bom rpm/guice-extensions rpm/guice-grapher rpm/guice-jmx rpm/guice-jndi rpm/guice-parent rpm/guice-servlet rpm/guice-throwingproviders"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/google-guice-5.1.0-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "338f7924402fdc7d8b7c8c1b0d410deb92177bcc91b494d1077ec8e0ab6c1e69"

URI_google-guice = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-guice-5.1.0-12.el10.noarch.rpm;name=google-guice;unpack=0"
SRC_URI += "${URI_google-guice}"
SRC_URI[google-guice.sha256sum] = "b9827f1885fac78374f7ef1a978df278b753bf938050dc10662129c6de112f62"
RDEPENDS:google-guice = " \
 aopalliance \
 atinject \
 javapackages-filesystem \
 guava \
"

URI_google-guice-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/google-guice-javadoc-5.1.0-12.el10.noarch.rpm;name=google-guice-javadoc;unpack=0"
SRC_URI += "${URI_google-guice-javadoc}"
SRC_URI[google-guice-javadoc.sha256sum] = "41350471753ef1706451c6d07db7f821a0c9d7511b797ec2304e07294344dcc6"
RDEPENDS:google-guice-javadoc = " \
 javapackages-filesystem \
"

URI_guice-assistedinject = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/guice-assistedinject-5.1.0-12.el10.noarch.rpm;name=guice-assistedinject;unpack=0"
SRC_URI += "${URI_guice-assistedinject}"
SRC_URI[guice-assistedinject.sha256sum] = "16cd8954cc9a6ae40f021fb1404ca5c181e93177b3c0b08ca3628f546445c1ab"
RDEPENDS:guice-assistedinject = " \
 javapackages-filesystem \
 google-guice \
"

URI_guice-bom = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/guice-bom-5.1.0-12.el10.noarch.rpm;name=guice-bom;unpack=0"
SRC_URI += "${URI_guice-bom}"
SRC_URI[guice-bom.sha256sum] = "925d047a2c1df6c5446b6b27997a07959e38debf5c30b240c59d4cfef5c3f140"
RDEPENDS:guice-bom = " \
 javapackages-filesystem \
 guice-parent \
"

URI_guice-extensions = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/guice-extensions-5.1.0-12.el10.noarch.rpm;name=guice-extensions;unpack=0"
SRC_URI += "${URI_guice-extensions}"
SRC_URI[guice-extensions.sha256sum] = "214e0a8fcba224fe8f9f797531e62de1200052982aeedcccfb76e282e80d952a"
RDEPENDS:guice-extensions = " \
 javapackages-filesystem \
 maven-bundle-plugin \
 maven-remote-resources-plugin \
 google-guice \
 guice-parent \
 maven-source-plugin \
"

URI_guice-grapher = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/guice-grapher-5.1.0-12.el10.noarch.rpm;name=guice-grapher;unpack=0"
SRC_URI += "${URI_guice-grapher}"
SRC_URI[guice-grapher.sha256sum] = "282c6f1bdbd7d98af9f815621dd609f6a05c3e63ee9f54c5d02e78d761c5ddae"
RDEPENDS:guice-grapher = " \
 guice-assistedinject \
 javapackages-filesystem \
 google-guice \
"

URI_guice-jmx = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/guice-jmx-5.1.0-12.el10.noarch.rpm;name=guice-jmx;unpack=0"
SRC_URI += "${URI_guice-jmx}"
SRC_URI[guice-jmx.sha256sum] = "b86f0c12a14aa18861e23f3fa5892ed50db67d43c7d1a6969bd7a6f1ea456f5a"
RDEPENDS:guice-jmx = " \
 javapackages-filesystem \
 google-guice \
"

URI_guice-jndi = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/guice-jndi-5.1.0-12.el10.noarch.rpm;name=guice-jndi;unpack=0"
SRC_URI += "${URI_guice-jndi}"
SRC_URI[guice-jndi.sha256sum] = "fe508b9c7e888ef95606e645a9ef4ec9d68978a8df467b06430e410f0d7736b9"
RDEPENDS:guice-jndi = " \
 javapackages-filesystem \
 google-guice \
"

URI_guice-parent = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/guice-parent-5.1.0-12.el10.noarch.rpm;name=guice-parent;unpack=0"
SRC_URI += "${URI_guice-parent}"
SRC_URI[guice-parent.sha256sum] = "794b9eb338249b47d54108e9119ef967d30f6f6ec2822c50e5dbbf035486b32c"
RDEPENDS:guice-parent = " \
 javapackages-filesystem \
"

URI_guice-servlet = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/guice-servlet-5.1.0-12.el10.noarch.rpm;name=guice-servlet;unpack=0"
SRC_URI += "${URI_guice-servlet}"
SRC_URI[guice-servlet.sha256sum] = "1be0aa5ef4685983bff3be8eefabf6d32ad6b203417fb38cadfba14b8beb94b6"
RDEPENDS:guice-servlet = " \
 javapackages-filesystem \
 google-guice \
"

URI_guice-throwingproviders = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/guice-throwingproviders-5.1.0-12.el10.noarch.rpm;name=guice-throwingproviders;unpack=0"
SRC_URI += "${URI_guice-throwingproviders}"
SRC_URI[guice-throwingproviders.sha256sum] = "52020f784d2fe56e67431b62f4ac72ac0af6684a4016711652a1d50b2162e92b"
RDEPENDS:guice-throwingproviders = " \
 jsr-305 \
 javapackages-filesystem \
 google-guice \
"
