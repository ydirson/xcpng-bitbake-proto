# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libgpiod"
PE = "0"
PV = "2.1.3"
PR = "2.el10"
PACKAGES = "libgpiod libgpiod-c++ libgpiod-devel libgpiod-utils python3-libgpiod"
PROVIDES = "rpm/libgpiod rpm/libgpiod-c++ rpm/libgpiod-devel rpm/libgpiod-utils rpm/python3-libgpiod"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libgpiod-2.1.3-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c50063bbb9401308da4905c7a831c2cbed9d9c539f28fbb948120ff35a0072dd"

URI_libgpiod = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libgpiod-2.1.3-2.el10.x86_64_v2.rpm;name=libgpiod;unpack=0"
SRC_URI += "${URI_libgpiod}"
SRC_URI[libgpiod.sha256sum] = "3ba6e89cf9b0c6d7fa191dbfd35cc620b9d0f0d3010065ad5eb0e26eb6925d99"
RDEPENDS:libgpiod = " \
 glibc \
"

URI_libgpiod-c++ = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libgpiod-c++-2.1.3-2.el10.x86_64_v2.rpm;name=libgpiod-c++;unpack=0"
SRC_URI += "${URI_libgpiod-c++}"
SRC_URI[libgpiod-c++.sha256sum] = "f0091e5cc61c1f6e3f49b64e26594c4e79426f829efff8ae31331242dc290d51"
RDEPENDS:libgpiod-c++ = " \
 glibc \
 libgcc \
 libstdc++ \
 libgpiod \
"

URI_libgpiod-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libgpiod-devel-2.1.3-2.el10.x86_64_v2.rpm;name=libgpiod-devel;unpack=0"
SRC_URI += "${URI_libgpiod-devel}"
SRC_URI[libgpiod-devel.sha256sum] = "ebffcb9ef985fd7bcecacccfed6a7656e81eb50c23dbfe4e682229e285deed26"
RDEPENDS:libgpiod-devel = " \
 libgpiod-c++ \
 python3-libgpiod \
 pkgconf-pkg-config \
 libgpiod \
"

URI_libgpiod-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libgpiod-utils-2.1.3-2.el10.x86_64_v2.rpm;name=libgpiod-utils;unpack=0"
SRC_URI += "${URI_libgpiod-utils}"
SRC_URI[libgpiod-utils.sha256sum] = "2e0a4a1ca8a1620ef7df5f56216f87584d45b24dea6751cb7eb9e99ecd168899"
RDEPENDS:libgpiod-utils = " \
 glibc \
 libgpiod \
"

URI_python3-libgpiod = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-libgpiod-2.1.3-2.el10.x86_64_v2.rpm;name=python3-libgpiod;unpack=0"
SRC_URI += "${URI_python3-libgpiod}"
SRC_URI[python3-libgpiod.sha256sum] = "5d9cd4932d94097be9ca15e8376a9f53141dd31ef3f7d998d65251ef84d73e5b"
RDEPENDS:python3-libgpiod = " \
 glibc \
 python3 \
 libgpiod \
"
