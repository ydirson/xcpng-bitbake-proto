# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtlottie"
PE = "0"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = "qt6-qtlottie qt6-qtlottie-devel qt6-qtlottie-tests"
PROVIDES = "rpm/qt6-qtlottie rpm/qt6-qtlottie-devel rpm/qt6-qtlottie-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtlottie-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f1dc8dd3ddea498ad3179892923956c198016d302569cf1b4fc4a278837f6ec"

URI_qt6-qtlottie = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtlottie-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtlottie;unpack=0"
SRC_URI += "${URI_qt6-qtlottie}"
SRC_URI[qt6-qtlottie.sha256sum] = "692becbddb2662a184b02cdc9c272d74aa496561367c43422b10f93f43b2a311"
RDEPENDS:qt6-qtlottie = " \
 qt6-qtdeclarative \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qtlottie-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtlottie-devel-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtlottie-devel;unpack=0"
SRC_URI += "${URI_qt6-qtlottie-devel}"
SRC_URI[qt6-qtlottie-devel.sha256sum] = "13e495d6baa7fa1bbfdd2c30d679765d5262c2614b938bf9851cd8aac39b81c3"
RDEPENDS:qt6-qtlottie-devel = " \
 qt6-qtlottie \
 qt6-qtbase-devel \
 cmake-filesystem \
"

URI_qt6-qtlottie-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtlottie-tests-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtlottie-tests;unpack=0"
SRC_URI += "${URI_qt6-qtlottie-tests}"
SRC_URI[qt6-qtlottie-tests.sha256sum] = "11b762269f4f57463d9e47a26f13c19f69403e916c477d2354c49f1e0326ebf4"
RDEPENDS:qt6-qtlottie-tests = " \
 qt6-qtdeclarative \
 qt6-qtlottie \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"
