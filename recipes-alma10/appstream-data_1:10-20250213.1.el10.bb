# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "appstream-data"
PE = "1"
PV = "10"
PR = "20250213.1.el10"
PACKAGES = "appstream-data"
PROVIDES = "rpm/appstream-data"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/appstream-data-10-20250213.1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6fc17cd98e84f90faf701176515b53082f399bfbd602c0d5017dfc605c8dd1cd"

URI_appstream-data = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/appstream-data-10-20250213.1.el10.noarch.rpm;name=appstream-data;unpack=0"
SRC_URI += "${URI_appstream-data}"
SRC_URI[appstream-data.sha256sum] = "a1cafb674550d9d3939c542ef54865e0ec5ce75c3bc7ece58d1ed7c87dde0cd0"
RDEPENDS:appstream-data = ""
