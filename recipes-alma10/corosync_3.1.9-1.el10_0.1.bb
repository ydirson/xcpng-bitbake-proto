# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "corosync"
PE = "0"
PV = "3.1.9"
PR = "1.el10_0.1"
PACKAGES = "corosynclib corosync-vqsim"
PROVIDES = "rpm/corosynclib rpm/corosync-vqsim"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/corosync-3.1.9-1.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7da082523f4d97aa1977b41953664a1a55cd25d16acd035e91618918acc32403"

URI_corosynclib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/corosynclib-3.1.9-1.el10_0.1.x86_64_v2.rpm;name=corosynclib;unpack=0"
SRC_URI += "${URI_corosynclib}"
SRC_URI[corosynclib.sha256sum] = "0b10f9c4a4a26284d3c8b1ecdffd9e430e656d5e7c7962663179f15a2b8dfdf6"
RDEPENDS:corosynclib = " \
 glibc \
 libqb \
"

URI_corosync-vqsim = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/corosync-vqsim-3.1.9-1.el10_0.1.x86_64_v2.rpm;name=corosync-vqsim;unpack=0"
SRC_URI += "${URI_corosync-vqsim}"
SRC_URI[corosync-vqsim.sha256sum] = "1bd1c5bec6b2383b0c017ec77a0ce536a7e633658ced3cd8307ed2bbd93fc6fb"
RDEPENDS:corosync-vqsim = " \
 libqb \
 libknet1 \
 corosynclib \
 readline \
 pkgconf-pkg-config \
 glibc \
"
