# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sblim-sfcc"
PE = "0"
PV = "2.2.8"
PR = "28.el10"
PACKAGES = "sblim-sfcc sblim-sfcc-devel"
PROVIDES = "rpm/sblim-sfcc rpm/sblim-sfcc-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/sblim-sfcc-2.2.8-28.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e72e694721433286e0cce29a80b1a4d5f10e05288f4ee69aa39efdab5e958eb2"

URI_sblim-sfcc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sblim-sfcc-2.2.8-28.el10.x86_64_v2.rpm;name=sblim-sfcc;unpack=0"
SRC_URI += "${URI_sblim-sfcc}"
SRC_URI[sblim-sfcc.sha256sum] = "9c1c6d4652ff83f4dcc27a443844ea869dc53786a45052205eea5a62d4a4d4dd"
RDEPENDS:sblim-sfcc = " \
 glibc \
 libcurl \
"

URI_sblim-sfcc-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/sblim-sfcc-devel-2.2.8-28.el10.x86_64_v2.rpm;name=sblim-sfcc-devel;unpack=0"
SRC_URI += "${URI_sblim-sfcc-devel}"
SRC_URI[sblim-sfcc-devel.sha256sum] = "d6ff03f49dda36b92b56e7d68d4784efd59a8a7c08bfed93b405811155de03de"
RDEPENDS:sblim-sfcc-devel = " \
 sblim-sfcc \
"
