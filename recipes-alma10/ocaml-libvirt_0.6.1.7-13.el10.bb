# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ocaml-libvirt"
PE = "0"
PV = "0.6.1.7"
PR = "13.el10"
PACKAGES = "ocaml-libvirt ocaml-libvirt-devel"
PROVIDES = "rpm/ocaml-libvirt rpm/ocaml-libvirt-devel"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/ocaml-libvirt-0.6.1.7-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e496d7dba6189d7af3ebff96214d435245118dab3ec3779efff72b45ffa43fd"

URI_ocaml-libvirt = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-libvirt-0.6.1.7-13.el10.x86_64_v2.rpm;name=ocaml-libvirt;unpack=0"
SRC_URI += "${URI_ocaml-libvirt}"
SRC_URI[ocaml-libvirt.sha256sum] = "cd1d51601fa0917c1eb35f63d0db6653e60c31d8a32390d3f76aba561746e556"
RDEPENDS:ocaml-libvirt = " \
 glibc \
 ocaml-runtime \
 libvirt-libs \
"

URI_ocaml-libvirt-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-libvirt-devel-0.6.1.7-13.el10.x86_64_v2.rpm;name=ocaml-libvirt-devel;unpack=0"
SRC_URI += "${URI_ocaml-libvirt-devel}"
SRC_URI[ocaml-libvirt-devel.sha256sum] = "479dbb82446d52b6b26a86fbd776af14a095765cafd889958c621ed73b5f8c08"
RDEPENDS:ocaml-libvirt-devel = " \
 ocaml-runtime \
 ocaml \
 ocaml-libvirt \
"
