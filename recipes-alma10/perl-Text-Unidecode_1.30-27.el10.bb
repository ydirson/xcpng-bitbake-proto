# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Text-Unidecode"
PE = "0"
PV = "1.30"
PR = "27.el10"
PACKAGES = "perl-Text-Unidecode perl-Text-Unidecode-tests"
PROVIDES = "rpm/perl-Text-Unidecode rpm/perl-Text-Unidecode-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Text-Unidecode-1.30-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "911da43e541de509325c005ce9f96dc171c080ccde96d79a9bc791c362f9cf4b"

URI_perl-Text-Unidecode = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Text-Unidecode-1.30-27.el10.noarch.rpm;name=perl-Text-Unidecode;unpack=0"
SRC_URI += "${URI_perl-Text-Unidecode}"
SRC_URI[perl-Text-Unidecode.sha256sum] = "8f76f780674c4194d22862c6623ae92319b567e4a3956e64791882dc5fdff9e4"
RDEPENDS:perl-Text-Unidecode = " \
 perl-Exporter \
 perl-libs \
 perl-vars \
"

URI_perl-Text-Unidecode-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Text-Unidecode-tests-1.30-27.el10.noarch.rpm;name=perl-Text-Unidecode-tests;unpack=0"
SRC_URI += "${URI_perl-Text-Unidecode-tests}"
SRC_URI[perl-Text-Unidecode-tests.sha256sum] = "899e387c32bfa64605b624c1007c1d93be18d09d50d66d07aa7be79e9051f8f2"
RDEPENDS:perl-Text-Unidecode-tests = " \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 perl-Text-Tabs+Wrap \
 perl-Text-Unidecode \
 bash \
 perl-interpreter \
"
