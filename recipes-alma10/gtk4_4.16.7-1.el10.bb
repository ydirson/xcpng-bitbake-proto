# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gtk4"
PE = "0"
PV = "4.16.7"
PR = "1.el10"
PACKAGES = "gtk4 gtk4-devel gtk4-devel-docs gtk4-devel-tools"
PROVIDES = "rpm/gtk4 rpm/gtk4-devel rpm/gtk4-devel-docs rpm/gtk4-devel-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gtk4-4.16.7-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5199b0c168cb06530556acbff9527c6e9f761e9b1ffc6adabcbaa5c8f6ef30f8"

URI_gtk4 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gtk4-4.16.7-1.el10.x86_64_v2.rpm;name=gtk4;unpack=0"
SRC_URI += "${URI_gtk4}"
SRC_URI[gtk4.sha256sum] = "0fa32ee940c95ae9aae0a8168d37a52a8c3a463278a32270cf1893eb53967a59"
RDEPENDS:gtk4 = " \
 libpng \
 libtracker-sparql \
 cups-libs \
 pango \
 fontconfig \
 libX11 \
 hicolor-icon-theme \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libepoxy \
 fribidi \
 adwaita-icon-theme \
 libXrandr \
 cairo \
 cairo-gobject \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 gdk-pixbuf2 \
 gdk-pixbuf2-modules \
 graphene \
 libxkbcommon \
 vulkan-loader \
 gstreamer1 \
 harfbuzz \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base \
 gtk-update-icon-cache \
 glib2 \
 colord-libs \
 glibc \
 libjpeg-turbo \
 libtiff \
"

URI_gtk4-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gtk4-devel-4.16.7-1.el10.x86_64_v2.rpm;name=gtk4-devel;unpack=0"
SRC_URI += "${URI_gtk4-devel}"
SRC_URI[gtk4-devel.sha256sum] = "573a7116d67890d90ad3af5405a33ec83d3209df21a01a6438d828ef522b5eec"
RDEPENDS:gtk4-devel = " \
 glib2-devel \
 libpng \
 libtracker-sparql \
 pango \
 fontconfig \
 libX11 \
 pango-devel \
 libX11-devel \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libepoxy \
 fribidi \
 libXrandr \
 cairo \
 cairo-devel \
 cairo-gobject \
 cairo-gobject-devel \
 libwayland-client \
 libwayland-egl \
 gdk-pixbuf2 \
 gdk-pixbuf2-devel \
 graphene \
 graphene-devel \
 libxkbcommon \
 vulkan-loader \
 vulkan-loader-devel \
 wayland-devel \
 harfbuzz \
 pkgconf-pkg-config \
 glib2 \
 glibc \
 gtk4 \
 gtk4-devel \
 libjpeg-turbo \
 libtiff \
"

URI_gtk4-devel-docs = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gtk4-devel-docs-4.16.7-1.el10.noarch.rpm;name=gtk4-devel-docs;unpack=0"
SRC_URI += "${URI_gtk4-devel-docs}"
SRC_URI[gtk4-devel-docs.sha256sum] = "44ed3f9320d4556b9752534a1c605995f97b4813d05ee782733d65bdd41e567c"
RDEPENDS:gtk4-devel-docs = " \
 gtk4 \
"

URI_gtk4-devel-tools = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gtk4-devel-tools-4.16.7-1.el10.x86_64_v2.rpm;name=gtk4-devel-tools;unpack=0"
SRC_URI += "${URI_gtk4-devel-tools}"
SRC_URI[gtk4-devel-tools.sha256sum] = "19226a8554b0f42ce517319bb3fd47afa11a5d478264a3cb49f3ad57087a9bda"
RDEPENDS:gtk4-devel-tools = " \
 libepoxy \
 harfbuzz \
 pango \
 gdk-pixbuf2 \
 cairo \
 glib2 \
 graphene \
 glibc \
 gtk4 \
"
