# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libpwquality"
PE = "0"
PV = "1.4.5"
PR = "12.el10"
PACKAGES = "libpwquality python3-pwquality libpwquality-devel"
PROVIDES = "rpm/libpwquality rpm/python3-pwquality rpm/libpwquality-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libpwquality-1.4.5-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0d2708000e62c921872dfc43de8b29f46f8b4f9bc71a958c321b856ef383af4"

URI_libpwquality = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libpwquality-1.4.5-12.el10.x86_64_v2.rpm;name=libpwquality;unpack=0"
SRC_URI += "${URI_libpwquality}"
SRC_URI[libpwquality.sha256sum] = "7e77b82f9ef9573d2bd290cc7e44cb98535d7bece45680ab485462b691824f92"
RDEPENDS:libpwquality = " \
 glibc \
 pam-libs \
 cracklib \
 cracklib-dicts \
"

URI_python3-pwquality = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-pwquality-1.4.5-12.el10.x86_64_v2.rpm;name=python3-pwquality;unpack=0"
SRC_URI += "${URI_python3-pwquality}"
SRC_URI[python3-pwquality.sha256sum] = "7dc4eeaefa3b8eb5c830d49816b2e202870f6d908ace79ff906937ff258b6b44"
RDEPENDS:python3-pwquality = " \
 glibc \
 libpwquality \
 python3 \
"

URI_libpwquality-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libpwquality-devel-1.4.5-12.el10.x86_64_v2.rpm;name=libpwquality-devel;unpack=0"
SRC_URI += "${URI_libpwquality-devel}"
SRC_URI[libpwquality-devel.sha256sum] = "8e12aa24305ecd65d4eea63a527a3ee512aba78d804a5c74207f23e32cee8d72"
RDEPENDS:libpwquality-devel = " \
 libpwquality \
 pkgconf-pkg-config \
"
