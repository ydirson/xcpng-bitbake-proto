# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtdeclarative"
PE = "0"
PV = "6.8.1"
PR = "4.el10"
PACKAGES = "qt6-qtdeclarative qt6-qtdeclarative-devel qt6-qtdeclarative-examples qt6-qtdeclarative-static qt6-qtdeclarative-tests"
PROVIDES = "rpm/qt6-qtdeclarative rpm/qt6-qtdeclarative-devel rpm/qt6-qtdeclarative-examples rpm/qt6-qtdeclarative-static rpm/qt6-qtdeclarative-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtdeclarative-6.8.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff0f3d6fdb67bcbddc1c25ec0f80b7d30a39ce997a1436a54842941442a46751"

URI_qt6-qtdeclarative = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtdeclarative-6.8.1-4.el10.x86_64_v2.rpm;name=qt6-qtdeclarative;unpack=0"
SRC_URI += "${URI_qt6-qtdeclarative}"
SRC_URI[qt6-qtdeclarative.sha256sum] = "3659a97cc8ba5811346ea9c173ac78b482de775c343993e95c06367c4f652869"
RDEPENDS:qt6-qtdeclarative = " \
 qt6-qtsvg \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qtdeclarative-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtdeclarative-devel-6.8.1-4.el10.x86_64_v2.rpm;name=qt6-qtdeclarative-devel;unpack=0"
SRC_URI += "${URI_qt6-qtdeclarative-devel}"
SRC_URI[qt6-qtdeclarative-devel.sha256sum] = "6d3fb91fa0a6ec33863d9505a2fd64f3f85f3e0b3b2b7bf9a249da9558f84c36"
RDEPENDS:qt6-qtdeclarative-devel = " \
 qt6-qtdeclarative \
 qt6-qtdeclarative-devel \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtbase-devel \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qtdeclarative-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtdeclarative-examples-6.8.1-4.el10.x86_64_v2.rpm;name=qt6-qtdeclarative-examples;unpack=0"
SRC_URI += "${URI_qt6-qtdeclarative-examples}"
SRC_URI[qt6-qtdeclarative-examples.sha256sum] = "869cc459df99d70e4619dd58992bcb7274b1d623a2af120c1962f929176938d5"
RDEPENDS:qt6-qtdeclarative-examples = " \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qtdeclarative-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtdeclarative-static-6.8.1-4.el10.x86_64_v2.rpm;name=qt6-qtdeclarative-static;unpack=0"
SRC_URI += "${URI_qt6-qtdeclarative-static}"
SRC_URI[qt6-qtdeclarative-static.sha256sum] = "a01c5c4a4a1051a152dc7595ee6f844fd57ac75e9686759145e0cae0368b7288"
RDEPENDS:qt6-qtdeclarative-static = " \
 qt6-qtdeclarative-devel \
 cmake-filesystem \
"

URI_qt6-qtdeclarative-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtdeclarative-tests-6.8.1-4.el10.x86_64_v2.rpm;name=qt6-qtdeclarative-tests;unpack=0"
SRC_URI += "${URI_qt6-qtdeclarative-tests}"
SRC_URI[qt6-qtdeclarative-tests.sha256sum] = "67dd5d6a501cc1c0cadff8c79468cac147d995b84e9bd763da28f5c5bcc0d9fa"
RDEPENDS:qt6-qtdeclarative-tests = " \
 python3 \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 bash \
 qt6-qtbase-gui \
 glibc \
"
