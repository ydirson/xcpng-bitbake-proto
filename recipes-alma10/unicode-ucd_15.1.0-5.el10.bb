# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "unicode-ucd"
PE = "0"
PV = "15.1.0"
PR = "5.el10"
PACKAGES = "unicode-ucd unicode-ucd-unihan"
PROVIDES = "rpm/unicode-ucd rpm/unicode-ucd-unihan"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/unicode-ucd-15.1.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8711fde850e051ffc7b42eb2af5f7b294b9f01851ad7ecbb4304ee59644dd55"

URI_unicode-ucd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/unicode-ucd-15.1.0-5.el10.noarch.rpm;name=unicode-ucd;unpack=0"
SRC_URI += "${URI_unicode-ucd}"
SRC_URI[unicode-ucd.sha256sum] = "f61d56dab01b276dd9153cdf3d36f337002cfa3231b4d7e66ef99e63171f0dcd"
RDEPENDS:unicode-ucd = ""

URI_unicode-ucd-unihan = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/unicode-ucd-unihan-15.1.0-5.el10.noarch.rpm;name=unicode-ucd-unihan;unpack=0"
SRC_URI += "${URI_unicode-ucd-unihan}"
SRC_URI[unicode-ucd-unihan.sha256sum] = "a1fb64526ab0a20cb1002670b1f07da87601bdeaa9f736771a66a4ec371f206e"
RDEPENDS:unicode-ucd-unihan = " \
 unicode-ucd \
"
