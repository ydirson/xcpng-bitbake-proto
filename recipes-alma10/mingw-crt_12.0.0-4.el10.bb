# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mingw-crt"
PE = "0"
PV = "12.0.0"
PR = "4.el10"
PACKAGES = "mingw32-crt mingw64-crt ucrt64-crt"
PROVIDES = "rpm/mingw32-crt rpm/mingw64-crt rpm/ucrt64-crt"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/mingw-crt-12.0.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "717d8fde6a0385aa0290acfa5dda40a57dc464b028cfd71bf7eef428de81089c"

URI_mingw32-crt = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw32-crt-12.0.0-4.el10.noarch.rpm;name=mingw32-crt;unpack=0"
SRC_URI += "${URI_mingw32-crt}"
SRC_URI[mingw32-crt.sha256sum] = "8e66c10a87573d753507215101ae3b058da48663a86122e1e156f619794bba3e"
RDEPENDS:mingw32-crt = " \
 mingw32-filesystem \
"

URI_mingw64-crt = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw64-crt-12.0.0-4.el10.noarch.rpm;name=mingw64-crt;unpack=0"
SRC_URI += "${URI_mingw64-crt}"
SRC_URI[mingw64-crt.sha256sum] = "8cdfb928028d9db26d56e08fd8767bf519f4c8306e2e3be73d570cf6f6e080e9"
RDEPENDS:mingw64-crt = " \
 mingw64-filesystem \
"

URI_ucrt64-crt = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ucrt64-crt-12.0.0-4.el10.noarch.rpm;name=ucrt64-crt;unpack=0"
SRC_URI += "${URI_ucrt64-crt}"
SRC_URI[ucrt64-crt.sha256sum] = "83e7be6485ee2f6f8028f4affb205aead7baf5640702bfc343e5fa3d4fb81743"
RDEPENDS:ucrt64-crt = " \
 ucrt64-filesystem \
"
