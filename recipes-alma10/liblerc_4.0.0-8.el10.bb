# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "liblerc"
PE = "0"
PV = "4.0.0"
PR = "8.el10"
PACKAGES = "liblerc liblerc-devel mingw32-liblerc mingw64-liblerc"
PROVIDES = "rpm/liblerc rpm/liblerc-devel rpm/mingw32-liblerc rpm/mingw64-liblerc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/liblerc-4.0.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "deb26d826b5aa235516b93471a458631252b06c6c7eb6d27ebbc5cd11c76f0e0"

URI_liblerc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/liblerc-4.0.0-8.el10.x86_64_v2.rpm;name=liblerc;unpack=0"
SRC_URI += "${URI_liblerc}"
SRC_URI[liblerc.sha256sum] = "2db4eca04cb768112064bbbd408c76c433ad95c2743a18e147b073d130d5ab15"
RDEPENDS:liblerc = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_liblerc-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/liblerc-devel-4.0.0-8.el10.x86_64_v2.rpm;name=liblerc-devel;unpack=0"
SRC_URI += "${URI_liblerc-devel}"
SRC_URI[liblerc-devel.sha256sum] = "cfec0883330c0eed35b1845b4827b61e1d6e1904b2747230c3bb78ddb1da1047"
RDEPENDS:liblerc-devel = " \
 liblerc \
 pkgconf-pkg-config \
"

URI_mingw32-liblerc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mingw32-liblerc-4.0.0-8.el10.noarch.rpm;name=mingw32-liblerc;unpack=0"
SRC_URI += "${URI_mingw32-liblerc}"
SRC_URI[mingw32-liblerc.sha256sum] = "5dffc25f00a7192b7d24e354bf1b69796726408c5fae27e9a408bfb1960a8581"
RDEPENDS:mingw32-liblerc = " \
 mingw32-libstdc++ \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-libgcc \
"

URI_mingw64-liblerc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mingw64-liblerc-4.0.0-8.el10.noarch.rpm;name=mingw64-liblerc;unpack=0"
SRC_URI += "${URI_mingw64-liblerc}"
SRC_URI[mingw64-liblerc.sha256sum] = "b76e58e01f38e602d42b3cb2f6e54c3e3b9c6d226f2e6b16a60f26a88c170223"
RDEPENDS:mingw64-liblerc = " \
 mingw64-libstdc++ \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-libgcc \
"
