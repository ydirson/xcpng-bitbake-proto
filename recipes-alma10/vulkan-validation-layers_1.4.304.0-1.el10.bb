# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "vulkan-validation-layers"
PE = "0"
PV = "1.4.304.0"
PR = "1.el10"
PACKAGES = "vulkan-validation-layers"
PROVIDES = "rpm/vulkan-validation-layers"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/vulkan-validation-layers-1.4.304.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27ee11ca36b3cd216455f406874247e4ab77dc2f161b1caa35773ee86cbfe081"

URI_vulkan-validation-layers = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/vulkan-validation-layers-1.4.304.0-1.el10.x86_64_v2.rpm;name=vulkan-validation-layers;unpack=0"
SRC_URI += "${URI_vulkan-validation-layers}"
SRC_URI[vulkan-validation-layers.sha256sum] = "c4b56fba765700007939e070b29d1e44cd7f8505686f8e6fa857bd5eeab5fff8"
RDEPENDS:vulkan-validation-layers = " \
 glibc \
 spirv-tools-libs \
 libgcc \
 libstdc++ \
"
