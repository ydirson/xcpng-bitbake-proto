# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xdg-user-dirs-gtk"
PE = "0"
PV = "0.11"
PR = "6.el10"
PACKAGES = "xdg-user-dirs-gtk"
PROVIDES = "rpm/xdg-user-dirs-gtk"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xdg-user-dirs-gtk-0.11-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9999dd41ac206f9658668e3ab8a896f7c88ae3de356a4d44dff8efa7a7f6e050"

URI_xdg-user-dirs-gtk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xdg-user-dirs-gtk-0.11-6.el10.x86_64_v2.rpm;name=xdg-user-dirs-gtk;unpack=0"
SRC_URI += "${URI_xdg-user-dirs-gtk}"
SRC_URI[xdg-user-dirs-gtk.sha256sum] = "2d7004ff06fe9e2eb4bf5674cfa676d793dca67f4ac9e15ab12d8c329272b0e1"
RDEPENDS:xdg-user-dirs-gtk = " \
 glibc \
 xdg-user-dirs \
 glib2 \
 gtk3 \
"
