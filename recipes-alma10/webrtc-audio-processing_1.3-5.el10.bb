# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "webrtc-audio-processing"
PE = "0"
PV = "1.3"
PR = "5.el10"
PACKAGES = "webrtc-audio-processing webrtc-audio-processing-devel"
PROVIDES = "rpm/webrtc-audio-processing rpm/webrtc-audio-processing-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/webrtc-audio-processing-1.3-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a7ae227a5e30c20ed91da48a95bfff8523e5f9276f15fb6ba36383b4885b716"

URI_webrtc-audio-processing = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/webrtc-audio-processing-1.3-5.el10.x86_64_v2.rpm;name=webrtc-audio-processing;unpack=0"
SRC_URI += "${URI_webrtc-audio-processing}"
SRC_URI[webrtc-audio-processing.sha256sum] = "b967141b374c22126a895fdd9b6de9b0a66be9ae9283f1c12df3e974da347bdc"
RDEPENDS:webrtc-audio-processing = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_webrtc-audio-processing-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/webrtc-audio-processing-devel-1.3-5.el10.x86_64_v2.rpm;name=webrtc-audio-processing-devel;unpack=0"
SRC_URI += "${URI_webrtc-audio-processing-devel}"
SRC_URI[webrtc-audio-processing-devel.sha256sum] = "8cb5d4375b0dba17db4252999558c037992cdb04ea9e9cf21339b9d240fdedbd"
RDEPENDS:webrtc-audio-processing-devel = " \
 pkgconf-pkg-config \
 webrtc-audio-processing \
"
