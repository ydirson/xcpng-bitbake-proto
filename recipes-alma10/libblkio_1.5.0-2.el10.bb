# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libblkio"
PE = "0"
PV = "1.5.0"
PR = "2.el10"
PACKAGES = "libblkio libblkio-devel"
PROVIDES = "rpm/libblkio rpm/libblkio-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libblkio-1.5.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb97fb4e238d1d3f3865de456fb6b43ffd9457607ff8e9d58a9d454950448d49"

URI_libblkio = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libblkio-1.5.0-2.el10.x86_64_v2.rpm;name=libblkio;unpack=0"
SRC_URI += "${URI_libblkio}"
SRC_URI[libblkio.sha256sum] = "057ef73b3aab9ee62f4677430f15d14f0640169044ecaa8778bfe1ea994b6b8e"
RDEPENDS:libblkio = " \
 glibc \
 libgcc \
"

URI_libblkio-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libblkio-devel-1.5.0-2.el10.x86_64_v2.rpm;name=libblkio-devel;unpack=0"
SRC_URI += "${URI_libblkio-devel}"
SRC_URI[libblkio-devel.sha256sum] = "b5c0f06a7746b4593e2dd66fc355a1f0b4dcdf5a00f4f2fc7e2905b324f0055e"
RDEPENDS:libblkio-devel = " \
 libblkio \
 pkgconf-pkg-config \
"
