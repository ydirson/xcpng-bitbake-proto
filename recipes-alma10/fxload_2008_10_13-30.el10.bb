# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "fxload"
PE = "0"
PV = "2008_10_13"
PR = "30.el10"
PACKAGES = "fxload"
PROVIDES = "rpm/fxload"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/fxload-2008_10_13-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce02771c83db0b3b789755c0509f7c5157024c5a4508f983e56aa01ee959af68"

URI_fxload = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fxload-2008_10_13-30.el10.x86_64_v2.rpm;name=fxload;unpack=0"
SRC_URI += "${URI_fxload}"
SRC_URI[fxload.sha256sum] = "0faced8d24d150c6b7fb0a006d84a1d46008aef1425349c07b2f6cb7602b92b4"
RDEPENDS:fxload = " \
 glibc \
 systemd-udev \
"
