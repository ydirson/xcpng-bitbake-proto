# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libtdb"
PE = "0"
PV = "1.4.12"
PR = "102.el10"
PACKAGES = "libtdb python3-tdb tdb-tools libtdb-devel"
PROVIDES = "rpm/libtdb rpm/python3-tdb rpm/tdb-tools rpm/libtdb-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libtdb-1.4.12-102.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22955a21d46ea5c0362fc4f9038cc61ccb31c5b28ee250fbb092fdd633042c81"

URI_libtdb = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libtdb-1.4.12-102.el10.x86_64_v2.rpm;name=libtdb;unpack=0"
SRC_URI += "${URI_libtdb}"
SRC_URI[libtdb.sha256sum] = "d2db2920fbaafe06d9ef30b367aba07524d459a92f78d1b4e70dafbd711cda07"
RDEPENDS:libtdb = " \
 glibc \
"

URI_python3-tdb = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-tdb-1.4.12-102.el10.x86_64_v2.rpm;name=python3-tdb;unpack=0"
SRC_URI += "${URI_python3-tdb}"
SRC_URI[python3-tdb.sha256sum] = "742a0283aa85d7c18c02205fd0f9654323bdaf8d9174458b456c054dc9cb7bdc"
RDEPENDS:python3-tdb = " \
 glibc \
 python3 \
 libtdb \
"

URI_tdb-tools = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/tdb-tools-1.4.12-102.el10.x86_64_v2.rpm;name=tdb-tools;unpack=0"
SRC_URI += "${URI_tdb-tools}"
SRC_URI[tdb-tools.sha256sum] = "8a9e788341fd207033f814d7e4a88fe536476c16cb5bd46c3626f5ec652b0237"
RDEPENDS:tdb-tools = " \
 glibc \
 libtdb \
"

URI_libtdb-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libtdb-devel-1.4.12-102.el10.x86_64_v2.rpm;name=libtdb-devel;unpack=0"
SRC_URI += "${URI_libtdb-devel}"
SRC_URI[libtdb-devel.sha256sum] = "6e2b7731be4b11dd3e6e243d5d8fe4f16e0a736074c3c7f1809f6091aad70e31"
RDEPENDS:libtdb-devel = " \
 pkgconf-pkg-config \
 libtdb \
"
