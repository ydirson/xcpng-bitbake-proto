# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "fuse"
PE = "0"
PV = "2.9.9"
PR = "25.el10"
PACKAGES = "fuse fuse-libs fuse-devel"
PROVIDES = "rpm/fuse rpm/fuse-libs rpm/fuse-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/fuse-2.9.9-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "002ad749efec12bec6badf5a9bd6b0aae327b97d6aad9ce67d1d089f33539397"

URI_fuse = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/fuse-2.9.9-25.el10.x86_64_v2.rpm;name=fuse;unpack=0"
SRC_URI += "${URI_fuse}"
SRC_URI[fuse.sha256sum] = "61d73e32ebfaaa3c448a606e0e54ea65c8ad522138dc2e45a284e69913fb612c"
RDEPENDS:fuse = " \
 glibc \
 fuse-common \
 which \
"

URI_fuse-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/fuse-libs-2.9.9-25.el10.x86_64_v2.rpm;name=fuse-libs;unpack=0"
SRC_URI += "${URI_fuse-libs}"
SRC_URI[fuse-libs.sha256sum] = "73f72e88c99c90ddbe52cb250ee246ac0716ae46f22419de84c75b7790e27a62"
RDEPENDS:fuse-libs = " \
 glibc \
"

URI_fuse-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/fuse-devel-2.9.9-25.el10.x86_64_v2.rpm;name=fuse-devel;unpack=0"
SRC_URI += "${URI_fuse-devel}"
SRC_URI[fuse-devel.sha256sum] = "1e601e226e85dce95391555de18d2cd81ca79747e186e84ad032028b23b03d52"
RDEPENDS:fuse-devel = " \
 pkgconf-pkg-config \
 fuse-libs \
"
