# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "snpguest"
PE = "0"
PV = "0.8.3"
PR = "1.el10"
PACKAGES = "snpguest"
PROVIDES = "rpm/snpguest"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/snpguest-0.8.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0745d5176d3d622b7995850dcb516093836807573e861853541943d4ef5ec633"

URI_snpguest = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/snpguest-0.8.3-1.el10.x86_64_v2.rpm;name=snpguest;unpack=0"
SRC_URI += "${URI_snpguest}"
SRC_URI[snpguest.sha256sum] = "d107ae8665477331305487a126f35db3f2b767c70b73600f150990cd0d2f9c4d"
RDEPENDS:snpguest = " \
 glibc \
 openssl-libs \
 libgcc \
"
