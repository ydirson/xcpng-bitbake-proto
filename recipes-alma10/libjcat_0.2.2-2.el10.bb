# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libjcat"
PE = "0"
PV = "0.2.2"
PR = "2.el10"
PACKAGES = "libjcat libjcat-devel libjcat-tests"
PROVIDES = "rpm/libjcat rpm/libjcat-devel rpm/libjcat-tests"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libjcat-0.2.2-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61fb0341029dc360cf24652469e94e5bb38e551e90ed1724d4192242be35e50b"

URI_libjcat = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libjcat-0.2.2-2.el10.x86_64_v2.rpm;name=libjcat;unpack=0"
SRC_URI += "${URI_libjcat}"
SRC_URI[libjcat.sha256sum] = "6b28ba258945a0642551e8833ecab94ff988958a0cc629e707e5beb2a480b32a"
RDEPENDS:libjcat = " \
 gnutls \
 libgcc \
 gpgme \
 json-glib \
 libgpg-error \
 glib2 \
 glibc \
"

URI_libjcat-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libjcat-devel-0.2.2-2.el10.x86_64_v2.rpm;name=libjcat-devel;unpack=0"
SRC_URI += "${URI_libjcat-devel}"
SRC_URI[libjcat-devel.sha256sum] = "7a6c81e6ded7b507af0cf0c70fb93a0b3bfbb06eeaeea55374dbd36a55ed9bde"
RDEPENDS:libjcat-devel = " \
 json-glib-devel \
 glib2-devel \
 gnutls-devel \
 pkgconf-pkg-config \
 libjcat \
"

URI_libjcat-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libjcat-tests-0.2.2-2.el10.x86_64_v2.rpm;name=libjcat-tests;unpack=0"
SRC_URI += "${URI_libjcat-tests}"
SRC_URI[libjcat-tests.sha256sum] = "063eb399865fabd6c461bd1561be03131bf8946d04a3710edda1cca3d4804583"
RDEPENDS:libjcat-tests = " \
 gnutls \
 libgcc \
 gpgme \
 json-glib \
 libgpg-error \
 glib2 \
 glibc \
"
