# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "wayland"
PE = "0"
PV = "1.23.0"
PR = "2.el10"
PACKAGES = "libwayland-client libwayland-cursor libwayland-egl libwayland-server wayland-devel wayland-doc"
PROVIDES = "rpm/libwayland-client rpm/libwayland-cursor rpm/libwayland-egl rpm/libwayland-server rpm/wayland-devel rpm/wayland-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/wayland-1.23.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5edcab77614b05ee079ade21adfb3354568e2731e881e526a38b7abed578a94b"

URI_libwayland-client = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libwayland-client-1.23.0-2.el10.x86_64_v2.rpm;name=libwayland-client;unpack=0"
SRC_URI += "${URI_libwayland-client}"
SRC_URI[libwayland-client.sha256sum] = "361c2b91f1c348ac74f1e88c4a9fb8ce6a19b48dd0a7eb2ea05480d4dc3a89f0"
RDEPENDS:libwayland-client = " \
 glibc \
 libffi \
"

URI_libwayland-cursor = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libwayland-cursor-1.23.0-2.el10.x86_64_v2.rpm;name=libwayland-cursor;unpack=0"
SRC_URI += "${URI_libwayland-cursor}"
SRC_URI[libwayland-cursor.sha256sum] = "70eb524439a74ad8f3eae9bd5b2170e6f6af44f4bcfc1e3da12aa9c1a3bce610"
RDEPENDS:libwayland-cursor = " \
 glibc \
 libwayland-client \
"

URI_libwayland-egl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libwayland-egl-1.23.0-2.el10.x86_64_v2.rpm;name=libwayland-egl;unpack=0"
SRC_URI += "${URI_libwayland-egl}"
SRC_URI[libwayland-egl.sha256sum] = "5d75a7b861f2683b947cff4fba3f2002e484c2c4b90b59313b536c9d7a0e3761"
RDEPENDS:libwayland-egl = " \
 glibc \
"

URI_libwayland-server = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libwayland-server-1.23.0-2.el10.x86_64_v2.rpm;name=libwayland-server;unpack=0"
SRC_URI += "${URI_libwayland-server}"
SRC_URI[libwayland-server.sha256sum] = "4ea622292fe94b27a69a8e5f6e5031c4acfad0b7cb0e0c55b8d7364aad06bb0c"
RDEPENDS:libwayland-server = " \
 glibc \
 libffi \
"

URI_wayland-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/wayland-devel-1.23.0-2.el10.x86_64_v2.rpm;name=wayland-devel;unpack=0"
SRC_URI += "${URI_wayland-devel}"
SRC_URI[wayland-devel.sha256sum] = "bdf8602e640337fe8b79e1b2025eb67addc87927ca26870338e45394c7b15556"
RDEPENDS:wayland-devel = " \
 wayland-devel \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libwayland-server \
 libxml2 \
 pkgconf-pkg-config \
 expat \
 glibc \
 libffi-devel \
"

URI_wayland-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/wayland-doc-1.23.0-2.el10.noarch.rpm;name=wayland-doc;unpack=0"
SRC_URI += "${URI_wayland-doc}"
SRC_URI[wayland-doc.sha256sum] = "0aa84e357a4dc47b32fdb9ef9f7a0cce5ee9f5782d2b6c55e9e9e92e134bab2a"
RDEPENDS:wayland-doc = ""
