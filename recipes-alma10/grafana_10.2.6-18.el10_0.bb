# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "grafana"
PE = "0"
PV = "10.2.6"
PR = "18.el10_0"
PACKAGES = "grafana grafana-selinux"
PROVIDES = "rpm/grafana rpm/grafana-selinux"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/grafana-10.2.6-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88055c8804f926a779127eafcf8e581ef8f200706cf3254f2f8da7110bb8aad6"

URI_grafana = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/grafana-10.2.6-18.el10_0.x86_64_v2.rpm;name=grafana;unpack=0"
SRC_URI += "${URI_grafana}"
SRC_URI[grafana.sha256sum] = "a26511a398151ba667d8965eec2e12224a2611349d0a2cdc6dfcb0a983fbbde1"
RDEPENDS:grafana = " \
 shadow-utils \
 systemd \
 shared-mime-info \
 bash \
 grafana-selinux \
 glibc \
"

URI_grafana-selinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/grafana-selinux-10.2.6-18.el10_0.x86_64_v2.rpm;name=grafana-selinux;unpack=0"
SRC_URI += "${URI_grafana-selinux}"
SRC_URI[grafana-selinux.sha256sum] = "2e18a3d8bb97c81accad3e7538cdb5dacd4b8d3386e04f803d0701004626ec1c"
RDEPENDS:grafana-selinux = " \
 policycoreutils-python-utils \
 policycoreutils \
 grafana \
 bash \
 initscripts-service \
 selinux-policy-targeted \
 selinux-policy \
"
