# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rubygem-rspec-core"
PE = "0"
PV = "3.13.0"
PR = "3.el10"
PACKAGES = "rubygem-rspec-core rubygem-rspec-core-doc"
PROVIDES = "rpm/rubygem-rspec-core rpm/rubygem-rspec-core-doc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/rubygem-rspec-core-3.13.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1359967391fb2fc7d106df73d56da01d9ab0817c31553472342e190e6dbbcfed"

URI_rubygem-rspec-core = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/rubygem-rspec-core-3.13.0-3.el10.noarch.rpm;name=rubygem-rspec-core;unpack=0"
SRC_URI += "${URI_rubygem-rspec-core}"
SRC_URI[rubygem-rspec-core.sha256sum] = "a75c8b86fd476e648b95e5ea7f73d9993204398c806b490dd6b274c0282bbe9f"
RDEPENDS:rubygem-rspec-core = " \
 rubygem-rake \
 ruby \
 rubygem-rspec-support \
 rubygems \
 coreutils \
"

URI_rubygem-rspec-core-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-rspec-core-doc-3.13.0-3.el10.noarch.rpm;name=rubygem-rspec-core-doc;unpack=0"
SRC_URI += "${URI_rubygem-rspec-core-doc}"
SRC_URI[rubygem-rspec-core-doc.sha256sum] = "37d12a8f229cd621a7a86a2ce4c413fdd9cd434c07727d6ad6571618f7c4ce90"
RDEPENDS:rubygem-rspec-core-doc = " \
 rubygem-rspec-core \
"
