# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libusb1"
PE = "0"
PV = "1.0.27"
PR = "4.el10"
PACKAGES = "libusb1 libusb1-devel libusb1-devel-doc libusb1-tests-examples"
PROVIDES = "rpm/libusb1 rpm/libusb1-devel rpm/libusb1-devel-doc rpm/libusb1-tests-examples"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libusb1-1.0.27-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce29cb4fff260fa2a3b0f9fb46d527de0514dce77d32b85b1d93acef209bfa02"

URI_libusb1 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libusb1-1.0.27-4.el10.x86_64_v2.rpm;name=libusb1;unpack=0"
SRC_URI += "${URI_libusb1}"
SRC_URI[libusb1.sha256sum] = "97bb80c57a2d1159525c666d311df0982519f12d0708e410f1620ce1099bd406"
RDEPENDS:libusb1 = " \
 glibc \
 systemd-libs \
"

URI_libusb1-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libusb1-devel-1.0.27-4.el10.x86_64_v2.rpm;name=libusb1-devel;unpack=0"
SRC_URI += "${URI_libusb1-devel}"
SRC_URI[libusb1-devel.sha256sum] = "065fd82517f0aab56eb67873d3f4ec1ee4bce6b60f298bb8a0b0da9483b46c7d"
RDEPENDS:libusb1-devel = " \
 pkgconf-pkg-config \
 libusb1 \
"

URI_libusb1-devel-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libusb1-devel-doc-1.0.27-4.el10.noarch.rpm;name=libusb1-devel-doc;unpack=0"
SRC_URI += "${URI_libusb1-devel-doc}"
SRC_URI[libusb1-devel-doc.sha256sum] = "77951a3fffe5816f54598e90ade95b916d80174ea7f66190ea148703c35784c3"
RDEPENDS:libusb1-devel-doc = " \
 libusb1-devel \
"

URI_libusb1-tests-examples = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libusb1-tests-examples-1.0.27-4.el10.x86_64_v2.rpm;name=libusb1-tests-examples;unpack=0"
SRC_URI += "${URI_libusb1-tests-examples}"
SRC_URI[libusb1-tests-examples.sha256sum] = "ebc73ef1460332d3f5e182527149307a48d19773ceb5e873416b15a6f725bc91"
RDEPENDS:libusb1-tests-examples = " \
 libgcc \
 umockdev \
 glib2 \
 glibc \
 libusb1 \
"
