# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-no"
PE = "1"
PV = "2.0.10"
PR = "26.el10"
PACKAGES = "hunspell-nb hunspell-nn hyphen-nb hyphen-nn"
PROVIDES = "rpm/hunspell-nb rpm/hunspell-nn rpm/hyphen-nb rpm/hyphen-nn"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-no-2.0.10-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec2c3044a249ab3e09bf11cd5d889bd3e72229670cb8becba9766727e6e50278"

URI_hunspell-nb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-nb-2.0.10-26.el10.noarch.rpm;name=hunspell-nb;unpack=0"
SRC_URI += "${URI_hunspell-nb}"
SRC_URI[hunspell-nb.sha256sum] = "90d0bf244edb030936067f83029aeb0eaaadc6bc4a5604700157ec168fe874a7"
RDEPENDS:hunspell-nb = " \
 hunspell \
"

URI_hunspell-nn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-nn-2.0.10-26.el10.noarch.rpm;name=hunspell-nn;unpack=0"
SRC_URI += "${URI_hunspell-nn}"
SRC_URI[hunspell-nn.sha256sum] = "d4eec055fb1ab0c6ffdb597c2ed21d0e6387fcc1a66367141c6d6371b50145fe"
RDEPENDS:hunspell-nn = " \
 hunspell \
"

URI_hyphen-nb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-nb-2.0.10-26.el10.noarch.rpm;name=hyphen-nb;unpack=0"
SRC_URI += "${URI_hyphen-nb}"
SRC_URI[hyphen-nb.sha256sum] = "2c9079f60e0903c946067763fd54acdb17a29257e1a9fdf4ac5a351f73d2e152"
RDEPENDS:hyphen-nb = " \
 hyphen \
"

URI_hyphen-nn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-nn-2.0.10-26.el10.noarch.rpm;name=hyphen-nn;unpack=0"
SRC_URI += "${URI_hyphen-nn}"
SRC_URI[hyphen-nn.sha256sum] = "7d9f3204759e6544a8d622ae90e2abfd65e9484b0bc8cf4e77b9c8ded39be606"
RDEPENDS:hyphen-nn = " \
 hyphen \
"
