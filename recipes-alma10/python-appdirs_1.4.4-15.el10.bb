# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-appdirs"
PE = "0"
PV = "1.4.4"
PR = "15.el10"
PACKAGES = "python3-appdirs"
PROVIDES = "rpm/python3-appdirs"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-appdirs-1.4.4-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f73fbe7d7f49a41fdc620e5830e57352394e7a3b22a97a4edf592ad4b95f589"

URI_python3-appdirs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-appdirs-1.4.4-15.el10.noarch.rpm;name=python3-appdirs;unpack=0"
SRC_URI += "${URI_python3-appdirs}"
SRC_URI[python3-appdirs.sha256sum] = "a2b052db169af4189e7d096b50b29c3479ba0341b5b63656308e47bcd1c74692"
RDEPENDS:python3-appdirs = " \
 python3 \
"
