# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "uid_wrapper"
PE = "0"
PV = "1.3.0"
PR = "8.el10"
PACKAGES = "uid_wrapper"
PROVIDES = "rpm/uid_wrapper"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/uid_wrapper-1.3.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "897847381ae9748d809916cd87efe239139ae7ffbb05ed29e47cfa689c6e7405"

URI_uid_wrapper = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/uid_wrapper-1.3.0-8.el10.x86_64_v2.rpm;name=uid_wrapper;unpack=0"
SRC_URI += "${URI_uid_wrapper}"
SRC_URI[uid_wrapper.sha256sum] = "aff5a314259d71a14b42cb9d2806697cbfd6ca6913289e58ae34c71e36ae8e9c"
RDEPENDS:uid_wrapper = " \
 glibc \
 cmake-filesystem \
 pkgconf-pkg-config \
"
