# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-kn"
PE = "1"
PV = "0.7.0"
PR = "27.el10"
PACKAGES = "hyphen-kn"
PROVIDES = "rpm/hyphen-kn"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-kn-0.7.0-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5924dc27a30c70075ad15e8147ffb051ab7886075504b1e0bfe48e860b192d9a"

URI_hyphen-kn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-kn-0.7.0-27.el10.noarch.rpm;name=hyphen-kn;unpack=0"
SRC_URI += "${URI_hyphen-kn}"
SRC_URI[hyphen-kn.sha256sum] = "18d91d14746f4a96b3ed1dc723346e2cc48a468ce89c453ff7a0d178fe6b49c1"
RDEPENDS:hyphen-kn = " \
 hyphen \
"
