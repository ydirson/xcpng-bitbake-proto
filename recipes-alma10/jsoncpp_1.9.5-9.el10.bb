# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jsoncpp"
PE = "0"
PV = "1.9.5"
PR = "9.el10"
PACKAGES = "jsoncpp jsoncpp-devel jsoncpp-doc"
PROVIDES = "rpm/jsoncpp rpm/jsoncpp-devel rpm/jsoncpp-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/jsoncpp-1.9.5-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a61eac8b648cfba2501e3c6b1fee0a3291ce9b5356082148d8440c473c802eef"

URI_jsoncpp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jsoncpp-1.9.5-9.el10.x86_64_v2.rpm;name=jsoncpp;unpack=0"
SRC_URI += "${URI_jsoncpp}"
SRC_URI[jsoncpp.sha256sum] = "76c1c5602a9ab4b6b05a19200c49ce15f4889a5746b01b928f974dc7e2fd1254"
RDEPENDS:jsoncpp = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_jsoncpp-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jsoncpp-devel-1.9.5-9.el10.x86_64_v2.rpm;name=jsoncpp-devel;unpack=0"
SRC_URI += "${URI_jsoncpp-devel}"
SRC_URI[jsoncpp-devel.sha256sum] = "3b0b2da8e0f09d9bad8a00d2a702620ec557c075e1168ae84d20b0cab737921d"
RDEPENDS:jsoncpp-devel = " \
 jsoncpp \
 cmake-filesystem \
 pkgconf-pkg-config \
"

URI_jsoncpp-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/jsoncpp-doc-1.9.5-9.el10.noarch.rpm;name=jsoncpp-doc;unpack=0"
SRC_URI += "${URI_jsoncpp-doc}"
SRC_URI[jsoncpp-doc.sha256sum] = "79b0b88015e5fd0f9da758bb8fc4ae03e9dca7565703b591864362981278f4bd"
RDEPENDS:jsoncpp-doc = ""
