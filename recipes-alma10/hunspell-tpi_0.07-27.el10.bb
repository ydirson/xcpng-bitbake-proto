# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-tpi"
PE = "0"
PV = "0.07"
PR = "27.el10"
PACKAGES = "hunspell-tpi"
PROVIDES = "rpm/hunspell-tpi"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-tpi-0.07-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6069ea865167ae7b196211f0e12b367e67a10db498b67adbaffefcb3cbcf6f12"

URI_hunspell-tpi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-tpi-0.07-27.el10.noarch.rpm;name=hunspell-tpi;unpack=0"
SRC_URI += "${URI_hunspell-tpi}"
SRC_URI[hunspell-tpi.sha256sum] = "1573ccc5fa8665474fbcc239b353f2a2e038cd272af6e55d9cd05cea3e3c687a"
RDEPENDS:hunspell-tpi = " \
 hunspell-filesystem \
"
