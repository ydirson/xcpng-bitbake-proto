# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libpeas1"
PE = "0"
PV = "1.36.0"
PR = "8.el10"
PACKAGES = "libpeas1 libpeas1-gtk libpeas1-loader-python3 libpeas1-devel"
PROVIDES = "rpm/libpeas1 rpm/libpeas1-gtk rpm/libpeas1-loader-python3 rpm/libpeas1-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libpeas1-1.36.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8f05ccc2d9fb39c5a47a926ca5597fc4382f9cd868d8de312bc9e01806c3109"

URI_libpeas1 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libpeas1-1.36.0-8.el10.x86_64_v2.rpm;name=libpeas1;unpack=0"
SRC_URI += "${URI_libpeas1}"
SRC_URI[libpeas1.sha256sum] = "6117ddcbe151109b1f77a391922f6301ae182473167979f7b50ed2c1912df6e8"
RDEPENDS:libpeas1 = " \
 glibc \
 glib2 \
 gobject-introspection \
"

URI_libpeas1-gtk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libpeas1-gtk-1.36.0-8.el10.x86_64_v2.rpm;name=libpeas1-gtk;unpack=0"
SRC_URI += "${URI_libpeas1-gtk}"
SRC_URI[libpeas1-gtk.sha256sum] = "01f83cb7df6a0d80aa34bebbb2c749fb8fbf73623710591363ad9c045959b6a4"
RDEPENDS:libpeas1-gtk = " \
 libpeas1 \
 gobject-introspection \
 glib2 \
 gtk3 \
 glibc \
"

URI_libpeas1-loader-python3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libpeas1-loader-python3-1.36.0-8.el10.x86_64_v2.rpm;name=libpeas1-loader-python3;unpack=0"
SRC_URI += "${URI_libpeas1-loader-python3}"
SRC_URI[libpeas1-loader-python3.sha256sum] = "6f983ddb29cea16b3fa691a3630450a97262d1c0c1069a9539c14dae442d1b4f"
RDEPENDS:libpeas1-loader-python3 = " \
 python3-gobject \
 libpeas1 \
 python3-libs \
 glib2 \
 glibc \
"

URI_libpeas1-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libpeas1-devel-1.36.0-8.el10.x86_64_v2.rpm;name=libpeas1-devel;unpack=0"
SRC_URI += "${URI_libpeas1-devel}"
SRC_URI[libpeas1-devel.sha256sum] = "f748b1fb4c4a532b13a2a79bd9fdbcf27527d9e2009376e039e2f97893f162d1"
RDEPENDS:libpeas1-devel = " \
 libpeas1 \
 glib2-devel \
 pkgconf-pkg-config \
 libpeas1-gtk \
 libpeas1-devel \
 gobject-introspection-devel \
 gtk3-devel \
"
