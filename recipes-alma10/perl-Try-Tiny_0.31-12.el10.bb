# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Try-Tiny"
PE = "0"
PV = "0.31"
PR = "12.el10"
PACKAGES = "perl-Try-Tiny perl-Try-Tiny-tests"
PROVIDES = "rpm/perl-Try-Tiny rpm/perl-Try-Tiny-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Try-Tiny-0.31-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "068b003857ca03caf680264a7b57e33b069d9bdf51172df7943d48c3aecb1fa6"

URI_perl-Try-Tiny = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Try-Tiny-0.31-12.el10.noarch.rpm;name=perl-Try-Tiny;unpack=0"
SRC_URI += "${URI_perl-Try-Tiny}"
SRC_URI[perl-Try-Tiny.sha256sum] = "8ab071ef81c3f4815ec28d6572ac357f03176dd4b1bd32a70ed50de9d5bf3c9d"
RDEPENDS:perl-Try-Tiny = " \
 perl-constant \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-Exporter \
"

URI_perl-Try-Tiny-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Try-Tiny-tests-0.31-12.el10.noarch.rpm;name=perl-Try-Tiny-tests;unpack=0"
SRC_URI += "${URI_perl-Try-Tiny-tests}"
SRC_URI[perl-Try-Tiny-tests.sha256sum] = "3d763970a015d6e0739de57aa3990646cddf6b6fa4af93576995cc618c54f9ac"
RDEPENDS:perl-Try-Tiny-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-ExtUtils-MakeMaker \
 perl-Try-Tiny \
 bash \
 perl-PathTools \
 perl-interpreter \
"
