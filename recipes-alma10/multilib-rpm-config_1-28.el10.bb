# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "multilib-rpm-config"
PE = "0"
PV = "1"
PR = "28.el10"
PACKAGES = "multilib-rpm-config"
PROVIDES = "rpm/multilib-rpm-config"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/multilib-rpm-config-1-28.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0eecad94fb08078a1b334fd04fccb00cec6f113d90cd338d0c925271cc17579"

URI_multilib-rpm-config = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/multilib-rpm-config-1-28.el10.noarch.rpm;name=multilib-rpm-config;unpack=0"
SRC_URI += "${URI_multilib-rpm-config}"
SRC_URI[multilib-rpm-config.sha256sum] = "6758e8b973ff4cd006eefc485a6cec761498e5057cd596af0bfcd59e5c1bea38"
RDEPENDS:multilib-rpm-config = " \
 redhat-rpm-config \
 bash \
"
