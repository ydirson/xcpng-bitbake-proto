# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ModemManager"
PE = "0"
PV = "1.22.0"
PR = "7.el10"
PACKAGES = "ModemManager ModemManager-glib ModemManager-devel ModemManager-glib-devel ModemManager-vala"
PROVIDES = "rpm/ModemManager rpm/ModemManager-glib rpm/ModemManager-devel rpm/ModemManager-glib-devel rpm/ModemManager-vala"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/ModemManager-1.22.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9cf54182e0ec05cde45bb50851eeee3ca2047a1a296a15d5256b6b2deac03a8"

URI_ModemManager = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/ModemManager-1.22.0-7.el10.x86_64_v2.rpm;name=ModemManager;unpack=0"
SRC_URI += "${URI_ModemManager}"
SRC_URI[ModemManager.sha256sum] = "6d560e37b61bf800c979f7a39872f5fad79f069e9fe94c98f43bbd1ab7a69ec9"
RDEPENDS:ModemManager = " \
 systemd \
 ModemManager-glib \
 systemd-libs \
 libmbim \
 libmbim-utils \
 libgcc \
 libqrtr-glib \
 libqmi \
 libqmi-utils \
 libgudev \
 polkit \
 polkit-libs \
 bash \
 glib2 \
 glibc \
"

URI_ModemManager-glib = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/ModemManager-glib-1.22.0-7.el10.x86_64_v2.rpm;name=ModemManager-glib;unpack=0"
SRC_URI += "${URI_ModemManager-glib}"
SRC_URI[ModemManager-glib.sha256sum] = "38776da22fab192c3662ed67c079664b8916289b945f42bdf4c31297ffde62d2"
RDEPENDS:ModemManager-glib = " \
 glibc \
 libgcc \
 glib2 \
"

URI_ModemManager-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ModemManager-devel-1.22.0-7.el10.x86_64_v2.rpm;name=ModemManager-devel;unpack=0"
SRC_URI += "${URI_ModemManager-devel}"
SRC_URI[ModemManager-devel.sha256sum] = "8a312b6c1018702a16e9c7f4ab0024bbc72147477e8d3050837a274d00b8578c"
RDEPENDS:ModemManager-devel = " \
 ModemManager \
 pkgconf-pkg-config \
"

URI_ModemManager-glib-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ModemManager-glib-devel-1.22.0-7.el10.x86_64_v2.rpm;name=ModemManager-glib-devel;unpack=0"
SRC_URI += "${URI_ModemManager-glib-devel}"
SRC_URI[ModemManager-glib-devel.sha256sum] = "480520a2ff7a7db12d3c699a59b128fce05ecb7258123bfc4d4364d13914ba6f"
RDEPENDS:ModemManager-glib-devel = " \
 ModemManager \
 ModemManager-glib \
 glib2-devel \
 ModemManager-devel \
 pkgconf-pkg-config \
"

URI_ModemManager-vala = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ModemManager-vala-1.22.0-7.el10.x86_64_v2.rpm;name=ModemManager-vala;unpack=0"
SRC_URI += "${URI_ModemManager-vala}"
SRC_URI[ModemManager-vala.sha256sum] = "eca7d8ef2f1197250d884397fe71b0919db7f85d332b03ad6eeee9a97c7be642"
RDEPENDS:ModemManager-vala = " \
 vala \
 ModemManager-glib \
"
