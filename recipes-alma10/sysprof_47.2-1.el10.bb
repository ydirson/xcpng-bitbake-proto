# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sysprof"
PE = "0"
PV = "47.2"
PR = "1.el10"
PACKAGES = "libsysprof sysprof sysprof-agent sysprof-capture-devel sysprof-cli sysprof-devel"
PROVIDES = "rpm/libsysprof rpm/sysprof rpm/sysprof-agent rpm/sysprof-capture-devel rpm/sysprof-cli rpm/sysprof-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/sysprof-47.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0943f6317dd189dd3a425255cc4c13f9d433d7cc569e815c9975bc7c1590e36"

URI_libsysprof = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libsysprof-47.2-1.el10.x86_64_v2.rpm;name=libsysprof;unpack=0"
SRC_URI += "${URI_libsysprof}"
SRC_URI[libsysprof.sha256sum] = "b5dd520973b5b219192f2a0ed4185795da7c2091ffc90127cfe8aa10cc7a473e"
RDEPENDS:libsysprof = " \
 systemd-libs \
 elfutils-debuginfod-client \
 libgcc \
 json-glib \
 libstdc++ \
 polkit-libs \
 glib2 \
 glibc \
 libdex \
"

URI_sysprof = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sysprof-47.2-1.el10.x86_64_v2.rpm;name=sysprof;unpack=0"
SRC_URI += "${URI_sysprof}"
SRC_URI[sysprof.sha256sum] = "fe11b7f2876b9b78ca5875d1c59fbe3724d67529f27b6cf28242b5b15f9569f8"
RDEPENDS:sysprof = " \
 sysprof-cli \
 systemd-libs \
 libdex \
 elfutils-debuginfod-client \
 libgcc \
 libpanel \
 json-glib \
 pango \
 libstdc++ \
 polkit-libs \
 glib2 \
 cairo \
 graphene \
 glibc \
 gtk4 \
 hicolor-icon-theme \
 libadwaita \
"

URI_sysprof-agent = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sysprof-agent-47.2-1.el10.x86_64_v2.rpm;name=sysprof-agent;unpack=0"
SRC_URI += "${URI_sysprof-agent}"
SRC_URI[sysprof-agent.sha256sum] = "9cad3ae783e1dc91daea91bb15690473638666c38089dee2f147deedac813e10"
RDEPENDS:sysprof-agent = " \
 systemd-libs \
 elfutils-debuginfod-client \
 libgcc \
 json-glib \
 libstdc++ \
 polkit-libs \
 glib2 \
 glibc \
 libdex \
"

URI_sysprof-capture-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sysprof-capture-devel-47.2-1.el10.x86_64_v2.rpm;name=sysprof-capture-devel;unpack=0"
SRC_URI += "${URI_sysprof-capture-devel}"
SRC_URI[sysprof-capture-devel.sha256sum] = "0f13aa69243619138f64c72756eb104d78b3dd32a8e37275f667d8024683b21b"
RDEPENDS:sysprof-capture-devel = " \
 pkgconf-pkg-config \
"

URI_sysprof-cli = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sysprof-cli-47.2-1.el10.x86_64_v2.rpm;name=sysprof-cli;unpack=0"
SRC_URI += "${URI_sysprof-cli}"
SRC_URI[sysprof-cli.sha256sum] = "aa7a7e0283321217d460a137ce3bf7ba36cbc3d8f7b13969ff28e50632ffb711"
RDEPENDS:sysprof-cli = " \
 systemd-libs \
 kernel-tools \
 elfutils-debuginfod-client \
 libgcc \
 json-glib \
 elfutils-libelf \
 elfutils-libs \
 libstdc++ \
 polkit-libs \
 glib2 \
 glibc \
 libsysprof \
 libdex \
"

URI_sysprof-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/sysprof-devel-47.2-1.el10.x86_64_v2.rpm;name=sysprof-devel;unpack=0"
SRC_URI += "${URI_sysprof-devel}"
SRC_URI[sysprof-devel.sha256sum] = "7991abec12748f3effb376268f5a60f53bcf47df1d444ab1414f969d44771dfb"
RDEPENDS:sysprof-devel = " \
 json-glib-devel \
 sysprof-capture-devel \
 glib2-devel \
 systemd-devel \
 polkit-devel \
 pkgconf-pkg-config \
 libdex-devel \
 libsysprof \
 elfutils-debuginfod-client-devel \
"
