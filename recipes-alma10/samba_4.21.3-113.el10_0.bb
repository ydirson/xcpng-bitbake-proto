# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "samba"
PE = "0"
PV = "4.21.3"
PR = "113.el10_0"
PACKAGES = "ldb-tools libldb libnetapi libsmbclient libwbclient python3-ldb python3-samba python3-samba-dc samba samba-client-libs samba-common samba-common-libs samba-common-tools samba-dc-libs samba-dcerpc samba-ldb-ldap-modules samba-libs samba-tools samba-usershares samba-winbind samba-winbind-modules samba-client samba-gpupdate samba-krb5-printing samba-vfs-iouring samba-winbind-clients samba-winbind-krb5-locator samba-winexe libldb-devel libnetapi-devel libsmbclient-devel libwbclient-devel python3-samba-test samba-devel samba-pidl samba-test samba-test-libs ctdb"
PROVIDES = "rpm/ldb-tools rpm/libldb rpm/libnetapi rpm/libsmbclient rpm/libwbclient rpm/python3-ldb rpm/python3-samba rpm/python3-samba-dc rpm/samba rpm/samba-client-libs rpm/samba-common rpm/samba-common-libs rpm/samba-common-tools rpm/samba-dc-libs rpm/samba-dcerpc rpm/samba-ldb-ldap-modules rpm/samba-libs rpm/samba-tools rpm/samba-usershares rpm/samba-winbind rpm/samba-winbind-modules rpm/samba-client rpm/samba-gpupdate rpm/samba-krb5-printing rpm/samba-vfs-iouring rpm/samba-winbind-clients rpm/samba-winbind-krb5-locator rpm/samba-winexe rpm/libldb-devel rpm/libnetapi-devel rpm/libsmbclient-devel rpm/libwbclient-devel rpm/python3-samba-test rpm/samba-devel rpm/samba-pidl rpm/samba-test rpm/samba-test-libs rpm/ctdb"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/samba-4.21.3-113.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "074cb4281d812ea20f34df905167d311fb6626c1ae16b6a04e8fc33d560491b9"

URI_ldb-tools = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/ldb-tools-4.21.3-113.el10_0.x86_64_v2.rpm;name=ldb-tools;unpack=0"
SRC_URI += "${URI_ldb-tools}"
SRC_URI[ldb-tools.sha256sum] = "c5b5621f70a9dca6074fb86e1b37fc1524056537c80445f8519d4c43b8d9f907"
RDEPENDS:ldb-tools = " \
 glibc \
 popt \
 libldb \
 libtalloc \
"

URI_libldb = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libldb-4.21.3-113.el10_0.x86_64_v2.rpm;name=libldb;unpack=0"
SRC_URI += "${URI_libldb}"
SRC_URI[libldb.sha256sum] = "e8384ddce63a601f555f154d54fc3954998cc38c78cfd7e06cd36af4a5562582"
RDEPENDS:libldb = " \
 libtevent \
 libtalloc \
 libtdb \
 glibc \
 lmdb-libs \
"

URI_libnetapi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libnetapi-4.21.3-113.el10_0.x86_64_v2.rpm;name=libnetapi;unpack=0"
SRC_URI += "${URI_libnetapi}"
SRC_URI[libnetapi.sha256sum] = "87366ecf3212e84c1a4446d3157239b8724cc0f0aa04c001ffc33af35cdacf1a"
RDEPENDS:libnetapi = " \
 gnutls \
 libwbclient \
 libldb \
 libgcc \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 libtalloc \
 glibc \
"

URI_libsmbclient = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libsmbclient-4.21.3-113.el10_0.x86_64_v2.rpm;name=libsmbclient;unpack=0"
SRC_URI += "${URI_libsmbclient}"
SRC_URI[libsmbclient.sha256sum] = "4e463db0c4467577d22e81d2ea2ef91fb1a691ec2279e77aa35d865eff24c5a4"
RDEPENDS:libsmbclient = " \
 libwbclient \
 libldb \
 samba-client-libs \
 libtevent \
 samba-common \
 samba-common-libs \
 libtalloc \
 glibc \
"

URI_libwbclient = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libwbclient-4.21.3-113.el10_0.x86_64_v2.rpm;name=libwbclient;unpack=0"
SRC_URI += "${URI_libwbclient}"
SRC_URI[libwbclient.sha256sum] = "88029e56bf18e8263fab8455977688daf3d556644ffb1858ffb39db94b4f99db"
RDEPENDS:libwbclient = " \
 glibc \
 samba-client-libs \
 bash \
"

URI_python3-ldb = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-ldb-4.21.3-113.el10_0.x86_64_v2.rpm;name=python3-ldb;unpack=0"
SRC_URI += "${URI_python3-ldb}"
SRC_URI[python3-ldb.sha256sum] = "abd0c4ca3d91c3ea9b86aac170eeee68825403adf790bc138ce8fb0b623de41e"
RDEPENDS:python3-ldb = " \
 python3 \
 libldb \
 samba-client-libs \
 python3-libs \
 libtalloc \
 glibc \
 python3-tdb \
"

URI_python3-samba = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-samba-4.21.3-113.el10_0.x86_64_v2.rpm;name=python3-samba;unpack=0"
SRC_URI += "${URI_python3-samba}"
SRC_URI[python3-samba.sha256sum] = "4ebd83db83e9e5c0a20d33b999b811cb0ada58d8a5a079a18f18208b43c22510"
RDEPENDS:python3-samba = " \
 python3 \
 python3-cryptography \
 samba-client-libs \
 krb5-libs \
 samba-common-libs \
 python3-dns \
 samba-dc-libs \
 libsmbclient \
 python3-ldb \
 samba-libs \
 python3-libs \
 libtalloc \
 libtevent \
 python3-requests \
 gnutls \
 libwbclient \
 libgcc \
 python3-talloc \
 python3-tdb \
 python3-tevent \
 libldb \
 glibc \
"

URI_python3-samba-dc = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-samba-dc-4.21.3-113.el10_0.x86_64_v2.rpm;name=python3-samba-dc;unpack=0"
SRC_URI += "${URI_python3-samba-dc}"
SRC_URI[python3-samba-dc.sha256sum] = "f84539c9456c0b6883319851a06080bbefe52feceb7dc0dba380399d9603fde2"
RDEPENDS:python3-samba-dc = " \
 python3 \
 libwbclient \
 libldb \
 python3-samba \
 samba-client-libs \
 python3-libs \
 libtalloc \
 python3-markdown \
 glibc \
 samba-dc-libs \
 python3-talloc \
"

URI_samba = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/samba-4.21.3-113.el10_0.x86_64_v2.rpm;name=samba;unpack=0"
SRC_URI += "${URI_samba}"
SRC_URI[samba.sha256sum] = "d53ebdb9caa0c82ed995ba3a0387c9337f6851c59bf34415f81773d99a0de53c"
RDEPENDS:samba = " \
 samba-client-libs \
 cups-libs \
 samba-common \
 samba-common-libs \
 samba-common-tools \
 dbus-libs \
 samba-dcerpc \
 samba-libs \
 libtalloc \
 libtdb \
 libtevent \
 openldap \
 gnutls \
 libwbclient \
 pam \
 bash \
 libldb \
 libnetapi \
 popt \
 glibc \
"

URI_samba-client-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/samba-client-libs-4.21.3-113.el10_0.x86_64_v2.rpm;name=samba-client-libs;unpack=0"
SRC_URI += "${URI_samba-client-libs}"
SRC_URI[samba-client-libs.sha256sum] = "0519ab89ddc5a2d69891107ae72eae1420f94e216c0cf30a580d7d64f29080c1"
RDEPENDS:samba-client-libs = " \
 glibc-gconv-extra \
 systemd-libs \
 samba-common \
 krb5-libs \
 samba-common-libs \
 libacl \
 jansson \
 libcap \
 libcom_err \
 libtalloc \
 libtasn1 \
 libtdb \
 libtevent \
 libtirpc \
 openldap \
 zlib-ng-compat \
 gnutls \
 libwbclient \
 libxcrypt \
 libgcc \
 pam-libs \
 avahi-libs \
 libicu \
 libldb \
 popt \
 glibc \
"

URI_samba-common = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/samba-common-4.21.3-113.el10_0.noarch.rpm;name=samba-common;unpack=0"
SRC_URI += "${URI_samba-common}"
SRC_URI[samba-common.sha256sum] = "6f0518d8a3611e4128757f6b37747e5d4535f1d73e9d8484018500af9326815d"
RDEPENDS:samba-common = " \
 systemd \
 bash \
"

URI_samba-common-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/samba-common-libs-4.21.3-113.el10_0.x86_64_v2.rpm;name=samba-common-libs;unpack=0"
SRC_URI += "${URI_samba-common-libs}"
SRC_URI[samba-common-libs.sha256sum] = "5bf486dd12f08c8225510e68067774517f730c9d41140e9efbd1685525d997bf"
RDEPENDS:samba-common-libs = " \
 libwbclient \
 libldb \
 samba-client-libs \
 samba-common \
 popt \
 libtalloc \
 libtdb \
 glibc \
 openldap \
"

URI_samba-common-tools = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/samba-common-tools-4.21.3-113.el10_0.x86_64_v2.rpm;name=samba-common-tools;unpack=0"
SRC_URI += "${URI_samba-common-tools}"
SRC_URI[samba-common-tools.sha256sum] = "4d82e49197859139f3bcfdb9a574d990f8461ab49c6e11c16ea94fc0cda41350"
RDEPENDS:samba-common-tools = " \
 python3 \
 samba-client-libs \
 krb5-libs \
 samba-common-libs \
 samba-ldb-ldap-modules \
 samba-libs \
 jansson \
 libcom_err \
 libtalloc \
 libtdb \
 libtevent \
 openldap \
 gnutls \
 libwbclient \
 libldb \
 readline \
 libnetapi \
 popt \
 glibc \
"

URI_samba-dc-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/samba-dc-libs-4.21.3-113.el10_0.x86_64_v2.rpm;name=samba-dc-libs;unpack=0"
SRC_URI += "${URI_samba-dc-libs}"
SRC_URI[samba-dc-libs.sha256sum] = "4ffbfcef8c02a71e0400dd6f79c2439d9045fc2311bcf9ba245fc753888e2844"
RDEPENDS:samba-dc-libs = " \
 gnutls \
 samba-libs \
 libldb \
 libwbclient \
 samba-client-libs \
 libtevent \
 samba-common-libs \
 libtalloc \
 glibc \
"

URI_samba-dcerpc = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/samba-dcerpc-4.21.3-113.el10_0.x86_64_v2.rpm;name=samba-dcerpc;unpack=0"
SRC_URI += "${URI_samba-dcerpc}"
SRC_URI[samba-dcerpc.sha256sum] = "a6b80c13906d340baf97aed268e2dab2b45fa407eeb52cf12066a8e48409483f"
RDEPENDS:samba-dcerpc = " \
 gnutls \
 samba-libs \
 jansson \
 libwbclient \
 libldb \
 samba-client-libs \
 cups-libs \
 libtevent \
 libnetapi \
 samba-common-libs \
 popt \
 libtalloc \
 libtdb \
 glibc \
 openldap \
"

URI_samba-ldb-ldap-modules = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/samba-ldb-ldap-modules-4.21.3-113.el10_0.x86_64_v2.rpm;name=samba-ldb-ldap-modules;unpack=0"
SRC_URI += "${URI_samba-ldb-ldap-modules}"
SRC_URI[samba-ldb-ldap-modules.sha256sum] = "f92ea00d0f65c18aa6ab7ad7ff5b017d584c3630e12e51271dfa74682951ea74"
RDEPENDS:samba-ldb-ldap-modules = " \
 libldb \
 libwbclient \
 samba-client-libs \
 libtevent \
 samba-common-libs \
 libtalloc \
 glibc \
 openldap \
"

URI_samba-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/samba-libs-4.21.3-113.el10_0.x86_64_v2.rpm;name=samba-libs;unpack=0"
SRC_URI += "${URI_samba-libs}"
SRC_URI[samba-libs.sha256sum] = "44c4ed3c743ea86ad22440316d256ba2c4c7a6fcf87523dd3799cc1caee66cdd"
RDEPENDS:samba-libs = " \
 libldb \
 libwbclient \
 samba-client-libs \
 libtevent \
 samba-common-libs \
 popt \
 libtalloc \
 libtdb \
 glibc \
"

URI_samba-tools = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/samba-tools-4.21.3-113.el10_0.x86_64_v2.rpm;name=samba-tools;unpack=0"
SRC_URI += "${URI_samba-tools}"
SRC_URI[samba-tools.sha256sum] = "e0e64925adadbff71a4e2678a0e42c14b353001579767af420c32c5c64c78ea9"
RDEPENDS:samba-tools = " \
 python3 \
 python3-samba \
 python3-samba-dc \
"

URI_samba-usershares = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/samba-usershares-4.21.3-113.el10_0.x86_64_v2.rpm;name=samba-usershares;unpack=0"
SRC_URI += "${URI_samba-usershares}"
SRC_URI[samba-usershares.sha256sum] = "162a2c45ad2c4405162a244f74ba792dfde780cf19ba878151f72fb9b7cbee1b"
RDEPENDS:samba-usershares = " \
 bash \
 samba \
 samba-common-tools \
"

URI_samba-winbind = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/samba-winbind-4.21.3-113.el10_0.x86_64_v2.rpm;name=samba-winbind;unpack=0"
SRC_URI += "${URI_samba-winbind}"
SRC_URI[samba-winbind.sha256sum] = "9fd72ad74e99ba93f8180744bb56264b4f2ce7f0bae1933c7467318d9f4ce7c7"
RDEPENDS:samba-winbind = " \
 samba-client-libs \
 samba-common \
 krb5-libs \
 samba-common-libs \
 samba-common-tools \
 samba-dcerpc \
 samba-libs \
 libcom_err \
 libtalloc \
 libtdb \
 libtevent \
 samba-winbind-modules \
 openldap \
 gnutls \
 libwbclient \
 bash \
 libldb \
 popt \
 glibc \
"

URI_samba-winbind-modules = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/samba-winbind-modules-4.21.3-113.el10_0.x86_64_v2.rpm;name=samba-winbind-modules;unpack=0"
SRC_URI += "${URI_samba-winbind-modules}"
SRC_URI[samba-winbind-modules.sha256sum] = "716d458d2570d68bee49c40a5d6f4977b759658f94c8f5c38ee75ef66561d4de"
RDEPENDS:samba-winbind-modules = " \
 samba-libs \
 libwbclient \
 samba-client-libs \
 pam \
 pam-libs \
 libtalloc \
 glibc \
"

URI_samba-client = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/samba-client-4.21.3-113.el10_0.x86_64_v2.rpm;name=samba-client;unpack=0"
SRC_URI += "${URI_samba-client}"
SRC_URI[samba-client.sha256sum] = "3aac095480c9beb33fb9c162675e69e04203b58d864f35e31ec63ee6387d983c"
RDEPENDS:samba-client = " \
 libsmbclient \
 gnutls \
 libarchive \
 libldb \
 libwbclient \
 samba-client-libs \
 readline \
 libtevent \
 samba-common \
 krb5-libs \
 libcom_err \
 bash \
 ncurses-libs \
 popt \
 libtalloc \
 glibc \
 alternatives \
 samba-common-libs \
"

URI_samba-gpupdate = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/samba-gpupdate-4.21.3-113.el10_0.x86_64_v2.rpm;name=samba-gpupdate;unpack=0"
SRC_URI += "${URI_samba-gpupdate}"
SRC_URI[samba-gpupdate.sha256sum] = "74859eb30594c276e6e9edc7cd872edc4277b86ce85e553481c47b5c064be644"
RDEPENDS:samba-gpupdate = " \
 python3 \
 cepces-certmonger \
 certmonger \
 samba-ldb-ldap-modules \
 python3-samba \
 python3-samba-dc \
"

URI_samba-krb5-printing = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/samba-krb5-printing-4.21.3-113.el10_0.x86_64_v2.rpm;name=samba-krb5-printing;unpack=0"
SRC_URI += "${URI_samba-krb5-printing}"
SRC_URI[samba-krb5-printing.sha256sum] = "b286b8e38c9b2c2361f8d40b90855a6519d558a5a397ae900869b7e068a8f454"
RDEPENDS:samba-krb5-printing = " \
 samba-client \
 samba-client-libs \
 krb5-libs \
 bash \
 glibc \
 alternatives \
"

URI_samba-vfs-iouring = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/samba-vfs-iouring-4.21.3-113.el10_0.x86_64_v2.rpm;name=samba-vfs-iouring;unpack=0"
SRC_URI += "${URI_samba-vfs-iouring}"
SRC_URI[samba-vfs-iouring.sha256sum] = "ca5674b0d344da50cefa56512c646643671c19057999072acb510999037b7b52"
RDEPENDS:samba-vfs-iouring = " \
 samba-libs \
 libldb \
 libwbclient \
 samba \
 samba-client-libs \
 libtevent \
 libtalloc \
 glibc \
 liburing \
"

URI_samba-winbind-clients = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/samba-winbind-clients-4.21.3-113.el10_0.x86_64_v2.rpm;name=samba-winbind-clients;unpack=0"
SRC_URI += "${URI_samba-winbind-clients}"
SRC_URI[samba-winbind-clients.sha256sum] = "28696c28496ae8f00d95336a6906368a41d5687bc21cb41fa3a64c5537c7e519"
RDEPENDS:samba-winbind-clients = " \
 gnutls \
 samba-libs \
 libwbclient \
 libldb \
 samba-client-libs \
 libtevent \
 samba-common \
 krb5-libs \
 libcom_err \
 samba-common-libs \
 popt \
 libtalloc \
 samba-winbind \
 glibc \
"

URI_samba-winbind-krb5-locator = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/samba-winbind-krb5-locator-4.21.3-113.el10_0.x86_64_v2.rpm;name=samba-winbind-krb5-locator;unpack=0"
SRC_URI += "${URI_samba-winbind-krb5-locator}"
SRC_URI[samba-winbind-krb5-locator.sha256sum] = "760b2f264d9044100af400ee39b9c9aeac434079ade5b1a8873bccd87f7f45dd"
RDEPENDS:samba-winbind-krb5-locator = " \
 libldb \
 libwbclient \
 samba-client-libs \
 samba-winbind \
 bash \
 libtalloc \
 glibc \
 alternatives \
"

URI_samba-winexe = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/samba-winexe-4.21.3-113.el10_0.x86_64_v2.rpm;name=samba-winexe;unpack=0"
SRC_URI += "${URI_samba-winexe}"
SRC_URI[samba-winexe.sha256sum] = "c6c0ab9316f13e776ecd15452e40b0813aba8503e9e1ff9deb9158a0f362847b"
RDEPENDS:samba-winexe = " \
 libldb \
 libwbclient \
 samba-client-libs \
 libtevent \
 samba-common-libs \
 popt \
 libtalloc \
 glibc \
"

URI_libldb-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libldb-devel-4.21.3-113.el10_0.x86_64_v2.rpm;name=libldb-devel;unpack=0"
SRC_URI += "${URI_libldb-devel}"
SRC_URI[libldb-devel.sha256sum] = "0490dfcef94012ea00d3b25d2c701fa78f2f93be607fb51900c549be61ff6931"
RDEPENDS:libldb-devel = " \
 libldb \
 pkgconf-pkg-config \
 libtalloc-devel \
 libtdb-devel \
 libtevent-devel \
"

URI_libnetapi-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libnetapi-devel-4.21.3-113.el10_0.x86_64_v2.rpm;name=libnetapi-devel;unpack=0"
SRC_URI += "${URI_libnetapi-devel}"
SRC_URI[libnetapi-devel.sha256sum] = "4dbd2cea2737505a16e6b48bd2a5767a4286d3d7c84cbed1b4e9f6c9b6d7c227"
RDEPENDS:libnetapi-devel = " \
 libnetapi \
 pkgconf-pkg-config \
"

URI_libsmbclient-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libsmbclient-devel-4.21.3-113.el10_0.x86_64_v2.rpm;name=libsmbclient-devel;unpack=0"
SRC_URI += "${URI_libsmbclient-devel}"
SRC_URI[libsmbclient-devel.sha256sum] = "9a1f8a0335923025844c471f02634d440a49be845deee819c633cba4b80e9248"
RDEPENDS:libsmbclient-devel = " \
 libsmbclient \
 pkgconf-pkg-config \
"

URI_libwbclient-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libwbclient-devel-4.21.3-113.el10_0.x86_64_v2.rpm;name=libwbclient-devel;unpack=0"
SRC_URI += "${URI_libwbclient-devel}"
SRC_URI[libwbclient-devel.sha256sum] = "8c30a57a74b53886b050582092f24c86bd0d7b06dae2bde3e977f5f336ab6e8b"
RDEPENDS:libwbclient-devel = " \
 libwbclient \
 pkgconf-pkg-config \
"

URI_python3-samba-test = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-samba-test-4.21.3-113.el10_0.x86_64_v2.rpm;name=python3-samba-test;unpack=0"
SRC_URI += "${URI_python3-samba-test}"
SRC_URI[python3-samba-test.sha256sum] = "3f123e08a100dada44707e20d2b997d03e4dc9982e92dc221404d3eebace6319"
RDEPENDS:python3-samba-test = " \
 python3 \
 python3-samba \
 samba-client-libs \
 samba-libs \
"

URI_samba-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/samba-devel-4.21.3-113.el10_0.x86_64_v2.rpm;name=samba-devel;unpack=0"
SRC_URI += "${URI_samba-devel}"
SRC_URI[samba-devel.sha256sum] = "8db2659971777051d9a062dc49f981bc9858f433ebcc39a8f7df85b07aa46f08"
RDEPENDS:samba-devel = " \
 samba-libs \
 libldb-devel \
 samba-client-libs \
 pkgconf-pkg-config \
 libnetapi \
 samba-devel \
 samba-dc-libs \
 libtalloc-devel \
 libtevent-devel \
"

URI_samba-pidl = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/samba-pidl-4.21.3-113.el10_0.noarch.rpm;name=samba-pidl;unpack=0"
SRC_URI += "${URI_samba-pidl}"
SRC_URI[samba-pidl.sha256sum] = "89cea9c3a4722bec9c780432da0ead29acf4fee34833ab6d7e6ebe0ce4fa83b3"
RDEPENDS:samba-pidl = " \
 perl-libs \
 perl-interpreter \
 perl-vars \
 perl-FindBin \
 perl-Parse-Yapp \
 perl-Getopt-Long \
 perl-File-Basename \
 perl-parent \
 perl-Exporter \
 samba-pidl \
 perl-base \
 perl-lib \
"

URI_samba-test = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/samba-test-4.21.3-113.el10_0.x86_64_v2.rpm;name=samba-test;unpack=0"
SRC_URI += "${URI_samba-test}"
SRC_URI[samba-test.sha256sum] = "ae69f125d0467b9acd857854f33ca77eccdcbecec9eeb9e7a847cb755c1730a9"
RDEPENDS:samba-test = " \
 samba-test-libs \
 samba \
 samba-client-libs \
 perl-Archive-Tar \
 samba-common \
 krb5-libs \
 samba-common-libs \
 samba-dc-libs \
 libsmbclient \
 samba-libs \
 libcom_err \
 samba-winbind \
 libtalloc \
 libtdb \
 libtevent \
 gnutls \
 libwbclient \
 python3-samba \
 libldb \
 readline \
 libnetapi \
 popt \
 glibc \
"

URI_samba-test-libs = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/samba-test-libs-4.21.3-113.el10_0.x86_64_v2.rpm;name=samba-test-libs;unpack=0"
SRC_URI += "${URI_samba-test-libs}"
SRC_URI[samba-test-libs.sha256sum] = "0b1f28f6eb7640724c0d45b1a72b2b62bcc9db088174fc48caeb2dba7c4a0763"
RDEPENDS:samba-test-libs = " \
 samba-libs \
 libldb \
 libwbclient \
 samba-client-libs \
 samba-common-libs \
 libtalloc \
 glibc \
"

URI_ctdb = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ctdb-4.21.3-113.el10_0.x86_64_v2.rpm;name=ctdb;unpack=0"
SRC_URI += "${URI_ctdb}"
SRC_URI[ctdb.sha256sum] = "c4631a24924499f9072e7f36d2353b1a9d3ea6d5b3bd52d3f7132a1ac251ff45"
RDEPENDS:ctdb = " \
 systemd \
 iproute \
 samba-client-libs \
 tdb-tools \
 samba-common-libs \
 procps-ng \
 net-tools \
 util-linux \
 libtalloc \
 libtdb \
 libtevent \
 libtirpc \
 sed \
 bash \
 ethtool \
 gawk \
 iptables-nft \
 popt \
 samba-winbind-clients \
 glibc \
 coreutils \
 psmisc \
"
