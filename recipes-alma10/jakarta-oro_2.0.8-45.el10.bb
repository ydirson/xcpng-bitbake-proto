# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jakarta-oro"
PE = "0"
PV = "2.0.8"
PR = "45.el10"
PACKAGES = "jakarta-oro jakarta-oro-javadoc"
PROVIDES = "rpm/jakarta-oro rpm/jakarta-oro-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/jakarta-oro-2.0.8-45.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "297ae9ea1b49734ef7387d7e26f38bb3b64d2ea17e1d79fcd3acb142814059ae"

URI_jakarta-oro = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jakarta-oro-2.0.8-45.el10.noarch.rpm;name=jakarta-oro;unpack=0"
SRC_URI += "${URI_jakarta-oro}"
SRC_URI[jakarta-oro.sha256sum] = "92f7081e73147f24523fa2ee81f73e7493fbb1bf005dc8d4dbb991c6f70b329c"
RDEPENDS:jakarta-oro = " \
 javapackages-filesystem \
"

URI_jakarta-oro-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jakarta-oro-javadoc-2.0.8-45.el10.noarch.rpm;name=jakarta-oro-javadoc;unpack=0"
SRC_URI += "${URI_jakarta-oro-javadoc}"
SRC_URI[jakarta-oro-javadoc.sha256sum] = "75e831d6a7e7174d91807340191454422adccf351af38ab23ae63ec946c438a9"
RDEPENDS:jakarta-oro-javadoc = " \
 javapackages-filesystem \
"
