# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libutempter"
PE = "0"
PV = "1.2.1"
PR = "15.el10"
PACKAGES = "libutempter libutempter-devel"
PROVIDES = "rpm/libutempter rpm/libutempter-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libutempter-1.2.1-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "532b97bffe9e78ebf6a348ba8a2bc157895a9584a6cd9bf8736ae66d0524dc16"

URI_libutempter = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libutempter-1.2.1-15.el10.x86_64_v2.rpm;name=libutempter;unpack=0"
SRC_URI += "${URI_libutempter}"
SRC_URI[libutempter.sha256sum] = "be7a1a3d55678b34e4bbf96c1de7feee0e717e519fccdcae9ba262621b0bacc5"
RDEPENDS:libutempter = " \
 glibc \
 shadow-utils \
 bash \
"

URI_libutempter-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libutempter-devel-1.2.1-15.el10.x86_64_v2.rpm;name=libutempter-devel;unpack=0"
SRC_URI += "${URI_libutempter-devel}"
SRC_URI[libutempter-devel.sha256sum] = "4399979a2822c90808acca118832d95fafa73cc4e2fd3b736541bbb10d6cd171"
RDEPENDS:libutempter-devel = " \
 libutempter \
"
