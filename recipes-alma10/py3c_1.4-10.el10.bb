# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "py3c"
PE = "0"
PV = "1.4"
PR = "10.el10"
PACKAGES = "py3c-devel py3c-doc"
PROVIDES = "rpm/py3c-devel rpm/py3c-doc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/py3c-1.4-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9da999efa8683fab1f94a3478af0fdb73ab1d2cb8ca9fb45729195bbab1defc9"

URI_py3c-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/py3c-devel-1.4-10.el10.x86_64_v2.rpm;name=py3c-devel;unpack=0"
SRC_URI += "${URI_py3c-devel}"
SRC_URI[py3c-devel.sha256sum] = "5599833dfc535537eb263969b7a4ba928a927582999b26b7bc4ec339290103ec"
RDEPENDS:py3c-devel = " \
 pkgconf-pkg-config \
 python3-devel \
"

URI_py3c-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/py3c-doc-1.4-10.el10.noarch.rpm;name=py3c-doc;unpack=0"
SRC_URI += "${URI_py3c-doc}"
SRC_URI[py3c-doc.sha256sum] = "3ec5a21b978159157f92a50d10535dc8324b1e1aba3725d723cf0de76f5c0ab8"
RDEPENDS:py3c-doc = ""
