# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cyrus-imapd"
PE = "0"
PV = "3.8.3"
PR = "7.el10"
PACKAGES = "cyrus-imapd cyrus-imapd-libs cyrus-imapd-utils perl-Cyrus cyrus-imapd-devel cyrus-imapd-doc-extra cyrus-imapd-virusscan"
PROVIDES = "rpm/cyrus-imapd rpm/cyrus-imapd-libs rpm/cyrus-imapd-utils rpm/perl-Cyrus rpm/cyrus-imapd-devel rpm/cyrus-imapd-doc-extra rpm/cyrus-imapd-virusscan"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/cyrus-imapd-3.8.3-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be52379a0aca9d1a32185cba0b52f66485ef1e4f118be35197c25f61914784a5"

URI_cyrus-imapd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cyrus-imapd-3.8.3-7.el10.x86_64_v2.rpm;name=cyrus-imapd;unpack=0"
SRC_URI += "${URI_cyrus-imapd}"
SRC_URI[cyrus-imapd.sha256sum] = "06ddd78db62a3941a5b7f969459d5c8f2ef43fbcb3c128246280e6633e4fb2d4"
RDEPENDS:cyrus-imapd = " \
 systemd \
 perl-libs \
 perl-Getopt-Long \
 perl-Getopt-Std \
 cyrus-sasl-lib \
 jansson \
 cyrus-imapd-libs \
 cyrus-imapd-utils \
 libcom_err \
 perl-Cyrus \
 openldap \
 shadow-utils \
 zlib-ng-compat \
 openssl-libs \
 libxml2 \
 libzstd \
 sqlite-libs \
 bash \
 pcre2 \
 file \
 sscg \
 libical \
 libnghttp2 \
 glibc \
 perl-interpreter \
"

URI_cyrus-imapd-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cyrus-imapd-libs-3.8.3-7.el10.x86_64_v2.rpm;name=cyrus-imapd-libs;unpack=0"
SRC_URI += "${URI_cyrus-imapd-libs}"
SRC_URI[cyrus-imapd-libs.sha256sum] = "8e1c606ffb18ab8a48c99268880063ae85cdbeb7d71f49d82642a216416235ea"
RDEPENDS:cyrus-imapd-libs = " \
 libpq \
 krb5-libs \
 cyrus-sasl-lib \
 jansson \
 libstdc++ \
 libcom_err \
 libuuid \
 zlib-ng-compat \
 openssl-libs \
 libgcc \
 libxml2 \
 libzstd \
 sqlite-libs \
 xapian-core-libs \
 pcre2 \
 libicu \
 libical \
 mariadb-connector-c \
 libnghttp2 \
 glibc \
"

URI_cyrus-imapd-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cyrus-imapd-utils-3.8.3-7.el10.x86_64_v2.rpm;name=cyrus-imapd-utils;unpack=0"
SRC_URI += "${URI_cyrus-imapd-utils}"
SRC_URI[cyrus-imapd-utils.sha256sum] = "2df12eb337d669513cdd571eb620e91df36f7ea86323ea5b38673916f5eb7cf0"
RDEPENDS:cyrus-imapd-utils = " \
 perl-libs \
 cyrus-imapd-libs \
 openssl-libs \
 perl-Getopt-Long \
 perl-POSIX \
 cyrus-sasl-lib \
 perl-File-Temp \
 perl-Cyrus \
 bash \
 glibc \
 perl-interpreter \
 perl-Term-ReadLine \
 perl-lib \
 perl-Pod-Usage \
"

URI_perl-Cyrus = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Cyrus-3.8.3-7.el10.x86_64_v2.rpm;name=perl-Cyrus;unpack=0"
SRC_URI += "${URI_perl-Cyrus}"
SRC_URI[perl-Cyrus.sha256sum] = "8c7f9ffe180dc619814dd3319a12c01bf6a1d37d0b46210789ec1cfb71414107"
RDEPENDS:perl-Cyrus = " \
 perl-libs \
 libpq \
 perl-Getopt-Long \
 cyrus-sasl-lib \
 perl-Carp \
 perl-vars \
 perl-IO \
 perl-Cyrus \
 perl-JSON \
 perl-MIME-Base64 \
 libuuid \
 zlib-ng-compat \
 perl-URI \
 openssl-libs \
 perl-Unix-Syslog \
 perl-DynaLoader \
 sqlite-libs \
 perl-Encode \
 pcre2 \
 perl-Exporter \
 perl-base \
 perl-Net-Server \
 perl-constant \
 perl-POSIX \
 mariadb-connector-c \
 glibc \
 perl-File-Path \
"

URI_cyrus-imapd-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/cyrus-imapd-devel-3.8.3-7.el10.x86_64_v2.rpm;name=cyrus-imapd-devel;unpack=0"
SRC_URI += "${URI_cyrus-imapd-devel}"
SRC_URI[cyrus-imapd-devel.sha256sum] = "304cc27afb0d25fda361749c2becc6d4919efa9c6926275447b950e69aa89b58"
RDEPENDS:cyrus-imapd-devel = " \
 cyrus-imapd-libs \
 pkgconf-pkg-config \
"

URI_cyrus-imapd-doc-extra = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/cyrus-imapd-doc-extra-3.8.3-7.el10.noarch.rpm;name=cyrus-imapd-doc-extra;unpack=0"
SRC_URI += "${URI_cyrus-imapd-doc-extra}"
SRC_URI[cyrus-imapd-doc-extra.sha256sum] = "17c9098a4bb2a921785ad53b24fded350df9b57901f92c69a4d17bfc73a88ff5"
RDEPENDS:cyrus-imapd-doc-extra = ""

URI_cyrus-imapd-virusscan = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/cyrus-imapd-virusscan-3.8.3-7.el10.x86_64_v2.rpm;name=cyrus-imapd-virusscan;unpack=0"
SRC_URI += "${URI_cyrus-imapd-virusscan}"
SRC_URI[cyrus-imapd-virusscan.sha256sum] = "a565a0841b1108c80ab24c87ea4ad6f5fe63ebeb4f8d5f5fc59df10886fb3bfc"
RDEPENDS:cyrus-imapd-virusscan = " \
 glibc \
 cyrus-imapd-libs \
 libcom_err \
"
