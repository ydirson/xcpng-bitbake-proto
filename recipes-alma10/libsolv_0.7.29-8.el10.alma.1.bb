# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libsolv"
PE = "0"
PV = "0.7.29"
PR = "8.el10.alma.1"
PACKAGES = "libsolv python3-solv libsolv-devel libsolv-tools libsolv-tools-base libsolv-demo perl-solv ruby-solv"
PROVIDES = "rpm/libsolv rpm/python3-solv rpm/libsolv-devel rpm/libsolv-tools rpm/libsolv-tools-base rpm/libsolv-demo rpm/perl-solv rpm/ruby-solv"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libsolv-0.7.29-8.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7bfddd66f9f01a33061f58d20810e54856aa441002005277bbcddc17bd67971"

URI_libsolv = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libsolv-0.7.29-8.el10.alma.1.x86_64_v2.rpm;name=libsolv;unpack=0"
SRC_URI += "${URI_libsolv}"
SRC_URI[libsolv.sha256sum] = "17cefd3b88cc592cb7952c371f711ba71f136f4695e741cc279d54c046a6441b"
RDEPENDS:libsolv = " \
 zlib-ng-compat \
 bzip2-libs \
 openssl-libs \
 libxml2 \
 libzstd \
 glibc \
 rpm-libs \
 xz-libs \
"

URI_python3-solv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-solv-0.7.29-8.el10.alma.1.x86_64_v2.rpm;name=python3-solv;unpack=0"
SRC_URI += "${URI_python3-solv}"
SRC_URI[python3-solv.sha256sum] = "fe1df769658e843e072cac8633172d2a5f2656144cc42f131cd717da4cf5d9b1"
RDEPENDS:python3-solv = " \
 glibc \
 libsolv \
 python3 \
"

URI_libsolv-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libsolv-devel-0.7.29-8.el10.alma.1.x86_64_v2.rpm;name=libsolv-devel;unpack=0"
SRC_URI += "${URI_libsolv-devel}"
SRC_URI[libsolv-devel.sha256sum] = "0f5749b7123344710ee52abe5f6df8c24e8cd2a66183b46a73e23900d12d2740"
RDEPENDS:libsolv-devel = " \
 rpm-devel \
 libsolv \
 pkgconf-pkg-config \
 libsolv-devel \
"

URI_libsolv-tools = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libsolv-tools-0.7.29-8.el10.alma.1.x86_64_v2.rpm;name=libsolv-tools;unpack=0"
SRC_URI += "${URI_libsolv-tools}"
SRC_URI[libsolv-tools.sha256sum] = "fcaeb7eafa4c17d9570c2122b881c5cabbb3115cb184fd3e10f696c0f3e94fb0"
RDEPENDS:libsolv-tools = " \
 glibc \
 libsolv \
 findutils \
 libsolv-tools-base \
"

URI_libsolv-tools-base = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libsolv-tools-base-0.7.29-8.el10.alma.1.x86_64_v2.rpm;name=libsolv-tools-base;unpack=0"
SRC_URI += "${URI_libsolv-tools-base}"
SRC_URI[libsolv-tools-base.sha256sum] = "6565c0fa13110d0f3132245fe2c0eb9a5fb3169bc29363bbd3339f7b9b3261f8"
RDEPENDS:libsolv-tools-base = " \
 glibc \
 libsolv \
 rpm-libs \
"

URI_libsolv-demo = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libsolv-demo-0.7.29-8.el10.alma.1.x86_64_v2.rpm;name=libsolv-demo;unpack=0"
SRC_URI += "${URI_libsolv-demo}"
SRC_URI[libsolv-demo.sha256sum] = "425c7edb0cde6cb12e8161b13ed4027ad5e2e238b7b7db61b77f4f984e2fc38d"
RDEPENDS:libsolv-demo = " \
 glibc \
 gnupg2 \
 libsolv \
 curl \
"

URI_perl-solv = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-solv-0.7.29-8.el10.alma.1.x86_64_v2.rpm;name=perl-solv;unpack=0"
SRC_URI += "${URI_perl-solv}"
SRC_URI[perl-solv.sha256sum] = "00d24dceca5f9b2fcf18956c2104a4e61416738f338e57798f67378a86eac0de"
RDEPENDS:perl-solv = " \
 libsolv \
 perl-libs \
 perl-vars \
 perl-DynaLoader \
 perl-overload \
 glibc \
 perl-Exporter \
 perl-base \
"

URI_ruby-solv = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ruby-solv-0.7.29-8.el10.alma.1.x86_64_v2.rpm;name=ruby-solv;unpack=0"
SRC_URI += "${URI_ruby-solv}"
SRC_URI[ruby-solv.sha256sum] = "885ebdda27ac9584ed94279aeaac99c6c59ff9c94d43e8b8a533439c59d3111b"
RDEPENDS:ruby-solv = " \
 glibc \
 libsolv \
"
