# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libappstream-glib"
PE = "0"
PV = "0.8.3"
PR = "3.el10"
PACKAGES = "libappstream-glib libappstream-glib-devel libappstream-glib-builder"
PROVIDES = "rpm/libappstream-glib rpm/libappstream-glib-devel rpm/libappstream-glib-builder"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libappstream-glib-0.8.3-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0280757c6c4ad00bf0d59a90a017c181aac34098aca3f036a70bb6397be5d32"

URI_libappstream-glib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libappstream-glib-0.8.3-3.el10.x86_64_v2.rpm;name=libappstream-glib;unpack=0"
SRC_URI += "${URI_libappstream-glib}"
SRC_URI[libappstream-glib.sha256sum] = "089667bfc8ba6de44e2c078bc9fe1a9de064708e39225e0b2c48e25d6311c3ac"
RDEPENDS:libappstream-glib = " \
 libuuid \
 libarchive \
 libgcc \
 json-glib \
 gdk-pixbuf2 \
 glib2 \
 libcurl \
 glibc \
 rpm-libs \
"

URI_libappstream-glib-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libappstream-glib-devel-0.8.3-3.el10.x86_64_v2.rpm;name=libappstream-glib-devel;unpack=0"
SRC_URI += "${URI_libappstream-glib-devel}"
SRC_URI[libappstream-glib-devel.sha256sum] = "6df4ca0e618efc3417b4318d0e010f3014f7ad35341f1111a1b6f053203f0b0b"
RDEPENDS:libappstream-glib-devel = " \
 libarchive-devel \
 glib2-devel \
 pkgconf-pkg-config \
 gdk-pixbuf2-devel \
 libuuid-devel \
 libappstream-glib \
"

URI_libappstream-glib-builder = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libappstream-glib-builder-0.8.3-3.el10.x86_64_v2.rpm;name=libappstream-glib-builder;unpack=0"
SRC_URI += "${URI_libappstream-glib-builder}"
SRC_URI[libappstream-glib-builder.sha256sum] = "5843fd6a4092868f78de92f74c39dff0b91b05f106bf3033991d0ea7161b4182"
RDEPENDS:libappstream-glib-builder = " \
 freetype \
 libarchive \
 libgcc \
 json-glib \
 pango \
 gdk-pixbuf2 \
 fontconfig \
 cairo \
 glib2 \
 gtk3 \
 glibc \
 rpm-libs \
 libappstream-glib \
"
