# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-cryptography"
PE = "0"
PV = "43.0.0"
PR = "4.el10"
PACKAGES = "python3-cryptography"
PROVIDES = "rpm/python3-cryptography"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/python-cryptography-43.0.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c209ee414e0157c9485e3bd7c6f6ffab6738306bac31fd9c49efa1f9133708e4"

URI_python3-cryptography = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-cryptography-43.0.0-4.el10.x86_64_v2.rpm;name=python3-cryptography;unpack=0"
SRC_URI += "${URI_python3-cryptography}"
SRC_URI[python3-cryptography.sha256sum] = "c01cc165739e1d759271178fe0ae81a6abd592d6d1ec64422cfc1d3584724c71"
RDEPENDS:python3-cryptography = " \
 python3 \
 python3-cffi \
 openssl-libs \
 libgcc \
 glibc \
"
