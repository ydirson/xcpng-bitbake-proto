# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Text-Soundex"
PE = "0"
PV = "3.05"
PR = "33.el10"
PACKAGES = "perl-Text-Soundex perl-Text-Soundex-tests"
PROVIDES = "rpm/perl-Text-Soundex rpm/perl-Text-Soundex-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Text-Soundex-3.05-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96c5502edb2b17b57000a59de9006a88278aa5fae9bab5830f7a9a9809dc29a3"

URI_perl-Text-Soundex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Text-Soundex-3.05-33.el10.x86_64_v2.rpm;name=perl-Text-Soundex;unpack=0"
SRC_URI += "${URI_perl-Text-Soundex}"
SRC_URI[perl-Text-Soundex.sha256sum] = "2c1ce9c724e9eb747e6d07018e9f7c9fc70e06f1e0d7b184def159af445ae855"
RDEPENDS:perl-Text-Soundex = " \
 perl-libs \
 perl-Carp \
 perl-deprecate \
 perl-Text-Unidecode \
 perl-if \
 glibc \
 perl-Exporter \
"

URI_perl-Text-Soundex-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Text-Soundex-tests-3.05-33.el10.x86_64_v2.rpm;name=perl-Text-Soundex-tests;unpack=0"
SRC_URI += "${URI_perl-Text-Soundex-tests}"
SRC_URI[perl-Text-Soundex-tests.sha256sum] = "7f1437f6d6a4fb15389f3fdd283dd48d02eef9f73868dc9e05be40da36fc57f1"
RDEPENDS:perl-Text-Soundex-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Text-Soundex \
 bash \
 perl-interpreter \
"
