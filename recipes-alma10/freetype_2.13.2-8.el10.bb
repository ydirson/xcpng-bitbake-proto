# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "freetype"
PE = "0"
PV = "2.13.2"
PR = "8.el10"
PACKAGES = "freetype freetype-devel freetype-demos"
PROVIDES = "rpm/freetype rpm/freetype-devel rpm/freetype-demos"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/freetype-2.13.2-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f46ec2dfa3d3a54142825d294e24a4d4dab79b7ae5447dfb248ce912e625699b"

URI_freetype = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/freetype-2.13.2-8.el10.x86_64_v2.rpm;name=freetype;unpack=0"
SRC_URI += "${URI_freetype}"
SRC_URI[freetype.sha256sum] = "7f6f20fce68c15df7068b895663ac4f7b4605bb9d20c555a4712810b8b37dd38"
RDEPENDS:freetype = " \
 zlib-ng-compat \
 bzip2-libs \
 libpng \
 harfbuzz \
 libbrotli \
 bash \
 glibc \
"

URI_freetype-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/freetype-devel-2.13.2-8.el10.x86_64_v2.rpm;name=freetype-devel;unpack=0"
SRC_URI += "${URI_freetype-devel}"
SRC_URI[freetype-devel.sha256sum] = "379c936541d99640de3703a3c9de404796afc71feaeb501ff2a741dc100b4cb8"
RDEPENDS:freetype-devel = " \
 brotli-devel \
 freetype \
 zlib-ng-compat-devel \
 pkgconf \
 harfbuzz-devel \
 pkgconf-pkg-config \
 bzip2-devel \
 bash \
 libpng-devel \
"

URI_freetype-demos = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/freetype-demos-2.13.2-8.el10.x86_64_v2.rpm;name=freetype-demos;unpack=0"
SRC_URI += "${URI_freetype-demos}"
SRC_URI[freetype-demos.sha256sum] = "160db2ca48f4808a77b693b1673d6c2933d924b57d3841f8b41fb8e453658f8b"
RDEPENDS:freetype-demos = " \
 glibc \
 freetype \
 libpng \
 libX11 \
"
