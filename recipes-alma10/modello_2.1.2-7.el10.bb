# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "modello"
PE = "0"
PV = "2.1.2"
PR = "7.el10"
PACKAGES = "modello modello-javadoc"
PROVIDES = "rpm/modello rpm/modello-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/modello-2.1.2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99f9014bb3c17a1a36d934971b79560b214b71f2575f4fe5dfd6a7fbd3c04fad"

URI_modello = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/modello-2.1.2-7.el10.noarch.rpm;name=modello;unpack=0"
SRC_URI += "${URI_modello}"
SRC_URI[modello.sha256sum] = "24b0a252b7006339589cc326f1902328e142bf4ecd3743b48754cb4df0c22b2f"
RDEPENDS:modello = " \
 plexus-containers-component-annotations \
 jsoup \
 plexus-utils \
 javapackages-filesystem \
 javapackages-tools \
 sisu \
 velocity \
 plexus-build-api0 \
 bash \
 google-guice \
"

URI_modello-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/modello-javadoc-2.1.2-7.el10.noarch.rpm;name=modello-javadoc;unpack=0"
SRC_URI += "${URI_modello-javadoc}"
SRC_URI[modello-javadoc.sha256sum] = "2620e4aabcbae7fe86672d5bb9d3bec138ad9e38accfd7c0e700fb16b2fa47a8"
RDEPENDS:modello-javadoc = " \
 javapackages-filesystem \
"
