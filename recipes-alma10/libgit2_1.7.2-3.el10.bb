# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libgit2"
PE = "0"
PV = "1.7.2"
PR = "3.el10"
PACKAGES = "libgit2 libgit2-devel"
PROVIDES = "rpm/libgit2 rpm/libgit2-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/libgit2-1.7.2-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1fe831c5bcd1058634efe4a9c9976611dbd84f26b82545ee9939c6102299e757"

URI_libgit2 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libgit2-1.7.2-3.el10.x86_64_v2.rpm;name=libgit2;unpack=0"
SRC_URI += "${URI_libgit2}"
SRC_URI[libgit2.sha256sum] = "e2cec8abf3f2160a34327801dcfe06d0549977f097e3270729077954b53af19e"
RDEPENDS:libgit2 = " \
 zlib-ng-compat \
 openssl-libs \
 libgcc \
 pcre2 \
 llhttp \
 glibc \
"

URI_libgit2-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libgit2-devel-1.7.2-3.el10.x86_64_v2.rpm;name=libgit2-devel;unpack=0"
SRC_URI += "${URI_libgit2-devel}"
SRC_URI[libgit2-devel.sha256sum] = "2644762f45f9fdad22ec5a99ad7efeb07e49ef7c90ed5377e5a4ff634989f935"
RDEPENDS:libgit2-devel = " \
 libgit2 \
 zlib-ng-compat-devel \
 pkgconf-pkg-config \
 pcre2-devel \
 openssl-devel \
"
