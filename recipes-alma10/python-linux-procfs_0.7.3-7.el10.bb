# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-linux-procfs"
PE = "0"
PV = "0.7.3"
PR = "7.el10"
PACKAGES = "python3-linux-procfs"
PROVIDES = "rpm/python3-linux-procfs"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/python-linux-procfs-0.7.3-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3345bbf17a6343997de632bae3116434d1eb9bbcfc62944777d43075983d6a2f"

URI_python3-linux-procfs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-linux-procfs-0.7.3-7.el10.noarch.rpm;name=python3-linux-procfs;unpack=0"
SRC_URI += "${URI_python3-linux-procfs}"
SRC_URI[python3-linux-procfs.sha256sum] = "d37209f3d86d028969608cd6c8b59ea99f27c7f62f0650f599b92e0f31db748f"
RDEPENDS:python3-linux-procfs = " \
 python3 \
 python3-six \
"
