# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-HTTP-CookieJar"
PE = "0"
PV = "0.014"
PR = "8.el10"
PACKAGES = "perl-HTTP-CookieJar perl-HTTP-CookieJar-tests"
PROVIDES = "rpm/perl-HTTP-CookieJar rpm/perl-HTTP-CookieJar-tests"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-HTTP-CookieJar-0.014-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b91f14794e9e000a6c9a20458748f2f15378276d0fc21ffe0258c5cb9d9cec43"

URI_perl-HTTP-CookieJar = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-HTTP-CookieJar-0.014-8.el10.noarch.rpm;name=perl-HTTP-CookieJar;unpack=0"
SRC_URI += "${URI_perl-HTTP-CookieJar}"
SRC_URI[perl-HTTP-CookieJar.sha256sum] = "c28acdc504b4842af8fe348dcf6906502f858cf89762f13cdba957ccee94a7dd"
RDEPENDS:perl-HTTP-CookieJar = " \
 perl-libs \
 perl-Carp \
 perl-HTTP-CookieJar \
 perl-parent \
 perl-HTTP-Date \
"

URI_perl-HTTP-CookieJar-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-HTTP-CookieJar-tests-0.014-8.el10.noarch.rpm;name=perl-HTTP-CookieJar-tests;unpack=0"
SRC_URI += "${URI_perl-HTTP-CookieJar-tests}"
SRC_URI[perl-HTTP-CookieJar-tests.sha256sum] = "bf6ab8411f30830a2948b2ffb2355373c7762d86c02da700465014d5fd8a6ac8"
RDEPENDS:perl-HTTP-CookieJar-tests = " \
 perl-Test-Requires \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Deep \
 perl-URI \
 perl-Test-Simple \
 perl-HTTP-CookieJar \
 bash \
 perl-interpreter \
 perl-lib \
 perl-Time-Local \
"
