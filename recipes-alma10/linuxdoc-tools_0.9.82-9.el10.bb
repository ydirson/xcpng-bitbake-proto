# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "linuxdoc-tools"
PE = "0"
PV = "0.9.82"
PR = "9.el10"
PACKAGES = "linuxdoc-tools"
PROVIDES = "rpm/linuxdoc-tools"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/linuxdoc-tools-0.9.82-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9fe0e970586f935e5dc75f1a7d5a1b3affba5f9efea8689ee237654435c9d2b"

URI_linuxdoc-tools = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/linuxdoc-tools-0.9.82-9.el10.x86_64_v2.rpm;name=linuxdoc-tools;unpack=0"
SRC_URI += "${URI_linuxdoc-tools}"
SRC_URI[linuxdoc-tools.sha256sum] = "8d90e1ac7be44945da31585757fc905284ed1f7d7613612cb255072e83bfa7fd"
RDEPENDS:linuxdoc-tools = " \
 perl-libs \
 perl-FileHandle \
 perl-subs \
 perl-vars \
 perl-File-Temp \
 perl-DirHandle \
 openjade \
 linuxdoc-tools \
 bash \
 perl-Exporter \
 perl-base \
 texlive-collection-latexrecommended \
 groff \
 texlive-texlive-scripts-extra \
 gawk \
 perl-File-Basename \
 perl-File-Copy \
 perl-PathTools \
 glibc \
 perl-interpreter \
 perl-lib \
"
