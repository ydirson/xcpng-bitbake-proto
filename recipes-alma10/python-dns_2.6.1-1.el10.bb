# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-dns"
PE = "0"
PV = "2.6.1"
PR = "1.el10"
PACKAGES = "python3-dns python3-dns+dnssec python3-dns+idna"
PROVIDES = "rpm/python3-dns rpm/python3-dns+dnssec rpm/python3-dns+idna"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/python-dns-2.6.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1be49a51c2a64a32466f29bd66629c835005eca1e909b27d00463b64df2248c0"

URI_python3-dns = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-dns-2.6.1-1.el10.noarch.rpm;name=python3-dns;unpack=0"
SRC_URI += "${URI_python3-dns}"
SRC_URI[python3-dns.sha256sum] = "e96494427f1d0c812cb772605070b0ab680a4968b6700ce00a1f2f0850deed17"
RDEPENDS:python3-dns = " \
 python3 \
"

URI_python3-dns+dnssec = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-dns+dnssec-2.6.1-1.el10.noarch.rpm;name=python3-dns+dnssec;unpack=0"
SRC_URI += "${URI_python3-dns+dnssec}"
SRC_URI[python3-dns+dnssec.sha256sum] = "c7e09b9767256d8ae28c831570037f610f66d6d5aa1b2359efa2b12692ad0ec8"
RDEPENDS:python3-dns+dnssec = " \
 python3 \
 python3-dns \
 python3-cryptography \
"

URI_python3-dns+idna = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-dns+idna-2.6.1-1.el10.noarch.rpm;name=python3-dns+idna;unpack=0"
SRC_URI += "${URI_python3-dns+idna}"
SRC_URI[python3-dns+idna.sha256sum] = "5dcf374da6cf2a3f09cc1097ba1df7b295a7ad4eb6b41d7534061c06a1111088"
RDEPENDS:python3-dns+idna = " \
 python3 \
 python3-idna \
 python3-dns \
"
