# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "langpacks"
PE = "0"
PV = "4.1"
PR = "3.el10"
PACKAGES = "default-fonts-core-mono default-fonts-core-sans default-fonts-core-serif default-fonts default-fonts-am default-fonts-ar default-fonts-as default-fonts-ast default-fonts-be default-fonts-bg default-fonts-bn default-fonts-bo default-fonts-br default-fonts-chr default-fonts-cjk default-fonts-cjk-mono default-fonts-cjk-sans default-fonts-cjk-serif default-fonts-core default-fonts-core-emoji default-fonts-core-math default-fonts-dv default-fonts-dz default-fonts-el default-fonts-eo default-fonts-eu default-fonts-fa default-fonts-gu default-fonts-he default-fonts-hi default-fonts-hy default-fonts-ia default-fonts-iu default-fonts-ka default-fonts-km default-fonts-kn default-fonts-ku default-fonts-lo default-fonts-mai default-fonts-ml default-fonts-mni default-fonts-mr default-fonts-my default-fonts-nb default-fonts-ne default-fonts-nn default-fonts-nr default-fonts-nso default-fonts-or default-fonts-other default-fonts-other-mono default-fonts-other-sans default-fonts-other-serif default-fonts-pa default-fonts-ru default-fonts-sat default-fonts-si default-fonts-ss default-fonts-ta default-fonts-te default-fonts-th default-fonts-tn default-fonts-ts default-fonts-uk default-fonts-ur default-fonts-ve default-fonts-vi default-fonts-xh default-fonts-yi default-fonts-zu langpacks-af langpacks-am langpacks-ar langpacks-as langpacks-ast langpacks-be langpacks-bg langpacks-bn langpacks-bo langpacks-br langpacks-bs langpacks-ca langpacks-chr langpacks-core-af langpacks-core-am langpacks-core-ar langpacks-core-as langpacks-core-ast langpacks-core-be langpacks-core-bg langpacks-core-bn langpacks-core-bo langpacks-core-br langpacks-core-bs langpacks-core-ca langpacks-core-chr langpacks-core-cs langpacks-core-cy langpacks-core-da langpacks-core-de langpacks-core-dv langpacks-core-dz langpacks-core-el langpacks-core-en langpacks-core-en_GB langpacks-core-eo langpacks-core-es langpacks-core-et langpacks-core-eu langpacks-core-fa langpacks-core-fi langpacks-core-fr langpacks-core-ga langpacks-core-gl langpacks-core-gu langpacks-core-he langpacks-core-hi langpacks-core-hr langpacks-core-hu langpacks-core-hy langpacks-core-ia langpacks-core-id langpacks-core-is langpacks-core-it langpacks-core-iu langpacks-core-ja langpacks-core-ka langpacks-core-kk langpacks-core-km langpacks-core-kn langpacks-core-ko langpacks-core-ku langpacks-core-lo langpacks-core-lt langpacks-core-lv langpacks-core-mai langpacks-core-mk langpacks-core-ml langpacks-core-mni langpacks-core-mr langpacks-core-ms langpacks-core-my langpacks-core-nb langpacks-core-ne langpacks-core-nl langpacks-core-nn langpacks-core-nr langpacks-core-nso langpacks-core-or langpacks-core-pa langpacks-core-pl langpacks-core-pt langpacks-core-pt_BR langpacks-core-ro langpacks-core-ru langpacks-core-sat langpacks-core-si langpacks-core-sk langpacks-core-sl langpacks-core-sq langpacks-core-sr langpacks-core-ss langpacks-core-sv langpacks-core-ta langpacks-core-te langpacks-core-th langpacks-core-tn langpacks-core-tr langpacks-core-ts langpacks-core-uk langpacks-core-ur langpacks-core-ve langpacks-core-vi langpacks-core-xh langpacks-core-yi langpacks-core-zh_CN langpacks-core-zh_HK langpacks-core-zh_TW langpacks-core-zu langpacks-cs langpacks-cy langpacks-da langpacks-de langpacks-dv langpacks-dz langpacks-el langpacks-en langpacks-en_GB langpacks-eo langpacks-es langpacks-et langpacks-eu langpacks-fa langpacks-fi langpacks-fonts-af langpacks-fonts-am langpacks-fonts-ar langpacks-fonts-as langpacks-fonts-ast langpacks-fonts-be langpacks-fonts-bg langpacks-fonts-bn langpacks-fonts-bo langpacks-fonts-br langpacks-fonts-bs langpacks-fonts-ca langpacks-fonts-chr langpacks-fonts-cs langpacks-fonts-cy langpacks-fonts-da langpacks-fonts-de langpacks-fonts-dv langpacks-fonts-dz langpacks-fonts-el langpacks-fonts-en langpacks-fonts-eo langpacks-fonts-es langpacks-fonts-et langpacks-fonts-eu langpacks-fonts-fa langpacks-fonts-fi langpacks-fonts-fr langpacks-fonts-ga langpacks-fonts-gl langpacks-fonts-gu langpacks-fonts-he langpacks-fonts-hi langpacks-fonts-hr langpacks-fonts-hu langpacks-fonts-hy langpacks-fonts-ia langpacks-fonts-id langpacks-fonts-is langpacks-fonts-it langpacks-fonts-iu langpacks-fonts-ja langpacks-fonts-ka langpacks-fonts-kk langpacks-fonts-km langpacks-fonts-kn langpacks-fonts-ko langpacks-fonts-ku langpacks-fonts-lo langpacks-fonts-lt langpacks-fonts-lv langpacks-fonts-mai langpacks-fonts-mk langpacks-fonts-ml langpacks-fonts-mni langpacks-fonts-mr langpacks-fonts-ms langpacks-fonts-my langpacks-fonts-nb langpacks-fonts-ne langpacks-fonts-nl langpacks-fonts-nn langpacks-fonts-nr langpacks-fonts-nso langpacks-fonts-or langpacks-fonts-pa langpacks-fonts-pl langpacks-fonts-pt langpacks-fonts-ro langpacks-fonts-ru langpacks-fonts-sat langpacks-fonts-si langpacks-fonts-sk langpacks-fonts-sl langpacks-fonts-sq langpacks-fonts-sr langpacks-fonts-ss langpacks-fonts-sv langpacks-fonts-ta langpacks-fonts-te langpacks-fonts-th langpacks-fonts-tn langpacks-fonts-tr langpacks-fonts-ts langpacks-fonts-uk langpacks-fonts-ur langpacks-fonts-ve langpacks-fonts-vi langpacks-fonts-xh langpacks-fonts-yi langpacks-fonts-zh_CN langpacks-fonts-zh_HK langpacks-fonts-zh_TW langpacks-fonts-zu langpacks-fr langpacks-ga langpacks-gl langpacks-gu langpacks-he langpacks-hi langpacks-hr langpacks-hu langpacks-hy langpacks-ia langpacks-id langpacks-is langpacks-it langpacks-iu langpacks-ja langpacks-ka langpacks-kk langpacks-km langpacks-kn langpacks-ko langpacks-ku langpacks-lo langpacks-lt langpacks-lv langpacks-mai langpacks-mk langpacks-ml langpacks-mni langpacks-mr langpacks-ms langpacks-my langpacks-nb langpacks-ne langpacks-nl langpacks-nn langpacks-nr langpacks-nso langpacks-or langpacks-pa langpacks-pl langpacks-pt langpacks-pt_BR langpacks-ro langpacks-ru langpacks-sat langpacks-si langpacks-sk langpacks-sl langpacks-sq langpacks-sr langpacks-ss langpacks-sv langpacks-ta langpacks-te langpacks-th langpacks-tn langpacks-tr langpacks-ts langpacks-uk langpacks-ur langpacks-ve langpacks-vi langpacks-xh langpacks-yi langpacks-zh_CN langpacks-zh_HK langpacks-zh_TW langpacks-zu"
PROVIDES = "rpm/default-fonts-core-mono rpm/default-fonts-core-sans rpm/default-fonts-core-serif rpm/default-fonts rpm/default-fonts-am rpm/default-fonts-ar rpm/default-fonts-as rpm/default-fonts-ast rpm/default-fonts-be rpm/default-fonts-bg rpm/default-fonts-bn rpm/default-fonts-bo rpm/default-fonts-br rpm/default-fonts-chr rpm/default-fonts-cjk rpm/default-fonts-cjk-mono rpm/default-fonts-cjk-sans rpm/default-fonts-cjk-serif rpm/default-fonts-core rpm/default-fonts-core-emoji rpm/default-fonts-core-math rpm/default-fonts-dv rpm/default-fonts-dz rpm/default-fonts-el rpm/default-fonts-eo rpm/default-fonts-eu rpm/default-fonts-fa rpm/default-fonts-gu rpm/default-fonts-he rpm/default-fonts-hi rpm/default-fonts-hy rpm/default-fonts-ia rpm/default-fonts-iu rpm/default-fonts-ka rpm/default-fonts-km rpm/default-fonts-kn rpm/default-fonts-ku rpm/default-fonts-lo rpm/default-fonts-mai rpm/default-fonts-ml rpm/default-fonts-mni rpm/default-fonts-mr rpm/default-fonts-my rpm/default-fonts-nb rpm/default-fonts-ne rpm/default-fonts-nn rpm/default-fonts-nr rpm/default-fonts-nso rpm/default-fonts-or rpm/default-fonts-other rpm/default-fonts-other-mono rpm/default-fonts-other-sans rpm/default-fonts-other-serif rpm/default-fonts-pa rpm/default-fonts-ru rpm/default-fonts-sat rpm/default-fonts-si rpm/default-fonts-ss rpm/default-fonts-ta rpm/default-fonts-te rpm/default-fonts-th rpm/default-fonts-tn rpm/default-fonts-ts rpm/default-fonts-uk rpm/default-fonts-ur rpm/default-fonts-ve rpm/default-fonts-vi rpm/default-fonts-xh rpm/default-fonts-yi rpm/default-fonts-zu rpm/langpacks-af rpm/langpacks-am rpm/langpacks-ar rpm/langpacks-as rpm/langpacks-ast rpm/langpacks-be rpm/langpacks-bg rpm/langpacks-bn rpm/langpacks-bo rpm/langpacks-br rpm/langpacks-bs rpm/langpacks-ca rpm/langpacks-chr rpm/langpacks-core-af rpm/langpacks-core-am rpm/langpacks-core-ar rpm/langpacks-core-as rpm/langpacks-core-ast rpm/langpacks-core-be rpm/langpacks-core-bg rpm/langpacks-core-bn rpm/langpacks-core-bo rpm/langpacks-core-br rpm/langpacks-core-bs rpm/langpacks-core-ca rpm/langpacks-core-chr rpm/langpacks-core-cs rpm/langpacks-core-cy rpm/langpacks-core-da rpm/langpacks-core-de rpm/langpacks-core-dv rpm/langpacks-core-dz rpm/langpacks-core-el rpm/langpacks-core-en rpm/langpacks-core-en_GB rpm/langpacks-core-eo rpm/langpacks-core-es rpm/langpacks-core-et rpm/langpacks-core-eu rpm/langpacks-core-fa rpm/langpacks-core-fi rpm/langpacks-core-fr rpm/langpacks-core-ga rpm/langpacks-core-gl rpm/langpacks-core-gu rpm/langpacks-core-he rpm/langpacks-core-hi rpm/langpacks-core-hr rpm/langpacks-core-hu rpm/langpacks-core-hy rpm/langpacks-core-ia rpm/langpacks-core-id rpm/langpacks-core-is rpm/langpacks-core-it rpm/langpacks-core-iu rpm/langpacks-core-ja rpm/langpacks-core-ka rpm/langpacks-core-kk rpm/langpacks-core-km rpm/langpacks-core-kn rpm/langpacks-core-ko rpm/langpacks-core-ku rpm/langpacks-core-lo rpm/langpacks-core-lt rpm/langpacks-core-lv rpm/langpacks-core-mai rpm/langpacks-core-mk rpm/langpacks-core-ml rpm/langpacks-core-mni rpm/langpacks-core-mr rpm/langpacks-core-ms rpm/langpacks-core-my rpm/langpacks-core-nb rpm/langpacks-core-ne rpm/langpacks-core-nl rpm/langpacks-core-nn rpm/langpacks-core-nr rpm/langpacks-core-nso rpm/langpacks-core-or rpm/langpacks-core-pa rpm/langpacks-core-pl rpm/langpacks-core-pt rpm/langpacks-core-pt_BR rpm/langpacks-core-ro rpm/langpacks-core-ru rpm/langpacks-core-sat rpm/langpacks-core-si rpm/langpacks-core-sk rpm/langpacks-core-sl rpm/langpacks-core-sq rpm/langpacks-core-sr rpm/langpacks-core-ss rpm/langpacks-core-sv rpm/langpacks-core-ta rpm/langpacks-core-te rpm/langpacks-core-th rpm/langpacks-core-tn rpm/langpacks-core-tr rpm/langpacks-core-ts rpm/langpacks-core-uk rpm/langpacks-core-ur rpm/langpacks-core-ve rpm/langpacks-core-vi rpm/langpacks-core-xh rpm/langpacks-core-yi rpm/langpacks-core-zh_CN rpm/langpacks-core-zh_HK rpm/langpacks-core-zh_TW rpm/langpacks-core-zu rpm/langpacks-cs rpm/langpacks-cy rpm/langpacks-da rpm/langpacks-de rpm/langpacks-dv rpm/langpacks-dz rpm/langpacks-el rpm/langpacks-en rpm/langpacks-en_GB rpm/langpacks-eo rpm/langpacks-es rpm/langpacks-et rpm/langpacks-eu rpm/langpacks-fa rpm/langpacks-fi rpm/langpacks-fonts-af rpm/langpacks-fonts-am rpm/langpacks-fonts-ar rpm/langpacks-fonts-as rpm/langpacks-fonts-ast rpm/langpacks-fonts-be rpm/langpacks-fonts-bg rpm/langpacks-fonts-bn rpm/langpacks-fonts-bo rpm/langpacks-fonts-br rpm/langpacks-fonts-bs rpm/langpacks-fonts-ca rpm/langpacks-fonts-chr rpm/langpacks-fonts-cs rpm/langpacks-fonts-cy rpm/langpacks-fonts-da rpm/langpacks-fonts-de rpm/langpacks-fonts-dv rpm/langpacks-fonts-dz rpm/langpacks-fonts-el rpm/langpacks-fonts-en rpm/langpacks-fonts-eo rpm/langpacks-fonts-es rpm/langpacks-fonts-et rpm/langpacks-fonts-eu rpm/langpacks-fonts-fa rpm/langpacks-fonts-fi rpm/langpacks-fonts-fr rpm/langpacks-fonts-ga rpm/langpacks-fonts-gl rpm/langpacks-fonts-gu rpm/langpacks-fonts-he rpm/langpacks-fonts-hi rpm/langpacks-fonts-hr rpm/langpacks-fonts-hu rpm/langpacks-fonts-hy rpm/langpacks-fonts-ia rpm/langpacks-fonts-id rpm/langpacks-fonts-is rpm/langpacks-fonts-it rpm/langpacks-fonts-iu rpm/langpacks-fonts-ja rpm/langpacks-fonts-ka rpm/langpacks-fonts-kk rpm/langpacks-fonts-km rpm/langpacks-fonts-kn rpm/langpacks-fonts-ko rpm/langpacks-fonts-ku rpm/langpacks-fonts-lo rpm/langpacks-fonts-lt rpm/langpacks-fonts-lv rpm/langpacks-fonts-mai rpm/langpacks-fonts-mk rpm/langpacks-fonts-ml rpm/langpacks-fonts-mni rpm/langpacks-fonts-mr rpm/langpacks-fonts-ms rpm/langpacks-fonts-my rpm/langpacks-fonts-nb rpm/langpacks-fonts-ne rpm/langpacks-fonts-nl rpm/langpacks-fonts-nn rpm/langpacks-fonts-nr rpm/langpacks-fonts-nso rpm/langpacks-fonts-or rpm/langpacks-fonts-pa rpm/langpacks-fonts-pl rpm/langpacks-fonts-pt rpm/langpacks-fonts-ro rpm/langpacks-fonts-ru rpm/langpacks-fonts-sat rpm/langpacks-fonts-si rpm/langpacks-fonts-sk rpm/langpacks-fonts-sl rpm/langpacks-fonts-sq rpm/langpacks-fonts-sr rpm/langpacks-fonts-ss rpm/langpacks-fonts-sv rpm/langpacks-fonts-ta rpm/langpacks-fonts-te rpm/langpacks-fonts-th rpm/langpacks-fonts-tn rpm/langpacks-fonts-tr rpm/langpacks-fonts-ts rpm/langpacks-fonts-uk rpm/langpacks-fonts-ur rpm/langpacks-fonts-ve rpm/langpacks-fonts-vi rpm/langpacks-fonts-xh rpm/langpacks-fonts-yi rpm/langpacks-fonts-zh_CN rpm/langpacks-fonts-zh_HK rpm/langpacks-fonts-zh_TW rpm/langpacks-fonts-zu rpm/langpacks-fr rpm/langpacks-ga rpm/langpacks-gl rpm/langpacks-gu rpm/langpacks-he rpm/langpacks-hi rpm/langpacks-hr rpm/langpacks-hu rpm/langpacks-hy rpm/langpacks-ia rpm/langpacks-id rpm/langpacks-is rpm/langpacks-it rpm/langpacks-iu rpm/langpacks-ja rpm/langpacks-ka rpm/langpacks-kk rpm/langpacks-km rpm/langpacks-kn rpm/langpacks-ko rpm/langpacks-ku rpm/langpacks-lo rpm/langpacks-lt rpm/langpacks-lv rpm/langpacks-mai rpm/langpacks-mk rpm/langpacks-ml rpm/langpacks-mni rpm/langpacks-mr rpm/langpacks-ms rpm/langpacks-my rpm/langpacks-nb rpm/langpacks-ne rpm/langpacks-nl rpm/langpacks-nn rpm/langpacks-nr rpm/langpacks-nso rpm/langpacks-or rpm/langpacks-pa rpm/langpacks-pl rpm/langpacks-pt rpm/langpacks-pt_BR rpm/langpacks-ro rpm/langpacks-ru rpm/langpacks-sat rpm/langpacks-si rpm/langpacks-sk rpm/langpacks-sl rpm/langpacks-sq rpm/langpacks-sr rpm/langpacks-ss rpm/langpacks-sv rpm/langpacks-ta rpm/langpacks-te rpm/langpacks-th rpm/langpacks-tn rpm/langpacks-tr rpm/langpacks-ts rpm/langpacks-uk rpm/langpacks-ur rpm/langpacks-ve rpm/langpacks-vi rpm/langpacks-xh rpm/langpacks-yi rpm/langpacks-zh_CN rpm/langpacks-zh_HK rpm/langpacks-zh_TW rpm/langpacks-zu"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/langpacks-4.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bfcb944405e3e84f69213b0e78691665500069b9429e5d4ea90019ef5127145b"

URI_default-fonts-core-mono = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/default-fonts-core-mono-4.1-3.el10.noarch.rpm;name=default-fonts-core-mono;unpack=0"
SRC_URI += "${URI_default-fonts-core-mono}"
SRC_URI[default-fonts-core-mono.sha256sum] = "08778083300fbb1c4da800a31d512c6b9495d1a25bdfa8a09da254b924950924"
RDEPENDS:default-fonts-core-mono = " \
 google-noto-sans-mono-vf-fonts \
 redhat-mono-vf-fonts \
"

URI_default-fonts-core-sans = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/default-fonts-core-sans-4.1-3.el10.noarch.rpm;name=default-fonts-core-sans;unpack=0"
SRC_URI += "${URI_default-fonts-core-sans}"
SRC_URI[default-fonts-core-sans.sha256sum] = "71aa2eb11070db7472ba12e571f2a891f934b80f33c6e16a40ad5b5547be6145"
RDEPENDS:default-fonts-core-sans = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_default-fonts-core-serif = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/default-fonts-core-serif-4.1-3.el10.noarch.rpm;name=default-fonts-core-serif;unpack=0"
SRC_URI += "${URI_default-fonts-core-serif}"
SRC_URI[default-fonts-core-serif.sha256sum] = "78f8200e28b46d3d7c3ac8ce05b57db2a9cd05679fdb023e6ec02a907d499122"
RDEPENDS:default-fonts-core-serif = " \
 google-noto-serif-vf-fonts \
"

URI_default-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-4.1-3.el10.noarch.rpm;name=default-fonts;unpack=0"
SRC_URI += "${URI_default-fonts}"
SRC_URI[default-fonts.sha256sum] = "725fd0d8201e25ada40d165e9e6470f497e223fe02477424d1be176101b457f0"
RDEPENDS:default-fonts = " \
 default-fonts-other \
 default-fonts-core \
 default-fonts-cjk \
"

URI_default-fonts-am = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-am-4.1-3.el10.noarch.rpm;name=default-fonts-am;unpack=0"
SRC_URI += "${URI_default-fonts-am}"
SRC_URI[default-fonts-am.sha256sum] = "f248ed430ce304381db83d91423a56cb6fbc31c615fa76a489c0391b6c3a56b1"
RDEPENDS:default-fonts-am = " \
 google-noto-sans-ethiopic-vf-fonts \
"

URI_default-fonts-ar = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ar-4.1-3.el10.noarch.rpm;name=default-fonts-ar;unpack=0"
SRC_URI += "${URI_default-fonts-ar}"
SRC_URI[default-fonts-ar.sha256sum] = "c51c6b6f035d280dccfffac190d84ad5ee83db396ac8fc4822d9c6d3d0cc30d6"
RDEPENDS:default-fonts-ar = " \
 google-noto-sans-arabic-vf-fonts \
"

URI_default-fonts-as = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-as-4.1-3.el10.noarch.rpm;name=default-fonts-as;unpack=0"
SRC_URI += "${URI_default-fonts-as}"
SRC_URI[default-fonts-as.sha256sum] = "0e14a46e7d8d864bde0e43273561b7b5335ed5fa09ede58a2cd09f326768422e"
RDEPENDS:default-fonts-as = " \
 google-noto-sans-bengali-vf-fonts \
"

URI_default-fonts-ast = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ast-4.1-3.el10.noarch.rpm;name=default-fonts-ast;unpack=0"
SRC_URI += "${URI_default-fonts-ast}"
SRC_URI[default-fonts-ast.sha256sum] = "aa6360a2ef4ff7223690d2fef4ab3fd0bd648aa94f71cbc90edbf895dd5063ab"
RDEPENDS:default-fonts-ast = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_default-fonts-be = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-be-4.1-3.el10.noarch.rpm;name=default-fonts-be;unpack=0"
SRC_URI += "${URI_default-fonts-be}"
SRC_URI[default-fonts-be.sha256sum] = "229394300b89c80fbbdd0c30785e669fec6c0daa1ccd45474ae85d409c11b9f6"
RDEPENDS:default-fonts-be = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_default-fonts-bg = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-bg-4.1-3.el10.noarch.rpm;name=default-fonts-bg;unpack=0"
SRC_URI += "${URI_default-fonts-bg}"
SRC_URI[default-fonts-bg.sha256sum] = "809a4489c2e116cc62376ee3c4258618da9e3ebb5069a4c60b3a169d786652bd"
RDEPENDS:default-fonts-bg = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_default-fonts-bn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-bn-4.1-3.el10.noarch.rpm;name=default-fonts-bn;unpack=0"
SRC_URI += "${URI_default-fonts-bn}"
SRC_URI[default-fonts-bn.sha256sum] = "c25fdba4ec12effd9f1b4a52619ed7e86a1e7e820b7afa716b575895c5c6976f"
RDEPENDS:default-fonts-bn = " \
 google-noto-sans-bengali-vf-fonts \
"

URI_default-fonts-bo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-bo-4.1-3.el10.noarch.rpm;name=default-fonts-bo;unpack=0"
SRC_URI += "${URI_default-fonts-bo}"
SRC_URI[default-fonts-bo.sha256sum] = "6d406cfce45e5b5402baa9ecba7e46281d6a02eb8f25a52395bcd737332cb48f"
RDEPENDS:default-fonts-bo = " \
 jomolhari-fonts \
"

URI_default-fonts-br = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-br-4.1-3.el10.noarch.rpm;name=default-fonts-br;unpack=0"
SRC_URI += "${URI_default-fonts-br}"
SRC_URI[default-fonts-br.sha256sum] = "5b2a95991c2acc661244b42aee578a359d37b1ebb9b6a1b6e2f5a95e7b03eae2"
RDEPENDS:default-fonts-br = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_default-fonts-chr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-chr-4.1-3.el10.noarch.rpm;name=default-fonts-chr;unpack=0"
SRC_URI += "${URI_default-fonts-chr}"
SRC_URI[default-fonts-chr.sha256sum] = "944feee2c6a8dbae9a2d7358617a91e615848ae2743a9e446f2fc2968a61e2b4"
RDEPENDS:default-fonts-chr = " \
 google-noto-sans-cherokee-vf-fonts \
"

URI_default-fonts-cjk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-cjk-4.1-3.el10.noarch.rpm;name=default-fonts-cjk;unpack=0"
SRC_URI += "${URI_default-fonts-cjk}"
SRC_URI[default-fonts-cjk.sha256sum] = "3fff1d43f0f90d5d9be2d810bbd4e84937095557f0e8d97dd8c1c30ed8a292ab"
RDEPENDS:default-fonts-cjk = " \
 default-fonts-cjk-sans \
 default-fonts-cjk-serif \
 default-fonts-cjk-mono \
"

URI_default-fonts-cjk-mono = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-cjk-mono-4.1-3.el10.noarch.rpm;name=default-fonts-cjk-mono;unpack=0"
SRC_URI += "${URI_default-fonts-cjk-mono}"
SRC_URI[default-fonts-cjk-mono.sha256sum] = "dee5c656cdbeba0367e5f1ae585afd8acdabde03f21131d1b304632d99e253dd"
RDEPENDS:default-fonts-cjk-mono = " \
 google-noto-sans-mono-cjk-vf-fonts \
"

URI_default-fonts-cjk-sans = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-cjk-sans-4.1-3.el10.noarch.rpm;name=default-fonts-cjk-sans;unpack=0"
SRC_URI += "${URI_default-fonts-cjk-sans}"
SRC_URI[default-fonts-cjk-sans.sha256sum] = "2456d737133de86dd949364d35d8aeb39c9dea6556e5ff6d5587969431054b23"
RDEPENDS:default-fonts-cjk-sans = " \
 google-noto-sans-cjk-vf-fonts \
"

URI_default-fonts-cjk-serif = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-cjk-serif-4.1-3.el10.noarch.rpm;name=default-fonts-cjk-serif;unpack=0"
SRC_URI += "${URI_default-fonts-cjk-serif}"
SRC_URI[default-fonts-cjk-serif.sha256sum] = "3e299baa98e33d822808ccddc723343a897a542a0a3d10bb95bb2d0d880959b0"
RDEPENDS:default-fonts-cjk-serif = " \
 google-noto-serif-cjk-vf-fonts \
"

URI_default-fonts-core = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-core-4.1-3.el10.noarch.rpm;name=default-fonts-core;unpack=0"
SRC_URI += "${URI_default-fonts-core}"
SRC_URI[default-fonts-core.sha256sum] = "1b74810e7cca61acfd7de8d5e3a139ed77d3e3cc7950d0f9399a907c92eefee8"
RDEPENDS:default-fonts-core = " \
 default-fonts-core-emoji \
 default-fonts-core-math \
 default-fonts-core-mono \
 default-fonts-core-sans \
 default-fonts-core-serif \
"

URI_default-fonts-core-emoji = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-core-emoji-4.1-3.el10.noarch.rpm;name=default-fonts-core-emoji;unpack=0"
SRC_URI += "${URI_default-fonts-core-emoji}"
SRC_URI[default-fonts-core-emoji.sha256sum] = "d7449a78f197afeafab7c7f8967a8c51e42902c3657fe6e006a3a99dafd85673"
RDEPENDS:default-fonts-core-emoji = " \
 google-noto-color-emoji-fonts \
"

URI_default-fonts-core-math = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-core-math-4.1-3.el10.noarch.rpm;name=default-fonts-core-math;unpack=0"
SRC_URI += "${URI_default-fonts-core-math}"
SRC_URI[default-fonts-core-math.sha256sum] = "a74dc36888a52621ac760c305786cc377bd6bef99880b4ed775510495f1d05d9"
RDEPENDS:default-fonts-core-math = " \
 google-noto-sans-symbols-2-fonts \
 google-noto-sans-symbols-vf-fonts \
 stix-fonts \
 google-noto-sans-math-fonts \
"

URI_default-fonts-dv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-dv-4.1-3.el10.noarch.rpm;name=default-fonts-dv;unpack=0"
SRC_URI += "${URI_default-fonts-dv}"
SRC_URI[default-fonts-dv.sha256sum] = "05b1d7e1244d4f933e2579f9b0625fc06022e92218e5650b535af68ffcd54e5b"
RDEPENDS:default-fonts-dv = " \
 google-noto-sans-thaana-vf-fonts \
"

URI_default-fonts-dz = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-dz-4.1-3.el10.noarch.rpm;name=default-fonts-dz;unpack=0"
SRC_URI += "${URI_default-fonts-dz}"
SRC_URI[default-fonts-dz.sha256sum] = "4b239b2f36417313b44309f2f966950e29bc367a7bdd7f1bd80e536a8be93765"
RDEPENDS:default-fonts-dz = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_default-fonts-el = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-el-4.1-3.el10.noarch.rpm;name=default-fonts-el;unpack=0"
SRC_URI += "${URI_default-fonts-el}"
SRC_URI[default-fonts-el.sha256sum] = "78c737a0db0b962eb98c44ea20d7d43acf78958e476ab105b6f98dd52511d647"
RDEPENDS:default-fonts-el = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_default-fonts-eo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-eo-4.1-3.el10.noarch.rpm;name=default-fonts-eo;unpack=0"
SRC_URI += "${URI_default-fonts-eo}"
SRC_URI[default-fonts-eo.sha256sum] = "fcf6e75eae81f2c04093491e3f6bed2af90de1c4d3c13fdb0daf5ef8971e16a3"
RDEPENDS:default-fonts-eo = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_default-fonts-eu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-eu-4.1-3.el10.noarch.rpm;name=default-fonts-eu;unpack=0"
SRC_URI += "${URI_default-fonts-eu}"
SRC_URI[default-fonts-eu.sha256sum] = "00d2a83583ef728ddcdcb378e0dc131cb487e8c97cd5a57534ee656f3437daf9"
RDEPENDS:default-fonts-eu = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_default-fonts-fa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-fa-4.1-3.el10.noarch.rpm;name=default-fonts-fa;unpack=0"
SRC_URI += "${URI_default-fonts-fa}"
SRC_URI[default-fonts-fa.sha256sum] = "14fd756eff5f98614b52c922d4cefa19f16f3f2046e2ca55d9d6b62f3aec90ac"
RDEPENDS:default-fonts-fa = " \
 vazirmatn-vf-fonts \
"

URI_default-fonts-gu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-gu-4.1-3.el10.noarch.rpm;name=default-fonts-gu;unpack=0"
SRC_URI += "${URI_default-fonts-gu}"
SRC_URI[default-fonts-gu.sha256sum] = "4d12c1df6b30d4bac1adfd2508f4cac74272ae7b18da6214a36d8d571e7cc41e"
RDEPENDS:default-fonts-gu = " \
 google-noto-sans-gujarati-vf-fonts \
"

URI_default-fonts-he = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-he-4.1-3.el10.noarch.rpm;name=default-fonts-he;unpack=0"
SRC_URI += "${URI_default-fonts-he}"
SRC_URI[default-fonts-he.sha256sum] = "c47b999e71af37781c5bd6adca0c5d29b437706414337d856a3c8fe4cc51c136"
RDEPENDS:default-fonts-he = " \
 google-noto-sans-hebrew-vf-fonts \
"

URI_default-fonts-hi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-hi-4.1-3.el10.noarch.rpm;name=default-fonts-hi;unpack=0"
SRC_URI += "${URI_default-fonts-hi}"
SRC_URI[default-fonts-hi.sha256sum] = "58b329c7cc1c2b42ea1b7e63443494548bb618bc8e22edd0b42ab3ea154f71e7"
RDEPENDS:default-fonts-hi = " \
 google-noto-sans-devanagari-vf-fonts \
"

URI_default-fonts-hy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-hy-4.1-3.el10.noarch.rpm;name=default-fonts-hy;unpack=0"
SRC_URI += "${URI_default-fonts-hy}"
SRC_URI[default-fonts-hy.sha256sum] = "5a64efb263023455f9b771fb953b0ad9e563ad58a5401d5349851515273611cb"
RDEPENDS:default-fonts-hy = " \
 google-noto-sans-armenian-vf-fonts \
"

URI_default-fonts-ia = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ia-4.1-3.el10.noarch.rpm;name=default-fonts-ia;unpack=0"
SRC_URI += "${URI_default-fonts-ia}"
SRC_URI[default-fonts-ia.sha256sum] = "3d8abc0d393451f717469e352d7a7dfce8180e3e1e9c444b7dace8b0fed80f15"
RDEPENDS:default-fonts-ia = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_default-fonts-iu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-iu-4.1-3.el10.noarch.rpm;name=default-fonts-iu;unpack=0"
SRC_URI += "${URI_default-fonts-iu}"
SRC_URI[default-fonts-iu.sha256sum] = "eb120dffefcc4d11f1f6ed13d604b2f9b89068c8baf263bf9184481552fa4375"
RDEPENDS:default-fonts-iu = " \
 google-noto-sans-canadian-aboriginal-vf-fonts \
"

URI_default-fonts-ka = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ka-4.1-3.el10.noarch.rpm;name=default-fonts-ka;unpack=0"
SRC_URI += "${URI_default-fonts-ka}"
SRC_URI[default-fonts-ka.sha256sum] = "84bdebefa13d672da95ab00ac0fbedb1dcdd2057f1a60ebb344392e915731a2d"
RDEPENDS:default-fonts-ka = " \
 google-noto-sans-georgian-vf-fonts \
"

URI_default-fonts-km = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-km-4.1-3.el10.noarch.rpm;name=default-fonts-km;unpack=0"
SRC_URI += "${URI_default-fonts-km}"
SRC_URI[default-fonts-km.sha256sum] = "68a3af263485cf56d1d3ef4300d6f384e000f9fe59b51ee6c9a908b0bb98c334"
RDEPENDS:default-fonts-km = " \
 google-noto-sans-khmer-vf-fonts \
"

URI_default-fonts-kn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-kn-4.1-3.el10.noarch.rpm;name=default-fonts-kn;unpack=0"
SRC_URI += "${URI_default-fonts-kn}"
SRC_URI[default-fonts-kn.sha256sum] = "b2fe556100801fc58666f8cf85943446e0ae7d930af69d0423c53fe7f569bf07"
RDEPENDS:default-fonts-kn = " \
 google-noto-sans-kannada-vf-fonts \
"

URI_default-fonts-ku = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ku-4.1-3.el10.noarch.rpm;name=default-fonts-ku;unpack=0"
SRC_URI += "${URI_default-fonts-ku}"
SRC_URI[default-fonts-ku.sha256sum] = "1281215d1b68cc8a1f4617346d5b0e6c59fe12e23dd9e231c84e06b2b535a5d1"
RDEPENDS:default-fonts-ku = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_default-fonts-lo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-lo-4.1-3.el10.noarch.rpm;name=default-fonts-lo;unpack=0"
SRC_URI += "${URI_default-fonts-lo}"
SRC_URI[default-fonts-lo.sha256sum] = "5c9a523f43b672934095cb82613ce55cbb0c5b1ea147b098bcc844849fc638f8"
RDEPENDS:default-fonts-lo = " \
 google-noto-sans-lao-vf-fonts \
"

URI_default-fonts-mai = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-mai-4.1-3.el10.noarch.rpm;name=default-fonts-mai;unpack=0"
SRC_URI += "${URI_default-fonts-mai}"
SRC_URI[default-fonts-mai.sha256sum] = "4388634643e962c883aaccc866349a2d0e0fde602841ff0ca046615daa005a16"
RDEPENDS:default-fonts-mai = " \
 google-noto-sans-devanagari-vf-fonts \
"

URI_default-fonts-ml = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ml-4.1-3.el10.noarch.rpm;name=default-fonts-ml;unpack=0"
SRC_URI += "${URI_default-fonts-ml}"
SRC_URI[default-fonts-ml.sha256sum] = "154ae5c3f1d10d39f0ac0ae24562c457888bbd354cc04cc78c5ab273a5139151"
RDEPENDS:default-fonts-ml = " \
 rit-meera-new-fonts \
"

URI_default-fonts-mni = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-mni-4.1-3.el10.noarch.rpm;name=default-fonts-mni;unpack=0"
SRC_URI += "${URI_default-fonts-mni}"
SRC_URI[default-fonts-mni.sha256sum] = "3e9420ec5b0c66e5c8b36ce89896380ecdfe073f9f2b1728e05405840be60b1c"
RDEPENDS:default-fonts-mni = " \
 google-noto-sans-meetei-mayek-vf-fonts \
"

URI_default-fonts-mr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-mr-4.1-3.el10.noarch.rpm;name=default-fonts-mr;unpack=0"
SRC_URI += "${URI_default-fonts-mr}"
SRC_URI[default-fonts-mr.sha256sum] = "a2988595edc763d5084116c98fe2f9b3b1226cc715c88217d7dea7caeff03288"
RDEPENDS:default-fonts-mr = " \
 google-noto-sans-devanagari-vf-fonts \
"

URI_default-fonts-my = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-my-4.1-3.el10.noarch.rpm;name=default-fonts-my;unpack=0"
SRC_URI += "${URI_default-fonts-my}"
SRC_URI[default-fonts-my.sha256sum] = "b0c7353badae6c1ef194140b8bda4d8c50e8421341d390536ee76d1b311f8ad2"
RDEPENDS:default-fonts-my = " \
 sil-padauk-fonts \
"

URI_default-fonts-nb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-nb-4.1-3.el10.noarch.rpm;name=default-fonts-nb;unpack=0"
SRC_URI += "${URI_default-fonts-nb}"
SRC_URI[default-fonts-nb.sha256sum] = "ada8f22845f9d710fcaa52a8472349d193ff32c39842839388cb7b1ecd4f1333"
RDEPENDS:default-fonts-nb = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_default-fonts-ne = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ne-4.1-3.el10.noarch.rpm;name=default-fonts-ne;unpack=0"
SRC_URI += "${URI_default-fonts-ne}"
SRC_URI[default-fonts-ne.sha256sum] = "3e9057ceb085546b8498b644250ed060874de9c9dd415b5dceec9316e8c8e114"
RDEPENDS:default-fonts-ne = " \
 madan-fonts \
"

URI_default-fonts-nn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-nn-4.1-3.el10.noarch.rpm;name=default-fonts-nn;unpack=0"
SRC_URI += "${URI_default-fonts-nn}"
SRC_URI[default-fonts-nn.sha256sum] = "648505529ff2d36d19c9eed6d787dc72a644869ebe5702a9a4eb473f329e9180"
RDEPENDS:default-fonts-nn = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_default-fonts-nr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-nr-4.1-3.el10.noarch.rpm;name=default-fonts-nr;unpack=0"
SRC_URI += "${URI_default-fonts-nr}"
SRC_URI[default-fonts-nr.sha256sum] = "848940e28e22356fa68a646af908414e47914e72daffe0daaee4f46fc6c0e726"
RDEPENDS:default-fonts-nr = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_default-fonts-nso = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-nso-4.1-3.el10.noarch.rpm;name=default-fonts-nso;unpack=0"
SRC_URI += "${URI_default-fonts-nso}"
SRC_URI[default-fonts-nso.sha256sum] = "fe20a43d47c3c721f72cff1608c915f077aa2ead201e66215e67901034f6a0d4"
RDEPENDS:default-fonts-nso = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_default-fonts-or = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-or-4.1-3.el10.noarch.rpm;name=default-fonts-or;unpack=0"
SRC_URI += "${URI_default-fonts-or}"
SRC_URI[default-fonts-or.sha256sum] = "d78b13929c899be87fd77871b2fce24be5a9d808ed381cfc0d658a1b08415fa8"
RDEPENDS:default-fonts-or = " \
 google-noto-sans-oriya-vf-fonts \
"

URI_default-fonts-other = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-other-4.1-3.el10.noarch.rpm;name=default-fonts-other;unpack=0"
SRC_URI += "${URI_default-fonts-other}"
SRC_URI[default-fonts-other.sha256sum] = "b841efb893e6ed3601d6037cfe35bd660ad5e069d0ae3fb3256d7d0529abadb0"
RDEPENDS:default-fonts-other = " \
 default-fonts-other-mono \
 default-fonts-other-sans \
 default-fonts-other-serif \
"

URI_default-fonts-other-mono = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-other-mono-4.1-3.el10.noarch.rpm;name=default-fonts-other-mono;unpack=0"
SRC_URI += "${URI_default-fonts-other-mono}"
SRC_URI[default-fonts-other-mono.sha256sum] = "ab13033513d463831ad6e194d6b22ec8dae09519da3a5315510d80a67d62db1a"
RDEPENDS:default-fonts-other-mono = " \
 google-noto-sans-mono-vf-fonts \
 redhat-mono-vf-fonts \
"

URI_default-fonts-other-sans = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-other-sans-4.1-3.el10.noarch.rpm;name=default-fonts-other-sans;unpack=0"
SRC_URI += "${URI_default-fonts-other-sans}"
SRC_URI[default-fonts-other-sans.sha256sum] = "5616aee9e2c30e166b92d80fe42c3ff2e8550b7eb81eb66fec6ce55d06041366"
RDEPENDS:default-fonts-other-sans = " \
 default-fonts-am \
 default-fonts-ar \
 default-fonts-as \
 default-fonts-ast \
 default-fonts-be \
 default-fonts-bg \
 default-fonts-bn \
 default-fonts-bo \
 default-fonts-br \
 default-fonts-chr \
 default-fonts-dv \
 default-fonts-dz \
 default-fonts-el \
 default-fonts-eo \
 default-fonts-eu \
 default-fonts-fa \
 default-fonts-gu \
 default-fonts-he \
 default-fonts-hi \
 default-fonts-hy \
 default-fonts-ia \
 default-fonts-iu \
 default-fonts-ka \
 default-fonts-km \
 default-fonts-kn \
 default-fonts-ku \
 default-fonts-lo \
 default-fonts-mai \
 default-fonts-ml \
 default-fonts-mni \
 default-fonts-mr \
 default-fonts-my \
 default-fonts-nb \
 default-fonts-ne \
 default-fonts-nn \
 default-fonts-nr \
 default-fonts-nso \
 default-fonts-or \
 default-fonts-pa \
 default-fonts-ru \
 default-fonts-sat \
 default-fonts-si \
 default-fonts-ss \
 default-fonts-ta \
 default-fonts-te \
 default-fonts-th \
 default-fonts-tn \
 default-fonts-ts \
 default-fonts-uk \
 default-fonts-ur \
 default-fonts-ve \
 default-fonts-vi \
 default-fonts-xh \
 default-fonts-yi \
 default-fonts-zu \
"

URI_default-fonts-other-serif = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-other-serif-4.1-3.el10.noarch.rpm;name=default-fonts-other-serif;unpack=0"
SRC_URI += "${URI_default-fonts-other-serif}"
SRC_URI[default-fonts-other-serif.sha256sum] = "ced59614329a04f6a3d4202473f6b1162ea4452ba919bec0f0b704c2c4ee553a"
RDEPENDS:default-fonts-other-serif = " \
 google-noto-serif-armenian-vf-fonts \
 google-noto-serif-bengali-vf-fonts \
 google-noto-serif-devanagari-vf-fonts \
 google-noto-serif-ethiopic-vf-fonts \
 google-noto-serif-georgian-vf-fonts \
 google-noto-serif-gujarati-vf-fonts \
 google-noto-naskh-arabic-vf-fonts \
 google-noto-serif-gurmukhi-vf-fonts \
 google-noto-serif-hebrew-vf-fonts \
 google-noto-serif-kannada-vf-fonts \
 google-noto-serif-khmer-vf-fonts \
 google-noto-serif-lao-vf-fonts \
 google-noto-serif-oriya-vf-fonts \
 google-noto-serif-sinhala-vf-fonts \
 google-noto-serif-tamil-vf-fonts \
 google-noto-serif-telugu-vf-fonts \
 google-noto-serif-thai-vf-fonts \
 google-noto-serif-vf-fonts \
 rit-rachana-fonts \
"

URI_default-fonts-pa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-pa-4.1-3.el10.noarch.rpm;name=default-fonts-pa;unpack=0"
SRC_URI += "${URI_default-fonts-pa}"
SRC_URI[default-fonts-pa.sha256sum] = "9d1a927ddfb0ed3f04c51b9128f64572fef983b3b1305b4af00603f735e33ccb"
RDEPENDS:default-fonts-pa = " \
 google-noto-sans-gurmukhi-vf-fonts \
"

URI_default-fonts-ru = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ru-4.1-3.el10.noarch.rpm;name=default-fonts-ru;unpack=0"
SRC_URI += "${URI_default-fonts-ru}"
SRC_URI[default-fonts-ru.sha256sum] = "bdc660c691b5979427d3125cba045a93ec44e54dc38416eab1b1a68dca578a9b"
RDEPENDS:default-fonts-ru = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_default-fonts-sat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-sat-4.1-3.el10.noarch.rpm;name=default-fonts-sat;unpack=0"
SRC_URI += "${URI_default-fonts-sat}"
SRC_URI[default-fonts-sat.sha256sum] = "f4e3b4e5c52da6728b1def664d35687217e36fa860314b283d35686fc7a1ac1a"
RDEPENDS:default-fonts-sat = " \
 google-noto-sans-ol-chiki-vf-fonts \
"

URI_default-fonts-si = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-si-4.1-3.el10.noarch.rpm;name=default-fonts-si;unpack=0"
SRC_URI += "${URI_default-fonts-si}"
SRC_URI[default-fonts-si.sha256sum] = "944910975c327e2a8e998755cbe9e4621ddc7202ed77ee002a4a703286e81c99"
RDEPENDS:default-fonts-si = " \
 google-noto-sans-sinhala-vf-fonts \
"

URI_default-fonts-ss = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ss-4.1-3.el10.noarch.rpm;name=default-fonts-ss;unpack=0"
SRC_URI += "${URI_default-fonts-ss}"
SRC_URI[default-fonts-ss.sha256sum] = "3c042024ee0f140ecaa62b3339f85dc24661f33e44327916179bf55cc24efe62"
RDEPENDS:default-fonts-ss = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_default-fonts-ta = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ta-4.1-3.el10.noarch.rpm;name=default-fonts-ta;unpack=0"
SRC_URI += "${URI_default-fonts-ta}"
SRC_URI[default-fonts-ta.sha256sum] = "b9fc40086e65f3d0df842feaa56cf1792ac50f37c662952a8aae221484858c1f"
RDEPENDS:default-fonts-ta = " \
 google-noto-sans-tamil-vf-fonts \
"

URI_default-fonts-te = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-te-4.1-3.el10.noarch.rpm;name=default-fonts-te;unpack=0"
SRC_URI += "${URI_default-fonts-te}"
SRC_URI[default-fonts-te.sha256sum] = "b1e2fdd4df4fe927160729f9a1e5f20faa8a00e03b1c6fd4e1e8fedfceb3de84"
RDEPENDS:default-fonts-te = " \
 google-noto-sans-telugu-vf-fonts \
"

URI_default-fonts-th = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-th-4.1-3.el10.noarch.rpm;name=default-fonts-th;unpack=0"
SRC_URI += "${URI_default-fonts-th}"
SRC_URI[default-fonts-th.sha256sum] = "7469b729c470a5e542ae6bae8bf59dfbf069465f9624ca209fb1dfcccb8c2689"
RDEPENDS:default-fonts-th = " \
 google-noto-sans-thai-vf-fonts \
"

URI_default-fonts-tn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-tn-4.1-3.el10.noarch.rpm;name=default-fonts-tn;unpack=0"
SRC_URI += "${URI_default-fonts-tn}"
SRC_URI[default-fonts-tn.sha256sum] = "ea5d3d1bff95ce2a2670a79baef3da5ea2d2cbade906bb3319c2ed717800684e"
RDEPENDS:default-fonts-tn = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_default-fonts-ts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ts-4.1-3.el10.noarch.rpm;name=default-fonts-ts;unpack=0"
SRC_URI += "${URI_default-fonts-ts}"
SRC_URI[default-fonts-ts.sha256sum] = "33799985459434abcf2205c5ad34f8f8f4f72234e0e31f81444a1adc670a0e77"
RDEPENDS:default-fonts-ts = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_default-fonts-uk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-uk-4.1-3.el10.noarch.rpm;name=default-fonts-uk;unpack=0"
SRC_URI += "${URI_default-fonts-uk}"
SRC_URI[default-fonts-uk.sha256sum] = "09f1e72b592252aee16c5ce0a7844024fa69b05ea33babac0b07f713da7fabd0"
RDEPENDS:default-fonts-uk = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_default-fonts-ur = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ur-4.1-3.el10.noarch.rpm;name=default-fonts-ur;unpack=0"
SRC_URI += "${URI_default-fonts-ur}"
SRC_URI[default-fonts-ur.sha256sum] = "6f1990cc77bd899f56b4315878e5745fd6fa312ac3b3af2eb82c2fa481e9aaf1"
RDEPENDS:default-fonts-ur = " \
 paktype-naskh-basic-fonts \
"

URI_default-fonts-ve = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-ve-4.1-3.el10.noarch.rpm;name=default-fonts-ve;unpack=0"
SRC_URI += "${URI_default-fonts-ve}"
SRC_URI[default-fonts-ve.sha256sum] = "6f848aff40576a80a1e0c0260927bc1a00d041f27ddbb41dd6cb5da501b44016"
RDEPENDS:default-fonts-ve = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_default-fonts-vi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-vi-4.1-3.el10.noarch.rpm;name=default-fonts-vi;unpack=0"
SRC_URI += "${URI_default-fonts-vi}"
SRC_URI[default-fonts-vi.sha256sum] = "084f676a8123355974f5d0f5a8fd0a0fda748413f06105d0501bacec36772663"
RDEPENDS:default-fonts-vi = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_default-fonts-xh = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-xh-4.1-3.el10.noarch.rpm;name=default-fonts-xh;unpack=0"
SRC_URI += "${URI_default-fonts-xh}"
SRC_URI[default-fonts-xh.sha256sum] = "012bdf1360f18fa4288da5f96b8a9f731f20168d23886a440c00cd6f567219b1"
RDEPENDS:default-fonts-xh = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_default-fonts-yi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-yi-4.1-3.el10.noarch.rpm;name=default-fonts-yi;unpack=0"
SRC_URI += "${URI_default-fonts-yi}"
SRC_URI[default-fonts-yi.sha256sum] = "0353e16faedd4f1a766bb84b09a57f2def21fe216c6ec83d8340d8a2bb3d239a"
RDEPENDS:default-fonts-yi = " \
 google-noto-sans-hebrew-vf-fonts \
"

URI_default-fonts-zu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/default-fonts-zu-4.1-3.el10.noarch.rpm;name=default-fonts-zu;unpack=0"
SRC_URI += "${URI_default-fonts-zu}"
SRC_URI[default-fonts-zu.sha256sum] = "4c378b8e252ec53217a6b6b85fa4923912d8b7cc23c28916a914d8215dd8103f"
RDEPENDS:default-fonts-zu = " \
 google-noto-sans-vf-fonts \
 redhat-text-vf-fonts \
"

URI_langpacks-af = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-af-4.1-3.el10.noarch.rpm;name=langpacks-af;unpack=0"
SRC_URI += "${URI_langpacks-af}"
SRC_URI[langpacks-af.sha256sum] = "2822a0b6742081a30d43f08a81b51655eb0c8e7db22f836b9e80332cdfc8086b"
RDEPENDS:langpacks-af = " \
 langpacks-core-af \
 langpacks-fonts-af \
"

URI_langpacks-am = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-am-4.1-3.el10.noarch.rpm;name=langpacks-am;unpack=0"
SRC_URI += "${URI_langpacks-am}"
SRC_URI[langpacks-am.sha256sum] = "adc34eefbdbc380bb72b7ea954781a8239263d6984f5db72947da01a66374017"
RDEPENDS:langpacks-am = " \
 langpacks-fonts-am \
 langpacks-core-am \
"

URI_langpacks-ar = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ar-4.1-3.el10.noarch.rpm;name=langpacks-ar;unpack=0"
SRC_URI += "${URI_langpacks-ar}"
SRC_URI[langpacks-ar.sha256sum] = "f95bc252ee637bac72a492569f2570dc5e56b8e08fa71261575888d8f6e0e136"
RDEPENDS:langpacks-ar = " \
 langpacks-fonts-ar \
 langpacks-core-ar \
"

URI_langpacks-as = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-as-4.1-3.el10.noarch.rpm;name=langpacks-as;unpack=0"
SRC_URI += "${URI_langpacks-as}"
SRC_URI[langpacks-as.sha256sum] = "8e1bb029342a0a8a8fd818951180631d2609772ee0f01129524014959efd6c4a"
RDEPENDS:langpacks-as = " \
 langpacks-fonts-as \
 langpacks-core-as \
"

URI_langpacks-ast = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ast-4.1-3.el10.noarch.rpm;name=langpacks-ast;unpack=0"
SRC_URI += "${URI_langpacks-ast}"
SRC_URI[langpacks-ast.sha256sum] = "f18e4e3118b7c325b5a5ab81302d3091c9c6d19200594a4677194c37861395f1"
RDEPENDS:langpacks-ast = " \
 langpacks-fonts-ast \
 langpacks-core-ast \
"

URI_langpacks-be = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-be-4.1-3.el10.noarch.rpm;name=langpacks-be;unpack=0"
SRC_URI += "${URI_langpacks-be}"
SRC_URI[langpacks-be.sha256sum] = "bb3c9681a834db623628738e83cb9a0cdfce63a9a3fbce67fdb61eb78f350b00"
RDEPENDS:langpacks-be = " \
 langpacks-fonts-be \
 langpacks-core-be \
"

URI_langpacks-bg = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-bg-4.1-3.el10.noarch.rpm;name=langpacks-bg;unpack=0"
SRC_URI += "${URI_langpacks-bg}"
SRC_URI[langpacks-bg.sha256sum] = "41a74cba69e8cc30d47d3899e415c7e54376034e4502c5e7ad437e71d34f1faa"
RDEPENDS:langpacks-bg = " \
 langpacks-fonts-bg \
 langpacks-core-bg \
"

URI_langpacks-bn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-bn-4.1-3.el10.noarch.rpm;name=langpacks-bn;unpack=0"
SRC_URI += "${URI_langpacks-bn}"
SRC_URI[langpacks-bn.sha256sum] = "7979e199d13d28e6828c8c650766bdcee9a6a2066347af74ef4b6c389668f037"
RDEPENDS:langpacks-bn = " \
 langpacks-fonts-bn \
 langpacks-core-bn \
"

URI_langpacks-bo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-bo-4.1-3.el10.noarch.rpm;name=langpacks-bo;unpack=0"
SRC_URI += "${URI_langpacks-bo}"
SRC_URI[langpacks-bo.sha256sum] = "8d9b0890703ac85564f4c85ae27d18e7fe2b3449e7b713122885a247bbc677c1"
RDEPENDS:langpacks-bo = " \
 langpacks-core-bo \
 langpacks-fonts-bo \
"

URI_langpacks-br = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-br-4.1-3.el10.noarch.rpm;name=langpacks-br;unpack=0"
SRC_URI += "${URI_langpacks-br}"
SRC_URI[langpacks-br.sha256sum] = "ddc0ee45b333ee6c775b8550ea333b9f21ddc8d3b241515b7764f477de52c498"
RDEPENDS:langpacks-br = " \
 langpacks-fonts-br \
 langpacks-core-br \
"

URI_langpacks-bs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-bs-4.1-3.el10.noarch.rpm;name=langpacks-bs;unpack=0"
SRC_URI += "${URI_langpacks-bs}"
SRC_URI[langpacks-bs.sha256sum] = "e58e7cbf8b66e8e9293f8ce1bee5784a96356f04a91ec297c6adbd35370ee31f"
RDEPENDS:langpacks-bs = " \
 langpacks-fonts-bs \
 langpacks-core-bs \
"

URI_langpacks-ca = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ca-4.1-3.el10.noarch.rpm;name=langpacks-ca;unpack=0"
SRC_URI += "${URI_langpacks-ca}"
SRC_URI[langpacks-ca.sha256sum] = "e73e16095cfaa1cc14fb76120c67815319b48d4ee1d97cf1497d29edbaafd25b"
RDEPENDS:langpacks-ca = " \
 langpacks-fonts-ca \
 langpacks-core-ca \
"

URI_langpacks-chr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-chr-4.1-3.el10.noarch.rpm;name=langpacks-chr;unpack=0"
SRC_URI += "${URI_langpacks-chr}"
SRC_URI[langpacks-chr.sha256sum] = "36cd62511a0c064093ef586c31195ec066ef5d5e49bc9be0090ad411d2cfc045"
RDEPENDS:langpacks-chr = " \
 langpacks-fonts-chr \
 langpacks-core-chr \
"

URI_langpacks-core-af = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-af-4.1-3.el10.noarch.rpm;name=langpacks-core-af;unpack=0"
SRC_URI += "${URI_langpacks-core-af}"
SRC_URI[langpacks-core-af.sha256sum] = "82e754bd4149edaf43632a9a4ba1b9767009cbbdd4c9504895b84f4edf641185"
RDEPENDS:langpacks-core-af = " \
 default-fonts-core-sans \
"

URI_langpacks-core-am = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-am-4.1-3.el10.noarch.rpm;name=langpacks-core-am;unpack=0"
SRC_URI += "${URI_langpacks-core-am}"
SRC_URI[langpacks-core-am.sha256sum] = "a095df889ca05c3982dd279ca19e54c8beb3ada6d036c246f12a314f36d6c821"
RDEPENDS:langpacks-core-am = " \
 default-fonts-am \
"

URI_langpacks-core-ar = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ar-4.1-3.el10.noarch.rpm;name=langpacks-core-ar;unpack=0"
SRC_URI += "${URI_langpacks-core-ar}"
SRC_URI[langpacks-core-ar.sha256sum] = "920cddbb73210b770911340333a2a07be3f5d0a438e845f66c684e329613d831"
RDEPENDS:langpacks-core-ar = " \
 default-fonts-ar \
"

URI_langpacks-core-as = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-as-4.1-3.el10.noarch.rpm;name=langpacks-core-as;unpack=0"
SRC_URI += "${URI_langpacks-core-as}"
SRC_URI[langpacks-core-as.sha256sum] = "70510ff80138815aa662925396c9db07c1f83ad08127cf6f041d43283e090860"
RDEPENDS:langpacks-core-as = " \
 ibus-m17n \
 default-fonts-as \
"

URI_langpacks-core-ast = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ast-4.1-3.el10.noarch.rpm;name=langpacks-core-ast;unpack=0"
SRC_URI += "${URI_langpacks-core-ast}"
SRC_URI[langpacks-core-ast.sha256sum] = "27239fdd9720219f27d855e425a83e7e4546fcfe12b2e3cb29233a5b90a62dda"
RDEPENDS:langpacks-core-ast = " \
 default-fonts-ast \
"

URI_langpacks-core-be = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-be-4.1-3.el10.noarch.rpm;name=langpacks-core-be;unpack=0"
SRC_URI += "${URI_langpacks-core-be}"
SRC_URI[langpacks-core-be.sha256sum] = "d5021d99aed0d9ffed099a79c54ac2bfe720a7a671d545ba240b68a923cd3978"
RDEPENDS:langpacks-core-be = " \
 default-fonts-be \
"

URI_langpacks-core-bg = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-bg-4.1-3.el10.noarch.rpm;name=langpacks-core-bg;unpack=0"
SRC_URI += "${URI_langpacks-core-bg}"
SRC_URI[langpacks-core-bg.sha256sum] = "009b8f0ab47534f9460687ff8590786bff9186adadbc78617d20474193e4ec09"
RDEPENDS:langpacks-core-bg = " \
 default-fonts-bg \
"

URI_langpacks-core-bn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-bn-4.1-3.el10.noarch.rpm;name=langpacks-core-bn;unpack=0"
SRC_URI += "${URI_langpacks-core-bn}"
SRC_URI[langpacks-core-bn.sha256sum] = "4fd42d7da6eb9e9d04b3b43c5b461e817399f237e634f3771d7eae877df378de"
RDEPENDS:langpacks-core-bn = " \
 ibus-m17n \
 default-fonts-bn \
"

URI_langpacks-core-bo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-bo-4.1-3.el10.noarch.rpm;name=langpacks-core-bo;unpack=0"
SRC_URI += "${URI_langpacks-core-bo}"
SRC_URI[langpacks-core-bo.sha256sum] = "5237acba717552dcc4a1dae0a4c559e969f031131311db555f68ddbd3fde0649"
RDEPENDS:langpacks-core-bo = " \
 ibus-m17n \
 default-fonts-bo \
"

URI_langpacks-core-br = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-br-4.1-3.el10.noarch.rpm;name=langpacks-core-br;unpack=0"
SRC_URI += "${URI_langpacks-core-br}"
SRC_URI[langpacks-core-br.sha256sum] = "d5edd5a9503c86d14e5a17873360653f634e6ee4f2d9e447bcb2a937757f1139"
RDEPENDS:langpacks-core-br = " \
 default-fonts-br \
"

URI_langpacks-core-bs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-bs-4.1-3.el10.noarch.rpm;name=langpacks-core-bs;unpack=0"
SRC_URI += "${URI_langpacks-core-bs}"
SRC_URI[langpacks-core-bs.sha256sum] = "ad67a33789c38b01fc54ea627bfba5ff42e0fdc5cb7ede1028cfdb4f7f8ae7dd"
RDEPENDS:langpacks-core-bs = " \
 default-fonts-core-sans \
"

URI_langpacks-core-ca = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ca-4.1-3.el10.noarch.rpm;name=langpacks-core-ca;unpack=0"
SRC_URI += "${URI_langpacks-core-ca}"
SRC_URI[langpacks-core-ca.sha256sum] = "2a94b71911cb578695794bf15fb7b83460e02843d954172ebaca533174e98588"
RDEPENDS:langpacks-core-ca = " \
 default-fonts-core-sans \
"

URI_langpacks-core-chr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-chr-4.1-3.el10.noarch.rpm;name=langpacks-core-chr;unpack=0"
SRC_URI += "${URI_langpacks-core-chr}"
SRC_URI[langpacks-core-chr.sha256sum] = "8f012ccbe265e675fe9fdddf46ee8ba01eda79fc09243d9d0e289b13b7d3ff34"
RDEPENDS:langpacks-core-chr = " \
 default-fonts-chr \
"

URI_langpacks-core-cs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-cs-4.1-3.el10.noarch.rpm;name=langpacks-core-cs;unpack=0"
SRC_URI += "${URI_langpacks-core-cs}"
SRC_URI[langpacks-core-cs.sha256sum] = "2f06d99ddce3c46c5af46e241c897ce4d36f819b1bcf92e9f75c9708ca8e502f"
RDEPENDS:langpacks-core-cs = " \
 default-fonts-core-sans \
"

URI_langpacks-core-cy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-cy-4.1-3.el10.noarch.rpm;name=langpacks-core-cy;unpack=0"
SRC_URI += "${URI_langpacks-core-cy}"
SRC_URI[langpacks-core-cy.sha256sum] = "8645d27d9b6272b50ab2d5975d1076def8f445a4f9d116db92d1076dcf50b5f0"
RDEPENDS:langpacks-core-cy = " \
 default-fonts-core-sans \
"

URI_langpacks-core-da = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-da-4.1-3.el10.noarch.rpm;name=langpacks-core-da;unpack=0"
SRC_URI += "${URI_langpacks-core-da}"
SRC_URI[langpacks-core-da.sha256sum] = "224ead5652dd1cafe078c4b312250f94119734e7ee0553011bfc9924b70581d7"
RDEPENDS:langpacks-core-da = " \
 default-fonts-core-sans \
"

URI_langpacks-core-de = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-de-4.1-3.el10.noarch.rpm;name=langpacks-core-de;unpack=0"
SRC_URI += "${URI_langpacks-core-de}"
SRC_URI[langpacks-core-de.sha256sum] = "ed6e888c6c57e1ad3fcfaa274bfe09190e22952ef37eb38ce7e86d4169dd7f0e"
RDEPENDS:langpacks-core-de = " \
 default-fonts-core-sans \
"

URI_langpacks-core-dv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-dv-4.1-3.el10.noarch.rpm;name=langpacks-core-dv;unpack=0"
SRC_URI += "${URI_langpacks-core-dv}"
SRC_URI[langpacks-core-dv.sha256sum] = "a583f2bbf2905798bcf18a7ce33e1f550660c1fb57f8851d812100fd51cfa49f"
RDEPENDS:langpacks-core-dv = " \
 default-fonts-dv \
"

URI_langpacks-core-dz = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-dz-4.1-3.el10.noarch.rpm;name=langpacks-core-dz;unpack=0"
SRC_URI += "${URI_langpacks-core-dz}"
SRC_URI[langpacks-core-dz.sha256sum] = "5f8c290e91d665033287715c4d14a7b4eefb7a9252110cc078457436786bdc0d"
RDEPENDS:langpacks-core-dz = " \
 default-fonts-dz \
"

URI_langpacks-core-el = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-el-4.1-3.el10.noarch.rpm;name=langpacks-core-el;unpack=0"
SRC_URI += "${URI_langpacks-core-el}"
SRC_URI[langpacks-core-el.sha256sum] = "3fc01da11b94f2b448fa49737bc97e99d0128f93449358a3ee22969f078e8a33"
RDEPENDS:langpacks-core-el = " \
 default-fonts-el \
"

URI_langpacks-core-en = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-en-4.1-3.el10.noarch.rpm;name=langpacks-core-en;unpack=0"
SRC_URI += "${URI_langpacks-core-en}"
SRC_URI[langpacks-core-en.sha256sum] = "7a89162a752634bac078b575c3726d21b5b49dfca8af65cf64db3938d09ec843"
RDEPENDS:langpacks-core-en = " \
 default-fonts-core-sans \
"

URI_langpacks-core-en_GB = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-en_GB-4.1-3.el10.noarch.rpm;name=langpacks-core-en_GB;unpack=0"
SRC_URI += "${URI_langpacks-core-en_GB}"
SRC_URI[langpacks-core-en_GB.sha256sum] = "3eeae1251ec7dd9823cde03da315b5f883a5ebeb290d896e2e65cd8f608ca008"
RDEPENDS:langpacks-core-en_GB = " \
 default-fonts-core-sans \
"

URI_langpacks-core-eo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-eo-4.1-3.el10.noarch.rpm;name=langpacks-core-eo;unpack=0"
SRC_URI += "${URI_langpacks-core-eo}"
SRC_URI[langpacks-core-eo.sha256sum] = "c6a4027b11ceabea53d716e9cd43b0b0e7cc3ad10a4d0bc5cce470389faed693"
RDEPENDS:langpacks-core-eo = " \
 default-fonts-eo \
"

URI_langpacks-core-es = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-es-4.1-3.el10.noarch.rpm;name=langpacks-core-es;unpack=0"
SRC_URI += "${URI_langpacks-core-es}"
SRC_URI[langpacks-core-es.sha256sum] = "d953299c89a1b17aceeb27342aee4ebe5a4ef990d11022e0277591706cac36d5"
RDEPENDS:langpacks-core-es = " \
 default-fonts-core-sans \
"

URI_langpacks-core-et = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-et-4.1-3.el10.noarch.rpm;name=langpacks-core-et;unpack=0"
SRC_URI += "${URI_langpacks-core-et}"
SRC_URI[langpacks-core-et.sha256sum] = "292ae638fedb557848a6f86b56effdbcd38642dcaf2297b75bcfa255b0cebeaa"
RDEPENDS:langpacks-core-et = " \
 default-fonts-core-sans \
"

URI_langpacks-core-eu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-eu-4.1-3.el10.noarch.rpm;name=langpacks-core-eu;unpack=0"
SRC_URI += "${URI_langpacks-core-eu}"
SRC_URI[langpacks-core-eu.sha256sum] = "96ab9276b8a7411621efd605f2051b473fc8338fb3dbab672821d2c29d77d9dd"
RDEPENDS:langpacks-core-eu = " \
 default-fonts-eu \
"

URI_langpacks-core-fa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-fa-4.1-3.el10.noarch.rpm;name=langpacks-core-fa;unpack=0"
SRC_URI += "${URI_langpacks-core-fa}"
SRC_URI[langpacks-core-fa.sha256sum] = "c53a4cfa6d8c231a95ef8a14dbdb342b1332688e31fe7a7074d57c5f4e13522e"
RDEPENDS:langpacks-core-fa = " \
 default-fonts-fa \
"

URI_langpacks-core-fi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-fi-4.1-3.el10.noarch.rpm;name=langpacks-core-fi;unpack=0"
SRC_URI += "${URI_langpacks-core-fi}"
SRC_URI[langpacks-core-fi.sha256sum] = "e199f245fd3f554ca29e8d1e04d4a83d044d302eb68b7e0273ea4a02f5622f0a"
RDEPENDS:langpacks-core-fi = " \
 default-fonts-core-sans \
"

URI_langpacks-core-fr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-fr-4.1-3.el10.noarch.rpm;name=langpacks-core-fr;unpack=0"
SRC_URI += "${URI_langpacks-core-fr}"
SRC_URI[langpacks-core-fr.sha256sum] = "592ce02b53d93fb20ab15ff36fcc5185ec29e0e3f99191d0822d70c6296576c8"
RDEPENDS:langpacks-core-fr = " \
 default-fonts-core-sans \
"

URI_langpacks-core-ga = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ga-4.1-3.el10.noarch.rpm;name=langpacks-core-ga;unpack=0"
SRC_URI += "${URI_langpacks-core-ga}"
SRC_URI[langpacks-core-ga.sha256sum] = "3ba3cf218bdba766302772e9285598f193e91c59bf9dc064083e088e4c4f9dec"
RDEPENDS:langpacks-core-ga = " \
 default-fonts-core-sans \
"

URI_langpacks-core-gl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-gl-4.1-3.el10.noarch.rpm;name=langpacks-core-gl;unpack=0"
SRC_URI += "${URI_langpacks-core-gl}"
SRC_URI[langpacks-core-gl.sha256sum] = "3daa1686beac8e7a8a9fe60c2b5ff683c872cc86197f6d7b870a20596397d4d0"
RDEPENDS:langpacks-core-gl = " \
 default-fonts-core-sans \
"

URI_langpacks-core-gu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-gu-4.1-3.el10.noarch.rpm;name=langpacks-core-gu;unpack=0"
SRC_URI += "${URI_langpacks-core-gu}"
SRC_URI[langpacks-core-gu.sha256sum] = "2d653129cd06a3e88bde2d62dd71526c76bf8ea7c568dc2c5490daa6bfea3248"
RDEPENDS:langpacks-core-gu = " \
 ibus-m17n \
 default-fonts-gu \
"

URI_langpacks-core-he = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-he-4.1-3.el10.noarch.rpm;name=langpacks-core-he;unpack=0"
SRC_URI += "${URI_langpacks-core-he}"
SRC_URI[langpacks-core-he.sha256sum] = "cf6d24d7964b619c83b439b7ff9b3f4d40cd5085d1502cd95f79bbbae02762b2"
RDEPENDS:langpacks-core-he = " \
 default-fonts-he \
"

URI_langpacks-core-hi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-hi-4.1-3.el10.noarch.rpm;name=langpacks-core-hi;unpack=0"
SRC_URI += "${URI_langpacks-core-hi}"
SRC_URI[langpacks-core-hi.sha256sum] = "6928f217a244554c6a40fc2d806892b75ba8de3fa8248058001cfce4e1a0916e"
RDEPENDS:langpacks-core-hi = " \
 ibus-m17n \
 default-fonts-hi \
"

URI_langpacks-core-hr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-hr-4.1-3.el10.noarch.rpm;name=langpacks-core-hr;unpack=0"
SRC_URI += "${URI_langpacks-core-hr}"
SRC_URI[langpacks-core-hr.sha256sum] = "a0e5f619d6f189dc8af29cee43f7d875acc8592baece7e479e58a5ad9129d400"
RDEPENDS:langpacks-core-hr = " \
 default-fonts-core-sans \
"

URI_langpacks-core-hu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-hu-4.1-3.el10.noarch.rpm;name=langpacks-core-hu;unpack=0"
SRC_URI += "${URI_langpacks-core-hu}"
SRC_URI[langpacks-core-hu.sha256sum] = "89647e435b2c323e6a4bf4db7241c77ed993773157676797e5ad4011ff5801bb"
RDEPENDS:langpacks-core-hu = " \
 default-fonts-core-sans \
"

URI_langpacks-core-hy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-hy-4.1-3.el10.noarch.rpm;name=langpacks-core-hy;unpack=0"
SRC_URI += "${URI_langpacks-core-hy}"
SRC_URI[langpacks-core-hy.sha256sum] = "56465641bc5e1c3df4a8c002b2bd460dea790d60b3c828b51ba2bbae8dcc0fdd"
RDEPENDS:langpacks-core-hy = " \
 default-fonts-hy \
"

URI_langpacks-core-ia = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ia-4.1-3.el10.noarch.rpm;name=langpacks-core-ia;unpack=0"
SRC_URI += "${URI_langpacks-core-ia}"
SRC_URI[langpacks-core-ia.sha256sum] = "f0cd5fcc94d81f40207c39c0035eb196ae2e0b50ed991d86f39ad85e134940d4"
RDEPENDS:langpacks-core-ia = " \
 default-fonts-ia \
"

URI_langpacks-core-id = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-id-4.1-3.el10.noarch.rpm;name=langpacks-core-id;unpack=0"
SRC_URI += "${URI_langpacks-core-id}"
SRC_URI[langpacks-core-id.sha256sum] = "3c73c5b0f30e6ade0ff4cbebb18a5325f0890ec7bde5b50f8ca93a7a30aa5261"
RDEPENDS:langpacks-core-id = " \
 default-fonts-core-sans \
"

URI_langpacks-core-is = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-is-4.1-3.el10.noarch.rpm;name=langpacks-core-is;unpack=0"
SRC_URI += "${URI_langpacks-core-is}"
SRC_URI[langpacks-core-is.sha256sum] = "534a73b33857f2b50c7f31da87d2f4ec01e90e09b5885e1b7c4a7f84cdd2fa5d"
RDEPENDS:langpacks-core-is = " \
 default-fonts-core-sans \
"

URI_langpacks-core-it = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-it-4.1-3.el10.noarch.rpm;name=langpacks-core-it;unpack=0"
SRC_URI += "${URI_langpacks-core-it}"
SRC_URI[langpacks-core-it.sha256sum] = "c390f34621d78c70903acdd6eefdbbe24c0105e807fe9e280d1ee14667c10678"
RDEPENDS:langpacks-core-it = " \
 default-fonts-core-sans \
"

URI_langpacks-core-iu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-iu-4.1-3.el10.noarch.rpm;name=langpacks-core-iu;unpack=0"
SRC_URI += "${URI_langpacks-core-iu}"
SRC_URI[langpacks-core-iu.sha256sum] = "176b1a24b079069654e26f91198a8b00eee577eb8a2e93043fdf0d11b53716c7"
RDEPENDS:langpacks-core-iu = " \
 default-fonts-iu \
"

URI_langpacks-core-ja = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ja-4.1-3.el10.noarch.rpm;name=langpacks-core-ja;unpack=0"
SRC_URI += "${URI_langpacks-core-ja}"
SRC_URI[langpacks-core-ja.sha256sum] = "0d7cdd8ae2c7b8543bff16ef7448983e4d3dee555e95eb9f293912173d98b5ba"
RDEPENDS:langpacks-core-ja = " \
 default-fonts-cjk-sans \
 ibus-anthy \
"

URI_langpacks-core-ka = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ka-4.1-3.el10.noarch.rpm;name=langpacks-core-ka;unpack=0"
SRC_URI += "${URI_langpacks-core-ka}"
SRC_URI[langpacks-core-ka.sha256sum] = "c7263a520a0cb30624e1d17251cdf0c704a05d823a6dacc00a1650d8d6d39429"
RDEPENDS:langpacks-core-ka = " \
 default-fonts-ka \
"

URI_langpacks-core-kk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-kk-4.1-3.el10.noarch.rpm;name=langpacks-core-kk;unpack=0"
SRC_URI += "${URI_langpacks-core-kk}"
SRC_URI[langpacks-core-kk.sha256sum] = "183831c860eabc6639d141f77c591c6ce71312dba342af4c0e34bedf595804de"
RDEPENDS:langpacks-core-kk = " \
 default-fonts-core-sans \
"

URI_langpacks-core-km = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-km-4.1-3.el10.noarch.rpm;name=langpacks-core-km;unpack=0"
SRC_URI += "${URI_langpacks-core-km}"
SRC_URI[langpacks-core-km.sha256sum] = "c3ce1f398f64c8e47504e83a0f0e2e179405f423f6cb8652899b9e8f005ed40e"
RDEPENDS:langpacks-core-km = " \
 default-fonts-km \
"

URI_langpacks-core-kn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-kn-4.1-3.el10.noarch.rpm;name=langpacks-core-kn;unpack=0"
SRC_URI += "${URI_langpacks-core-kn}"
SRC_URI[langpacks-core-kn.sha256sum] = "653773fe8e8644dfa1a052240fb2405b83791d1bd566917bcc3a8bdb9ea2b84c"
RDEPENDS:langpacks-core-kn = " \
 ibus-m17n \
 default-fonts-kn \
"

URI_langpacks-core-ko = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ko-4.1-3.el10.noarch.rpm;name=langpacks-core-ko;unpack=0"
SRC_URI += "${URI_langpacks-core-ko}"
SRC_URI[langpacks-core-ko.sha256sum] = "c7d30e492c5e59002a382e87095ac28636b191b6938045d9a4224cf216d4b2dc"
RDEPENDS:langpacks-core-ko = " \
 default-fonts-cjk-sans \
 ibus-hangul \
"

URI_langpacks-core-ku = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ku-4.1-3.el10.noarch.rpm;name=langpacks-core-ku;unpack=0"
SRC_URI += "${URI_langpacks-core-ku}"
SRC_URI[langpacks-core-ku.sha256sum] = "16221abba2d1067a4b1f7a7f4a43cb293c59f0c6101a05cbaea9bbcc58bbf00c"
RDEPENDS:langpacks-core-ku = " \
 default-fonts-ku \
"

URI_langpacks-core-lo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-lo-4.1-3.el10.noarch.rpm;name=langpacks-core-lo;unpack=0"
SRC_URI += "${URI_langpacks-core-lo}"
SRC_URI[langpacks-core-lo.sha256sum] = "9bf898fdcafb117d5f3dfa2f053cdb039e2272212deef666ec73e18928ca4a00"
RDEPENDS:langpacks-core-lo = " \
 default-fonts-lo \
"

URI_langpacks-core-lt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-lt-4.1-3.el10.noarch.rpm;name=langpacks-core-lt;unpack=0"
SRC_URI += "${URI_langpacks-core-lt}"
SRC_URI[langpacks-core-lt.sha256sum] = "8923da43bc6390b0f5d3047bec810d1d7d528a65a1be1ed2f839397ffc2036ca"
RDEPENDS:langpacks-core-lt = " \
 default-fonts-core-sans \
"

URI_langpacks-core-lv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-lv-4.1-3.el10.noarch.rpm;name=langpacks-core-lv;unpack=0"
SRC_URI += "${URI_langpacks-core-lv}"
SRC_URI[langpacks-core-lv.sha256sum] = "40e36a8fbe3d74b4a01b99d7e906c3f43288f7f0a00981be786f0d815a6fe77d"
RDEPENDS:langpacks-core-lv = " \
 default-fonts-core-sans \
"

URI_langpacks-core-mai = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-mai-4.1-3.el10.noarch.rpm;name=langpacks-core-mai;unpack=0"
SRC_URI += "${URI_langpacks-core-mai}"
SRC_URI[langpacks-core-mai.sha256sum] = "3399ceabd4d402be3728d756dbe1eadddef7068b67b10e3bfdf02924773b15b8"
RDEPENDS:langpacks-core-mai = " \
 ibus-m17n \
 default-fonts-mai \
"

URI_langpacks-core-mk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-mk-4.1-3.el10.noarch.rpm;name=langpacks-core-mk;unpack=0"
SRC_URI += "${URI_langpacks-core-mk}"
SRC_URI[langpacks-core-mk.sha256sum] = "782126f38dd83974d185a56457fd00ba9a7f2bf9af2b96b709b5c63c301e9af7"
RDEPENDS:langpacks-core-mk = " \
 default-fonts-core-sans \
"

URI_langpacks-core-ml = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ml-4.1-3.el10.noarch.rpm;name=langpacks-core-ml;unpack=0"
SRC_URI += "${URI_langpacks-core-ml}"
SRC_URI[langpacks-core-ml.sha256sum] = "0bf24e799260ad8c8920f8807af9a156258555eafe8a9ab87646b7b5dccaaf88"
RDEPENDS:langpacks-core-ml = " \
 ibus-m17n \
 default-fonts-ml \
"

URI_langpacks-core-mni = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-mni-4.1-3.el10.noarch.rpm;name=langpacks-core-mni;unpack=0"
SRC_URI += "${URI_langpacks-core-mni}"
SRC_URI[langpacks-core-mni.sha256sum] = "ae78d44768f074af3878f582daede7036c552ae9be10175955990c17daa62d9d"
RDEPENDS:langpacks-core-mni = " \
 default-fonts-mni \
 ibus-m17n \
"

URI_langpacks-core-mr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-mr-4.1-3.el10.noarch.rpm;name=langpacks-core-mr;unpack=0"
SRC_URI += "${URI_langpacks-core-mr}"
SRC_URI[langpacks-core-mr.sha256sum] = "6419f277e5ddf5e67bd91ae742187b1c8eb5339ccc70cd5f6dfd35d8d125784b"
RDEPENDS:langpacks-core-mr = " \
 default-fonts-mr \
 ibus-m17n \
"

URI_langpacks-core-ms = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ms-4.1-3.el10.noarch.rpm;name=langpacks-core-ms;unpack=0"
SRC_URI += "${URI_langpacks-core-ms}"
SRC_URI[langpacks-core-ms.sha256sum] = "002b5ca94ba78f33ab7eed58fca6d08023004266d5f417bf1eeaac55c8e81b7a"
RDEPENDS:langpacks-core-ms = " \
 default-fonts-core-sans \
"

URI_langpacks-core-my = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-my-4.1-3.el10.noarch.rpm;name=langpacks-core-my;unpack=0"
SRC_URI += "${URI_langpacks-core-my}"
SRC_URI[langpacks-core-my.sha256sum] = "8c5e6ad57e96e904cf793748a6c0b94fbdc782257291eadaa903cf013155c718"
RDEPENDS:langpacks-core-my = " \
 default-fonts-my \
"

URI_langpacks-core-nb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-nb-4.1-3.el10.noarch.rpm;name=langpacks-core-nb;unpack=0"
SRC_URI += "${URI_langpacks-core-nb}"
SRC_URI[langpacks-core-nb.sha256sum] = "c08b4d299949ac7ea7d49ce0b7f9ad84a914fc991f6f567634328b1fd9c59fb6"
RDEPENDS:langpacks-core-nb = " \
 default-fonts-nb \
"

URI_langpacks-core-ne = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ne-4.1-3.el10.noarch.rpm;name=langpacks-core-ne;unpack=0"
SRC_URI += "${URI_langpacks-core-ne}"
SRC_URI[langpacks-core-ne.sha256sum] = "54668fdbb1d615a6d38a6c4be6d7b9cc9b6ef0c66eb89890f012872c301c6281"
RDEPENDS:langpacks-core-ne = " \
 ibus-m17n \
 default-fonts-ne \
"

URI_langpacks-core-nl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-nl-4.1-3.el10.noarch.rpm;name=langpacks-core-nl;unpack=0"
SRC_URI += "${URI_langpacks-core-nl}"
SRC_URI[langpacks-core-nl.sha256sum] = "e61de655bc025c7d1f317963d8747ab278b0f8ac5f74226733a336726ec82568"
RDEPENDS:langpacks-core-nl = " \
 default-fonts-core-sans \
"

URI_langpacks-core-nn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-nn-4.1-3.el10.noarch.rpm;name=langpacks-core-nn;unpack=0"
SRC_URI += "${URI_langpacks-core-nn}"
SRC_URI[langpacks-core-nn.sha256sum] = "c0653ac8419d32a702472fc1e2e1420e43bd914813d37ce39349132d4b149af8"
RDEPENDS:langpacks-core-nn = " \
 default-fonts-nn \
"

URI_langpacks-core-nr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-nr-4.1-3.el10.noarch.rpm;name=langpacks-core-nr;unpack=0"
SRC_URI += "${URI_langpacks-core-nr}"
SRC_URI[langpacks-core-nr.sha256sum] = "87e1de74bef890b507c4ea8347f50e8d69490a412734c2edbedf07449f76e9c6"
RDEPENDS:langpacks-core-nr = " \
 default-fonts-nr \
"

URI_langpacks-core-nso = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-nso-4.1-3.el10.noarch.rpm;name=langpacks-core-nso;unpack=0"
SRC_URI += "${URI_langpacks-core-nso}"
SRC_URI[langpacks-core-nso.sha256sum] = "5e6e65d033edaa1d51f325eb355341d26e31d1a15c96b204ce6c1b612eb3b20b"
RDEPENDS:langpacks-core-nso = " \
 default-fonts-nso \
"

URI_langpacks-core-or = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-or-4.1-3.el10.noarch.rpm;name=langpacks-core-or;unpack=0"
SRC_URI += "${URI_langpacks-core-or}"
SRC_URI[langpacks-core-or.sha256sum] = "1bb49d375d5c318d316624f0afefde091ed7af4d99f14d497d782c4c167e566e"
RDEPENDS:langpacks-core-or = " \
 default-fonts-or \
 ibus-m17n \
"

URI_langpacks-core-pa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-pa-4.1-3.el10.noarch.rpm;name=langpacks-core-pa;unpack=0"
SRC_URI += "${URI_langpacks-core-pa}"
SRC_URI[langpacks-core-pa.sha256sum] = "9b8f88b8ed61483ef35e9ede10e0c3fc55f097668bd9ce30b682713d146c4ede"
RDEPENDS:langpacks-core-pa = " \
 ibus-m17n \
 default-fonts-pa \
"

URI_langpacks-core-pl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-pl-4.1-3.el10.noarch.rpm;name=langpacks-core-pl;unpack=0"
SRC_URI += "${URI_langpacks-core-pl}"
SRC_URI[langpacks-core-pl.sha256sum] = "f5b03495cee3b611c2129be8512de393467806d4f71d75c86472d353c587a8d8"
RDEPENDS:langpacks-core-pl = " \
 default-fonts-core-sans \
"

URI_langpacks-core-pt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-pt-4.1-3.el10.noarch.rpm;name=langpacks-core-pt;unpack=0"
SRC_URI += "${URI_langpacks-core-pt}"
SRC_URI[langpacks-core-pt.sha256sum] = "3fcea63fdd3a309a86816c61da03572476b3697309f621260f0be2c7c5382c42"
RDEPENDS:langpacks-core-pt = " \
 default-fonts-core-sans \
"

URI_langpacks-core-pt_BR = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-pt_BR-4.1-3.el10.noarch.rpm;name=langpacks-core-pt_BR;unpack=0"
SRC_URI += "${URI_langpacks-core-pt_BR}"
SRC_URI[langpacks-core-pt_BR.sha256sum] = "546832fca0832f4642e6fb38ec433ad535fc684502391077fd060df4fb5bc362"
RDEPENDS:langpacks-core-pt_BR = " \
 default-fonts-core-sans \
"

URI_langpacks-core-ro = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ro-4.1-3.el10.noarch.rpm;name=langpacks-core-ro;unpack=0"
SRC_URI += "${URI_langpacks-core-ro}"
SRC_URI[langpacks-core-ro.sha256sum] = "e732bbc99aaca0140b3cd7078755532931d2ee07afcd747b95c94ea38a3a9797"
RDEPENDS:langpacks-core-ro = " \
 default-fonts-core-sans \
"

URI_langpacks-core-ru = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ru-4.1-3.el10.noarch.rpm;name=langpacks-core-ru;unpack=0"
SRC_URI += "${URI_langpacks-core-ru}"
SRC_URI[langpacks-core-ru.sha256sum] = "ff0cb1cc2b8e89fe74ec442bdf9c101be0b21530892e81ad7ce83d3fbb7154ee"
RDEPENDS:langpacks-core-ru = " \
 default-fonts-ru \
"

URI_langpacks-core-sat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-sat-4.1-3.el10.noarch.rpm;name=langpacks-core-sat;unpack=0"
SRC_URI += "${URI_langpacks-core-sat}"
SRC_URI[langpacks-core-sat.sha256sum] = "a119ca89b3713c79791471ff0e6e1b1ef419376e0f830070b3cb45a2281f54c0"
RDEPENDS:langpacks-core-sat = " \
 ibus-m17n \
 default-fonts-sat \
"

URI_langpacks-core-si = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-si-4.1-3.el10.noarch.rpm;name=langpacks-core-si;unpack=0"
SRC_URI += "${URI_langpacks-core-si}"
SRC_URI[langpacks-core-si.sha256sum] = "a1ab026b117601698b1c454bbe5475ca70fb2126937ee1aaf2818dcda5769b04"
RDEPENDS:langpacks-core-si = " \
 default-fonts-si \
 ibus-m17n \
"

URI_langpacks-core-sk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-sk-4.1-3.el10.noarch.rpm;name=langpacks-core-sk;unpack=0"
SRC_URI += "${URI_langpacks-core-sk}"
SRC_URI[langpacks-core-sk.sha256sum] = "9c2b612d56e223376df55953963d9ba8f2f15d9fffbef1fb0cadb980ee4d1f8a"
RDEPENDS:langpacks-core-sk = " \
 default-fonts-core-sans \
"

URI_langpacks-core-sl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-sl-4.1-3.el10.noarch.rpm;name=langpacks-core-sl;unpack=0"
SRC_URI += "${URI_langpacks-core-sl}"
SRC_URI[langpacks-core-sl.sha256sum] = "6e0827da4408bf50321fd0c5946bfd5554f83ccfe2784ab54a31323f2a022b58"
RDEPENDS:langpacks-core-sl = " \
 default-fonts-core-sans \
"

URI_langpacks-core-sq = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-sq-4.1-3.el10.noarch.rpm;name=langpacks-core-sq;unpack=0"
SRC_URI += "${URI_langpacks-core-sq}"
SRC_URI[langpacks-core-sq.sha256sum] = "be117075d30e7aff2c2f4817a0aa6aed6e18b56bd6cbc119bbce917a48f73382"
RDEPENDS:langpacks-core-sq = " \
 default-fonts-core-sans \
"

URI_langpacks-core-sr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-sr-4.1-3.el10.noarch.rpm;name=langpacks-core-sr;unpack=0"
SRC_URI += "${URI_langpacks-core-sr}"
SRC_URI[langpacks-core-sr.sha256sum] = "19588e955295c05236f47b6bc754d00bae4f279279e050e16ba533e6bd4efff2"
RDEPENDS:langpacks-core-sr = " \
 default-fonts-core-sans \
"

URI_langpacks-core-ss = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ss-4.1-3.el10.noarch.rpm;name=langpacks-core-ss;unpack=0"
SRC_URI += "${URI_langpacks-core-ss}"
SRC_URI[langpacks-core-ss.sha256sum] = "cd6119d905d53ce95f5123f5a14c88fdad8f6bbf6e659e0656bf347aac13a268"
RDEPENDS:langpacks-core-ss = " \
 default-fonts-ss \
"

URI_langpacks-core-sv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-sv-4.1-3.el10.noarch.rpm;name=langpacks-core-sv;unpack=0"
SRC_URI += "${URI_langpacks-core-sv}"
SRC_URI[langpacks-core-sv.sha256sum] = "aef67055b4aa2350fc3a5baa5f56c554a735b9fd25b770aed176847f6bdcb89e"
RDEPENDS:langpacks-core-sv = " \
 default-fonts-core-sans \
"

URI_langpacks-core-ta = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ta-4.1-3.el10.noarch.rpm;name=langpacks-core-ta;unpack=0"
SRC_URI += "${URI_langpacks-core-ta}"
SRC_URI[langpacks-core-ta.sha256sum] = "0bb4a2d76e9359ca6d26aeef139ff2636b8b4e8f7d78ab72f63f655013255d2c"
RDEPENDS:langpacks-core-ta = " \
 ibus-m17n \
 default-fonts-ta \
"

URI_langpacks-core-te = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-te-4.1-3.el10.noarch.rpm;name=langpacks-core-te;unpack=0"
SRC_URI += "${URI_langpacks-core-te}"
SRC_URI[langpacks-core-te.sha256sum] = "e208cade15b3f1c4cd7b580c1c1c69bfaadf02ffd54db0ec199ececdc6d5a5ed"
RDEPENDS:langpacks-core-te = " \
 ibus-m17n \
 default-fonts-te \
"

URI_langpacks-core-th = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-th-4.1-3.el10.noarch.rpm;name=langpacks-core-th;unpack=0"
SRC_URI += "${URI_langpacks-core-th}"
SRC_URI[langpacks-core-th.sha256sum] = "07af5c6f384e5b660dc5f5e399aa7a3d8b038bf59f89ad653699ddbb3b3b2402"
RDEPENDS:langpacks-core-th = " \
 ibus-m17n \
 default-fonts-th \
"

URI_langpacks-core-tn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-tn-4.1-3.el10.noarch.rpm;name=langpacks-core-tn;unpack=0"
SRC_URI += "${URI_langpacks-core-tn}"
SRC_URI[langpacks-core-tn.sha256sum] = "b290b75defbe39f1f651d11d7ea83f9fd887f8e56eb8f9324097ace7f519a9cf"
RDEPENDS:langpacks-core-tn = " \
 default-fonts-tn \
"

URI_langpacks-core-tr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-tr-4.1-3.el10.noarch.rpm;name=langpacks-core-tr;unpack=0"
SRC_URI += "${URI_langpacks-core-tr}"
SRC_URI[langpacks-core-tr.sha256sum] = "27639e5c0e726e3d2866222f1abb46977c63ad2d962cb842398d0ea22b241abf"
RDEPENDS:langpacks-core-tr = " \
 default-fonts-core-sans \
"

URI_langpacks-core-ts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ts-4.1-3.el10.noarch.rpm;name=langpacks-core-ts;unpack=0"
SRC_URI += "${URI_langpacks-core-ts}"
SRC_URI[langpacks-core-ts.sha256sum] = "0313e9c8744371b8dd7762d4aab641caa29eb4fde441bec093aeb7d618fb72ff"
RDEPENDS:langpacks-core-ts = " \
 default-fonts-ts \
"

URI_langpacks-core-uk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-uk-4.1-3.el10.noarch.rpm;name=langpacks-core-uk;unpack=0"
SRC_URI += "${URI_langpacks-core-uk}"
SRC_URI[langpacks-core-uk.sha256sum] = "be0bbf88870704eb7d6e1bc433a67832517bbf4ff0c53099c1269e74604ba8d6"
RDEPENDS:langpacks-core-uk = " \
 default-fonts-uk \
"

URI_langpacks-core-ur = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ur-4.1-3.el10.noarch.rpm;name=langpacks-core-ur;unpack=0"
SRC_URI += "${URI_langpacks-core-ur}"
SRC_URI[langpacks-core-ur.sha256sum] = "3759f28f0c9662c8338f809051694c1ef908c2bf1591d09456b8ef78a560becf"
RDEPENDS:langpacks-core-ur = " \
 default-fonts-ur \
 ibus-m17n \
"

URI_langpacks-core-ve = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-ve-4.1-3.el10.noarch.rpm;name=langpacks-core-ve;unpack=0"
SRC_URI += "${URI_langpacks-core-ve}"
SRC_URI[langpacks-core-ve.sha256sum] = "16a376f40ed8f12819e1b565cef5458c7d20d280865a7e2624e4ad62abcbbf1f"
RDEPENDS:langpacks-core-ve = " \
 default-fonts-ve \
"

URI_langpacks-core-vi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-vi-4.1-3.el10.noarch.rpm;name=langpacks-core-vi;unpack=0"
SRC_URI += "${URI_langpacks-core-vi}"
SRC_URI[langpacks-core-vi.sha256sum] = "764abc13c3a811bf5bd46932f924534f71168fc124ec5bed310309ec5f1d70b6"
RDEPENDS:langpacks-core-vi = " \
 ibus-m17n \
 default-fonts-vi \
"

URI_langpacks-core-xh = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-xh-4.1-3.el10.noarch.rpm;name=langpacks-core-xh;unpack=0"
SRC_URI += "${URI_langpacks-core-xh}"
SRC_URI[langpacks-core-xh.sha256sum] = "eb7dc00c6a36e512b37ec2a008c734f798546bac0946cd36b6ddcc88285b35d7"
RDEPENDS:langpacks-core-xh = " \
 default-fonts-xh \
"

URI_langpacks-core-yi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-yi-4.1-3.el10.noarch.rpm;name=langpacks-core-yi;unpack=0"
SRC_URI += "${URI_langpacks-core-yi}"
SRC_URI[langpacks-core-yi.sha256sum] = "55a97e3cf24f5117fed2be6939cb8b88a1234d69e2fe76f9dff58802081abaf9"
RDEPENDS:langpacks-core-yi = " \
 default-fonts-yi \
"

URI_langpacks-core-zh_CN = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-zh_CN-4.1-3.el10.noarch.rpm;name=langpacks-core-zh_CN;unpack=0"
SRC_URI += "${URI_langpacks-core-zh_CN}"
SRC_URI[langpacks-core-zh_CN.sha256sum] = "ffb0bdf925cad0d9ce952a5b555b6c0ab3d0ce0a13ea5fda5c03e3ea16b5b021"
RDEPENDS:langpacks-core-zh_CN = " \
 default-fonts-cjk-sans \
 ibus-libpinyin \
"

URI_langpacks-core-zh_HK = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-zh_HK-4.1-3.el10.noarch.rpm;name=langpacks-core-zh_HK;unpack=0"
SRC_URI += "${URI_langpacks-core-zh_HK}"
SRC_URI[langpacks-core-zh_HK.sha256sum] = "bbec3c3a5a21f4b2e208d762d841b0920646efabb715b295f8b5569434743350"
RDEPENDS:langpacks-core-zh_HK = " \
 default-fonts-cjk-sans \
 ibus-table-chinese-cangjie \
"

URI_langpacks-core-zh_TW = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-zh_TW-4.1-3.el10.noarch.rpm;name=langpacks-core-zh_TW;unpack=0"
SRC_URI += "${URI_langpacks-core-zh_TW}"
SRC_URI[langpacks-core-zh_TW.sha256sum] = "a08c0e878341aba3263942744079b4c9249fcbb245064252ea7f93ff0ffd8a6e"
RDEPENDS:langpacks-core-zh_TW = " \
 default-fonts-cjk-sans \
 ibus-libzhuyin \
"

URI_langpacks-core-zu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-core-zu-4.1-3.el10.noarch.rpm;name=langpacks-core-zu;unpack=0"
SRC_URI += "${URI_langpacks-core-zu}"
SRC_URI[langpacks-core-zu.sha256sum] = "4112640a4d1c300f4db708e487f10ee4173e1cbfadacee51c849b7a23e500df0"
RDEPENDS:langpacks-core-zu = " \
 default-fonts-zu \
"

URI_langpacks-cs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-cs-4.1-3.el10.noarch.rpm;name=langpacks-cs;unpack=0"
SRC_URI += "${URI_langpacks-cs}"
SRC_URI[langpacks-cs.sha256sum] = "278e7155d51b2ebeab4c13a79bfc9626c307f373f9134a49a0a910c2c3d81a55"
RDEPENDS:langpacks-cs = " \
 langpacks-fonts-cs \
 langpacks-core-cs \
"

URI_langpacks-cy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-cy-4.1-3.el10.noarch.rpm;name=langpacks-cy;unpack=0"
SRC_URI += "${URI_langpacks-cy}"
SRC_URI[langpacks-cy.sha256sum] = "9f7ff165e860e0a7a6c44b53912caf855909bac204a2dc07a80155198d19a667"
RDEPENDS:langpacks-cy = " \
 langpacks-fonts-cy \
 langpacks-core-cy \
"

URI_langpacks-da = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-da-4.1-3.el10.noarch.rpm;name=langpacks-da;unpack=0"
SRC_URI += "${URI_langpacks-da}"
SRC_URI[langpacks-da.sha256sum] = "c8b18d5b34a6af2558e2ef6f4c9d011b8ecf57b23dcbd1a24ac38e11dd95fc35"
RDEPENDS:langpacks-da = " \
 langpacks-fonts-da \
 langpacks-core-da \
"

URI_langpacks-de = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-de-4.1-3.el10.noarch.rpm;name=langpacks-de;unpack=0"
SRC_URI += "${URI_langpacks-de}"
SRC_URI[langpacks-de.sha256sum] = "8106cbb599a70a0a6870d2bc205f232ef1aab8600135c1af5e7d6643ac7f186b"
RDEPENDS:langpacks-de = " \
 langpacks-core-de \
 langpacks-fonts-de \
"

URI_langpacks-dv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-dv-4.1-3.el10.noarch.rpm;name=langpacks-dv;unpack=0"
SRC_URI += "${URI_langpacks-dv}"
SRC_URI[langpacks-dv.sha256sum] = "d134a9182f9339901181ab5529bfb6fcd36d6ec74f72a2c895d7efbc28a790e2"
RDEPENDS:langpacks-dv = " \
 langpacks-fonts-dv \
 langpacks-core-dv \
"

URI_langpacks-dz = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-dz-4.1-3.el10.noarch.rpm;name=langpacks-dz;unpack=0"
SRC_URI += "${URI_langpacks-dz}"
SRC_URI[langpacks-dz.sha256sum] = "25ea590e31df3d5200daf307d3bf668812d1b1bb9680013c3cd2430b2caac191"
RDEPENDS:langpacks-dz = " \
 langpacks-fonts-dz \
 langpacks-core-dz \
"

URI_langpacks-el = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-el-4.1-3.el10.noarch.rpm;name=langpacks-el;unpack=0"
SRC_URI += "${URI_langpacks-el}"
SRC_URI[langpacks-el.sha256sum] = "998b8106ad0dece14e304644b1c1cc45b57abee8e79dc84472767a12041a589d"
RDEPENDS:langpacks-el = " \
 langpacks-fonts-el \
 langpacks-core-el \
"

URI_langpacks-en = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-en-4.1-3.el10.noarch.rpm;name=langpacks-en;unpack=0"
SRC_URI += "${URI_langpacks-en}"
SRC_URI[langpacks-en.sha256sum] = "24ef4d2701f14e07508d8a5c6ef8d8d4fadd9e002558258d83b7ac1cd1bba0e9"
RDEPENDS:langpacks-en = " \
 langpacks-fonts-en \
 langpacks-core-en \
"

URI_langpacks-en_GB = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-en_GB-4.1-3.el10.noarch.rpm;name=langpacks-en_GB;unpack=0"
SRC_URI += "${URI_langpacks-en_GB}"
SRC_URI[langpacks-en_GB.sha256sum] = "25cc1125bec4a3e8d2e8c5d9016b2c9ae92de24fd92d9d8a51ad603c8d8d54a8"
RDEPENDS:langpacks-en_GB = " \
 langpacks-fonts-en \
 langpacks-core-en_GB \
"

URI_langpacks-eo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-eo-4.1-3.el10.noarch.rpm;name=langpacks-eo;unpack=0"
SRC_URI += "${URI_langpacks-eo}"
SRC_URI[langpacks-eo.sha256sum] = "fbd688e8d58aab3909cb3c8158ce0589232647ce0cb4301354b2a5c53df7f015"
RDEPENDS:langpacks-eo = " \
 langpacks-fonts-eo \
 langpacks-core-eo \
"

URI_langpacks-es = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-es-4.1-3.el10.noarch.rpm;name=langpacks-es;unpack=0"
SRC_URI += "${URI_langpacks-es}"
SRC_URI[langpacks-es.sha256sum] = "ee66b4a5bad78053098e635eb4a79cf5e2d8c4bc1fcf5747224f6dec3cab844c"
RDEPENDS:langpacks-es = " \
 langpacks-fonts-es \
 langpacks-core-es \
"

URI_langpacks-et = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-et-4.1-3.el10.noarch.rpm;name=langpacks-et;unpack=0"
SRC_URI += "${URI_langpacks-et}"
SRC_URI[langpacks-et.sha256sum] = "ae87ed6245b1042958fcc6853fc8f70066e6cb5d2f55c573db15a9f2bc1e47e2"
RDEPENDS:langpacks-et = " \
 langpacks-core-et \
 langpacks-fonts-et \
"

URI_langpacks-eu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-eu-4.1-3.el10.noarch.rpm;name=langpacks-eu;unpack=0"
SRC_URI += "${URI_langpacks-eu}"
SRC_URI[langpacks-eu.sha256sum] = "cd9d7ff2440e7eeeb9c767c133410d42cc0e82a91a57bdb161a07944ec42ea3d"
RDEPENDS:langpacks-eu = " \
 langpacks-core-eu \
 langpacks-fonts-eu \
"

URI_langpacks-fa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fa-4.1-3.el10.noarch.rpm;name=langpacks-fa;unpack=0"
SRC_URI += "${URI_langpacks-fa}"
SRC_URI[langpacks-fa.sha256sum] = "31531d0ba71d2527e36b6df3c9141613d50a2510d6c77fe1f4e38d31e85e492f"
RDEPENDS:langpacks-fa = " \
 langpacks-fonts-fa \
 langpacks-core-fa \
"

URI_langpacks-fi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fi-4.1-3.el10.noarch.rpm;name=langpacks-fi;unpack=0"
SRC_URI += "${URI_langpacks-fi}"
SRC_URI[langpacks-fi.sha256sum] = "ddf63241d1d0cc9b47862e9f5152086f5dc9e44dac5adb40496c281f4f28f190"
RDEPENDS:langpacks-fi = " \
 langpacks-fonts-fi \
 langpacks-core-fi \
"

URI_langpacks-fonts-af = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-af-4.1-3.el10.noarch.rpm;name=langpacks-fonts-af;unpack=0"
SRC_URI += "${URI_langpacks-fonts-af}"
SRC_URI[langpacks-fonts-af.sha256sum] = "d5248f5f982a5035e0717017e62a83733c387d7e4846f0a82a856ff78cfdebd3"
RDEPENDS:langpacks-fonts-af = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-am = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-am-4.1-3.el10.noarch.rpm;name=langpacks-fonts-am;unpack=0"
SRC_URI += "${URI_langpacks-fonts-am}"
SRC_URI[langpacks-fonts-am.sha256sum] = "42d0e54cc95f5ca8302ed4449ee8922a94f3ca87ef1a02a012f384147b1f5f15"
RDEPENDS:langpacks-fonts-am = " \
 google-noto-serif-ethiopic-vf-fonts \
 default-fonts-am \
"

URI_langpacks-fonts-ar = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ar-4.1-3.el10.noarch.rpm;name=langpacks-fonts-ar;unpack=0"
SRC_URI += "${URI_langpacks-fonts-ar}"
SRC_URI[langpacks-fonts-ar.sha256sum] = "5d5ac8b391f53d6b18ecb318ddd9049650b85916cbf43fb3db4dd7a5aa69d1f6"
RDEPENDS:langpacks-fonts-ar = " \
 google-noto-naskh-arabic-vf-fonts \
 default-fonts-ar \
"

URI_langpacks-fonts-as = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-as-4.1-3.el10.noarch.rpm;name=langpacks-fonts-as;unpack=0"
SRC_URI += "${URI_langpacks-fonts-as}"
SRC_URI[langpacks-fonts-as.sha256sum] = "3bf56fa4ba07a0e423fb26b5780c768f5091aa7261e0a2a6f8fefbc450c3ebe8"
RDEPENDS:langpacks-fonts-as = " \
 google-noto-serif-bengali-vf-fonts \
 default-fonts-as \
"

URI_langpacks-fonts-ast = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ast-4.1-3.el10.noarch.rpm;name=langpacks-fonts-ast;unpack=0"
SRC_URI += "${URI_langpacks-fonts-ast}"
SRC_URI[langpacks-fonts-ast.sha256sum] = "254c7039bc0cb533bc4865e0174c3ebd9c3053a36545947c7e5b368688dd5d37"
RDEPENDS:langpacks-fonts-ast = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 redhat-mono-vf-fonts \
 default-fonts-ast \
"

URI_langpacks-fonts-be = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-be-4.1-3.el10.noarch.rpm;name=langpacks-fonts-be;unpack=0"
SRC_URI += "${URI_langpacks-fonts-be}"
SRC_URI[langpacks-fonts-be.sha256sum] = "04cf166c743efd008b67a0ac7508c7dead142dda9a80c281a7b4a8a561fdefc8"
RDEPENDS:langpacks-fonts-be = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 redhat-mono-vf-fonts \
 default-fonts-be \
"

URI_langpacks-fonts-bg = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-bg-4.1-3.el10.noarch.rpm;name=langpacks-fonts-bg;unpack=0"
SRC_URI += "${URI_langpacks-fonts-bg}"
SRC_URI[langpacks-fonts-bg.sha256sum] = "8e798b2c36d2396a79906387cffe3a9068efa5c882d29982796d517683732ec5"
RDEPENDS:langpacks-fonts-bg = " \
 google-noto-sans-mono-vf-fonts \
 default-fonts-bg \
 google-noto-serif-vf-fonts \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-bn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-bn-4.1-3.el10.noarch.rpm;name=langpacks-fonts-bn;unpack=0"
SRC_URI += "${URI_langpacks-fonts-bn}"
SRC_URI[langpacks-fonts-bn.sha256sum] = "9a0df7a1ab535364f6fc1b6bcfd3d9ab59abb3bfb0e4b2b36304c87bbb034ba5"
RDEPENDS:langpacks-fonts-bn = " \
 default-fonts-bn \
 google-noto-serif-bengali-vf-fonts \
"

URI_langpacks-fonts-bo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-bo-4.1-3.el10.noarch.rpm;name=langpacks-fonts-bo;unpack=0"
SRC_URI += "${URI_langpacks-fonts-bo}"
SRC_URI[langpacks-fonts-bo.sha256sum] = "23e81a5624fd67db51dfeac67efc457b0d15b62022e1c52fba06f047accf35a0"
RDEPENDS:langpacks-fonts-bo = " \
 default-fonts-bo \
"

URI_langpacks-fonts-br = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-br-4.1-3.el10.noarch.rpm;name=langpacks-fonts-br;unpack=0"
SRC_URI += "${URI_langpacks-fonts-br}"
SRC_URI[langpacks-fonts-br.sha256sum] = "917c28fa188d085125fc35b9558c8b59f38bd1c93fd84cec17f51c8062ef90e2"
RDEPENDS:langpacks-fonts-br = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-br \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-bs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-bs-4.1-3.el10.noarch.rpm;name=langpacks-fonts-bs;unpack=0"
SRC_URI += "${URI_langpacks-fonts-bs}"
SRC_URI[langpacks-fonts-bs.sha256sum] = "a870c1cb66f71802d3398cbce9b3f4c02f41db2edbabffb6b1bb1fa42f79086d"
RDEPENDS:langpacks-fonts-bs = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-ca = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ca-4.1-3.el10.noarch.rpm;name=langpacks-fonts-ca;unpack=0"
SRC_URI += "${URI_langpacks-fonts-ca}"
SRC_URI[langpacks-fonts-ca.sha256sum] = "5984b0c7f7d306bd951fec162693b358636b742641fd510e56a613b607d38f9b"
RDEPENDS:langpacks-fonts-ca = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-chr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-chr-4.1-3.el10.noarch.rpm;name=langpacks-fonts-chr;unpack=0"
SRC_URI += "${URI_langpacks-fonts-chr}"
SRC_URI[langpacks-fonts-chr.sha256sum] = "373d66f6f93abe09e927e3bc297e4ace88b0bad40aff60028e53d3e8d09946bb"
RDEPENDS:langpacks-fonts-chr = " \
 default-fonts-chr \
"

URI_langpacks-fonts-cs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-cs-4.1-3.el10.noarch.rpm;name=langpacks-fonts-cs;unpack=0"
SRC_URI += "${URI_langpacks-fonts-cs}"
SRC_URI[langpacks-fonts-cs.sha256sum] = "a61fbbcc347d45adf055e0140a4a572441e9916e7d621035af23dc939454b4b8"
RDEPENDS:langpacks-fonts-cs = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-cy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-cy-4.1-3.el10.noarch.rpm;name=langpacks-fonts-cy;unpack=0"
SRC_URI += "${URI_langpacks-fonts-cy}"
SRC_URI[langpacks-fonts-cy.sha256sum] = "edd02b7a4969c5ccecd8f92595a3ab94ed49ac06781b2177d241a1b1fe84f975"
RDEPENDS:langpacks-fonts-cy = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-da = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-da-4.1-3.el10.noarch.rpm;name=langpacks-fonts-da;unpack=0"
SRC_URI += "${URI_langpacks-fonts-da}"
SRC_URI[langpacks-fonts-da.sha256sum] = "54994cf6b8dd97c3b7ec8f9d94b433fc941d8678bc0e50a88846e14d06d5d175"
RDEPENDS:langpacks-fonts-da = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-de = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-de-4.1-3.el10.noarch.rpm;name=langpacks-fonts-de;unpack=0"
SRC_URI += "${URI_langpacks-fonts-de}"
SRC_URI[langpacks-fonts-de.sha256sum] = "648fb7b043c72add65b85ffb9b3839fe7a30009d459425d2d5d062d48efa4eeb"
RDEPENDS:langpacks-fonts-de = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-dv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-dv-4.1-3.el10.noarch.rpm;name=langpacks-fonts-dv;unpack=0"
SRC_URI += "${URI_langpacks-fonts-dv}"
SRC_URI[langpacks-fonts-dv.sha256sum] = "3effc851ecc829f9ce7424b0992d4cc163391aa7eca8c54b1589f34baea599f5"
RDEPENDS:langpacks-fonts-dv = " \
 default-fonts-dv \
"

URI_langpacks-fonts-dz = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-dz-4.1-3.el10.noarch.rpm;name=langpacks-fonts-dz;unpack=0"
SRC_URI += "${URI_langpacks-fonts-dz}"
SRC_URI[langpacks-fonts-dz.sha256sum] = "2c66072c0f13c62a6875a8bcf9272c641ba5a0f4080d0876b374ed31a32032ea"
RDEPENDS:langpacks-fonts-dz = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 redhat-mono-vf-fonts \
 default-fonts-dz \
"

URI_langpacks-fonts-el = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-el-4.1-3.el10.noarch.rpm;name=langpacks-fonts-el;unpack=0"
SRC_URI += "${URI_langpacks-fonts-el}"
SRC_URI[langpacks-fonts-el.sha256sum] = "d7a1c4e5101c63445683fadfca922f30f51633f0ad35920cb88945475ec7bc5d"
RDEPENDS:langpacks-fonts-el = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 redhat-mono-vf-fonts \
 default-fonts-el \
"

URI_langpacks-fonts-en = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-en-4.1-3.el10.noarch.rpm;name=langpacks-fonts-en;unpack=0"
SRC_URI += "${URI_langpacks-fonts-en}"
SRC_URI[langpacks-fonts-en.sha256sum] = "00114a3d2bd335ed1b41857b67f1f5ba6c58c5b2b2a8cfb603e7a469f0da5462"
RDEPENDS:langpacks-fonts-en = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-eo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-eo-4.1-3.el10.noarch.rpm;name=langpacks-fonts-eo;unpack=0"
SRC_URI += "${URI_langpacks-fonts-eo}"
SRC_URI[langpacks-fonts-eo.sha256sum] = "12e7bd3a41b113cff9c5d80bca794875246eec7ded459a5a659ea769f2c4063e"
RDEPENDS:langpacks-fonts-eo = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 redhat-mono-vf-fonts \
 default-fonts-eo \
"

URI_langpacks-fonts-es = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-es-4.1-3.el10.noarch.rpm;name=langpacks-fonts-es;unpack=0"
SRC_URI += "${URI_langpacks-fonts-es}"
SRC_URI[langpacks-fonts-es.sha256sum] = "6266e1ffe85e070b045d206114d96980fcb350fe1540b882b6939785220d4838"
RDEPENDS:langpacks-fonts-es = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-et = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-et-4.1-3.el10.noarch.rpm;name=langpacks-fonts-et;unpack=0"
SRC_URI += "${URI_langpacks-fonts-et}"
SRC_URI[langpacks-fonts-et.sha256sum] = "5658ddf2299822c2c8a2b932426317de506fb6adc3ebf7f06403b70656b8a21d"
RDEPENDS:langpacks-fonts-et = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-eu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-eu-4.1-3.el10.noarch.rpm;name=langpacks-fonts-eu;unpack=0"
SRC_URI += "${URI_langpacks-fonts-eu}"
SRC_URI[langpacks-fonts-eu.sha256sum] = "d48bac15fbeecf5c7208a50d72535dd27f10a419daa23c16c74dc51cd0a0dc46"
RDEPENDS:langpacks-fonts-eu = " \
 google-noto-sans-mono-vf-fonts \
 default-fonts-eu \
 google-noto-serif-vf-fonts \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-fa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-fa-4.1-3.el10.noarch.rpm;name=langpacks-fonts-fa;unpack=0"
SRC_URI += "${URI_langpacks-fonts-fa}"
SRC_URI[langpacks-fonts-fa.sha256sum] = "3ec4767e7715e2fca50e4e22f6a2b76cfd68dd16ecb72b4b24af157f2467661b"
RDEPENDS:langpacks-fonts-fa = " \
 default-fonts-fa \
 google-noto-naskh-arabic-vf-fonts \
"

URI_langpacks-fonts-fi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-fi-4.1-3.el10.noarch.rpm;name=langpacks-fonts-fi;unpack=0"
SRC_URI += "${URI_langpacks-fonts-fi}"
SRC_URI[langpacks-fonts-fi.sha256sum] = "5c75dce1cffdc85d90c23ce129c6a9ec961beca0e8cfa0bbd7618e92ba50bc19"
RDEPENDS:langpacks-fonts-fi = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-fr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-fr-4.1-3.el10.noarch.rpm;name=langpacks-fonts-fr;unpack=0"
SRC_URI += "${URI_langpacks-fonts-fr}"
SRC_URI[langpacks-fonts-fr.sha256sum] = "8c5a95f33cb6dd9559566b65b291cfed29bdc70fb317b75d6ea89199eb70a88f"
RDEPENDS:langpacks-fonts-fr = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-ga = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ga-4.1-3.el10.noarch.rpm;name=langpacks-fonts-ga;unpack=0"
SRC_URI += "${URI_langpacks-fonts-ga}"
SRC_URI[langpacks-fonts-ga.sha256sum] = "525a50c9edcc794b9377aa4150790dfa7790a17cd014b6b24f656927528389de"
RDEPENDS:langpacks-fonts-ga = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-gl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-gl-4.1-3.el10.noarch.rpm;name=langpacks-fonts-gl;unpack=0"
SRC_URI += "${URI_langpacks-fonts-gl}"
SRC_URI[langpacks-fonts-gl.sha256sum] = "02072760c2a14c1cd6891956d68c22305c2d453f6e9aa3c0c10533736d93a3d5"
RDEPENDS:langpacks-fonts-gl = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-gu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-gu-4.1-3.el10.noarch.rpm;name=langpacks-fonts-gu;unpack=0"
SRC_URI += "${URI_langpacks-fonts-gu}"
SRC_URI[langpacks-fonts-gu.sha256sum] = "9bfd9bbe10487d6ba89d6116cd33af64266ef295ddda131688867a376bc7172e"
RDEPENDS:langpacks-fonts-gu = " \
 google-noto-serif-gujarati-vf-fonts \
 default-fonts-gu \
"

URI_langpacks-fonts-he = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-he-4.1-3.el10.noarch.rpm;name=langpacks-fonts-he;unpack=0"
SRC_URI += "${URI_langpacks-fonts-he}"
SRC_URI[langpacks-fonts-he.sha256sum] = "71bdc97c53bcb2dbe9e32585f08422e3cf4f405c7a786d20d7bf284e6ab203bc"
RDEPENDS:langpacks-fonts-he = " \
 default-fonts-he \
 google-noto-serif-hebrew-vf-fonts \
"

URI_langpacks-fonts-hi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-hi-4.1-3.el10.noarch.rpm;name=langpacks-fonts-hi;unpack=0"
SRC_URI += "${URI_langpacks-fonts-hi}"
SRC_URI[langpacks-fonts-hi.sha256sum] = "16afbcec9a565eac2404c06a4c5c9cdee5e33601bfa2abd2963760d0883e56f0"
RDEPENDS:langpacks-fonts-hi = " \
 default-fonts-hi \
 google-noto-serif-devanagari-vf-fonts \
"

URI_langpacks-fonts-hr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-hr-4.1-3.el10.noarch.rpm;name=langpacks-fonts-hr;unpack=0"
SRC_URI += "${URI_langpacks-fonts-hr}"
SRC_URI[langpacks-fonts-hr.sha256sum] = "5f9854040051e2b30d68799e4e3bcc610cb02e8bf37149db39f10ba4dfc20dba"
RDEPENDS:langpacks-fonts-hr = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-hu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-hu-4.1-3.el10.noarch.rpm;name=langpacks-fonts-hu;unpack=0"
SRC_URI += "${URI_langpacks-fonts-hu}"
SRC_URI[langpacks-fonts-hu.sha256sum] = "6f0624ff7ab7426a70eca669ec740c5488ec7813ea551bd7f99d903f739170bf"
RDEPENDS:langpacks-fonts-hu = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-hy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-hy-4.1-3.el10.noarch.rpm;name=langpacks-fonts-hy;unpack=0"
SRC_URI += "${URI_langpacks-fonts-hy}"
SRC_URI[langpacks-fonts-hy.sha256sum] = "87ff92cbf022f4c79af967298ed805a8f4338cdcac3a17aeb4dadb0cb2e40d65"
RDEPENDS:langpacks-fonts-hy = " \
 google-noto-serif-armenian-vf-fonts \
 default-fonts-hy \
"

URI_langpacks-fonts-ia = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ia-4.1-3.el10.noarch.rpm;name=langpacks-fonts-ia;unpack=0"
SRC_URI += "${URI_langpacks-fonts-ia}"
SRC_URI[langpacks-fonts-ia.sha256sum] = "eed9acce99a565845bdec050aee0bd06984058d968222c874235df5cd38549b4"
RDEPENDS:langpacks-fonts-ia = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 redhat-mono-vf-fonts \
 default-fonts-ia \
"

URI_langpacks-fonts-id = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-id-4.1-3.el10.noarch.rpm;name=langpacks-fonts-id;unpack=0"
SRC_URI += "${URI_langpacks-fonts-id}"
SRC_URI[langpacks-fonts-id.sha256sum] = "61a02577f87ed140bf76975bd1b8f5e1141bf216d811cfc1e922d33bac1c7f62"
RDEPENDS:langpacks-fonts-id = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-is = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-is-4.1-3.el10.noarch.rpm;name=langpacks-fonts-is;unpack=0"
SRC_URI += "${URI_langpacks-fonts-is}"
SRC_URI[langpacks-fonts-is.sha256sum] = "f200213954908a07d60f6b6b3fe67aacb9d5c5f3e9592fc13d6eb079e4e9e226"
RDEPENDS:langpacks-fonts-is = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-it = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-it-4.1-3.el10.noarch.rpm;name=langpacks-fonts-it;unpack=0"
SRC_URI += "${URI_langpacks-fonts-it}"
SRC_URI[langpacks-fonts-it.sha256sum] = "100a45b6d19dba88558d4223722fe1ce03f5e4823ce0f425338fe37f1fd1249b"
RDEPENDS:langpacks-fonts-it = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-iu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-iu-4.1-3.el10.noarch.rpm;name=langpacks-fonts-iu;unpack=0"
SRC_URI += "${URI_langpacks-fonts-iu}"
SRC_URI[langpacks-fonts-iu.sha256sum] = "c90c1524675c30f3d81038ce09720a95ec6d26c6243a1585c125d8df87652cba"
RDEPENDS:langpacks-fonts-iu = " \
 default-fonts-iu \
"

URI_langpacks-fonts-ja = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ja-4.1-3.el10.noarch.rpm;name=langpacks-fonts-ja;unpack=0"
SRC_URI += "${URI_langpacks-fonts-ja}"
SRC_URI[langpacks-fonts-ja.sha256sum] = "59dcde481a5331a7fa9fd6dcd398cc6e3741e4cae45de2cb5553c6e5cc9e84e7"
RDEPENDS:langpacks-fonts-ja = " \
 default-fonts-cjk-sans \
 google-noto-sans-mono-cjk-vf-fonts \
 google-noto-serif-cjk-vf-fonts \
"

URI_langpacks-fonts-ka = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ka-4.1-3.el10.noarch.rpm;name=langpacks-fonts-ka;unpack=0"
SRC_URI += "${URI_langpacks-fonts-ka}"
SRC_URI[langpacks-fonts-ka.sha256sum] = "52ddd01649c30be906660937643aa23acf0c13493918e26c1181cb9019c0d9de"
RDEPENDS:langpacks-fonts-ka = " \
 default-fonts-ka \
 google-noto-serif-georgian-vf-fonts \
"

URI_langpacks-fonts-kk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-kk-4.1-3.el10.noarch.rpm;name=langpacks-fonts-kk;unpack=0"
SRC_URI += "${URI_langpacks-fonts-kk}"
SRC_URI[langpacks-fonts-kk.sha256sum] = "be3c29c87a7471aaf4a60e28db81936ad5e1692d708cd62a43f2363e04b4fc1b"
RDEPENDS:langpacks-fonts-kk = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-km = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-km-4.1-3.el10.noarch.rpm;name=langpacks-fonts-km;unpack=0"
SRC_URI += "${URI_langpacks-fonts-km}"
SRC_URI[langpacks-fonts-km.sha256sum] = "bc1bb01ad3631ffc1b8a695744d6936899a2be27b247a75fa398ae3e6f72c8fe"
RDEPENDS:langpacks-fonts-km = " \
 google-noto-serif-khmer-vf-fonts \
 default-fonts-km \
"

URI_langpacks-fonts-kn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-kn-4.1-3.el10.noarch.rpm;name=langpacks-fonts-kn;unpack=0"
SRC_URI += "${URI_langpacks-fonts-kn}"
SRC_URI[langpacks-fonts-kn.sha256sum] = "f08bc9404480076976993e3ee5d8ccbb9dba84860343f4f050ab0ccc29c284f1"
RDEPENDS:langpacks-fonts-kn = " \
 default-fonts-kn \
 google-noto-serif-kannada-vf-fonts \
"

URI_langpacks-fonts-ko = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ko-4.1-3.el10.noarch.rpm;name=langpacks-fonts-ko;unpack=0"
SRC_URI += "${URI_langpacks-fonts-ko}"
SRC_URI[langpacks-fonts-ko.sha256sum] = "db76859dd7827fa256e03c58ffce7d37f26e5bf8c6fef2040030cf21bf5cc650"
RDEPENDS:langpacks-fonts-ko = " \
 default-fonts-cjk-sans \
 google-noto-sans-mono-cjk-vf-fonts \
 google-noto-serif-cjk-vf-fonts \
"

URI_langpacks-fonts-ku = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ku-4.1-3.el10.noarch.rpm;name=langpacks-fonts-ku;unpack=0"
SRC_URI += "${URI_langpacks-fonts-ku}"
SRC_URI[langpacks-fonts-ku.sha256sum] = "90724ee1c5267b049f9600222db1872c90d61b1e26434c55e799a9a82a7edd6f"
RDEPENDS:langpacks-fonts-ku = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-ku \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-lo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-lo-4.1-3.el10.noarch.rpm;name=langpacks-fonts-lo;unpack=0"
SRC_URI += "${URI_langpacks-fonts-lo}"
SRC_URI[langpacks-fonts-lo.sha256sum] = "1ec889f68f76efa2bed440872153d2f6339bb2d104e38abc684cdd0fecfcfd05"
RDEPENDS:langpacks-fonts-lo = " \
 default-fonts-lo \
 google-noto-serif-lao-vf-fonts \
"

URI_langpacks-fonts-lt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-lt-4.1-3.el10.noarch.rpm;name=langpacks-fonts-lt;unpack=0"
SRC_URI += "${URI_langpacks-fonts-lt}"
SRC_URI[langpacks-fonts-lt.sha256sum] = "e31ccdd61688295677ec23388fcaae0036eb0916d0d0a4cb45dc50f0659017e8"
RDEPENDS:langpacks-fonts-lt = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-lv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-lv-4.1-3.el10.noarch.rpm;name=langpacks-fonts-lv;unpack=0"
SRC_URI += "${URI_langpacks-fonts-lv}"
SRC_URI[langpacks-fonts-lv.sha256sum] = "5e729203ff79b42de6bef7da91b73a9ee975abb32817cda8ee79b160845d9be3"
RDEPENDS:langpacks-fonts-lv = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-mai = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-mai-4.1-3.el10.noarch.rpm;name=langpacks-fonts-mai;unpack=0"
SRC_URI += "${URI_langpacks-fonts-mai}"
SRC_URI[langpacks-fonts-mai.sha256sum] = "ed8ae4948e9fbaa486c0ee6a13ada95ba973ef1c06d5028e28c23072da393ce7"
RDEPENDS:langpacks-fonts-mai = " \
 default-fonts-mai \
 google-noto-serif-devanagari-vf-fonts \
"

URI_langpacks-fonts-mk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-mk-4.1-3.el10.noarch.rpm;name=langpacks-fonts-mk;unpack=0"
SRC_URI += "${URI_langpacks-fonts-mk}"
SRC_URI[langpacks-fonts-mk.sha256sum] = "02566072bca9ba75847e36a90be1d00e56072930accf39a0f048907d7698c22f"
RDEPENDS:langpacks-fonts-mk = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-ml = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ml-4.1-3.el10.noarch.rpm;name=langpacks-fonts-ml;unpack=0"
SRC_URI += "${URI_langpacks-fonts-ml}"
SRC_URI[langpacks-fonts-ml.sha256sum] = "9e2fe3b678d2138eb2ec6b6740fb932044fa94790b643a32ad44c72a05320141"
RDEPENDS:langpacks-fonts-ml = " \
 rit-rachana-fonts \
 default-fonts-ml \
"

URI_langpacks-fonts-mni = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-mni-4.1-3.el10.noarch.rpm;name=langpacks-fonts-mni;unpack=0"
SRC_URI += "${URI_langpacks-fonts-mni}"
SRC_URI[langpacks-fonts-mni.sha256sum] = "3896d9b3839ab8fab94b11e4c973cb8082ebcf1517579491f0e2f6edda40954c"
RDEPENDS:langpacks-fonts-mni = " \
 default-fonts-mni \
"

URI_langpacks-fonts-mr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-mr-4.1-3.el10.noarch.rpm;name=langpacks-fonts-mr;unpack=0"
SRC_URI += "${URI_langpacks-fonts-mr}"
SRC_URI[langpacks-fonts-mr.sha256sum] = "a7e4fb473a6aa76e33da8ba1bda473b70297553656bdc1b049ae99c72d640b58"
RDEPENDS:langpacks-fonts-mr = " \
 default-fonts-mr \
 google-noto-serif-devanagari-vf-fonts \
"

URI_langpacks-fonts-ms = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ms-4.1-3.el10.noarch.rpm;name=langpacks-fonts-ms;unpack=0"
SRC_URI += "${URI_langpacks-fonts-ms}"
SRC_URI[langpacks-fonts-ms.sha256sum] = "9e16a79885dfcf121cd87d1ed2d4e10e0654c88904932f0d37fab77db608e063"
RDEPENDS:langpacks-fonts-ms = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-my = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-my-4.1-3.el10.noarch.rpm;name=langpacks-fonts-my;unpack=0"
SRC_URI += "${URI_langpacks-fonts-my}"
SRC_URI[langpacks-fonts-my.sha256sum] = "a90d8f3835f8ab9ef7b83aa493cd928aa55684f93360ed92d7009fdac7d10112"
RDEPENDS:langpacks-fonts-my = " \
 default-fonts-my \
"

URI_langpacks-fonts-nb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-nb-4.1-3.el10.noarch.rpm;name=langpacks-fonts-nb;unpack=0"
SRC_URI += "${URI_langpacks-fonts-nb}"
SRC_URI[langpacks-fonts-nb.sha256sum] = "6f511d45c2b5657a5ab9a47d67d87ccdbb1f70b3c28f88355e83380a03df6ba0"
RDEPENDS:langpacks-fonts-nb = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-nb \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-ne = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ne-4.1-3.el10.noarch.rpm;name=langpacks-fonts-ne;unpack=0"
SRC_URI += "${URI_langpacks-fonts-ne}"
SRC_URI[langpacks-fonts-ne.sha256sum] = "bb6912f4ccea1122ea48107f3cb4ba0c0e8ddaec8fa5d15d53e98e2500c322d9"
RDEPENDS:langpacks-fonts-ne = " \
 default-fonts-ne \
"

URI_langpacks-fonts-nl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-nl-4.1-3.el10.noarch.rpm;name=langpacks-fonts-nl;unpack=0"
SRC_URI += "${URI_langpacks-fonts-nl}"
SRC_URI[langpacks-fonts-nl.sha256sum] = "b58ca20376acdd9e3efac8b6cefede65c6c774c262c663712cadead019bc31e8"
RDEPENDS:langpacks-fonts-nl = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-nn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-nn-4.1-3.el10.noarch.rpm;name=langpacks-fonts-nn;unpack=0"
SRC_URI += "${URI_langpacks-fonts-nn}"
SRC_URI[langpacks-fonts-nn.sha256sum] = "5b01593bed28cf2493d0da8b2c54671611c982b82464eb072e752e057e9675a5"
RDEPENDS:langpacks-fonts-nn = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 redhat-mono-vf-fonts \
 default-fonts-nn \
"

URI_langpacks-fonts-nr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-nr-4.1-3.el10.noarch.rpm;name=langpacks-fonts-nr;unpack=0"
SRC_URI += "${URI_langpacks-fonts-nr}"
SRC_URI[langpacks-fonts-nr.sha256sum] = "a1d3b43ed0c60e527e4ebca3bc95f33b4236f41e77057a1ef2653ea35f5c898e"
RDEPENDS:langpacks-fonts-nr = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 redhat-mono-vf-fonts \
 default-fonts-nr \
"

URI_langpacks-fonts-nso = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-nso-4.1-3.el10.noarch.rpm;name=langpacks-fonts-nso;unpack=0"
SRC_URI += "${URI_langpacks-fonts-nso}"
SRC_URI[langpacks-fonts-nso.sha256sum] = "86145970c93c31c0f5c6368c311c38a72d8d729b6e6fb13e8d428cef395857ce"
RDEPENDS:langpacks-fonts-nso = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 redhat-mono-vf-fonts \
 default-fonts-nso \
"

URI_langpacks-fonts-or = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-or-4.1-3.el10.noarch.rpm;name=langpacks-fonts-or;unpack=0"
SRC_URI += "${URI_langpacks-fonts-or}"
SRC_URI[langpacks-fonts-or.sha256sum] = "36cfd885cb0e589ff0b9c0e5a2cf7d0a086c065f34542a02164007221b2ddde6"
RDEPENDS:langpacks-fonts-or = " \
 default-fonts-or \
 google-noto-serif-oriya-vf-fonts \
"

URI_langpacks-fonts-pa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-pa-4.1-3.el10.noarch.rpm;name=langpacks-fonts-pa;unpack=0"
SRC_URI += "${URI_langpacks-fonts-pa}"
SRC_URI[langpacks-fonts-pa.sha256sum] = "036f989b34a296467257ec9e06401bf60666810ab75f492bf18c55db5fbc69c5"
RDEPENDS:langpacks-fonts-pa = " \
 google-noto-serif-gurmukhi-vf-fonts \
 default-fonts-pa \
"

URI_langpacks-fonts-pl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-pl-4.1-3.el10.noarch.rpm;name=langpacks-fonts-pl;unpack=0"
SRC_URI += "${URI_langpacks-fonts-pl}"
SRC_URI[langpacks-fonts-pl.sha256sum] = "a111676c8e0badcfc249ff02283a7f4e79117c7fbbabe0cba3c46ccb60aeed31"
RDEPENDS:langpacks-fonts-pl = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-pt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-pt-4.1-3.el10.noarch.rpm;name=langpacks-fonts-pt;unpack=0"
SRC_URI += "${URI_langpacks-fonts-pt}"
SRC_URI[langpacks-fonts-pt.sha256sum] = "bcf52446f6d46a567a053a3abae40b45838336ff168fdb9ad23a5b7f8d82643e"
RDEPENDS:langpacks-fonts-pt = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-ro = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ro-4.1-3.el10.noarch.rpm;name=langpacks-fonts-ro;unpack=0"
SRC_URI += "${URI_langpacks-fonts-ro}"
SRC_URI[langpacks-fonts-ro.sha256sum] = "cbe37e4603d591584815c62353cba666edf363062d86e96b876299855e944b57"
RDEPENDS:langpacks-fonts-ro = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-ru = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ru-4.1-3.el10.noarch.rpm;name=langpacks-fonts-ru;unpack=0"
SRC_URI += "${URI_langpacks-fonts-ru}"
SRC_URI[langpacks-fonts-ru.sha256sum] = "cf896414beffecbe0560c50a8880248cfb548393b02dd725f23825fb34f67c9b"
RDEPENDS:langpacks-fonts-ru = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 redhat-mono-vf-fonts \
 default-fonts-ru \
"

URI_langpacks-fonts-sat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-sat-4.1-3.el10.noarch.rpm;name=langpacks-fonts-sat;unpack=0"
SRC_URI += "${URI_langpacks-fonts-sat}"
SRC_URI[langpacks-fonts-sat.sha256sum] = "a3994102d28d791a7f3aaf81ab6c300605beececec4880afc46aa175a92bfe83"
RDEPENDS:langpacks-fonts-sat = " \
 default-fonts-sat \
"

URI_langpacks-fonts-si = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-si-4.1-3.el10.noarch.rpm;name=langpacks-fonts-si;unpack=0"
SRC_URI += "${URI_langpacks-fonts-si}"
SRC_URI[langpacks-fonts-si.sha256sum] = "511bf733a1b345f580232d70f945f6bb21851fbb5055352ee2a4ea36734c1029"
RDEPENDS:langpacks-fonts-si = " \
 default-fonts-si \
 google-noto-serif-sinhala-vf-fonts \
"

URI_langpacks-fonts-sk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-sk-4.1-3.el10.noarch.rpm;name=langpacks-fonts-sk;unpack=0"
SRC_URI += "${URI_langpacks-fonts-sk}"
SRC_URI[langpacks-fonts-sk.sha256sum] = "114d19786b39711dd018b774122c5344bc2be1b6211a09fcff986237fd71e441"
RDEPENDS:langpacks-fonts-sk = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-sl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-sl-4.1-3.el10.noarch.rpm;name=langpacks-fonts-sl;unpack=0"
SRC_URI += "${URI_langpacks-fonts-sl}"
SRC_URI[langpacks-fonts-sl.sha256sum] = "42f6895cda07bedd77750be18663bd23e2d046b897c0f56483fa362f6de91c82"
RDEPENDS:langpacks-fonts-sl = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-sq = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-sq-4.1-3.el10.noarch.rpm;name=langpacks-fonts-sq;unpack=0"
SRC_URI += "${URI_langpacks-fonts-sq}"
SRC_URI[langpacks-fonts-sq.sha256sum] = "a95c332976e6b368006486611dae2a4ce50f27540a290bd8016ec440ee880a20"
RDEPENDS:langpacks-fonts-sq = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-sr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-sr-4.1-3.el10.noarch.rpm;name=langpacks-fonts-sr;unpack=0"
SRC_URI += "${URI_langpacks-fonts-sr}"
SRC_URI[langpacks-fonts-sr.sha256sum] = "6fb461f0fa0f9304c5ab23dc17990353771e947b02b8808f8225d0b476282b2c"
RDEPENDS:langpacks-fonts-sr = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-ss = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ss-4.1-3.el10.noarch.rpm;name=langpacks-fonts-ss;unpack=0"
SRC_URI += "${URI_langpacks-fonts-ss}"
SRC_URI[langpacks-fonts-ss.sha256sum] = "2621c8321cb0c6a3e52ae73a34e093b2cd6541ff2d227be259bf77bfe5e2dd42"
RDEPENDS:langpacks-fonts-ss = " \
 google-noto-sans-mono-vf-fonts \
 default-fonts-ss \
 google-noto-serif-vf-fonts \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-sv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-sv-4.1-3.el10.noarch.rpm;name=langpacks-fonts-sv;unpack=0"
SRC_URI += "${URI_langpacks-fonts-sv}"
SRC_URI[langpacks-fonts-sv.sha256sum] = "e35a41d8ad48b945988e6deb9ccf69bf871ec41e47b60e04affdaac97463b50d"
RDEPENDS:langpacks-fonts-sv = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-ta = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ta-4.1-3.el10.noarch.rpm;name=langpacks-fonts-ta;unpack=0"
SRC_URI += "${URI_langpacks-fonts-ta}"
SRC_URI[langpacks-fonts-ta.sha256sum] = "abc259bde808418d751b4663fd9b209692b037eafcd75c970ef0af37f953ca9b"
RDEPENDS:langpacks-fonts-ta = " \
 default-fonts-ta \
 google-noto-serif-tamil-vf-fonts \
"

URI_langpacks-fonts-te = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-te-4.1-3.el10.noarch.rpm;name=langpacks-fonts-te;unpack=0"
SRC_URI += "${URI_langpacks-fonts-te}"
SRC_URI[langpacks-fonts-te.sha256sum] = "8289f1b27201648615dd0e53d7acd7ae0041dfae964fdc1481595ef9477c5471"
RDEPENDS:langpacks-fonts-te = " \
 default-fonts-te \
 google-noto-serif-telugu-vf-fonts \
"

URI_langpacks-fonts-th = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-th-4.1-3.el10.noarch.rpm;name=langpacks-fonts-th;unpack=0"
SRC_URI += "${URI_langpacks-fonts-th}"
SRC_URI[langpacks-fonts-th.sha256sum] = "32270c6c34b423ca038db29ee340a047b177da68451988f776812e2bad1dd1f0"
RDEPENDS:langpacks-fonts-th = " \
 google-noto-serif-thai-vf-fonts \
 default-fonts-th \
"

URI_langpacks-fonts-tn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-tn-4.1-3.el10.noarch.rpm;name=langpacks-fonts-tn;unpack=0"
SRC_URI += "${URI_langpacks-fonts-tn}"
SRC_URI[langpacks-fonts-tn.sha256sum] = "f7af38e5e1d555561c8d83e43bef9f419ddcd70086fd68cbda6ab998f7d12061"
RDEPENDS:langpacks-fonts-tn = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 redhat-mono-vf-fonts \
 default-fonts-tn \
"

URI_langpacks-fonts-tr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-tr-4.1-3.el10.noarch.rpm;name=langpacks-fonts-tr;unpack=0"
SRC_URI += "${URI_langpacks-fonts-tr}"
SRC_URI[langpacks-fonts-tr.sha256sum] = "76ee53740bd07a477e5d8f283a508b424ca35a8f0b3b8d3f892b656bf20c4ade"
RDEPENDS:langpacks-fonts-tr = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-core-sans \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-ts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ts-4.1-3.el10.noarch.rpm;name=langpacks-fonts-ts;unpack=0"
SRC_URI += "${URI_langpacks-fonts-ts}"
SRC_URI[langpacks-fonts-ts.sha256sum] = "f632783022b9aa94e88d86677f3b9174b45c439bb4561ea31d1d1ed2de19594b"
RDEPENDS:langpacks-fonts-ts = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 redhat-mono-vf-fonts \
 default-fonts-ts \
"

URI_langpacks-fonts-uk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-uk-4.1-3.el10.noarch.rpm;name=langpacks-fonts-uk;unpack=0"
SRC_URI += "${URI_langpacks-fonts-uk}"
SRC_URI[langpacks-fonts-uk.sha256sum] = "7541c8d870047f632cb5a425da834cb0c6d0b9f41d770b0b5ab1354db0011152"
RDEPENDS:langpacks-fonts-uk = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 redhat-mono-vf-fonts \
 default-fonts-uk \
"

URI_langpacks-fonts-ur = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ur-4.1-3.el10.noarch.rpm;name=langpacks-fonts-ur;unpack=0"
SRC_URI += "${URI_langpacks-fonts-ur}"
SRC_URI[langpacks-fonts-ur.sha256sum] = "ab747eef7dfdf1ff2f0c2b0cbf998d3a493de8f361afcdb4b8e3e65bcaf4a58c"
RDEPENDS:langpacks-fonts-ur = " \
 default-fonts-ur \
 google-noto-naskh-arabic-vf-fonts \
"

URI_langpacks-fonts-ve = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-ve-4.1-3.el10.noarch.rpm;name=langpacks-fonts-ve;unpack=0"
SRC_URI += "${URI_langpacks-fonts-ve}"
SRC_URI[langpacks-fonts-ve.sha256sum] = "3e7bbf5015f158ae91f7403f6f74405e613071937b20df5616b10d8517a2ed1c"
RDEPENDS:langpacks-fonts-ve = " \
 google-noto-sans-mono-vf-fonts \
 default-fonts-ve \
 google-noto-serif-vf-fonts \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-vi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-vi-4.1-3.el10.noarch.rpm;name=langpacks-fonts-vi;unpack=0"
SRC_URI += "${URI_langpacks-fonts-vi}"
SRC_URI[langpacks-fonts-vi.sha256sum] = "9d9bcf44be1ba804d1610280e512e18693584b331ef9c409864cf95a6c847314"
RDEPENDS:langpacks-fonts-vi = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 redhat-mono-vf-fonts \
 default-fonts-vi \
"

URI_langpacks-fonts-xh = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-xh-4.1-3.el10.noarch.rpm;name=langpacks-fonts-xh;unpack=0"
SRC_URI += "${URI_langpacks-fonts-xh}"
SRC_URI[langpacks-fonts-xh.sha256sum] = "f94f7a5d96662a60404908b4d3910816e293563cd20eda0172bf4d85f59958dc"
RDEPENDS:langpacks-fonts-xh = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 default-fonts-xh \
 redhat-mono-vf-fonts \
"

URI_langpacks-fonts-yi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-yi-4.1-3.el10.noarch.rpm;name=langpacks-fonts-yi;unpack=0"
SRC_URI += "${URI_langpacks-fonts-yi}"
SRC_URI[langpacks-fonts-yi.sha256sum] = "89ea61738a409de609124fd1abf5e62ab5827c48320e67b7f2aff98a6f3fd02f"
RDEPENDS:langpacks-fonts-yi = " \
 google-noto-serif-hebrew-vf-fonts \
 default-fonts-yi \
"

URI_langpacks-fonts-zh_CN = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-zh_CN-4.1-3.el10.noarch.rpm;name=langpacks-fonts-zh_CN;unpack=0"
SRC_URI += "${URI_langpacks-fonts-zh_CN}"
SRC_URI[langpacks-fonts-zh_CN.sha256sum] = "ada63652512542816d215a73e41120dc08b41c57236908417a5158baa439ef9d"
RDEPENDS:langpacks-fonts-zh_CN = " \
 default-fonts-cjk-sans \
 google-noto-sans-mono-cjk-vf-fonts \
 google-noto-serif-cjk-vf-fonts \
"

URI_langpacks-fonts-zh_HK = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-zh_HK-4.1-3.el10.noarch.rpm;name=langpacks-fonts-zh_HK;unpack=0"
SRC_URI += "${URI_langpacks-fonts-zh_HK}"
SRC_URI[langpacks-fonts-zh_HK.sha256sum] = "24284131f364972005187b60288034c29d6e5d07e9acfea49dc81e7f3c9fc349"
RDEPENDS:langpacks-fonts-zh_HK = " \
 default-fonts-cjk-sans \
 google-noto-sans-mono-cjk-vf-fonts \
 google-noto-serif-cjk-vf-fonts \
"

URI_langpacks-fonts-zh_TW = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-zh_TW-4.1-3.el10.noarch.rpm;name=langpacks-fonts-zh_TW;unpack=0"
SRC_URI += "${URI_langpacks-fonts-zh_TW}"
SRC_URI[langpacks-fonts-zh_TW.sha256sum] = "5646ff4fe071a1e77edd5a97f3e9859c294303edd3dc949c0642aff3c40187f4"
RDEPENDS:langpacks-fonts-zh_TW = " \
 default-fonts-cjk-sans \
 google-noto-sans-mono-cjk-vf-fonts \
 google-noto-serif-cjk-vf-fonts \
"

URI_langpacks-fonts-zu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fonts-zu-4.1-3.el10.noarch.rpm;name=langpacks-fonts-zu;unpack=0"
SRC_URI += "${URI_langpacks-fonts-zu}"
SRC_URI[langpacks-fonts-zu.sha256sum] = "1149ae83f104cbca2df24cc2d2efc953ff9e7830c22f68817259cf0481ccbed3"
RDEPENDS:langpacks-fonts-zu = " \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 redhat-mono-vf-fonts \
 default-fonts-zu \
"

URI_langpacks-fr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-fr-4.1-3.el10.noarch.rpm;name=langpacks-fr;unpack=0"
SRC_URI += "${URI_langpacks-fr}"
SRC_URI[langpacks-fr.sha256sum] = "901398872e29b789c4ed9e94b45189a05219c3b7ecb2a149dca9bbc66cbc0137"
RDEPENDS:langpacks-fr = " \
 langpacks-fonts-fr \
 langpacks-core-fr \
"

URI_langpacks-ga = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ga-4.1-3.el10.noarch.rpm;name=langpacks-ga;unpack=0"
SRC_URI += "${URI_langpacks-ga}"
SRC_URI[langpacks-ga.sha256sum] = "b6676e99ff37189e61c86a5676e71b061735f52e615151fc889e577a5cf9c854"
RDEPENDS:langpacks-ga = " \
 langpacks-fonts-ga \
 langpacks-core-ga \
"

URI_langpacks-gl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-gl-4.1-3.el10.noarch.rpm;name=langpacks-gl;unpack=0"
SRC_URI += "${URI_langpacks-gl}"
SRC_URI[langpacks-gl.sha256sum] = "de33f81aecfd8f68cc26bed8d40789d34f73899d6e64243784cc6af2a4d84494"
RDEPENDS:langpacks-gl = " \
 langpacks-fonts-gl \
 langpacks-core-gl \
"

URI_langpacks-gu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-gu-4.1-3.el10.noarch.rpm;name=langpacks-gu;unpack=0"
SRC_URI += "${URI_langpacks-gu}"
SRC_URI[langpacks-gu.sha256sum] = "e332b71d3262dcf8648581d2dd0806152bd54fc6dc5dd66aac9c9f56df99d432"
RDEPENDS:langpacks-gu = " \
 langpacks-fonts-gu \
 langpacks-core-gu \
"

URI_langpacks-he = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-he-4.1-3.el10.noarch.rpm;name=langpacks-he;unpack=0"
SRC_URI += "${URI_langpacks-he}"
SRC_URI[langpacks-he.sha256sum] = "3d936167771a0b31ce8e29a422deac62bc6125a0d7e8c0cfda6f7ec6643e155d"
RDEPENDS:langpacks-he = " \
 langpacks-core-he \
 langpacks-fonts-he \
"

URI_langpacks-hi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-hi-4.1-3.el10.noarch.rpm;name=langpacks-hi;unpack=0"
SRC_URI += "${URI_langpacks-hi}"
SRC_URI[langpacks-hi.sha256sum] = "ea165157ce83306d649ab617cd1263b7f89eea6bc7901aa015712ef9de2a082e"
RDEPENDS:langpacks-hi = " \
 langpacks-core-hi \
 langpacks-fonts-hi \
"

URI_langpacks-hr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-hr-4.1-3.el10.noarch.rpm;name=langpacks-hr;unpack=0"
SRC_URI += "${URI_langpacks-hr}"
SRC_URI[langpacks-hr.sha256sum] = "3095edf3348a1f201176b74071cfcfd85bd5c78e8940d534924cd6b6ed31d7c6"
RDEPENDS:langpacks-hr = " \
 langpacks-fonts-hr \
 langpacks-core-hr \
"

URI_langpacks-hu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-hu-4.1-3.el10.noarch.rpm;name=langpacks-hu;unpack=0"
SRC_URI += "${URI_langpacks-hu}"
SRC_URI[langpacks-hu.sha256sum] = "a72f1f9f01ee0ebb6d45111e05131a0cc8e112d24d09dfc4deddf5629c9080d7"
RDEPENDS:langpacks-hu = " \
 langpacks-fonts-hu \
 langpacks-core-hu \
"

URI_langpacks-hy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-hy-4.1-3.el10.noarch.rpm;name=langpacks-hy;unpack=0"
SRC_URI += "${URI_langpacks-hy}"
SRC_URI[langpacks-hy.sha256sum] = "83e96331f762b4c1d7c00513b46b519e634bfccd284ab6a896b95e390dadf777"
RDEPENDS:langpacks-hy = " \
 langpacks-fonts-hy \
 langpacks-core-hy \
"

URI_langpacks-ia = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ia-4.1-3.el10.noarch.rpm;name=langpacks-ia;unpack=0"
SRC_URI += "${URI_langpacks-ia}"
SRC_URI[langpacks-ia.sha256sum] = "d587cf9e4b281b183285c10202b49b5a776ef29c94f73bf2d70e73cf1bfe88f4"
RDEPENDS:langpacks-ia = " \
 langpacks-fonts-ia \
 langpacks-core-ia \
"

URI_langpacks-id = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-id-4.1-3.el10.noarch.rpm;name=langpacks-id;unpack=0"
SRC_URI += "${URI_langpacks-id}"
SRC_URI[langpacks-id.sha256sum] = "fc32f685b0525021ef1f95afbef60a3e045d9489d9abe3e37bd40c3448a6c25a"
RDEPENDS:langpacks-id = " \
 langpacks-fonts-id \
 langpacks-core-id \
"

URI_langpacks-is = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-is-4.1-3.el10.noarch.rpm;name=langpacks-is;unpack=0"
SRC_URI += "${URI_langpacks-is}"
SRC_URI[langpacks-is.sha256sum] = "a3297be546f54fd6288c34543da1847cdf6db6d7e88e9dcc16f82ad384662aa2"
RDEPENDS:langpacks-is = " \
 langpacks-fonts-is \
 langpacks-core-is \
"

URI_langpacks-it = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-it-4.1-3.el10.noarch.rpm;name=langpacks-it;unpack=0"
SRC_URI += "${URI_langpacks-it}"
SRC_URI[langpacks-it.sha256sum] = "b6578cdf3c295951b04388929911a6c0fa7fc97716f21074de0907cf2ddca4ea"
RDEPENDS:langpacks-it = " \
 langpacks-core-it \
 langpacks-fonts-it \
"

URI_langpacks-iu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-iu-4.1-3.el10.noarch.rpm;name=langpacks-iu;unpack=0"
SRC_URI += "${URI_langpacks-iu}"
SRC_URI[langpacks-iu.sha256sum] = "499c7207847b4d956db9d3d49965e778b225550792d4bfb0e42a21edeceeda80"
RDEPENDS:langpacks-iu = " \
 langpacks-core-iu \
 langpacks-fonts-iu \
"

URI_langpacks-ja = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ja-4.1-3.el10.noarch.rpm;name=langpacks-ja;unpack=0"
SRC_URI += "${URI_langpacks-ja}"
SRC_URI[langpacks-ja.sha256sum] = "02f39f4bdfeba592bbedc3713d9cac94e1f8d768622bf7402dc409e9bb8c4d4a"
RDEPENDS:langpacks-ja = " \
 langpacks-fonts-ja \
 langpacks-core-ja \
"

URI_langpacks-ka = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ka-4.1-3.el10.noarch.rpm;name=langpacks-ka;unpack=0"
SRC_URI += "${URI_langpacks-ka}"
SRC_URI[langpacks-ka.sha256sum] = "ec30f7ad83151de8c6bab6ddd7be1fdde7a8a7e2253b57e29548c2ed19074aee"
RDEPENDS:langpacks-ka = " \
 langpacks-fonts-ka \
 langpacks-core-ka \
"

URI_langpacks-kk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-kk-4.1-3.el10.noarch.rpm;name=langpacks-kk;unpack=0"
SRC_URI += "${URI_langpacks-kk}"
SRC_URI[langpacks-kk.sha256sum] = "a3a3370e824902667676b88d1ad23deb19bce36572560a52870113b8407c5de9"
RDEPENDS:langpacks-kk = " \
 langpacks-fonts-kk \
 langpacks-core-kk \
"

URI_langpacks-km = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-km-4.1-3.el10.noarch.rpm;name=langpacks-km;unpack=0"
SRC_URI += "${URI_langpacks-km}"
SRC_URI[langpacks-km.sha256sum] = "645cc3f979ce740e2b53800973ec5a3f09efbb3e6feb2b19dc34cc76563fbcaa"
RDEPENDS:langpacks-km = " \
 langpacks-fonts-km \
 langpacks-core-km \
"

URI_langpacks-kn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-kn-4.1-3.el10.noarch.rpm;name=langpacks-kn;unpack=0"
SRC_URI += "${URI_langpacks-kn}"
SRC_URI[langpacks-kn.sha256sum] = "99928b6f8fcd0837e5d5bd2f73d5eeb2ffbcbff4573e4e82f1ce096a1706c630"
RDEPENDS:langpacks-kn = " \
 langpacks-fonts-kn \
 langpacks-core-kn \
"

URI_langpacks-ko = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ko-4.1-3.el10.noarch.rpm;name=langpacks-ko;unpack=0"
SRC_URI += "${URI_langpacks-ko}"
SRC_URI[langpacks-ko.sha256sum] = "7aa782aa0a2bd212476fc4b827cf32a0a4cb7bb148a3b0b8d20f71b79573cc5b"
RDEPENDS:langpacks-ko = " \
 langpacks-fonts-ko \
 langpacks-core-ko \
"

URI_langpacks-ku = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ku-4.1-3.el10.noarch.rpm;name=langpacks-ku;unpack=0"
SRC_URI += "${URI_langpacks-ku}"
SRC_URI[langpacks-ku.sha256sum] = "73bc5f9fc2b831991220481d81187dbe8005a0e92798b25971484403a57edcaf"
RDEPENDS:langpacks-ku = " \
 langpacks-core-ku \
 langpacks-fonts-ku \
"

URI_langpacks-lo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-lo-4.1-3.el10.noarch.rpm;name=langpacks-lo;unpack=0"
SRC_URI += "${URI_langpacks-lo}"
SRC_URI[langpacks-lo.sha256sum] = "bb65bb0307f4d24940a8b5e75d70ea48fd16ca0dcc881d6b6fc9ce83f22c0738"
RDEPENDS:langpacks-lo = " \
 langpacks-core-lo \
 langpacks-fonts-lo \
"

URI_langpacks-lt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-lt-4.1-3.el10.noarch.rpm;name=langpacks-lt;unpack=0"
SRC_URI += "${URI_langpacks-lt}"
SRC_URI[langpacks-lt.sha256sum] = "d1b7d5a43c84e833d36af87d16fec1a8c3e384b38b040dc6a22f11099ffa307c"
RDEPENDS:langpacks-lt = " \
 langpacks-fonts-lt \
 langpacks-core-lt \
"

URI_langpacks-lv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-lv-4.1-3.el10.noarch.rpm;name=langpacks-lv;unpack=0"
SRC_URI += "${URI_langpacks-lv}"
SRC_URI[langpacks-lv.sha256sum] = "80a0cd3cb7edee88c91f9a41981a137e11011089852173357f217cadb835b07b"
RDEPENDS:langpacks-lv = " \
 langpacks-fonts-lv \
 langpacks-core-lv \
"

URI_langpacks-mai = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-mai-4.1-3.el10.noarch.rpm;name=langpacks-mai;unpack=0"
SRC_URI += "${URI_langpacks-mai}"
SRC_URI[langpacks-mai.sha256sum] = "cc79f530e94f8bc4b5dcbde28638a57ca70b4142bf8487990953030a3c8c3811"
RDEPENDS:langpacks-mai = " \
 langpacks-fonts-mai \
 langpacks-core-mai \
"

URI_langpacks-mk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-mk-4.1-3.el10.noarch.rpm;name=langpacks-mk;unpack=0"
SRC_URI += "${URI_langpacks-mk}"
SRC_URI[langpacks-mk.sha256sum] = "000a508cb3325158328b983033dd36141f06da1196c8233248468b688ac8480a"
RDEPENDS:langpacks-mk = " \
 langpacks-fonts-mk \
 langpacks-core-mk \
"

URI_langpacks-ml = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ml-4.1-3.el10.noarch.rpm;name=langpacks-ml;unpack=0"
SRC_URI += "${URI_langpacks-ml}"
SRC_URI[langpacks-ml.sha256sum] = "713de5b92784f2e79cba079a9227df94d968feb899898665b8e9d142454e7aa1"
RDEPENDS:langpacks-ml = " \
 langpacks-fonts-ml \
 langpacks-core-ml \
"

URI_langpacks-mni = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-mni-4.1-3.el10.noarch.rpm;name=langpacks-mni;unpack=0"
SRC_URI += "${URI_langpacks-mni}"
SRC_URI[langpacks-mni.sha256sum] = "1bd77a0df851a17bd347f342db51695c94ae4178494b76dd8147411d2f56142c"
RDEPENDS:langpacks-mni = " \
 langpacks-fonts-mni \
 langpacks-core-mni \
"

URI_langpacks-mr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-mr-4.1-3.el10.noarch.rpm;name=langpacks-mr;unpack=0"
SRC_URI += "${URI_langpacks-mr}"
SRC_URI[langpacks-mr.sha256sum] = "7815e2e0e26cd345b3a7e93f8806a186eeaadfa0c0b298ae1e73f637cd04138b"
RDEPENDS:langpacks-mr = " \
 langpacks-core-mr \
 langpacks-fonts-mr \
"

URI_langpacks-ms = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ms-4.1-3.el10.noarch.rpm;name=langpacks-ms;unpack=0"
SRC_URI += "${URI_langpacks-ms}"
SRC_URI[langpacks-ms.sha256sum] = "51f71be1116090d4502fab1679922449f3f605e828a1b114e60fc209d81ece4e"
RDEPENDS:langpacks-ms = " \
 langpacks-core-ms \
 langpacks-fonts-ms \
"

URI_langpacks-my = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-my-4.1-3.el10.noarch.rpm;name=langpacks-my;unpack=0"
SRC_URI += "${URI_langpacks-my}"
SRC_URI[langpacks-my.sha256sum] = "744c6b45cf852bffb26a405648e7ae2a020aa2f02d73525f8fc2b7bb18712f68"
RDEPENDS:langpacks-my = " \
 langpacks-fonts-my \
 langpacks-core-my \
"

URI_langpacks-nb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-nb-4.1-3.el10.noarch.rpm;name=langpacks-nb;unpack=0"
SRC_URI += "${URI_langpacks-nb}"
SRC_URI[langpacks-nb.sha256sum] = "f2366635e9e5ebceb695a99cbc4475178cbd55233b81d31c5e701426ee137301"
RDEPENDS:langpacks-nb = " \
 langpacks-fonts-nb \
 langpacks-core-nb \
"

URI_langpacks-ne = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ne-4.1-3.el10.noarch.rpm;name=langpacks-ne;unpack=0"
SRC_URI += "${URI_langpacks-ne}"
SRC_URI[langpacks-ne.sha256sum] = "010f71ebe30abc37125409491100fdf6f50f90638d0bbb05fa94dd48f9fc9a28"
RDEPENDS:langpacks-ne = " \
 langpacks-fonts-ne \
 langpacks-core-ne \
"

URI_langpacks-nl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-nl-4.1-3.el10.noarch.rpm;name=langpacks-nl;unpack=0"
SRC_URI += "${URI_langpacks-nl}"
SRC_URI[langpacks-nl.sha256sum] = "ba509bd8394c836e6f9fea8a190caf7fcfb0adda200adf2b04f68d201c40ab08"
RDEPENDS:langpacks-nl = " \
 langpacks-fonts-nl \
 langpacks-core-nl \
"

URI_langpacks-nn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-nn-4.1-3.el10.noarch.rpm;name=langpacks-nn;unpack=0"
SRC_URI += "${URI_langpacks-nn}"
SRC_URI[langpacks-nn.sha256sum] = "fb72d0a56f78979dfeb06e95c99e17d4d029b1e775e32126a93a8f2bcc9c9b00"
RDEPENDS:langpacks-nn = " \
 langpacks-fonts-nn \
 langpacks-core-nn \
"

URI_langpacks-nr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-nr-4.1-3.el10.noarch.rpm;name=langpacks-nr;unpack=0"
SRC_URI += "${URI_langpacks-nr}"
SRC_URI[langpacks-nr.sha256sum] = "36af942cc18f9e5f5a63ec0e2232fbdd8e8a8e747bc720087b2e697fe9c05099"
RDEPENDS:langpacks-nr = " \
 langpacks-fonts-nr \
 langpacks-core-nr \
"

URI_langpacks-nso = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-nso-4.1-3.el10.noarch.rpm;name=langpacks-nso;unpack=0"
SRC_URI += "${URI_langpacks-nso}"
SRC_URI[langpacks-nso.sha256sum] = "0bfba89c445c762dd59b79bb86802bb85aaccc17e291edddf4b557e0c4de0cdc"
RDEPENDS:langpacks-nso = " \
 langpacks-core-nso \
 langpacks-fonts-nso \
"

URI_langpacks-or = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-or-4.1-3.el10.noarch.rpm;name=langpacks-or;unpack=0"
SRC_URI += "${URI_langpacks-or}"
SRC_URI[langpacks-or.sha256sum] = "b5b2bf62c79fb86f72172a5d7d2be7376ba40b0da57eca4bc3145494e9909e52"
RDEPENDS:langpacks-or = " \
 langpacks-core-or \
 langpacks-fonts-or \
"

URI_langpacks-pa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-pa-4.1-3.el10.noarch.rpm;name=langpacks-pa;unpack=0"
SRC_URI += "${URI_langpacks-pa}"
SRC_URI[langpacks-pa.sha256sum] = "0d9c3a37c121a8392fa7d569f77592df7db240af9f87fb6a636271a9dab9fc0d"
RDEPENDS:langpacks-pa = " \
 langpacks-fonts-pa \
 langpacks-core-pa \
"

URI_langpacks-pl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-pl-4.1-3.el10.noarch.rpm;name=langpacks-pl;unpack=0"
SRC_URI += "${URI_langpacks-pl}"
SRC_URI[langpacks-pl.sha256sum] = "93ffa70881a5ab269f7a82dbc919c28472e9b17231fb78bafc81376c4c00bbc8"
RDEPENDS:langpacks-pl = " \
 langpacks-fonts-pl \
 langpacks-core-pl \
"

URI_langpacks-pt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-pt-4.1-3.el10.noarch.rpm;name=langpacks-pt;unpack=0"
SRC_URI += "${URI_langpacks-pt}"
SRC_URI[langpacks-pt.sha256sum] = "fcbd97c7aa54ca40172192b75d9d73393ce0911a5f298ed7816858dca35ff48b"
RDEPENDS:langpacks-pt = " \
 langpacks-fonts-pt \
 langpacks-core-pt \
"

URI_langpacks-pt_BR = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-pt_BR-4.1-3.el10.noarch.rpm;name=langpacks-pt_BR;unpack=0"
SRC_URI += "${URI_langpacks-pt_BR}"
SRC_URI[langpacks-pt_BR.sha256sum] = "82b1b2be7f352bf1c8b82b870d4f34983eccc032b7d96b849f7cea7ce3ce4615"
RDEPENDS:langpacks-pt_BR = " \
 langpacks-fonts-pt \
 langpacks-core-pt_BR \
"

URI_langpacks-ro = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ro-4.1-3.el10.noarch.rpm;name=langpacks-ro;unpack=0"
SRC_URI += "${URI_langpacks-ro}"
SRC_URI[langpacks-ro.sha256sum] = "07ab3fd77b341d43311f00c21409e8411af0e5ef26c1474f23d136f5d00a29e6"
RDEPENDS:langpacks-ro = " \
 langpacks-fonts-ro \
 langpacks-core-ro \
"

URI_langpacks-ru = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ru-4.1-3.el10.noarch.rpm;name=langpacks-ru;unpack=0"
SRC_URI += "${URI_langpacks-ru}"
SRC_URI[langpacks-ru.sha256sum] = "129670494be56979bd0a4011dae55d8216a426431ea07e223e6c7b4831dbf537"
RDEPENDS:langpacks-ru = " \
 langpacks-fonts-ru \
 langpacks-core-ru \
"

URI_langpacks-sat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-sat-4.1-3.el10.noarch.rpm;name=langpacks-sat;unpack=0"
SRC_URI += "${URI_langpacks-sat}"
SRC_URI[langpacks-sat.sha256sum] = "ae5bf9c76a280e4712ef9929cd2abc85130dc5001a31fb35b49a7394070afe73"
RDEPENDS:langpacks-sat = " \
 langpacks-core-sat \
 langpacks-fonts-sat \
"

URI_langpacks-si = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-si-4.1-3.el10.noarch.rpm;name=langpacks-si;unpack=0"
SRC_URI += "${URI_langpacks-si}"
SRC_URI[langpacks-si.sha256sum] = "a1886893f0b15166cc9b74694a07d8c83b2e575f94f65c27aaa40bff2c7ff18a"
RDEPENDS:langpacks-si = " \
 langpacks-core-si \
 langpacks-fonts-si \
"

URI_langpacks-sk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-sk-4.1-3.el10.noarch.rpm;name=langpacks-sk;unpack=0"
SRC_URI += "${URI_langpacks-sk}"
SRC_URI[langpacks-sk.sha256sum] = "bdc395f2ba14b306721f553f2c57040328263ca0e6f668a5f960f81ba2a83324"
RDEPENDS:langpacks-sk = " \
 langpacks-core-sk \
 langpacks-fonts-sk \
"

URI_langpacks-sl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-sl-4.1-3.el10.noarch.rpm;name=langpacks-sl;unpack=0"
SRC_URI += "${URI_langpacks-sl}"
SRC_URI[langpacks-sl.sha256sum] = "8903cce59c4e5b5af90e83a6000337afbfcbf0b99927a805a0566b32d5ea3c37"
RDEPENDS:langpacks-sl = " \
 langpacks-fonts-sl \
 langpacks-core-sl \
"

URI_langpacks-sq = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-sq-4.1-3.el10.noarch.rpm;name=langpacks-sq;unpack=0"
SRC_URI += "${URI_langpacks-sq}"
SRC_URI[langpacks-sq.sha256sum] = "be03ea21870f027cf6a2328f0a9a8569d6a1830d6f6de9701700571a2213a022"
RDEPENDS:langpacks-sq = " \
 langpacks-fonts-sq \
 langpacks-core-sq \
"

URI_langpacks-sr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-sr-4.1-3.el10.noarch.rpm;name=langpacks-sr;unpack=0"
SRC_URI += "${URI_langpacks-sr}"
SRC_URI[langpacks-sr.sha256sum] = "25634eda6cf4747c64c28e92566b68c6f82b49ecd66bdb51e4d86bb529b74f4e"
RDEPENDS:langpacks-sr = " \
 langpacks-fonts-sr \
 langpacks-core-sr \
"

URI_langpacks-ss = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ss-4.1-3.el10.noarch.rpm;name=langpacks-ss;unpack=0"
SRC_URI += "${URI_langpacks-ss}"
SRC_URI[langpacks-ss.sha256sum] = "ce9f27361547bac97e4c11574102fbc6a8756243efa40bfa4ea92c7c750c26d4"
RDEPENDS:langpacks-ss = " \
 langpacks-fonts-ss \
 langpacks-core-ss \
"

URI_langpacks-sv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-sv-4.1-3.el10.noarch.rpm;name=langpacks-sv;unpack=0"
SRC_URI += "${URI_langpacks-sv}"
SRC_URI[langpacks-sv.sha256sum] = "0402f9558f92c987f03648af207e3f99ccada7023a367f4cc53a504ceec012ee"
RDEPENDS:langpacks-sv = " \
 langpacks-fonts-sv \
 langpacks-core-sv \
"

URI_langpacks-ta = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ta-4.1-3.el10.noarch.rpm;name=langpacks-ta;unpack=0"
SRC_URI += "${URI_langpacks-ta}"
SRC_URI[langpacks-ta.sha256sum] = "9b58da130c832ec67597c9d3caa799b6eb211c8f656a2a45708e99029af1166a"
RDEPENDS:langpacks-ta = " \
 langpacks-core-ta \
 langpacks-fonts-ta \
"

URI_langpacks-te = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-te-4.1-3.el10.noarch.rpm;name=langpacks-te;unpack=0"
SRC_URI += "${URI_langpacks-te}"
SRC_URI[langpacks-te.sha256sum] = "3473ddf9a97350170509757f14396900da383425ac69f2fce527b61fcfb6e2df"
RDEPENDS:langpacks-te = " \
 langpacks-core-te \
 langpacks-fonts-te \
"

URI_langpacks-th = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-th-4.1-3.el10.noarch.rpm;name=langpacks-th;unpack=0"
SRC_URI += "${URI_langpacks-th}"
SRC_URI[langpacks-th.sha256sum] = "c2c8a677dba921282fe47eee4cff81566e6908fe5929265149128b9c2d789ac3"
RDEPENDS:langpacks-th = " \
 langpacks-core-th \
 langpacks-fonts-th \
"

URI_langpacks-tn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-tn-4.1-3.el10.noarch.rpm;name=langpacks-tn;unpack=0"
SRC_URI += "${URI_langpacks-tn}"
SRC_URI[langpacks-tn.sha256sum] = "f86bc027f27ab37133237e5a0dce783fdb7413f535e1e0205bbb31853b59fa2e"
RDEPENDS:langpacks-tn = " \
 langpacks-fonts-tn \
 langpacks-core-tn \
"

URI_langpacks-tr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-tr-4.1-3.el10.noarch.rpm;name=langpacks-tr;unpack=0"
SRC_URI += "${URI_langpacks-tr}"
SRC_URI[langpacks-tr.sha256sum] = "d9baf4d210cfb0b0b53e985b61ca3c3a61c2949ac7d6df2a0ca0c6c892ba402a"
RDEPENDS:langpacks-tr = " \
 langpacks-fonts-tr \
 langpacks-core-tr \
"

URI_langpacks-ts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ts-4.1-3.el10.noarch.rpm;name=langpacks-ts;unpack=0"
SRC_URI += "${URI_langpacks-ts}"
SRC_URI[langpacks-ts.sha256sum] = "d4219edfa455a03d5649cad89057db68fc912a8dc0180c5edd2a543649cbadf6"
RDEPENDS:langpacks-ts = " \
 langpacks-fonts-ts \
 langpacks-core-ts \
"

URI_langpacks-uk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-uk-4.1-3.el10.noarch.rpm;name=langpacks-uk;unpack=0"
SRC_URI += "${URI_langpacks-uk}"
SRC_URI[langpacks-uk.sha256sum] = "4208e99c2e37a03a10a75f0a8715981e099e13012904b0c08892a1a3ae19524d"
RDEPENDS:langpacks-uk = " \
 langpacks-fonts-uk \
 langpacks-core-uk \
"

URI_langpacks-ur = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ur-4.1-3.el10.noarch.rpm;name=langpacks-ur;unpack=0"
SRC_URI += "${URI_langpacks-ur}"
SRC_URI[langpacks-ur.sha256sum] = "9fe0c4a487bddfa25c638758ebdbe88019a57147080416a3128d5ad8430b05b3"
RDEPENDS:langpacks-ur = " \
 langpacks-fonts-ur \
 langpacks-core-ur \
"

URI_langpacks-ve = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-ve-4.1-3.el10.noarch.rpm;name=langpacks-ve;unpack=0"
SRC_URI += "${URI_langpacks-ve}"
SRC_URI[langpacks-ve.sha256sum] = "282edf5a6bcd67d7c7335c83327ff09d17ff9ac1dcd7ed54a5bbcb8ac66011db"
RDEPENDS:langpacks-ve = " \
 langpacks-core-ve \
 langpacks-fonts-ve \
"

URI_langpacks-vi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-vi-4.1-3.el10.noarch.rpm;name=langpacks-vi;unpack=0"
SRC_URI += "${URI_langpacks-vi}"
SRC_URI[langpacks-vi.sha256sum] = "d61c792ac3107751726c2aa3e02139374c256ed242f729fce592a76f1dc37af0"
RDEPENDS:langpacks-vi = " \
 langpacks-core-vi \
 langpacks-fonts-vi \
"

URI_langpacks-xh = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-xh-4.1-3.el10.noarch.rpm;name=langpacks-xh;unpack=0"
SRC_URI += "${URI_langpacks-xh}"
SRC_URI[langpacks-xh.sha256sum] = "c68d0f3d627b662ad48231e63bcc8bbea31b2f8ee9477c1861511f1e50cf2724"
RDEPENDS:langpacks-xh = " \
 langpacks-core-xh \
 langpacks-fonts-xh \
"

URI_langpacks-yi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-yi-4.1-3.el10.noarch.rpm;name=langpacks-yi;unpack=0"
SRC_URI += "${URI_langpacks-yi}"
SRC_URI[langpacks-yi.sha256sum] = "e2713a48d89f54af286f267cbc985b4c7daaeaf324ca88a070728c8cf1623be4"
RDEPENDS:langpacks-yi = " \
 langpacks-fonts-yi \
 langpacks-core-yi \
"

URI_langpacks-zh_CN = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-zh_CN-4.1-3.el10.noarch.rpm;name=langpacks-zh_CN;unpack=0"
SRC_URI += "${URI_langpacks-zh_CN}"
SRC_URI[langpacks-zh_CN.sha256sum] = "2b4146bd16660c605e423d5278d1aff432a7e0da0d45ea7460e785eba9be04b2"
RDEPENDS:langpacks-zh_CN = " \
 langpacks-fonts-zh_CN \
 langpacks-core-zh_CN \
"

URI_langpacks-zh_HK = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-zh_HK-4.1-3.el10.noarch.rpm;name=langpacks-zh_HK;unpack=0"
SRC_URI += "${URI_langpacks-zh_HK}"
SRC_URI[langpacks-zh_HK.sha256sum] = "a6f7d678a15622fa3c64f73e374e3a5ab7e656a0e939a2332e3258ffe4740d83"
RDEPENDS:langpacks-zh_HK = " \
 langpacks-fonts-zh_HK \
 langpacks-core-zh_HK \
"

URI_langpacks-zh_TW = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-zh_TW-4.1-3.el10.noarch.rpm;name=langpacks-zh_TW;unpack=0"
SRC_URI += "${URI_langpacks-zh_TW}"
SRC_URI[langpacks-zh_TW.sha256sum] = "eeceb7107d1edf5ff4bc409f4074f99f00e06b2f01735bf0177508f0c2f7c318"
RDEPENDS:langpacks-zh_TW = " \
 langpacks-fonts-zh_TW \
 langpacks-core-zh_TW \
"

URI_langpacks-zu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/langpacks-zu-4.1-3.el10.noarch.rpm;name=langpacks-zu;unpack=0"
SRC_URI += "${URI_langpacks-zu}"
SRC_URI[langpacks-zu.sha256sum] = "c05c21fac5975b3c3297aafffa194b4cf387827de307156e8a22e428ded23205"
RDEPENDS:langpacks-zu = " \
 langpacks-fonts-zu \
 langpacks-core-zu \
"
