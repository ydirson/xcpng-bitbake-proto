# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sgpio"
PE = "0"
PV = "1.2.0.10"
PR = "38.el10"
PACKAGES = "sgpio"
PROVIDES = "rpm/sgpio"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/sgpio-1.2.0.10-38.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7cdad3447b5823b1a4a8faea1601560f5869063f2a031fc13d5311690887b4ec"

URI_sgpio = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sgpio-1.2.0.10-38.el10.x86_64_v2.rpm;name=sgpio;unpack=0"
SRC_URI += "${URI_sgpio}"
SRC_URI[sgpio.sha256sum] = "a37a24735f6077a156c53e3af9cad607b6a7a11aaacdaeb866ecc142bb7e53af"
RDEPENDS:sgpio = " \
 glibc \
"
