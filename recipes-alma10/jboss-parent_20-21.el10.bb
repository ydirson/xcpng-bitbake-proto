# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jboss-parent"
PE = "0"
PV = "20"
PR = "21.el10"
PACKAGES = "jboss-parent"
PROVIDES = "rpm/jboss-parent"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/jboss-parent-20-21.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5c65054874ea82f129e10344a109b3babc10823fa11654c77f7d830b3227c26"

URI_jboss-parent = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/jboss-parent-20-21.el10.noarch.rpm;name=jboss-parent;unpack=0"
SRC_URI += "${URI_jboss-parent}"
SRC_URI[jboss-parent.sha256sum] = "784eb552009eb3da0699e8630b5eacdfb67d37c9d7c7ab1addfe7eb0e4222004"
RDEPENDS:jboss-parent = " \
 maven-source-plugin \
 javapackages-filesystem \
 java-21-openjdk-headless \
"
