# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Net-Ping"
PE = "0"
PV = "2.76"
PR = "511.el10"
PACKAGES = "perl-Net-Ping perl-Net-Ping-tests"
PROVIDES = "rpm/perl-Net-Ping rpm/perl-Net-Ping-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Net-Ping-2.76-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "467ebf9af36bffa9dd9d604cb4efc873cc4ff5b10ce92a9a747e784c00f6015a"

URI_perl-Net-Ping = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Net-Ping-2.76-511.el10.noarch.rpm;name=perl-Net-Ping;unpack=0"
SRC_URI += "${URI_perl-Net-Ping}"
SRC_URI[perl-Net-Ping.sha256sum] = "66a6fa92b3749c8996de606bc1c6d19fbd9819ee5301fbf5abfff310128ac6a3"
RDEPENDS:perl-Net-Ping = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-FileHandle \
 perl-IO \
 perl-Socket \
 perl-Fcntl \
 perl-POSIX \
 perl-Exporter \
 perl-Time-HiRes \
"

URI_perl-Net-Ping-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Net-Ping-tests-2.76-511.el10.noarch.rpm;name=perl-Net-Ping-tests;unpack=0"
SRC_URI += "${URI_perl-Net-Ping-tests}"
SRC_URI[perl-Net-Ping-tests.sha256sum] = "ffe375482cd011e38de242453e14b7423f77d88551ffdd1757e33c653b864bbc"
RDEPENDS:perl-Net-Ping-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-IO \
 perl-Socket \
 bash \
 perl-PathTools \
 perl-interpreter \
 perl-Net-Ping \
"
