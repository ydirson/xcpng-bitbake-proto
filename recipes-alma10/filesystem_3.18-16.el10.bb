# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "filesystem"
PE = "0"
PV = "3.18"
PR = "16.el10"
PACKAGES = "filesystem filesystem-content"
PROVIDES = "rpm/filesystem rpm/filesystem-content"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/filesystem-3.18-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "011facdf645823fed4574fb0921b7c67c68871d95979c2ed4f348da02c7c71af"

URI_filesystem = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/filesystem-3.18-16.el10.x86_64_v2.rpm;name=filesystem;unpack=0"
SRC_URI += "${URI_filesystem}"
SRC_URI[filesystem.sha256sum] = "48a832985e0498608f6002366d29879dd1d375b75ac3472dcddb22b64ca31e98"
RDEPENDS:filesystem = " \
 setup \
"

URI_filesystem-content = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/filesystem-content-3.18-16.el10.x86_64_v2.rpm;name=filesystem-content;unpack=0"
SRC_URI += "${URI_filesystem-content}"
SRC_URI[filesystem-content.sha256sum] = "203c55769cf08a3f9033bb5bb437a04aa833aaaa7c6be87274e5f21db962e997"
RDEPENDS:filesystem-content = ""
