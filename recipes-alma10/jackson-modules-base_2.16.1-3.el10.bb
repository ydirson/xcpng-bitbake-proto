# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jackson-modules-base"
PE = "0"
PV = "2.16.1"
PR = "3.el10"
PACKAGES = "jackson-module-jaxb-annotations jackson-modules-base"
PROVIDES = "rpm/jackson-module-jaxb-annotations rpm/jackson-modules-base"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/jackson-modules-base-2.16.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70a80719c461740dc59b612567d2bd1ce96bf07fde3a47509f4d2d2b480e3fc2"

URI_jackson-module-jaxb-annotations = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/jackson-module-jaxb-annotations-2.16.1-3.el10.noarch.rpm;name=jackson-module-jaxb-annotations;unpack=0"
SRC_URI += "${URI_jackson-module-jaxb-annotations}"
SRC_URI[jackson-module-jaxb-annotations.sha256sum] = "6563b6362de8ab08d08bd6068bbe1dbb8839bf21778e73df617193bc7582dbda"
RDEPENDS:jackson-module-jaxb-annotations = " \
 jakarta-activation \
 javapackages-filesystem \
 jackson-annotations \
 jaxb-api \
 jackson-core \
 jackson-databind \
 java-21-openjdk-headless \
"

URI_jackson-modules-base = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/jackson-modules-base-2.16.1-3.el10.noarch.rpm;name=jackson-modules-base;unpack=0"
SRC_URI += "${URI_jackson-modules-base}"
SRC_URI[jackson-modules-base.sha256sum] = "e4dfb6ed7c1528f67837fb6efde925c2f008257c15ee0122b95f926e9bdda3ca"
RDEPENDS:jackson-modules-base = " \
 jackson-bom \
 javapackages-filesystem \
 java-21-openjdk-headless \
"
