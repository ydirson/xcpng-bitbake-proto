# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-File-Fetch"
PE = "0"
PV = "1.04"
PR = "511.el10"
PACKAGES = "perl-File-Fetch perl-File-Fetch-tests"
PROVIDES = "rpm/perl-File-Fetch rpm/perl-File-Fetch-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-File-Fetch-1.04-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0fccfcc9b57ef825bdba5158b067ccc189e8024c77172dec7e72e36f09004bcb"

URI_perl-File-Fetch = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-File-Fetch-1.04-511.el10.noarch.rpm;name=perl-File-Fetch;unpack=0"
SRC_URI += "${URI_perl-File-Fetch}"
SRC_URI[perl-File-Fetch.sha256sum] = "8c3b277c9c859cff9c7df36c6e58f76b2007a60df736e966bcb674d07a0736dd"
RDEPENDS:perl-File-Fetch = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-FileHandle \
 perl-Module-Load-Conditional \
 perl-File-Basename \
 perl-IPC-Cmd \
 perl-Params-Check \
 perl-File-Copy \
 perl-PathTools \
 perl-Locale-Maketext-Simple \
 perl-File-Path \
 perl-File-Temp \
"

URI_perl-File-Fetch-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-File-Fetch-tests-1.04-511.el10.noarch.rpm;name=perl-File-Fetch-tests;unpack=0"
SRC_URI += "${URI_perl-File-Fetch-tests}"
SRC_URI[perl-File-Fetch-tests.sha256sum] = "eb19107014273807aaf408f15aa3fde2bb9e29f8d4fb1e5f675b1b0f2f51806f"
RDEPENDS:perl-File-Fetch-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-vars \
 perl-IO \
 perl-File-Basename \
 bash \
 perl-PathTools \
 perl-File-Fetch \
 perl-interpreter \
 perl-File-Path \
 perl-Data-Dumper \
 perl-lib \
"
