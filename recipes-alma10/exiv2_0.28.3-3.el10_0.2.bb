# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "exiv2"
PE = "0"
PV = "0.28.3"
PR = "3.el10_0.2"
PACKAGES = "exiv2 exiv2-libs exiv2-devel exiv2-doc"
PROVIDES = "rpm/exiv2 rpm/exiv2-libs rpm/exiv2-devel rpm/exiv2-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/exiv2-0.28.3-3.el10_0.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b1db4b906387070539f64e06babf8a10a7ed8427f9e67a9e39c463aae6d1c69"

URI_exiv2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/exiv2-0.28.3-3.el10_0.2.x86_64_v2.rpm;name=exiv2;unpack=0"
SRC_URI += "${URI_exiv2}"
SRC_URI[exiv2.sha256sum] = "5cc2092bf98b6c303ee78a2e4a98a26d5c81daaf03d497f659a2a37b2dc70692"
RDEPENDS:exiv2 = " \
 glibc \
 libgcc \
 libstdc++ \
 exiv2-libs \
"

URI_exiv2-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/exiv2-libs-0.28.3-3.el10_0.2.x86_64_v2.rpm;name=exiv2-libs;unpack=0"
SRC_URI += "${URI_exiv2-libs}"
SRC_URI[exiv2-libs.sha256sum] = "839389ff032f9e275465411edd4db6247f7dc5ceea5600d100ff08f5fbbfbc34"
RDEPENDS:exiv2-libs = " \
 zlib-ng-compat \
 inih-cpp \
 libgcc \
 libbrotli \
 libstdc++ \
 expat \
 glibc \
"

URI_exiv2-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/exiv2-devel-0.28.3-3.el10_0.2.x86_64_v2.rpm;name=exiv2-devel;unpack=0"
SRC_URI += "${URI_exiv2-devel}"
SRC_URI[exiv2-devel.sha256sum] = "093626748bf9f3764f7850a47c8d6f9b2da015291aa79b191af1f7f616a1b9d5"
RDEPENDS:exiv2-devel = " \
 brotli-devel \
 cmake-filesystem \
 inih-devel \
 zlib-ng-compat-devel \
 pkgconf-pkg-config \
 exiv2-libs \
 expat-devel \
"

URI_exiv2-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/exiv2-doc-0.28.3-3.el10_0.2.noarch.rpm;name=exiv2-doc;unpack=0"
SRC_URI += "${URI_exiv2-doc}"
SRC_URI[exiv2-doc.sha256sum] = "df5197478815f16ca0878ace43f689b865b95841cef933edf587a6d389415457"
RDEPENDS:exiv2-doc = ""
