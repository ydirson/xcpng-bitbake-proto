# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libcbor"
PE = "0"
PV = "0.11.0"
PR = "3.el10"
PACKAGES = "libcbor libcbor-devel"
PROVIDES = "rpm/libcbor rpm/libcbor-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libcbor-0.11.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "879cb64fd40acd4cdeb2004327e88761838ccf7859b6395a35d71a721c9cc2af"

URI_libcbor = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libcbor-0.11.0-3.el10.x86_64_v2.rpm;name=libcbor;unpack=0"
SRC_URI += "${URI_libcbor}"
SRC_URI[libcbor.sha256sum] = "8d4366ee5820ae618cd3261a412f77d6ba5fdfb0ba729c8587fc56a368cec96e"
RDEPENDS:libcbor = " \
 glibc \
"

URI_libcbor-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libcbor-devel-0.11.0-3.el10.x86_64_v2.rpm;name=libcbor-devel;unpack=0"
SRC_URI += "${URI_libcbor-devel}"
SRC_URI[libcbor-devel.sha256sum] = "7226d9c1640988afafa4baca12326cf32acd07b80710b042a397cd59d0121e0e"
RDEPENDS:libcbor-devel = " \
 libcbor \
 cmake-filesystem \
 pkgconf-pkg-config \
"
