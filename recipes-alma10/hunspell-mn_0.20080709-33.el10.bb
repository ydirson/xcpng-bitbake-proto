# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-mn"
PE = "0"
PV = "0.20080709"
PR = "33.el10"
PACKAGES = "hunspell-mn"
PROVIDES = "rpm/hunspell-mn"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-mn-0.20080709-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0dddec5ad99121340cc917e5470de3b0af9dcf09d23aab8b7e85363243ba226"

URI_hunspell-mn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-mn-0.20080709-33.el10.noarch.rpm;name=hunspell-mn;unpack=0"
SRC_URI += "${URI_hunspell-mn}"
SRC_URI[hunspell-mn.sha256sum] = "50f9b80d631efc14ee175010d97311084de205cd00cedd10c03e61e78a7471ca"
RDEPENDS:hunspell-mn = " \
 hunspell-filesystem \
"
