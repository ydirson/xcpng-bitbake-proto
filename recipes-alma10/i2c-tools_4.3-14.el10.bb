# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "i2c-tools"
PE = "0"
PV = "4.3"
PR = "14.el10"
PACKAGES = "i2c-tools i2c-tools-perl libi2c python3-i2c-tools libi2c-devel"
PROVIDES = "rpm/i2c-tools rpm/i2c-tools-perl rpm/libi2c rpm/python3-i2c-tools rpm/libi2c-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/i2c-tools-4.3-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a95b481c34aca9668d90b55f452b0d6e7f3a1d1e97f36a3b8d6fb3ebdd0508f8"

URI_i2c-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/i2c-tools-4.3-14.el10.x86_64_v2.rpm;name=i2c-tools;unpack=0"
SRC_URI += "${URI_i2c-tools}"
SRC_URI[i2c-tools.sha256sum] = "fab74306243ec88d9bdecd4d3464032e3adbceb3763715279733c0f145d40b78"
RDEPENDS:i2c-tools = " \
 libi2c \
 systemd-udev \
 kmod \
 bash \
 glibc \
"

URI_i2c-tools-perl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/i2c-tools-perl-4.3-14.el10.x86_64_v2.rpm;name=i2c-tools-perl;unpack=0"
SRC_URI += "${URI_i2c-tools-perl}"
SRC_URI[i2c-tools-perl.sha256sum] = "8c1a8d1bf9a7a8809c28b8033e053529cf39f529481e47f8708a2fb18242c22a"
RDEPENDS:i2c-tools-perl = " \
 perl-constant \
 perl-libs \
 libi2c \
 perl-vars \
 perl-Fcntl \
 perl-POSIX \
 perl-File-Basename \
 perl-interpreter \
"

URI_libi2c = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libi2c-4.3-14.el10.x86_64_v2.rpm;name=libi2c;unpack=0"
SRC_URI += "${URI_libi2c}"
SRC_URI[libi2c.sha256sum] = "f58e96cdf103512c2d2331bfb160c3d19dac3dedd9ebcfb9fe361e56137024b5"
RDEPENDS:libi2c = " \
 glibc \
"

URI_python3-i2c-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-i2c-tools-4.3-14.el10.x86_64_v2.rpm;name=python3-i2c-tools;unpack=0"
SRC_URI += "${URI_python3-i2c-tools}"
SRC_URI[python3-i2c-tools.sha256sum] = "266bec193e6a3f8dcfa5ff071fa721f16226450ea03880f1d01d3794233193a4"
RDEPENDS:python3-i2c-tools = " \
 glibc \
 libi2c \
 python3 \
"

URI_libi2c-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libi2c-devel-4.3-14.el10.x86_64_v2.rpm;name=libi2c-devel;unpack=0"
SRC_URI += "${URI_libi2c-devel}"
SRC_URI[libi2c-devel.sha256sum] = "6b46d88802c4e25a0565ca16efaa09acd82c7fd287d042e1b2f9acdf64ddbfdf"
RDEPENDS:libi2c-devel = " \
 libi2c \
"
