# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mrtg"
PE = "0"
PV = "2.17.10"
PR = "11.el10"
PACKAGES = "mrtg mrtg-selinux"
PROVIDES = "rpm/mrtg rpm/mrtg-selinux"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mrtg-2.17.10-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c5a60e174be3a4b6a51af461aefdee38aa930ebfe9fccba7a70a3dc979ece17"

URI_mrtg = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mrtg-2.17.10-11.el10.x86_64_v2.rpm;name=mrtg;unpack=0"
SRC_URI += "${URI_mrtg}"
SRC_URI[mrtg.sha256sum] = "ff6fca30b42789db4e2e80e5bca93bd05ca517cbfc96a6ebc42a93c7c5d94906"
RDEPENDS:mrtg = " \
 perl-SNMP_Session \
 systemd \
 perl-libs \
 mrtg \
 mrtg-selinux \
 perl-locale \
 perl-Socket \
 perl-FindBin \
 perl-Socket6 \
 perl-Getopt-Long \
 perl-CGI \
 perl-Carp \
 perl-vars \
 perl-IO \
 perl-IO-Socket-INET6 \
 gd \
 perl-Math-BigInt \
 bash \
 perl-Exporter \
 perl-POSIX \
 glibc \
 perl-interpreter \
 perl-lib \
 perl-Pod-Usage \
"

URI_mrtg-selinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mrtg-selinux-2.17.10-11.el10.noarch.rpm;name=mrtg-selinux;unpack=0"
SRC_URI += "${URI_mrtg-selinux}"
SRC_URI[mrtg-selinux.sha256sum] = "66d9f246f6a897796b271ad7072e8466ab02219ab3e7fbd8f40d55ebfba088c9"
RDEPENDS:mrtg-selinux = " \
 policycoreutils-python-utils \
 policycoreutils \
 bash \
 selinux-policy \
 libselinux-utils \
 selinux-policy-targeted \
"
