# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "flatpak-xdg-utils"
PE = "0"
PV = "1.0.6"
PR = "1.el10"
PACKAGES = "flatpak-spawn flatpak-xdg-utils flatpak-xdg-utils-tests"
PROVIDES = "rpm/flatpak-spawn rpm/flatpak-xdg-utils rpm/flatpak-xdg-utils-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/flatpak-xdg-utils-1.0.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd017837443aaf9c3f72bce03ce9eb57f4566c54f91beacb4376250c93973358"

URI_flatpak-spawn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/flatpak-spawn-1.0.6-1.el10.x86_64_v2.rpm;name=flatpak-spawn;unpack=0"
SRC_URI += "${URI_flatpak-spawn}"
SRC_URI[flatpak-spawn.sha256sum] = "4fe559a20884cd463dcf475b37b4bfc2b917215e91570478c3a3a439cfd941c5"
RDEPENDS:flatpak-spawn = " \
 glibc \
 libgcc \
 glib2 \
"

URI_flatpak-xdg-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/flatpak-xdg-utils-1.0.6-1.el10.x86_64_v2.rpm;name=flatpak-xdg-utils;unpack=0"
SRC_URI += "${URI_flatpak-xdg-utils}"
SRC_URI[flatpak-xdg-utils.sha256sum] = "98808af4ffff077c0859b7dcc4d8fde0990f3b41d276a7859125729990f0c7e4"
RDEPENDS:flatpak-xdg-utils = " \
 glibc \
 libgcc \
 flatpak-spawn \
 glib2 \
"

URI_flatpak-xdg-utils-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/flatpak-xdg-utils-tests-1.0.6-1.el10.x86_64_v2.rpm;name=flatpak-xdg-utils-tests;unpack=0"
SRC_URI += "${URI_flatpak-xdg-utils-tests}"
SRC_URI[flatpak-xdg-utils-tests.sha256sum] = "9f0d645ab7547e903e05907067803f37d9144c478aed6666c8ce087008db5372"
RDEPENDS:flatpak-xdg-utils-tests = " \
 flatpak-spawn \
 flatpak-xdg-utils \
 libgcc \
 glib2 \
 glibc \
"
