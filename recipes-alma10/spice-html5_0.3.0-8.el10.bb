# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "spice-html5"
PE = "0"
PV = "0.3.0"
PR = "8.el10"
PACKAGES = "spice-html5"
PROVIDES = "rpm/spice-html5"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/spice-html5-0.3.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f1c27ef18e11f18bcade5c9642aed3c5355bd8924201c33df56aa905769506e7"

URI_spice-html5 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/spice-html5-0.3.0-8.el10.noarch.rpm;name=spice-html5;unpack=0"
SRC_URI += "${URI_spice-html5}"
SRC_URI[spice-html5.sha256sum] = "21af7dc0e7d73c7b09cb33f4571a8bd9ebcd0f5aa613102c74fa7331a1dd2f6e"
RDEPENDS:spice-html5 = ""
