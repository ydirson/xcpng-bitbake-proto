# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sssd"
PE = "0"
PV = "2.10.2"
PR = "3.el10_0.3"
PACKAGES = "libipa_hbac libsss_autofs libsss_certmap libsss_idmap libsss_nss_idmap libsss_sudo python3-libipa_hbac python3-libsss_nss_idmap python3-sss python3-sss-murmur python3-sssdconfig sssd sssd-ad sssd-client sssd-common sssd-common-pac sssd-dbus sssd-ipa sssd-kcm sssd-krb5 sssd-krb5-common sssd-ldap sssd-nfs-idmap sssd-passkey sssd-proxy sssd-tools sssd-winbind-idmap sssd-idp libsss_nss_idmap-devel libipa_hbac-devel libsss_certmap-devel libsss_idmap-devel"
PROVIDES = "rpm/libipa_hbac rpm/libsss_autofs rpm/libsss_certmap rpm/libsss_idmap rpm/libsss_nss_idmap rpm/libsss_sudo rpm/python3-libipa_hbac rpm/python3-libsss_nss_idmap rpm/python3-sss rpm/python3-sss-murmur rpm/python3-sssdconfig rpm/sssd rpm/sssd-ad rpm/sssd-client rpm/sssd-common rpm/sssd-common-pac rpm/sssd-dbus rpm/sssd-ipa rpm/sssd-kcm rpm/sssd-krb5 rpm/sssd-krb5-common rpm/sssd-ldap rpm/sssd-nfs-idmap rpm/sssd-passkey rpm/sssd-proxy rpm/sssd-tools rpm/sssd-winbind-idmap rpm/sssd-idp rpm/libsss_nss_idmap-devel rpm/libipa_hbac-devel rpm/libsss_certmap-devel rpm/libsss_idmap-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/sssd-2.10.2-3.el10_0.3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aeacd71f0caa22c693037d1aea1029605e2cbbfbc39cb89695b4c30d057e75e8"

URI_libipa_hbac = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libipa_hbac-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=libipa_hbac;unpack=0"
SRC_URI += "${URI_libipa_hbac}"
SRC_URI[libipa_hbac.sha256sum] = "0ccc24ef2b7298812d0a8dae07bf7fd98c60e7e1f3d4642b08f0e43206ce10fd"
RDEPENDS:libipa_hbac = " \
 glibc \
 libunistring \
"

URI_libsss_autofs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libsss_autofs-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=libsss_autofs;unpack=0"
SRC_URI += "${URI_libsss_autofs}"
SRC_URI[libsss_autofs.sha256sum] = "8ae8ffda6e70858f23aa1135e128a537ecb49775f0ad741f5589041af753ce41"
RDEPENDS:libsss_autofs = " \
 glibc \
"

URI_libsss_certmap = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libsss_certmap-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=libsss_certmap;unpack=0"
SRC_URI += "${URI_libsss_certmap}"
SRC_URI[libsss_certmap.sha256sum] = "44c358f9ae73ae016b61a74fb8ca31954e5b7a7a86345aab71d3ee498afd7b34"
RDEPENDS:libsss_certmap = " \
 glibc \
 openssl-libs \
 libtalloc \
"

URI_libsss_idmap = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libsss_idmap-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=libsss_idmap;unpack=0"
SRC_URI += "${URI_libsss_idmap}"
SRC_URI[libsss_idmap.sha256sum] = "46c8f7153f801f8a011c1df88e93650c3978bfd3a864f05a13676a36b573bddb"
RDEPENDS:libsss_idmap = " \
 glibc \
"

URI_libsss_nss_idmap = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libsss_nss_idmap-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=libsss_nss_idmap;unpack=0"
SRC_URI += "${URI_libsss_nss_idmap}"
SRC_URI[libsss_nss_idmap.sha256sum] = "893fd8bf0d5afa58f7200e78e10900a21b0b0eac8f08c9b65ec112b992db29a8"
RDEPENDS:libsss_nss_idmap = " \
 glibc \
"

URI_libsss_sudo = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libsss_sudo-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=libsss_sudo;unpack=0"
SRC_URI += "${URI_libsss_sudo}"
SRC_URI[libsss_sudo.sha256sum] = "7628e92337b4e0557e5c4d43eabc3814ea16555c879746805900b1cd08245540"
RDEPENDS:libsss_sudo = " \
 glibc \
"

URI_python3-libipa_hbac = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-libipa_hbac-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=python3-libipa_hbac;unpack=0"
SRC_URI += "${URI_python3-libipa_hbac}"
SRC_URI[python3-libipa_hbac.sha256sum] = "b0580905b19bab36cdd864993db4b001aac9d5c8bbb80359ff1e0dfbb41a8c4e"
RDEPENDS:python3-libipa_hbac = " \
 glibc \
 python3 \
 libipa_hbac \
 libunistring \
"

URI_python3-libsss_nss_idmap = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-libsss_nss_idmap-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=python3-libsss_nss_idmap;unpack=0"
SRC_URI += "${URI_python3-libsss_nss_idmap}"
SRC_URI[python3-libsss_nss_idmap.sha256sum] = "4e9bf91686ae432ca5054c5eb6fbe307bcd574fe1b224d7779f2c108903ba4fb"
RDEPENDS:python3-libsss_nss_idmap = " \
 glibc \
 python3 \
 libsss_nss_idmap \
"

URI_python3-sss = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-sss-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=python3-sss;unpack=0"
SRC_URI += "${URI_python3-sss}"
SRC_URI[python3-sss.sha256sum] = "33b9cd2998be2f695f10a174450e60d267f83241921e93b092f39f9ef1ee76db"
RDEPENDS:python3-sss = " \
 python3 \
 systemd-libs \
 libref_array \
 dbus-libs \
 libselinux \
 libbasicobjects \
 libcap \
 libcollection \
 libtalloc \
 libtdb \
 libtevent \
 libdhash \
 libunistring \
 openssl-libs \
 pcre2 \
 libini_config \
 sssd-common \
 libldb \
 popt \
 glibc \
"

URI_python3-sss-murmur = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-sss-murmur-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=python3-sss-murmur;unpack=0"
SRC_URI += "${URI_python3-sss-murmur}"
SRC_URI[python3-sss-murmur.sha256sum] = "261527c796ae347dca2287abedbf8215a89dc1e7315ff8ed2c7c1bb0c322a957"
RDEPENDS:python3-sss-murmur = " \
 glibc \
 python3 \
"

URI_python3-sssdconfig = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-sssdconfig-2.10.2-3.el10_0.3.noarch.rpm;name=python3-sssdconfig;unpack=0"
SRC_URI += "${URI_python3-sssdconfig}"
SRC_URI[python3-sssdconfig.sha256sum] = "7e4b26aee2e7453221b25613fc7c72167e8d99db2244de831ad5ed00854f4a83"
RDEPENDS:python3-sssdconfig = " \
 python3 \
"

URI_sssd = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/sssd-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=sssd;unpack=0"
SRC_URI += "${URI_sssd}"
SRC_URI[sssd.sha256sum] = "4fd2a02830f644d5028c19db16c7f37af22cb9c48f4ed959c398bc73b8bc784e"
RDEPENDS:sssd = " \
 sssd-ipa \
 shadow-utils \
 sssd-krb5 \
 sssd-ldap \
 sssd-proxy \
 sssd-ad \
 sssd-common \
"

URI_sssd-ad = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/sssd-ad-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=sssd-ad;unpack=0"
SRC_URI += "${URI_sssd-ad}"
SRC_URI[sssd-ad.sha256sum] = "43d9c3eedb091e97c48526978d0ab25898d69d3a19e160b08afdb992a3ce59d1"
RDEPENDS:sssd-ad = " \
 systemd-libs \
 keyutils-libs \
 samba-client-libs \
 krb5-libs \
 libref_array \
 cyrus-sasl-lib \
 dbus-libs \
 libselinux \
 libsmbclient \
 libbasicobjects \
 libsss_certmap \
 libcap \
 libsss_idmap \
 libcollection \
 libcom_err \
 libtalloc \
 libtdb \
 libtevent \
 libdhash \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 libini_config \
 sssd-common \
 sssd-common-pac \
 libldb \
 sssd-krb5-common \
 popt \
 glibc \
"

URI_sssd-client = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/sssd-client-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=sssd-client;unpack=0"
SRC_URI += "${URI_sssd-client}"
SRC_URI[sssd-client.sha256sum] = "01afa96d31030b405aafc19cbdfdeeb4d0d443be4aff74795d6fe7da265ed6ea"
RDEPENDS:sssd-client = " \
 libsss_idmap \
 pam-libs \
 krb5-libs \
 libsss_nss_idmap \
 libcom_err \
 bash \
 glibc \
 alternatives \
"

URI_sssd-common = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/sssd-common-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=sssd-common;unpack=0"
SRC_URI += "${URI_sssd-common}"
SRC_URI[sssd-common.sha256sum] = "d08d4093dad956987889289aae46ab71159e196a171ce3fd455627cdefabdf69"
RDEPENDS:sssd-common = " \
 systemd \
 systemd-libs \
 keyutils-libs \
 krb5-libs \
 libref_array \
 dbus-libs \
 libselinux \
 libbasicobjects \
 libsss_autofs \
 libsss_certmap \
 libcap \
 libsss_idmap \
 libcollection \
 libcom_err \
 libsss_sudo \
 libtalloc \
 libtdb \
 libtevent \
 libdhash \
 openldap \
 libunistring \
 shadow-utils \
 openssl-libs \
 p11-kit \
 pam-libs \
 bash \
 pcre2 \
 sssd-client \
 libini_config \
 glibc \
 c-ares \
 libldb \
 sssd-nfs-idmap \
 popt \
 libnl3 \
 coreutils \
"

URI_sssd-common-pac = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/sssd-common-pac-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=sssd-common-pac;unpack=0"
SRC_URI += "${URI_sssd-common-pac}"
SRC_URI[sssd-common-pac.sha256sum] = "0627b8581eec4814423a1557815a643d5cc1a01500d2548f519617cfaaeaf8fe"
RDEPENDS:sssd-common-pac = " \
 systemd-libs \
 libldb \
 samba-client-libs \
 libtevent \
 libsss_idmap \
 popt \
 libtalloc \
 libtdb \
 glibc \
 libselinux \
 sssd-common \
"

URI_sssd-dbus = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/sssd-dbus-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=sssd-dbus;unpack=0"
SRC_URI += "${URI_sssd-dbus}"
SRC_URI[sssd-dbus.sha256sum] = "af61b555f6c002a351a75416c77aa84ad9659e235c7d48e66d8027294994d041"
RDEPENDS:sssd-dbus = " \
 systemd \
 systemd-libs \
 libldb \
 libtevent \
 bash \
 libtalloc \
 popt \
 libtdb \
 glibc \
 libselinux \
 libdhash \
 sssd-common \
 dbus-libs \
"

URI_sssd-ipa = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/sssd-ipa-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=sssd-ipa;unpack=0"
SRC_URI += "${URI_sssd-ipa}"
SRC_URI[sssd-ipa.sha256sum] = "36664ee667f42bcb99ea0e6072ffb80a9b3fa59f7870ec9ad72bdb47991996a8"
RDEPENDS:sssd-ipa = " \
 systemd-libs \
 keyutils-libs \
 samba-client-libs \
 krb5-libs \
 libref_array \
 dbus-libs \
 libselinux \
 libsemanage \
 libbasicobjects \
 libsss_certmap \
 libcap \
 libsss_idmap \
 libcollection \
 libcom_err \
 libtalloc \
 libtdb \
 libtevent \
 libdhash \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 libini_config \
 sssd-common \
 libipa_hbac \
 sssd-common-pac \
 libldb \
 sssd-krb5-common \
 popt \
 glibc \
"

URI_sssd-kcm = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/sssd-kcm-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=sssd-kcm;unpack=0"
SRC_URI += "${URI_sssd-kcm}"
SRC_URI[sssd-kcm.sha256sum] = "9d6db052d36d5b666d8d07c57b847a10b3b9f3935b5b2381ec7ca57fbe2cd5ed"
RDEPENDS:sssd-kcm = " \
 libuuid \
 systemd \
 systemd-libs \
 libldb \
 sssd-krb5-common \
 libtevent \
 krb5-libs \
 bash \
 libtalloc \
 popt \
 glibc \
 libselinux \
 libdhash \
 sssd-common \
"

URI_sssd-krb5 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/sssd-krb5-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=sssd-krb5;unpack=0"
SRC_URI += "${URI_sssd-krb5}"
SRC_URI[sssd-krb5.sha256sum] = "ce79fcf4e02b80efb57e318f4f0c9957eb55aa8c1043f2f01ee669daab49169a"
RDEPENDS:sssd-krb5 = " \
 systemd-libs \
 keyutils-libs \
 krb5-libs \
 libref_array \
 dbus-libs \
 libselinux \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libtalloc \
 libtdb \
 libtevent \
 libdhash \
 libunistring \
 openssl-libs \
 pcre2 \
 libini_config \
 sssd-common \
 libldb \
 sssd-krb5-common \
 popt \
 glibc \
"

URI_sssd-krb5-common = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/sssd-krb5-common-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=sssd-krb5-common;unpack=0"
SRC_URI += "${URI_sssd-krb5-common}"
SRC_URI[sssd-krb5-common.sha256sum] = "7287ba21c8e90061d8cec48c16c715fc48288424ed2157ad62a6f804c824f16a"
RDEPENDS:sssd-krb5-common = " \
 systemd-libs \
 jansson \
 libcap \
 cyrus-sasl-gssapi \
 krb5-libs \
 popt \
 libtalloc \
 glibc \
 sssd-common \
"

URI_sssd-ldap = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/sssd-ldap-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=sssd-ldap;unpack=0"
SRC_URI += "${URI_sssd-ldap}"
SRC_URI[sssd-ldap.sha256sum] = "33344fa271581a8d0bc37ba447fccdc45c4b3be09e4f14ac85396bffeadbdbde"
RDEPENDS:sssd-ldap = " \
 systemd-libs \
 keyutils-libs \
 krb5-libs \
 libref_array \
 dbus-libs \
 libselinux \
 libbasicobjects \
 libsss_certmap \
 libcap \
 libsss_idmap \
 libcollection \
 libcom_err \
 libtalloc \
 libtdb \
 libtevent \
 libdhash \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 libini_config \
 sssd-common \
 libldb \
 sssd-krb5-common \
 popt \
 glibc \
"

URI_sssd-nfs-idmap = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/sssd-nfs-idmap-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=sssd-nfs-idmap;unpack=0"
SRC_URI += "${URI_sssd-nfs-idmap}"
SRC_URI[sssd-nfs-idmap.sha256sum] = "3b85c4652dd8cf01bc50242c1f0ae5b25ec4c1dc3b414989bfc6ca897c27b507"
RDEPENDS:sssd-nfs-idmap = " \
 glibc \
 libnfsidmap \
"

URI_sssd-passkey = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/sssd-passkey-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=sssd-passkey;unpack=0"
SRC_URI += "${URI_sssd-passkey}"
SRC_URI[sssd-passkey.sha256sum] = "6959c92b6b7722d5e21a89679dff09f34b64c88a34f2046aa5b7d8e3cf9c3b37"
RDEPENDS:sssd-passkey = " \
 jansson \
 libfido2 \
 openssl-libs \
 acl \
 krb5-libs \
 libcom_err \
 popt \
 libtalloc \
 glibc \
 sssd-common \
"

URI_sssd-proxy = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/sssd-proxy-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=sssd-proxy;unpack=0"
SRC_URI += "${URI_sssd-proxy}"
SRC_URI[sssd-proxy.sha256sum] = "e3a4430f559f8538281e8177e6502b6bf4db9985a8a74fdcb34a13e0a94f001c"
RDEPENDS:sssd-proxy = " \
 systemd-libs \
 libref_array \
 dbus-libs \
 libselinux \
 libbasicobjects \
 libsss_certmap \
 libcap \
 libcollection \
 libtalloc \
 libtdb \
 libtevent \
 libdhash \
 libunistring \
 openssl-libs \
 pam-libs \
 pcre2 \
 libini_config \
 sssd-common \
 libldb \
 popt \
 glibc \
"

URI_sssd-tools = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/sssd-tools-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=sssd-tools;unpack=0"
SRC_URI += "${URI_sssd-tools}"
SRC_URI[sssd-tools.sha256sum] = "493e8fef3574afaacc7d635ff5c8fe2a78a32b634db2833296ce8be3f8fd78ea"
RDEPENDS:sssd-tools = " \
 python3 \
 sssd-dbus \
 libldb \
 libsss_certmap \
 pam-libs \
 libref_array \
 bash \
 popt \
 libtalloc \
 python3-sssdconfig \
 glibc \
 python3-sss \
 libdhash \
 python3-systemd \
 sssd-common \
"

URI_sssd-winbind-idmap = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/sssd-winbind-idmap-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=sssd-winbind-idmap;unpack=0"
SRC_URI += "${URI_sssd-winbind-idmap}"
SRC_URI[sssd-winbind-idmap.sha256sum] = "6d07eb417b3ee06451bbe79a3dca3e211d4f54a81c51e91dc22e375281a13680"
RDEPENDS:sssd-winbind-idmap = " \
 glibc \
 libsss_nss_idmap \
 libtalloc \
 libsss_idmap \
"

URI_sssd-idp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sssd-idp-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=sssd-idp;unpack=0"
SRC_URI += "${URI_sssd-idp}"
SRC_URI[sssd-idp.sha256sum] = "60dafab87c3d9d16a285deaa107118d106e52d30e54ef6350447a2bbf65f783a"
RDEPENDS:sssd-idp = " \
 jansson \
 krb5-libs \
 libcom_err \
 popt \
 libtalloc \
 libcurl \
 glibc \
 libjose \
 sssd-common \
"

URI_libsss_nss_idmap-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libsss_nss_idmap-devel-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=libsss_nss_idmap-devel;unpack=0"
SRC_URI += "${URI_libsss_nss_idmap-devel}"
SRC_URI[libsss_nss_idmap-devel.sha256sum] = "668af90b89bd80512721db3ef674af45ff40bdd4560334646810278c7101eab0"
RDEPENDS:libsss_nss_idmap-devel = " \
 libsss_nss_idmap \
 pkgconf-pkg-config \
"

URI_libipa_hbac-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libipa_hbac-devel-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=libipa_hbac-devel;unpack=0"
SRC_URI += "${URI_libipa_hbac-devel}"
SRC_URI[libipa_hbac-devel.sha256sum] = "fcf49843dea14746e2b078d58e3af09528afb9f6147e93c918a364abd3c60fd0"
RDEPENDS:libipa_hbac-devel = " \
 libipa_hbac \
 pkgconf-pkg-config \
"

URI_libsss_certmap-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libsss_certmap-devel-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=libsss_certmap-devel;unpack=0"
SRC_URI += "${URI_libsss_certmap-devel}"
SRC_URI[libsss_certmap-devel.sha256sum] = "860a8204380b81b65728f390e1b3afd56e977607b5d5bb6facd57ae18ed5e725"
RDEPENDS:libsss_certmap-devel = " \
 libsss_certmap \
 pkgconf-pkg-config \
"

URI_libsss_idmap-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libsss_idmap-devel-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=libsss_idmap-devel;unpack=0"
SRC_URI += "${URI_libsss_idmap-devel}"
SRC_URI[libsss_idmap-devel.sha256sum] = "cd96e3aad7c3962bd7cac312363fbfc9b2030455f811daab98055a362fd03998"
RDEPENDS:libsss_idmap-devel = " \
 pkgconf-pkg-config \
 libsss_idmap \
"
