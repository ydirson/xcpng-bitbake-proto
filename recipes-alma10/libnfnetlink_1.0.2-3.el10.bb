# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libnfnetlink"
PE = "0"
PV = "1.0.2"
PR = "3.el10"
PACKAGES = "libnfnetlink libnfnetlink-devel"
PROVIDES = "rpm/libnfnetlink rpm/libnfnetlink-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libnfnetlink-1.0.2-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30bfdada4b0b7e669f05f83167456f18dc70024e18d448daa5256e4eaeca9d5a"

URI_libnfnetlink = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libnfnetlink-1.0.2-3.el10.x86_64_v2.rpm;name=libnfnetlink;unpack=0"
SRC_URI += "${URI_libnfnetlink}"
SRC_URI[libnfnetlink.sha256sum] = "1ba976a217dd2d39cea6f2cede9cbd4a56fde0504c5297c6faafb4157447d4bf"
RDEPENDS:libnfnetlink = " \
 glibc \
"

URI_libnfnetlink-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libnfnetlink-devel-1.0.2-3.el10.x86_64_v2.rpm;name=libnfnetlink-devel;unpack=0"
SRC_URI += "${URI_libnfnetlink-devel}"
SRC_URI[libnfnetlink-devel.sha256sum] = "2d0fe5af006586c29279b841169a04c6775940fb32ddd68126225e7e26433b97"
RDEPENDS:libnfnetlink-devel = " \
 libnfnetlink \
 kernel-headers \
 pkgconf-pkg-config \
"
