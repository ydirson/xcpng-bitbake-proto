# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-bg"
PE = "0"
PV = "4.3"
PR = "31.el10"
PACKAGES = "hunspell-bg"
PROVIDES = "rpm/hunspell-bg"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-bg-4.3-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3992e46da57e09a92ac0b521fa21f3a3dbf2e47f09869fc3dd42215ae13413cd"

URI_hunspell-bg = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-bg-4.3-31.el10.noarch.rpm;name=hunspell-bg;unpack=0"
SRC_URI += "${URI_hunspell-bg}"
SRC_URI[hunspell-bg.sha256sum] = "dcd3f79abfeb90e7420f9de8ecddaef14c76d703dcc945cc21b95a79cec24c5d"
RDEPENDS:hunspell-bg = " \
 hunspell-filesystem \
"
