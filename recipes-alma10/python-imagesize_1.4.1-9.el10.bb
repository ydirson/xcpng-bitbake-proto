# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-imagesize"
PE = "0"
PV = "1.4.1"
PR = "9.el10"
PACKAGES = "python3-imagesize"
PROVIDES = "rpm/python3-imagesize"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/python-imagesize-1.4.1-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45b1c83ab378850ad6e3b6bba18388852830a381fbff5818febab857ccec95f1"

URI_python3-imagesize = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-imagesize-1.4.1-9.el10.noarch.rpm;name=python3-imagesize;unpack=0"
SRC_URI += "${URI_python3-imagesize}"
SRC_URI[python3-imagesize.sha256sum] = "a2c359c6dd2f97fd17d9fd6187f6382b151348811bbc5986768b5b7c1f424bb1"
RDEPENDS:python3-imagesize = " \
 python3 \
"
