# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sqlite"
PE = "0"
PV = "3.46.1"
PR = "5.el10_0"
PACKAGES = "sqlite-libs sqlite sqlite-devel lemon sqlite-analyzer sqlite-doc sqlite-tcl sqlite-tools"
PROVIDES = "rpm/sqlite-libs rpm/sqlite rpm/sqlite-devel rpm/lemon rpm/sqlite-analyzer rpm/sqlite-doc rpm/sqlite-tcl rpm/sqlite-tools"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/sqlite-3.46.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a64cc31499652d782498f3ef135b26fc5b4cca9ca1e27da6718ce87430f1ffec"

URI_sqlite-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/sqlite-libs-3.46.1-5.el10_0.x86_64_v2.rpm;name=sqlite-libs;unpack=0"
SRC_URI += "${URI_sqlite-libs}"
SRC_URI[sqlite-libs.sha256sum] = "845acc568ab94b4843d7c481d3f3e2301174aedb1533a52fe2b8235c7f0ad50c"
RDEPENDS:sqlite-libs = " \
 glibc \
 zlib-ng-compat \
"

URI_sqlite = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sqlite-3.46.1-5.el10_0.x86_64_v2.rpm;name=sqlite;unpack=0"
SRC_URI += "${URI_sqlite}"
SRC_URI[sqlite.sha256sum] = "8e38f713e6693cd4af5b3a8929dfd97a8f0b11c5bf55e8aadaa0295d140ca114"
RDEPENDS:sqlite = " \
 glibc \
 sqlite-libs \
 zlib-ng-compat \
 readline \
"

URI_sqlite-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sqlite-devel-3.46.1-5.el10_0.x86_64_v2.rpm;name=sqlite-devel;unpack=0"
SRC_URI += "${URI_sqlite-devel}"
SRC_URI[sqlite-devel.sha256sum] = "5389c8bf0479552adc7a5773a9a9b984170e90c810c1a38de2da6a3d76293f39"
RDEPENDS:sqlite-devel = " \
 sqlite-libs \
 sqlite \
 pkgconf-pkg-config \
"

URI_lemon = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/lemon-3.46.1-5.el10_0.x86_64_v2.rpm;name=lemon;unpack=0"
SRC_URI += "${URI_lemon}"
SRC_URI[lemon.sha256sum] = "bb0284cbc14f68a68ac10e91b9ee6080fb985629719f68bc67aa33ac7a23e544"
RDEPENDS:lemon = " \
 glibc \
"

URI_sqlite-analyzer = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sqlite-analyzer-3.46.1-5.el10_0.x86_64_v2.rpm;name=sqlite-analyzer;unpack=0"
SRC_URI += "${URI_sqlite-analyzer}"
SRC_URI[sqlite-analyzer.sha256sum] = "a065dcfd326907650c38cec7d44d0f47e4ce09ab624930b22feb7d37513b3e82"
RDEPENDS:sqlite-analyzer = " \
 glibc \
 sqlite \
 tcl \
"

URI_sqlite-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sqlite-doc-3.46.1-5.el10_0.noarch.rpm;name=sqlite-doc;unpack=0"
SRC_URI += "${URI_sqlite-doc}"
SRC_URI[sqlite-doc.sha256sum] = "9ee167ad27de834ecfdf787aa3a08b41b229679695e5154ae42cc0c1cd179e10"
RDEPENDS:sqlite-doc = ""

URI_sqlite-tcl = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sqlite-tcl-3.46.1-5.el10_0.x86_64_v2.rpm;name=sqlite-tcl;unpack=0"
SRC_URI += "${URI_sqlite-tcl}"
SRC_URI[sqlite-tcl.sha256sum] = "1d096304a34547e922bac92d4274d1deeabc806ca63835b9fce35a4db075d17d"
RDEPENDS:sqlite-tcl = " \
 zlib-ng-compat \
 tcl \
 sqlite-libs \
 glibc \
 sqlite \
"

URI_sqlite-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sqlite-tools-3.46.1-5.el10_0.x86_64_v2.rpm;name=sqlite-tools;unpack=0"
SRC_URI += "${URI_sqlite-tools}"
SRC_URI[sqlite-tools.sha256sum] = "061e51134c4e22071b048aa1c4b2993f022c539c5a7cff997e0dba7bc8bbceb9"
RDEPENDS:sqlite-tools = " \
 glibc \
"
