# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mokutil"
PE = "2"
PV = "0.6.0"
PR = "11.el10"
PACKAGES = "mokutil"
PROVIDES = "rpm/mokutil"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/mokutil-0.6.0-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1fa5c771cb23229076c92fdfcb81a2c4fc9de2cc2638add7da5329e80b4682c6"

URI_mokutil = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/mokutil-0.6.0-11.el10.x86_64_v2.rpm;name=mokutil;unpack=0"
SRC_URI += "${URI_mokutil}"
SRC_URI[mokutil.sha256sum] = "2d47b76bafc7e6992d1ad4c7f74e1bc922ddf140c50f802295f8ca779392b55c"
RDEPENDS:mokutil = " \
 efivar-libs \
 keyutils-libs \
 libxcrypt \
 openssl-libs \
 glibc \
"
