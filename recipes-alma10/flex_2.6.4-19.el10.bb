# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "flex"
PE = "0"
PV = "2.6.4"
PR = "19.el10"
PACKAGES = "flex libfl-static libfl-devel libfl2"
PROVIDES = "rpm/flex rpm/libfl-static rpm/libfl-devel rpm/libfl2"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/flex-2.6.4-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6934df491088498ba132fb3e9447a6efd88975a40eb4e72781b98acc92c2002c"

URI_flex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/flex-2.6.4-19.el10.x86_64_v2.rpm;name=flex;unpack=0"
SRC_URI += "${URI_flex}"
SRC_URI[flex.sha256sum] = "ced8a8995cfcfa0ccac6da12565cd133c253ce54b8c735b74c1ec637de70a00c"
RDEPENDS:flex = " \
 glibc \
 m4 \
"

URI_libfl-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libfl-static-2.6.4-19.el10.x86_64_v2.rpm;name=libfl-static;unpack=0"
SRC_URI += "${URI_libfl-static}"
SRC_URI[libfl-static.sha256sum] = "8f6d68386f07054077b54db38eeeba32b4a28641af768236ddc01ef235b8b12a"
RDEPENDS:libfl-static = ""

URI_libfl-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libfl-devel-2.6.4-19.el10.x86_64_v2.rpm;name=libfl-devel;unpack=0"
SRC_URI += "${URI_libfl-devel}"
SRC_URI[libfl-devel.sha256sum] = "60d65a15038b414f3b37b6d6b9be1ab40c49a0a96b90011e9ae4e381753cfe71"
RDEPENDS:libfl-devel = " \
 libfl2 \
"

URI_libfl2 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libfl2-2.6.4-19.el10.x86_64_v2.rpm;name=libfl2;unpack=0"
SRC_URI += "${URI_libfl2}"
SRC_URI[libfl2.sha256sum] = "d0058e7eefd7780da0fded9a8d1df0b523013e50013196250cecfa0e79f23785"
RDEPENDS:libfl2 = " \
 glibc \
"
