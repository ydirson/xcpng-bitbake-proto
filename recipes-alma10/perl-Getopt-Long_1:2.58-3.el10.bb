# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Getopt-Long"
PE = "1"
PV = "2.58"
PR = "3.el10"
PACKAGES = "perl-Getopt-Long perl-Getopt-Long-tests"
PROVIDES = "rpm/perl-Getopt-Long rpm/perl-Getopt-Long-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Getopt-Long-2.58-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4308b7686fe43363aa3949ba879c7a4a95f0f5ff7b4c24295ad5b8e09b899fee"

URI_perl-Getopt-Long = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Getopt-Long-2.58-3.el10.noarch.rpm;name=perl-Getopt-Long;unpack=0"
SRC_URI += "${URI_perl-Getopt-Long}"
SRC_URI[perl-Getopt-Long.sha256sum] = "0818ae10c8f3644563f58b19e11a50113fbb030a63134a3751cec0c4bd87e28b"
RDEPENDS:perl-Getopt-Long = " \
 perl-constant \
 perl-libs \
 perl-Text-ParseWords \
 perl-Getopt-Long \
 perl-overload \
 perl-Exporter \
 perl-base \
 perl-Pod-Usage \
"

URI_perl-Getopt-Long-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Getopt-Long-tests-2.58-3.el10.noarch.rpm;name=perl-Getopt-Long-tests;unpack=0"
SRC_URI += "${URI_perl-Getopt-Long-tests}"
SRC_URI[perl-Getopt-Long-tests.sha256sum] = "33bd88a7f9e8c2f8b5553b1f79754da64efa90946a75255602a1861c9d60958f"
RDEPENDS:perl-Getopt-Long-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Getopt-Long \
 perl-overload \
 bash \
 perl-interpreter \
"
