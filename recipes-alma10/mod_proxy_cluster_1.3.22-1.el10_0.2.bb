# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mod_proxy_cluster"
PE = "0"
PV = "1.3.22"
PR = "1.el10_0.2"
PACKAGES = "mod_proxy_cluster"
PROVIDES = "rpm/mod_proxy_cluster"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mod_proxy_cluster-1.3.22-1.el10_0.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eedee5c1840e8ba13be751075b9ce6e6161b23029d4f201c3b5299870631dbb6"

URI_mod_proxy_cluster = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mod_proxy_cluster-1.3.22-1.el10_0.2.x86_64_v2.rpm;name=mod_proxy_cluster;unpack=0"
SRC_URI += "${URI_mod_proxy_cluster}"
SRC_URI[mod_proxy_cluster.sha256sum] = "5d51a253a8f328a97afaf0feeb45131add00d1dd7096716e4f0c68b3689dd397"
RDEPENDS:mod_proxy_cluster = " \
 python3-policycoreutils \
 httpd \
 policycoreutils-python-utils \
 apr \
 apr-util \
 bash \
 glibc \
"
