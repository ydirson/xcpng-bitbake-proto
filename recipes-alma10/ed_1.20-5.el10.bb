# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ed"
PE = "0"
PV = "1.20"
PR = "5.el10"
PACKAGES = "ed"
PROVIDES = "rpm/ed"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/ed-1.20-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84ffea7405834522a007221ca7c3b0c79ae4ca41e2a0ff954ae4cd34706c7825"

URI_ed = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/ed-1.20-5.el10.x86_64_v2.rpm;name=ed;unpack=0"
SRC_URI += "${URI_ed}"
SRC_URI[ed.sha256sum] = "0d5fa8cf5011f57c05db5b0db162ed71312b07343251096fc23f5bd83413d351"
RDEPENDS:ed = " \
 glibc \
 bash \
"
