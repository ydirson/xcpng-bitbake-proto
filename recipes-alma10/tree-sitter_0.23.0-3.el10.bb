# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tree-sitter"
PE = "0"
PV = "0.23.0"
PR = "3.el10"
PACKAGES = "libtree-sitter libtree-sitter-devel"
PROVIDES = "rpm/libtree-sitter rpm/libtree-sitter-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tree-sitter-0.23.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e72f9ae5f86f91079a7a9131bf02ee41502f931051ea3ad1fd8ab06503e9aa9"

URI_libtree-sitter = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libtree-sitter-0.23.0-3.el10.x86_64_v2.rpm;name=libtree-sitter;unpack=0"
SRC_URI += "${URI_libtree-sitter}"
SRC_URI[libtree-sitter.sha256sum] = "1f8c2b9d5f607ff3924a2f3a90f9af63b9af1b9a28c29a65fa7d6fb3cc07ce85"
RDEPENDS:libtree-sitter = " \
 glibc \
"

URI_libtree-sitter-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libtree-sitter-devel-0.23.0-3.el10.x86_64_v2.rpm;name=libtree-sitter-devel;unpack=0"
SRC_URI += "${URI_libtree-sitter-devel}"
SRC_URI[libtree-sitter-devel.sha256sum] = "d03baec2e408ee48d2972751f74bad82464a0dfa69e936fdf6446985adcf2b52"
RDEPENDS:libtree-sitter-devel = " \
 libtree-sitter \
 pkgconf-pkg-config \
"
