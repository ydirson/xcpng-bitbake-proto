# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-is"
PE = "0"
PV = "0.20090823"
PR = "31.el10"
PACKAGES = "hunspell-is"
PROVIDES = "rpm/hunspell-is"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-is-0.20090823-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff4956ce508ca5fd659a359344ad54d5d127766e5bf3fe95c616ceeefa0b276a"

URI_hunspell-is = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-is-0.20090823-31.el10.noarch.rpm;name=hunspell-is;unpack=0"
SRC_URI += "${URI_hunspell-is}"
SRC_URI[hunspell-is.sha256sum] = "8cc1ddac05e29cf69c52554ef6f204d4996eec14c101c062522bf684eb5425cc"
RDEPENDS:hunspell-is = " \
 hunspell-filesystem \
"
