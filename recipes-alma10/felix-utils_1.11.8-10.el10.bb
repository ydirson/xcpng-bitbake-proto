# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "felix-utils"
PE = "0"
PV = "1.11.8"
PR = "10.el10"
PACKAGES = "felix-utils felix-utils-javadoc"
PROVIDES = "rpm/felix-utils rpm/felix-utils-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/felix-utils-1.11.8-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd044f684fbf088ea97fff71bb2d433719562b5b04bada5c9ba34bdc3507af78"

URI_felix-utils = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/felix-utils-1.11.8-10.el10.noarch.rpm;name=felix-utils;unpack=0"
SRC_URI += "${URI_felix-utils}"
SRC_URI[felix-utils.sha256sum] = "2812269fbf9902feea254f09641086e4cd2020eabd6d209608c377611dfcceb0"
RDEPENDS:felix-utils = " \
 javapackages-filesystem \
"

URI_felix-utils-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/felix-utils-javadoc-1.11.8-10.el10.noarch.rpm;name=felix-utils-javadoc;unpack=0"
SRC_URI += "${URI_felix-utils-javadoc}"
SRC_URI[felix-utils-javadoc.sha256sum] = "bc3022fc4196f928780c35acf7a2447e0e76457d809ea4cf7b8b5b53f08a8713"
RDEPENDS:felix-utils-javadoc = " \
 javapackages-filesystem \
"
