# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "socat"
PE = "0"
PV = "1.7.4.4"
PR = "8.el10"
PACKAGES = "socat"
PROVIDES = "rpm/socat"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/socat-1.7.4.4-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b9e21f09e5aef00419686e76a44f1efc52b6168aa41e12c27633489a120deb3"

URI_socat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/socat-1.7.4.4-8.el10.x86_64_v2.rpm;name=socat;unpack=0"
SRC_URI += "${URI_socat}"
SRC_URI[socat.sha256sum] = "37529e8a17531d225b80ac14a66ee5dab8d9b92d24bc5ed282cbd1179d00776f"
RDEPENDS:socat = " \
 glibc \
 openssl-libs \
 readline \
"
