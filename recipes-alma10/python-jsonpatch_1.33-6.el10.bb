# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-jsonpatch"
PE = "0"
PV = "1.33"
PR = "6.el10"
PACKAGES = "python3-jsonpatch"
PROVIDES = "rpm/python3-jsonpatch"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-jsonpatch-1.33-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da9ab611d58273dd8dab59663c6621d566c3c850802b5587e76b5820a6cf47a9"

URI_python3-jsonpatch = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-jsonpatch-1.33-6.el10.noarch.rpm;name=python3-jsonpatch;unpack=0"
SRC_URI += "${URI_python3-jsonpatch}"
SRC_URI[python3-jsonpatch.sha256sum] = "37ed43424ff4b07d286e14d5882269116d879a19b66f51e9296f4e7a803cab2d"
RDEPENDS:python3-jsonpatch = " \
 python3 \
 python3-jsonpointer \
"
