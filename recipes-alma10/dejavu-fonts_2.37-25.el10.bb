# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dejavu-fonts"
PE = "0"
PV = "2.37"
PR = "25.el10"
PACKAGES = "dejavu-sans-fonts dejavu-sans-mono-fonts dejavu-serif-fonts dejavu-lgc-sans-fonts dejavu-lgc-sans-mono-fonts dejavu-lgc-serif-fonts dejavu-fonts-all dejavu-fonts-doc dejavu-lgc-fonts-all"
PROVIDES = "rpm/dejavu-sans-fonts rpm/dejavu-sans-mono-fonts rpm/dejavu-serif-fonts rpm/dejavu-lgc-sans-fonts rpm/dejavu-lgc-sans-mono-fonts rpm/dejavu-lgc-serif-fonts rpm/dejavu-fonts-all rpm/dejavu-fonts-doc rpm/dejavu-lgc-fonts-all"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/dejavu-fonts-2.37-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a4d1c473174133b8ff31df6e088bd8d8d3bc9eb27b5b4f4948a32a0510d5da3"

URI_dejavu-sans-fonts = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/dejavu-sans-fonts-2.37-25.el10.noarch.rpm;name=dejavu-sans-fonts;unpack=0"
SRC_URI += "${URI_dejavu-sans-fonts}"
SRC_URI[dejavu-sans-fonts.sha256sum] = "42dd4d1ab62f0da288c5cc56bb833a88b861dc5fb237b6c7f81e32e7147d1a23"
RDEPENDS:dejavu-sans-fonts = " \
 fonts-filesystem \
"

URI_dejavu-sans-mono-fonts = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/dejavu-sans-mono-fonts-2.37-25.el10.noarch.rpm;name=dejavu-sans-mono-fonts;unpack=0"
SRC_URI += "${URI_dejavu-sans-mono-fonts}"
SRC_URI[dejavu-sans-mono-fonts.sha256sum] = "1c90ed14525d1ad38acdda7ef7d173fccfd3685ab92d446ebe00cd38d02c1137"
RDEPENDS:dejavu-sans-mono-fonts = " \
 fonts-filesystem \
"

URI_dejavu-serif-fonts = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/dejavu-serif-fonts-2.37-25.el10.noarch.rpm;name=dejavu-serif-fonts;unpack=0"
SRC_URI += "${URI_dejavu-serif-fonts}"
SRC_URI[dejavu-serif-fonts.sha256sum] = "1b386fc4285b5e9e22d7936effbd07702eea7cb45f3ed204849dcd8bd522d96e"
RDEPENDS:dejavu-serif-fonts = " \
 fonts-filesystem \
"

URI_dejavu-lgc-sans-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dejavu-lgc-sans-fonts-2.37-25.el10.noarch.rpm;name=dejavu-lgc-sans-fonts;unpack=0"
SRC_URI += "${URI_dejavu-lgc-sans-fonts}"
SRC_URI[dejavu-lgc-sans-fonts.sha256sum] = "00b4d7337bb25b89a2f93b909f4134f94c9f2afd165972322b7a0e8bd8878855"
RDEPENDS:dejavu-lgc-sans-fonts = " \
 fonts-filesystem \
"

URI_dejavu-lgc-sans-mono-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dejavu-lgc-sans-mono-fonts-2.37-25.el10.noarch.rpm;name=dejavu-lgc-sans-mono-fonts;unpack=0"
SRC_URI += "${URI_dejavu-lgc-sans-mono-fonts}"
SRC_URI[dejavu-lgc-sans-mono-fonts.sha256sum] = "ff8ea4b6f009aba46d3f6f1b886b490bd46a3c63e0d3110149b702fbd6a361a5"
RDEPENDS:dejavu-lgc-sans-mono-fonts = " \
 fonts-filesystem \
"

URI_dejavu-lgc-serif-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dejavu-lgc-serif-fonts-2.37-25.el10.noarch.rpm;name=dejavu-lgc-serif-fonts;unpack=0"
SRC_URI += "${URI_dejavu-lgc-serif-fonts}"
SRC_URI[dejavu-lgc-serif-fonts.sha256sum] = "a32bb81c2ef0317f177b3338a94cedc45bacc8fd7012187ac6c964e43e198964"
RDEPENDS:dejavu-lgc-serif-fonts = " \
 fonts-filesystem \
"

URI_dejavu-fonts-all = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/dejavu-fonts-all-2.37-25.el10.noarch.rpm;name=dejavu-fonts-all;unpack=0"
SRC_URI += "${URI_dejavu-fonts-all}"
SRC_URI[dejavu-fonts-all.sha256sum] = "50a7945f57a3cc696a4e9e331ee09605697df0c2b9e0075aba6656962a8352c0"
RDEPENDS:dejavu-fonts-all = " \
 dejavu-sans-fonts \
 dejavu-sans-mono-fonts \
 dejavu-serif-fonts \
"

URI_dejavu-fonts-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/dejavu-fonts-doc-2.37-25.el10.noarch.rpm;name=dejavu-fonts-doc;unpack=0"
SRC_URI += "${URI_dejavu-fonts-doc}"
SRC_URI[dejavu-fonts-doc.sha256sum] = "09a41d52879cbf9149f49128a59ef3511cdfdf1561a8051ff67018f5830761bf"
RDEPENDS:dejavu-fonts-doc = ""

URI_dejavu-lgc-fonts-all = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/dejavu-lgc-fonts-all-2.37-25.el10.noarch.rpm;name=dejavu-lgc-fonts-all;unpack=0"
SRC_URI += "${URI_dejavu-lgc-fonts-all}"
SRC_URI[dejavu-lgc-fonts-all.sha256sum] = "25aeaaa798ed34311107b061a04a7dfb69814983e03a50e454f899b607504bf3"
RDEPENDS:dejavu-lgc-fonts-all = " \
 dejavu-lgc-serif-fonts \
 dejavu-lgc-sans-fonts \
 dejavu-lgc-sans-mono-fonts \
"
