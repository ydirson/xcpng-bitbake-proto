# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-hu"
PE = "0"
PV = "0.20090612"
PR = "35.el10"
PACKAGES = "hyphen-hu"
PROVIDES = "rpm/hyphen-hu"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-hu-0.20090612-35.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aeb75697ab2b4c90ab245c84a2625bbd29ba3679ad2735efd7fdd2f89fbda343"

URI_hyphen-hu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-hu-0.20090612-35.el10.noarch.rpm;name=hyphen-hu;unpack=0"
SRC_URI += "${URI_hyphen-hu}"
SRC_URI[hyphen-hu.sha256sum] = "7eaef8a8e9bd5014c78f3bfe685fea801680ceb3a574856f5bf224a43fa673ea"
RDEPENDS:hyphen-hu = " \
 hyphen \
"
