# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libical"
PE = "0"
PV = "3.0.18"
PR = "3.el10"
PACKAGES = "libical libical-glib libical-devel libical-glib-devel libical-glib-doc"
PROVIDES = "rpm/libical rpm/libical-glib rpm/libical-devel rpm/libical-glib-devel rpm/libical-glib-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libical-3.0.18-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31a9aa0e7b29c93a7c70709957ddd6742d1c67e2a667f63c2595f7188a4654e3"

URI_libical = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libical-3.0.18-3.el10.x86_64_v2.rpm;name=libical;unpack=0"
SRC_URI += "${URI_libical}"
SRC_URI[libical.sha256sum] = "9b1402d4c494d94c56b33f53b9327304105c560638f4d3d54d82bba74486b53b"
RDEPENDS:libical = " \
 tzdata \
 libgcc \
 libstdc++ \
 glibc \
 libicu \
"

URI_libical-glib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libical-glib-3.0.18-3.el10.x86_64_v2.rpm;name=libical-glib;unpack=0"
SRC_URI += "${URI_libical-glib}"
SRC_URI[libical-glib.sha256sum] = "f8091c26ef65c36cd02a3602acc9fddc774f8b2f5a879d99b4bffa04d9413261"
RDEPENDS:libical-glib = " \
 glibc \
 glib2 \
 libical \
"

URI_libical-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libical-devel-3.0.18-3.el10.x86_64_v2.rpm;name=libical-devel;unpack=0"
SRC_URI += "${URI_libical-devel}"
SRC_URI[libical-devel.sha256sum] = "36b1fca847b184717a04d2610a7e469a6f40cae568f6bde8b96962a2b430ce96"
RDEPENDS:libical-devel = " \
 libicu-devel \
 cmake-filesystem \
 pkgconf-pkg-config \
 libical \
"

URI_libical-glib-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libical-glib-devel-3.0.18-3.el10.x86_64_v2.rpm;name=libical-glib-devel;unpack=0"
SRC_URI += "${URI_libical-glib-devel}"
SRC_URI[libical-glib-devel.sha256sum] = "33c80a3a92e8ab304c125d9443c4def69c3e60c79f0355fb566f4f8bd28fdc9f"
RDEPENDS:libical-glib-devel = " \
 libical-glib \
 libical-devel \
 glib2-devel \
 pkgconf-pkg-config \
"

URI_libical-glib-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libical-glib-doc-3.0.18-3.el10.noarch.rpm;name=libical-glib-doc;unpack=0"
SRC_URI += "${URI_libical-glib-doc}"
SRC_URI[libical-glib-doc.sha256sum] = "11adbb2b84f10bd6a8556358be31132151f40899811d90d9be81ffbc89f01b95"
RDEPENDS:libical-glib-doc = ""
