# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xorg-x11-proto-devel"
PE = "0"
PV = "2024.1"
PR = "3.el10"
PACKAGES = "xorg-x11-proto-devel"
PROVIDES = "rpm/xorg-x11-proto-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xorg-x11-proto-devel-2024.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00f666339881d5664776e94bc605a2bd6851102a1c143cda3769f4d3d0373605"

URI_xorg-x11-proto-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xorg-x11-proto-devel-2024.1-3.el10.noarch.rpm;name=xorg-x11-proto-devel;unpack=0"
SRC_URI += "${URI_xorg-x11-proto-devel}"
SRC_URI[xorg-x11-proto-devel.sha256sum] = "2bea35b7beb98d163c08e8c37bf95788ac663edee1a96ef0a653ce6e9b96c30e"
RDEPENDS:xorg-x11-proto-devel = " \
 xorg-x11-proto-devel \
 pkgconf-pkg-config \
"
