# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dbus-broker"
PE = "0"
PV = "36"
PR = "1.el10"
PACKAGES = "dbus-broker"
PROVIDES = "rpm/dbus-broker"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/dbus-broker-36-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1f0cbbdb792a8e975a14ecafe2c234bdadc6504f791ec8d9afddacc3a8436b2"

URI_dbus-broker = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/dbus-broker-36-1.el10.x86_64_v2.rpm;name=dbus-broker;unpack=0"
SRC_URI += "${URI_dbus-broker}"
SRC_URI[dbus-broker.sha256sum] = "b8b22221fa91a55f58fd2ff6840082b8c117435eaad38497f18c69926d0c8eeb"
RDEPENDS:dbus-broker = " \
 shadow-utils \
 systemd-libs \
 audit-libs \
 libgcc \
 libcap-ng \
 bash \
 expat \
 glibc \
 libselinux \
 dbus-common \
"
