# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libzip"
PE = "0"
PV = "1.10.1"
PR = "5.el10"
PACKAGES = "libzip libzip-tools libzip-devel"
PROVIDES = "rpm/libzip rpm/libzip-tools rpm/libzip-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libzip-1.10.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc5819e6f21f2df604b73daf3f84c669cde8d86ddbc1216a4a6c7a754c5cf194"

URI_libzip = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libzip-1.10.1-5.el10.x86_64_v2.rpm;name=libzip;unpack=0"
SRC_URI += "${URI_libzip}"
SRC_URI[libzip.sha256sum] = "37d5e4540b6d0e79154962bd7f7a430bf48cedca6bae44fee312dccdc35adfd7"
RDEPENDS:libzip = " \
 zlib-ng-compat \
 bzip2-libs \
 openssl-libs \
 libzstd \
 glibc \
 xz-libs \
"

URI_libzip-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libzip-tools-1.10.1-5.el10.x86_64_v2.rpm;name=libzip-tools;unpack=0"
SRC_URI += "${URI_libzip-tools}"
SRC_URI[libzip-tools.sha256sum] = "d78bfe1edcc119617aceae49b81074a6cf025308f9b32ab0a2a0dbe22ab3df23"
RDEPENDS:libzip-tools = " \
 glibc \
 libzip \
 zlib-ng-compat \
"

URI_libzip-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libzip-devel-1.10.1-5.el10.x86_64_v2.rpm;name=libzip-devel;unpack=0"
SRC_URI += "${URI_libzip-devel}"
SRC_URI[libzip-devel.sha256sum] = "c62b473cfcdcfb4991fd07c00fbe3fa8ecc8c09e7a025ba25e4fabd312131bf7"
RDEPENDS:libzip-devel = " \
 libzip \
 cmake-filesystem \
 pkgconf-pkg-config \
"
