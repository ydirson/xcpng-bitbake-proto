# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "newt"
PE = "0"
PV = "0.52.24"
PR = "5.el10"
PACKAGES = "newt newt-devel python3-newt"
PROVIDES = "rpm/newt rpm/newt-devel rpm/python3-newt"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/newt-0.52.24-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb305dadb56d55e416ae0d3ac94fb381f7017f03c2797abe5ac6db9a3b7e1d66"

URI_newt = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/newt-0.52.24-5.el10.x86_64_v2.rpm;name=newt;unpack=0"
SRC_URI += "${URI_newt}"
SRC_URI[newt.sha256sum] = "6b02cdd0b0a7e6b1720f88bc781aed12c0c067d686e41f764794e67aecad1bf9"
RDEPENDS:newt = " \
 glibc \
 slang \
 popt \
"

URI_newt-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/newt-devel-0.52.24-5.el10.x86_64_v2.rpm;name=newt-devel;unpack=0"
SRC_URI += "${URI_newt-devel}"
SRC_URI[newt-devel.sha256sum] = "34f8cf8650b03a0fd046d6466550b8cbede63604994bc6d8e0f0a16b256b3f07"
RDEPENDS:newt-devel = " \
 newt \
 slang-devel \
 pkgconf-pkg-config \
"

URI_python3-newt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-newt-0.52.24-5.el10.x86_64_v2.rpm;name=python3-newt;unpack=0"
SRC_URI += "${URI_python3-newt}"
SRC_URI[python3-newt.sha256sum] = "e23cf6ec6e3c681bf4b125819fcc6b13fe49474a54f711bc8fb67b73fdbc3bb6"
RDEPENDS:python3-newt = " \
 glibc \
 newt \
 python3 \
"
