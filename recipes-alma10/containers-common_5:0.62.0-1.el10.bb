# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "containers-common"
PE = "5"
PV = "0.62.0"
PR = "1.el10"
PACKAGES = "containers-common containers-common-extra"
PROVIDES = "rpm/containers-common rpm/containers-common-extra"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/containers-common-0.62.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b74a393b91e612757ad5bf425a1b708914d9fd6635ad78c3e3762302ff77920e"

URI_containers-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/containers-common-0.62.0-1.el10.noarch.rpm;name=containers-common;unpack=0"
SRC_URI += "${URI_containers-common}"
SRC_URI[containers-common.sha256sum] = "66d92377bf8287ab24f05dfd3981a4e21cba5dfe8689ce9aecfb2524b74570a2"
RDEPENDS:containers-common = " \
 container-selinux \
 netavark \
"

URI_containers-common-extra = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/containers-common-extra-0.62.0-1.el10.noarch.rpm;name=containers-common-extra;unpack=0"
SRC_URI += "${URI_containers-common-extra}"
SRC_URI[containers-common-extra.sha256sum] = "3292ccfb82baafc3472f47b90617438b3680e1a298ace75b152dd8c99dc97be2"
RDEPENDS:containers-common-extra = " \
 containers-common \
 nftables \
 netavark \
 crun \
 passt \
"
