# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mesa"
PE = "0"
PV = "24.2.8"
PR = "3.el10_0.alma.1"
PACKAGES = "mesa-dri-drivers mesa-filesystem mesa-libEGL mesa-libEGL-devel mesa-libGL mesa-libGL-devel mesa-libgbm mesa-libgbm-devel mesa-libglapi mesa-libxatracker mesa-vulkan-drivers mesa-libOSMesa mesa-libOSMesa-devel mesa-libxatracker-devel mesa-va-drivers mesa-vdpau-drivers"
PROVIDES = "rpm/mesa-dri-drivers rpm/mesa-filesystem rpm/mesa-libEGL rpm/mesa-libEGL-devel rpm/mesa-libGL rpm/mesa-libGL-devel rpm/mesa-libgbm rpm/mesa-libgbm-devel rpm/mesa-libglapi rpm/mesa-libxatracker rpm/mesa-vulkan-drivers rpm/mesa-libOSMesa rpm/mesa-libOSMesa-devel rpm/mesa-libxatracker-devel rpm/mesa-va-drivers rpm/mesa-vdpau-drivers"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mesa-24.2.8-3.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b24ef8438833c76a9bf832dd21cdac1d09e86713ea17bc2015c865d0d7a3469a"

URI_mesa-dri-drivers = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mesa-dri-drivers-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=mesa-dri-drivers;unpack=0"
SRC_URI += "${URI_mesa-dri-drivers}"
SRC_URI[mesa-dri-drivers.sha256sum] = "ee15b8e47647013adb24018e5d43eedba9e36328fdb4d7efa415d41e30d3ba2d"
RDEPENDS:mesa-dri-drivers = " \
 libxshmfence \
 zlib-ng-compat \
 mesa-filesystem \
 libgcc \
 elfutils-libelf \
 libzstd \
 libxcb \
 libstdc++ \
 libX11-xcb \
 mesa-libgbm \
 expat \
 glibc \
 mesa-libglapi \
 llvm-libs \
 libdrm \
"

URI_mesa-filesystem = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mesa-filesystem-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=mesa-filesystem;unpack=0"
SRC_URI += "${URI_mesa-filesystem}"
SRC_URI[mesa-filesystem.sha256sum] = "ad3cebd9714112713acf4e667c23ea803ca233922c6272b9890d094587168ba9"
RDEPENDS:mesa-filesystem = ""

URI_mesa-libEGL = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mesa-libEGL-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=mesa-libEGL;unpack=0"
SRC_URI += "${URI_mesa-libEGL}"
SRC_URI[mesa-libEGL.sha256sum] = "b83584b69fa4aa5d3c7c53b85e0cb4c5600303e08560c035c4b186101cc86498"
RDEPENDS:mesa-libEGL = " \
 libxshmfence \
 libwayland-client \
 mesa-dri-drivers \
 libglvnd-egl \
 libwayland-server \
 libxcb \
 libX11-xcb \
 mesa-libgbm \
 expat \
 glibc \
 mesa-libglapi \
 libdrm \
"

URI_mesa-libEGL-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mesa-libEGL-devel-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=mesa-libEGL-devel;unpack=0"
SRC_URI += "${URI_mesa-libEGL-devel}"
SRC_URI[mesa-libEGL-devel.sha256sum] = "09e0676b89c6773bcee39c1c52cbb3e504ae6fc2d5baaa8440ed004b94967534"
RDEPENDS:mesa-libEGL-devel = " \
 mesa-libEGL \
 libglvnd-devel \
"

URI_mesa-libGL = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mesa-libGL-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=mesa-libGL;unpack=0"
SRC_URI += "${URI_mesa-libGL}"
SRC_URI[mesa-libGL.sha256sum] = "509999e9f62dd0ba09b0a7bcab2b8439be34b414283ea14a5de4c62f21ce6ec8"
RDEPENDS:mesa-libGL = " \
 libXfixes \
 libxshmfence \
 mesa-dri-drivers \
 libglvnd-glx \
 libX11 \
 libxcb \
 libX11-xcb \
 libXxf86vm \
 expat \
 glibc \
 mesa-libglapi \
 libdrm \
 libXext \
"

URI_mesa-libGL-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mesa-libGL-devel-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=mesa-libGL-devel;unpack=0"
SRC_URI += "${URI_mesa-libGL-devel}"
SRC_URI[mesa-libGL-devel.sha256sum] = "abe3bed725e4e2194c51bb4d1ef55a999428b302ad1bceaa56d6d9b0a6b8d919"
RDEPENDS:mesa-libGL-devel = " \
 libglvnd-devel \
 pkgconf-pkg-config \
 mesa-libGL \
 mesa-libglapi \
 libdrm-devel \
"

URI_mesa-libgbm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mesa-libgbm-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=mesa-libgbm;unpack=0"
SRC_URI += "${URI_mesa-libgbm}"
SRC_URI[mesa-libgbm.sha256sum] = "577ad30d12f318ea9a8f3c733bc301d54f0ff6a33133525a4ec570464c4030c3"
RDEPENDS:mesa-libgbm = " \
 mesa-dri-drivers \
 libwayland-server \
 libxcb \
 expat \
 glibc \
 libdrm \
"

URI_mesa-libgbm-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mesa-libgbm-devel-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=mesa-libgbm-devel;unpack=0"
SRC_URI += "${URI_mesa-libgbm-devel}"
SRC_URI[mesa-libgbm-devel.sha256sum] = "0380971e25870bc99a16dfde992d32feaea1a9a2eb70895a13f3db47fd7a4231"
RDEPENDS:mesa-libgbm-devel = " \
 mesa-libgbm \
 pkgconf-pkg-config \
"

URI_mesa-libglapi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mesa-libglapi-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=mesa-libglapi;unpack=0"
SRC_URI += "${URI_mesa-libglapi}"
SRC_URI[mesa-libglapi.sha256sum] = "59dda405bfabcd859132fd335a478be4d59a739c69cdb3bec6bbc68e6b923b8c"
RDEPENDS:mesa-libglapi = " \
 glibc \
 mesa-dri-drivers \
"

URI_mesa-libxatracker = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mesa-libxatracker-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=mesa-libxatracker;unpack=0"
SRC_URI += "${URI_mesa-libxatracker}"
SRC_URI[mesa-libxatracker.sha256sum] = "434e055b672de3b649192cd2da88db6585fcfc7debf195f915ac0e0e823e07b0"
RDEPENDS:mesa-libxatracker = " \
 zlib-ng-compat \
 libgcc \
 libzstd \
 libstdc++ \
 expat \
 glibc \
 llvm-libs \
 libdrm \
"

URI_mesa-vulkan-drivers = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mesa-vulkan-drivers-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=mesa-vulkan-drivers;unpack=0"
SRC_URI += "${URI_mesa-vulkan-drivers}"
SRC_URI[mesa-vulkan-drivers.sha256sum] = "ff550e4cb381558df408e1c97d4106ec76e5e9f655cac83295e200fa6b6dd79c"
RDEPENDS:mesa-vulkan-drivers = " \
 libxshmfence \
 zlib-ng-compat \
 libwayland-client \
 mesa-filesystem \
 libgcc \
 elfutils-libelf \
 libzstd \
 libxcb \
 libstdc++ \
 libX11-xcb \
 expat \
 glibc \
 vulkan-loader \
 llvm-libs \
 libdrm \
"

URI_mesa-libOSMesa = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mesa-libOSMesa-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=mesa-libOSMesa;unpack=0"
SRC_URI += "${URI_mesa-libOSMesa}"
SRC_URI[mesa-libOSMesa.sha256sum] = "cd011baaaba809baa4c8c7cf4de5e1780adca426432e62fd7105afc2296a9311"
RDEPENDS:mesa-libOSMesa = " \
 zlib-ng-compat \
 libgcc \
 libzstd \
 libstdc++ \
 glibc \
 mesa-libglapi \
 llvm-libs \
 libdrm \
"

URI_mesa-libOSMesa-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mesa-libOSMesa-devel-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=mesa-libOSMesa-devel;unpack=0"
SRC_URI += "${URI_mesa-libOSMesa-devel}"
SRC_URI[mesa-libOSMesa-devel.sha256sum] = "7f25f6e08d9caffbf1b8ae2a68a028723e2edff0a16de48db8f55971fcf3e511"
RDEPENDS:mesa-libOSMesa-devel = " \
 mesa-libOSMesa \
 pkgconf-pkg-config \
"

URI_mesa-libxatracker-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mesa-libxatracker-devel-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=mesa-libxatracker-devel;unpack=0"
SRC_URI += "${URI_mesa-libxatracker-devel}"
SRC_URI[mesa-libxatracker-devel.sha256sum] = "a3ad4940dd2859c004fc004c1f4bb0c52ac5e7bfe01718b800df2eb60cf1372f"
RDEPENDS:mesa-libxatracker-devel = " \
 mesa-libxatracker \
 pkgconf-pkg-config \
"

URI_mesa-va-drivers = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mesa-va-drivers-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=mesa-va-drivers;unpack=0"
SRC_URI += "${URI_mesa-va-drivers}"
SRC_URI[mesa-va-drivers.sha256sum] = "a58add00d13be8c0c351d5568696eb2f056d7122e2f17a5cfa0003e83644bbda"
RDEPENDS:mesa-va-drivers = " \
 mesa-filesystem \
"

URI_mesa-vdpau-drivers = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mesa-vdpau-drivers-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=mesa-vdpau-drivers;unpack=0"
SRC_URI += "${URI_mesa-vdpau-drivers}"
SRC_URI[mesa-vdpau-drivers.sha256sum] = "9f2c004b069f39c25fa76cf0e9423f6dd3a6cce014837a2def4cd5675dbd55f6"
RDEPENDS:mesa-vdpau-drivers = " \
 mesa-filesystem \
"
