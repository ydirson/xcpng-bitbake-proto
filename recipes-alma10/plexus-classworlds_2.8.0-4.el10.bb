# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "plexus-classworlds"
PE = "0"
PV = "2.8.0"
PR = "4.el10"
PACKAGES = "plexus-classworlds plexus-classworlds-javadoc"
PROVIDES = "rpm/plexus-classworlds rpm/plexus-classworlds-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/plexus-classworlds-2.8.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "024bbabfd982bb0d5e79fec9e70fc4084a75a676fbc936ac19704cac5dd052ae"

URI_plexus-classworlds = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/plexus-classworlds-2.8.0-4.el10.noarch.rpm;name=plexus-classworlds;unpack=0"
SRC_URI += "${URI_plexus-classworlds}"
SRC_URI[plexus-classworlds.sha256sum] = "ac54e23e95711f9d0d220861f7c256459ad710cd17affd1e4087b281680605a4"
RDEPENDS:plexus-classworlds = " \
 javapackages-filesystem \
"

URI_plexus-classworlds-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-classworlds-javadoc-2.8.0-4.el10.noarch.rpm;name=plexus-classworlds-javadoc;unpack=0"
SRC_URI += "${URI_plexus-classworlds-javadoc}"
SRC_URI[plexus-classworlds-javadoc.sha256sum] = "8a2869740cf8e8d5786b58fe61ad4c12bf250ed8bcaa6b3c20e1313d306ab968"
RDEPENDS:plexus-classworlds-javadoc = " \
 javapackages-filesystem \
"
