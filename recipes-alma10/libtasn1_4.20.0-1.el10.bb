# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libtasn1"
PE = "0"
PV = "4.20.0"
PR = "1.el10"
PACKAGES = "libtasn1 libtasn1-devel libtasn1-tools"
PROVIDES = "rpm/libtasn1 rpm/libtasn1-devel rpm/libtasn1-tools"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libtasn1-4.20.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9030ab43374c0ce6a1da8e68138d4aea7fb64762b7a66f68a0f1f38d5d30df2d"

URI_libtasn1 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libtasn1-4.20.0-1.el10.x86_64_v2.rpm;name=libtasn1;unpack=0"
SRC_URI += "${URI_libtasn1}"
SRC_URI[libtasn1.sha256sum] = "87389257451e49f97c457124c68283ffbd020326e830ffe7f799f448dd6d3c1e"
RDEPENDS:libtasn1 = " \
 glibc \
"

URI_libtasn1-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libtasn1-devel-4.20.0-1.el10.x86_64_v2.rpm;name=libtasn1-devel;unpack=0"
SRC_URI += "${URI_libtasn1-devel}"
SRC_URI[libtasn1-devel.sha256sum] = "1e9f0b92c0ed1da730230df845a17645d2885065a9ff5784e7e8474bf08a54b6"
RDEPENDS:libtasn1-devel = " \
 libtasn1-tools \
 pkgconf-pkg-config \
 libtasn1 \
"

URI_libtasn1-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libtasn1-tools-4.20.0-1.el10.x86_64_v2.rpm;name=libtasn1-tools;unpack=0"
SRC_URI += "${URI_libtasn1-tools}"
SRC_URI[libtasn1-tools.sha256sum] = "586be6af1af8911645dd5628bd3196447abab38c5e74aba58784ad76504b97ab"
RDEPENDS:libtasn1-tools = " \
 glibc \
 libtasn1 \
"
