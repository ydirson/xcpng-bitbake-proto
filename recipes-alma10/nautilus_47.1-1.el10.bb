# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "nautilus"
PE = "0"
PV = "47.1"
PR = "1.el10"
PACKAGES = "nautilus nautilus-extensions nautilus-devel"
PROVIDES = "rpm/nautilus rpm/nautilus-extensions rpm/nautilus-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/nautilus-47.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a1e1b27116de5e5576a3830081b19217ea4c758ae00a45411abf340157c0052"

URI_nautilus = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nautilus-47.1-1.el10.x86_64_v2.rpm;name=nautilus;unpack=0"
SRC_URI += "${URI_nautilus}"
SRC_URI[nautilus.sha256sum] = "f9b364a73ed434495f45ace5c1c5306e0e0c877bf4170e195d35c6e468c083f6"
RDEPENDS:nautilus = " \
 gvfs \
 libtracker-sparql \
 pango \
 libX11 \
 libselinux \
 gnome-autoar \
 nautilus-extensions \
 gnome-desktop4 \
 cairo \
 libportal \
 libportal-gtk4 \
 libadwaita \
 libgexiv2 \
 libwayland-client \
 libgcc \
 gdk-pixbuf2 \
 graphene \
 tracker-miners \
 gstreamer1 \
 gsettings-desktop-schemas \
 gstreamer1-plugins-base \
 glib2 \
 glibc \
 gtk4 \
"

URI_nautilus-extensions = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nautilus-extensions-47.1-1.el10.x86_64_v2.rpm;name=nautilus-extensions;unpack=0"
SRC_URI += "${URI_nautilus-extensions}"
SRC_URI[nautilus-extensions.sha256sum] = "6606dbd2b3298482764fbf020b91447200fdabe226dc91a8021bac10292abd6a"
RDEPENDS:nautilus-extensions = " \
 glibc \
 libgcc \
 glib2 \
"

URI_nautilus-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/nautilus-devel-47.1-1.el10.x86_64_v2.rpm;name=nautilus-devel;unpack=0"
SRC_URI += "${URI_nautilus-devel}"
SRC_URI[nautilus-devel.sha256sum] = "75bb578766d739d3e4de755ccfdfdea51a248a70d0fd111f5cc699c562a21263"
RDEPENDS:nautilus-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 nautilus \
 nautilus-extensions \
"
