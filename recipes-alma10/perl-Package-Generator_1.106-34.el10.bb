# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Package-Generator"
PE = "0"
PV = "1.106"
PR = "34.el10"
PACKAGES = "perl-Package-Generator perl-Package-Generator-tests"
PROVIDES = "rpm/perl-Package-Generator rpm/perl-Package-Generator-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Package-Generator-1.106-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4139e1ce08674be380b506c6291e0d8cb0f1e3b04ebbf27a8cb21689f9b5b573"

URI_perl-Package-Generator = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Package-Generator-1.106-34.el10.noarch.rpm;name=perl-Package-Generator;unpack=0"
SRC_URI += "${URI_perl-Package-Generator}"
SRC_URI[perl-Package-Generator.sha256sum] = "be2738fd1b0a14b5b170ccbf076391568d764bef5e6330cb9a361fa81ae006f9"
RDEPENDS:perl-Package-Generator = " \
 perl-Symbol \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
"

URI_perl-Package-Generator-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Package-Generator-tests-1.106-34.el10.noarch.rpm;name=perl-Package-Generator-tests;unpack=0"
SRC_URI += "${URI_perl-Package-Generator-tests}"
SRC_URI[perl-Package-Generator-tests.sha256sum] = "73d4d3923bdaf14ff03b207620be916cf32484ed626c5c7fea71d9d518918294"
RDEPENDS:perl-Package-Generator-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Package-Generator \
 bash \
 perl-interpreter \
"
