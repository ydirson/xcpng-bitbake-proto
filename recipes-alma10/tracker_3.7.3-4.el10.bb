# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tracker"
PE = "0"
PV = "3.7.3"
PR = "4.el10"
PACKAGES = "libtracker-sparql tracker tracker-devel tracker-doc"
PROVIDES = "rpm/libtracker-sparql rpm/tracker rpm/tracker-devel rpm/tracker-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tracker-3.7.3-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49c3e6fccaa35d99b3cda4a21472bb709d37dfca177113dbecb6fb76cf283756"

URI_libtracker-sparql = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libtracker-sparql-3.7.3-4.el10.x86_64_v2.rpm;name=libtracker-sparql;unpack=0"
SRC_URI += "${URI_libtracker-sparql}"
SRC_URI[libtracker-sparql.sha256sum] = "e9e3fe743000f88f8ef89f5480b764559f45b4e1eedf81ea945963c4668a1e7f"
RDEPENDS:libtracker-sparql = " \
 libsoup3 \
 libxml2 \
 json-glib \
 avahi-glib \
 sqlite-libs \
 avahi-libs \
 bash \
 glib2 \
 glibc \
 libicu \
"

URI_tracker = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tracker-3.7.3-4.el10.x86_64_v2.rpm;name=tracker;unpack=0"
SRC_URI += "${URI_tracker}"
SRC_URI[tracker.sha256sum] = "f287e696d6020c8419d184f68267236fe64658481ccf6a1eaf2ee92a5d2362d9"
RDEPENDS:tracker = " \
 libtracker-sparql \
 libgcc \
 json-glib \
 avahi-glib \
 sqlite-libs \
 avahi-libs \
 bash \
 glib2 \
 glibc \
"

URI_tracker-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/tracker-devel-3.7.3-4.el10.x86_64_v2.rpm;name=tracker-devel;unpack=0"
SRC_URI += "${URI_tracker-devel}"
SRC_URI[tracker-devel.sha256sum] = "0a645246f658fa7f0e8af44a59972f9943d8d1dba9b7f3ab56ea03755835ad2e"
RDEPENDS:tracker-devel = " \
 json-glib-devel \
 libxml2-devel \
 glib2-devel \
 libtracker-sparql \
 pkgconf-pkg-config \
 bash \
 sqlite-devel \
"

URI_tracker-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/tracker-doc-3.7.3-4.el10.noarch.rpm;name=tracker-doc;unpack=0"
SRC_URI += "${URI_tracker-doc}"
SRC_URI[tracker-doc.sha256sum] = "60625c525e1320fdd7ba8ca422355daa1b6f3d1e363b98f7c5478f1631343a90"
RDEPENDS:tracker-doc = ""
