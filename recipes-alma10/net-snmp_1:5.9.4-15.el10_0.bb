# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "net-snmp"
PE = "1"
PV = "5.9.4"
PR = "15.el10_0"
PACKAGES = "net-snmp net-snmp-agent-libs net-snmp-devel net-snmp-libs net-snmp-perl net-snmp-perl-module net-snmp-utils python3-net-snmp net-snmp-gui"
PROVIDES = "rpm/net-snmp rpm/net-snmp-agent-libs rpm/net-snmp-devel rpm/net-snmp-libs rpm/net-snmp-perl rpm/net-snmp-perl-module rpm/net-snmp-utils rpm/python3-net-snmp rpm/net-snmp-gui"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/net-snmp-5.9.4-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f1270e7e8b0ef3c97dc2e9f8236a1ce6675f607eb417e705ea24c80cab97338"

URI_net-snmp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/net-snmp-5.9.4-15.el10_0.x86_64_v2.rpm;name=net-snmp;unpack=0"
SRC_URI += "${URI_net-snmp}"
SRC_URI[net-snmp.sha256sum] = "b8fad94a86f8c6791e7dec091581763d188827e05bb635e9ee22eca73cb3f29f"
RDEPENDS:net-snmp = " \
 systemd \
 net-snmp-agent-libs \
 net-snmp-libs \
 perl-IO \
 perl-Term-ReadLine \
 perl-Getopt-Std \
 perl-File-Copy \
 bash \
 glibc \
 perl-interpreter \
 perl-Data-Dumper \
"

URI_net-snmp-agent-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/net-snmp-agent-libs-5.9.4-15.el10_0.x86_64_v2.rpm;name=net-snmp-agent-libs;unpack=0"
SRC_URI += "${URI_net-snmp-agent-libs}"
SRC_URI[net-snmp-agent-libs.sha256sum] = "c60d1b37ed9a2a712cad28a41e495081a0250f933d6c51f53f2a1c8c0ced6df5"
RDEPENDS:net-snmp-agent-libs = " \
 lm_sensors-libs \
 perl-libs \
 net-snmp-libs \
 libxcrypt \
 openssl-libs \
 mariadb-connector-c \
 glibc \
 rpm-libs \
"

URI_net-snmp-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/net-snmp-devel-5.9.4-15.el10_0.x86_64_v2.rpm;name=net-snmp-devel;unpack=0"
SRC_URI += "${URI_net-snmp-devel}"
SRC_URI[net-snmp-devel.sha256sum] = "98c8316020d52d1be55e389e8c01b457509a9866e49bfc6417c5c47fae43653b"
RDEPENDS:net-snmp-devel = " \
 lm_sensors-devel \
 net-snmp-agent-libs \
 net-snmp-libs \
 perl-devel \
 redhat-rpm-config \
 pkgconf-pkg-config \
 openssl-devel \
 rpm-devel \
 bash \
 elfutils-devel \
 elfutils-libelf-devel \
"

URI_net-snmp-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/net-snmp-libs-5.9.4-15.el10_0.x86_64_v2.rpm;name=net-snmp-libs;unpack=0"
SRC_URI += "${URI_net-snmp-libs}"
SRC_URI[net-snmp-libs.sha256sum] = "48d5e61a054259e9e536431ea75a613e674e221d54f52642db7d1706f5eb461c"
RDEPENDS:net-snmp-libs = " \
 glibc \
 openssl-libs \
"

URI_net-snmp-perl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/net-snmp-perl-5.9.4-15.el10_0.x86_64_v2.rpm;name=net-snmp-perl;unpack=0"
SRC_URI += "${URI_net-snmp-perl}"
SRC_URI[net-snmp-perl.sha256sum] = "89c0150b267fa01b0dfef034f66a16d6897dad4a9e4fd40b74deb323f13c591e"
RDEPENDS:net-snmp-perl = " \
 perl-libnet \
 perl-libs \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-Sys-Hostname \
 perl-Carp \
 perl-vars \
 perl-JSON \
 perl-Data-Dumper \
 net-snmp-agent-libs \
 net-snmp-devel \
 net-snmp-libs \
 net-snmp-perl-module \
 bash \
 perl-Fcntl \
 perl-POSIX \
 perl-File-Basename \
 perl-File-Copy \
 perl-PathTools \
 perl-interpreter \
 perl-File-Path \
"

URI_net-snmp-perl-module = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/net-snmp-perl-module-5.9.4-15.el10_0.x86_64_v2.rpm;name=net-snmp-perl-module;unpack=0"
SRC_URI += "${URI_net-snmp-perl-module}"
SRC_URI[net-snmp-perl-module.sha256sum] = "591d625a65ed20316479d8234a30d682d127d85aa18917ca4b1d8ea78a221b0b"
RDEPENDS:net-snmp-perl-module = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-interpreter \
 net-snmp-libs \
 net-snmp-agent-libs \
 net-snmp-perl-module \
 perl-DynaLoader \
 perl-overload \
 perl-AutoLoader \
 glibc \
 perl-Exporter \
 perl-Data-Dumper \
"

URI_net-snmp-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/net-snmp-utils-5.9.4-15.el10_0.x86_64_v2.rpm;name=net-snmp-utils;unpack=0"
SRC_URI += "${URI_net-snmp-utils}"
SRC_URI[net-snmp-utils.sha256sum] = "225877d60746bd1230fc183c79ae3f32495e99cac15e6f601df8bb9e3696891b"
RDEPENDS:net-snmp-utils = " \
 glibc \
 openssl-libs \
 net-snmp-libs \
"

URI_python3-net-snmp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-net-snmp-5.9.4-15.el10_0.x86_64_v2.rpm;name=python3-net-snmp;unpack=0"
SRC_URI += "${URI_python3-net-snmp}"
SRC_URI[python3-net-snmp.sha256sum] = "6c9ac8593e685b891c17efbc7bed7df039c3e1d1588fd74efe8299ec2e2c14b9"
RDEPENDS:python3-net-snmp = " \
 glibc \
 python3 \
 net-snmp-libs \
"

URI_net-snmp-gui = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/net-snmp-gui-5.9.4-15.el10_0.x86_64_v2.rpm;name=net-snmp-gui;unpack=0"
SRC_URI += "${URI_net-snmp-gui}"
SRC_URI[net-snmp-gui.sha256sum] = "c909d861e443c7f6f94579df9f48c68c92e84ed85c22d5839d5f3e2b4c150229"
RDEPENDS:net-snmp-gui = " \
 perl-Tk \
 perl-libs \
 net-snmp-perl-module \
 perl-Getopt-Std \
 perl-interpreter \
 perl-Data-Dumper \
"
