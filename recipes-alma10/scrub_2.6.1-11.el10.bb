# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "scrub"
PE = "0"
PV = "2.6.1"
PR = "11.el10"
PACKAGES = "scrub"
PROVIDES = "rpm/scrub"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/scrub-2.6.1-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3109f54a12fe9ab79e2df5112b4a0d395a5f75f7627d496396c4f95ad0832d6"

URI_scrub = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/scrub-2.6.1-11.el10.x86_64_v2.rpm;name=scrub;unpack=0"
SRC_URI += "${URI_scrub}"
SRC_URI[scrub.sha256sum] = "f3848f490d88ce32a229355e024b17984edd3000554f9e4c7abc9947b9692fac"
RDEPENDS:scrub = " \
 glibc \
 openssl-libs \
"
