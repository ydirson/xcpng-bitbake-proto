# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "osgi-core"
PE = "0"
PV = "8.0.0"
PR = "14.el10"
PACKAGES = "osgi-core osgi-core-javadoc"
PROVIDES = "rpm/osgi-core rpm/osgi-core-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/osgi-core-8.0.0-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b298fb7e4b017d14dd7105de5a444e6358fec1f9e01a50a2037c5ef2615d9c2"

URI_osgi-core = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/osgi-core-8.0.0-14.el10.noarch.rpm;name=osgi-core;unpack=0"
SRC_URI += "${URI_osgi-core}"
SRC_URI[osgi-core.sha256sum] = "31c055febf689e0dc81bc418ac634147b3b18a03cbff3fc81cd9fd4a500e14f5"
RDEPENDS:osgi-core = " \
 javapackages-filesystem \
"

URI_osgi-core-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/osgi-core-javadoc-8.0.0-14.el10.noarch.rpm;name=osgi-core-javadoc;unpack=0"
SRC_URI += "${URI_osgi-core-javadoc}"
SRC_URI[osgi-core-javadoc.sha256sum] = "8ab0904f05aa0247ab7af2d11b12fd6478dd4aea82f71bde000f0d23090c380c"
RDEPENDS:osgi-core-javadoc = " \
 javapackages-filesystem \
"
