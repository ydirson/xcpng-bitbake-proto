# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ipxe"
PE = "0"
PV = "20240119"
PR = "5.gitde8a0821.el10"
PACKAGES = "ipxe-bootimgs-aarch64 ipxe-bootimgs-x86 ipxe-roms-qemu"
PROVIDES = "rpm/ipxe-bootimgs-aarch64 rpm/ipxe-bootimgs-x86 rpm/ipxe-roms-qemu"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ipxe-20240119-5.gitde8a0821.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "221a9d48aa0459c6c379b5ff5dca85cd3d30118737c145068ad6f48442712686"

URI_ipxe-bootimgs-aarch64 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ipxe-bootimgs-aarch64-20240119-5.gitde8a0821.el10.noarch.rpm;name=ipxe-bootimgs-aarch64;unpack=0"
SRC_URI += "${URI_ipxe-bootimgs-aarch64}"
SRC_URI[ipxe-bootimgs-aarch64.sha256sum] = "dbf774edb66c5b517ce238aa75cfb2b09de3ae98eef949e99cda8eb3092f5655"
RDEPENDS:ipxe-bootimgs-aarch64 = ""

URI_ipxe-bootimgs-x86 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ipxe-bootimgs-x86-20240119-5.gitde8a0821.el10.noarch.rpm;name=ipxe-bootimgs-x86;unpack=0"
SRC_URI += "${URI_ipxe-bootimgs-x86}"
SRC_URI[ipxe-bootimgs-x86.sha256sum] = "49a54239b26b2ddcb32e5c00348950c7ac8884b6060ef8a71d1fed43642f4dd6"
RDEPENDS:ipxe-bootimgs-x86 = ""

URI_ipxe-roms-qemu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ipxe-roms-qemu-20240119-5.gitde8a0821.el10.noarch.rpm;name=ipxe-roms-qemu;unpack=0"
SRC_URI += "${URI_ipxe-roms-qemu}"
SRC_URI[ipxe-roms-qemu.sha256sum] = "895189907d1f71f84b4571a331a83d061ddf3de8c0aaf41a9ac5d4a17b352c08"
RDEPENDS:ipxe-roms-qemu = ""
