# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "papi"
PE = "0"
PV = "7.1.0"
PR = "6.el10"
PACKAGES = "papi papi-devel papi-libs papi-testsuite"
PROVIDES = "rpm/papi rpm/papi-devel rpm/papi-libs rpm/papi-testsuite"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/papi-7.1.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3f2386310ff3c0feb2fb23edabd2f4b025cf535481a829bcd9d2da3453b5302"

URI_papi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/papi-7.1.0-6.el10.x86_64_v2.rpm;name=papi;unpack=0"
SRC_URI += "${URI_papi}"
SRC_URI[papi.sha256sum] = "71f055d9c7b44d8ab149bca9e6900370bc496b3464977663689fca854bb7a16e"
RDEPENDS:papi = " \
 glibc \
 papi-libs \
 python3 \
"

URI_papi-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/papi-devel-7.1.0-6.el10.x86_64_v2.rpm;name=papi-devel;unpack=0"
SRC_URI += "${URI_papi-devel}"
SRC_URI[papi-devel.sha256sum] = "6c89d069f680c671742f9846cf64dd6d7db19257b3be216995fbf4f6235b3cc6"
RDEPENDS:papi-devel = " \
 papi-libs \
 pkgconf-pkg-config \
 papi \
"

URI_papi-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/papi-libs-7.1.0-6.el10.x86_64_v2.rpm;name=papi-libs;unpack=0"
SRC_URI += "${URI_papi-libs}"
SRC_URI[papi-libs.sha256sum] = "36ce03db47a96f6a2956c355972d6ab9359d34ca9100007648dffe06739a6e2d"
RDEPENDS:papi-libs = " \
 glibc \
 libpfm \
"

URI_papi-testsuite = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/papi-testsuite-7.1.0-6.el10.x86_64_v2.rpm;name=papi-testsuite;unpack=0"
SRC_URI += "${URI_papi-testsuite}"
SRC_URI[papi-testsuite.sha256sum] = "95ae08977b8fd132400e90f0e6159177c0599a4cffe6c680c32941d2b252133a"
RDEPENDS:papi-testsuite = " \
 papi-libs \
 libgcc \
 libgfortran \
 libgomp \
 bash \
 papi \
 glibc \
"
