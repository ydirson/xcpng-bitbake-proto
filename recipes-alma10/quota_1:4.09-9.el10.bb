# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "quota"
PE = "1"
PV = "4.09"
PR = "9.el10"
PACKAGES = "quota quota-nls quota-doc quota-nld quota-rpc quota-warnquota quota-devel"
PROVIDES = "rpm/quota rpm/quota-nls rpm/quota-doc rpm/quota-nld rpm/quota-rpc rpm/quota-warnquota rpm/quota-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/quota-4.09-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee43a2746d057ec41b295eb91a2fac64d03c2096032eebb7d5d0d7f69a83c805"

URI_quota = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/quota-4.09-9.el10.x86_64_v2.rpm;name=quota;unpack=0"
SRC_URI += "${URI_quota}"
SRC_URI[quota.sha256sum] = "5a258c7877e2af69d1c9cafd95ded6249c0cf6c66cb4eb0e5263e43ba1286f6b"
RDEPENDS:quota = " \
 glibc \
 libtirpc \
 e2fsprogs-libs \
 quota-nls \
"

URI_quota-nls = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/quota-nls-4.09-9.el10.noarch.rpm;name=quota-nls;unpack=0"
SRC_URI += "${URI_quota-nls}"
SRC_URI[quota-nls.sha256sum] = "0b67cc0b51418d1cb7e14f3bba95765a98152a64f028add27b2cd3b6fa62d67e"
RDEPENDS:quota-nls = ""

URI_quota-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/quota-doc-4.09-9.el10.noarch.rpm;name=quota-doc;unpack=0"
SRC_URI += "${URI_quota-doc}"
SRC_URI[quota-doc.sha256sum] = "b9c9b1457bbf8887675e43e680c92853ee09367b0f9330d6a1ea4626f2443547"
RDEPENDS:quota-doc = " \
 quota \
"

URI_quota-nld = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/quota-nld-4.09-9.el10.x86_64_v2.rpm;name=quota-nld;unpack=0"
SRC_URI += "${URI_quota-nld}"
SRC_URI[quota-nld.sha256sum] = "1262617ef7c89b72840376cd51348d39ae77d1eb8f1f27d85e4c09f8ff3038d6"
RDEPENDS:quota-nld = " \
 systemd \
 quota-nls \
 libnl3 \
 bash \
 glibc \
 dbus-libs \
"

URI_quota-rpc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/quota-rpc-4.09-9.el10.x86_64_v2.rpm;name=quota-rpc;unpack=0"
SRC_URI += "${URI_quota-rpc}"
SRC_URI[quota-rpc.sha256sum] = "34a54d640aaed5376916763b4e3ed86449bba030e6679de670f46ae08230d8c5"
RDEPENDS:quota-rpc = " \
 systemd \
 quota-nls \
 bash \
 glibc \
 libtirpc \
 rpcbind \
"

URI_quota-warnquota = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/quota-warnquota-4.09-9.el10.x86_64_v2.rpm;name=quota-warnquota;unpack=0"
SRC_URI += "${URI_quota-warnquota}"
SRC_URI[quota-warnquota.sha256sum] = "ff4c5ce8c781929af509dc0818183d56637cd9d5fb69d4178ba2ec43111cd956"
RDEPENDS:quota-warnquota = " \
 glibc \
 libtirpc \
 quota-nls \
 openldap \
"

URI_quota-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/quota-devel-4.09-9.el10.x86_64_v2.rpm;name=quota-devel;unpack=0"
SRC_URI += "${URI_quota-devel}"
SRC_URI[quota-devel.sha256sum] = "b247a61a8553f435a6abadd14e91dbabc9a88dc813f6078fc35089b0d9687abc"
RDEPENDS:quota-devel = " \
 libtirpc-devel \
"
