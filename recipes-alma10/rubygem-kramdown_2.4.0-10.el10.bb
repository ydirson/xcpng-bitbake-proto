# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rubygem-kramdown"
PE = "0"
PV = "2.4.0"
PR = "10.el10"
PACKAGES = "rubygem-kramdown rubygem-kramdown-doc"
PROVIDES = "rpm/rubygem-kramdown rpm/rubygem-kramdown-doc"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/rubygem-kramdown-2.4.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5673221dcec0c901201a6b0b295e4f9c8bdb8b0093dd66ea1f1d79270c5944c8"

URI_rubygem-kramdown = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-kramdown-2.4.0-10.el10.noarch.rpm;name=rubygem-kramdown;unpack=0"
SRC_URI += "${URI_rubygem-kramdown}"
SRC_URI[rubygem-kramdown.sha256sum] = "8146fa29d03601db5332104b47e963058f772854bc530d493db94d694843b23e"
RDEPENDS:rubygem-kramdown = " \
 rubygems \
 rubygem-rexml \
 ruby-libs \
 ruby \
"

URI_rubygem-kramdown-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-kramdown-doc-2.4.0-10.el10.noarch.rpm;name=rubygem-kramdown-doc;unpack=0"
SRC_URI += "${URI_rubygem-kramdown-doc}"
SRC_URI[rubygem-kramdown-doc.sha256sum] = "4d69cbc6f9962f065c66a35e22aa63ecf193911941acd12b0a6783cd25f171b6"
RDEPENDS:rubygem-kramdown-doc = " \
 rubygem-kramdown \
"
