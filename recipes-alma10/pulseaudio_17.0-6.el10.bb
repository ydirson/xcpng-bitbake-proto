# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pulseaudio"
PE = "0"
PV = "17.0"
PR = "6.el10"
PACKAGES = "pulseaudio-libs pulseaudio-libs-devel pulseaudio-libs-glib2 pulseaudio-utils"
PROVIDES = "rpm/pulseaudio-libs rpm/pulseaudio-libs-devel rpm/pulseaudio-libs-glib2 rpm/pulseaudio-utils"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/pulseaudio-17.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97d2f9125de1ff60f292448f51064796a1c9c556d336e2f0e17f3f220db497e8"

URI_pulseaudio-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pulseaudio-libs-17.0-6.el10.x86_64_v2.rpm;name=pulseaudio-libs;unpack=0"
SRC_URI += "${URI_pulseaudio-libs}"
SRC_URI[pulseaudio-libs.sha256sum] = "0253b1364ebbef6a521dd1ba1fa2e789242473874c4a06d63bfc697f72529198"
RDEPENDS:pulseaudio-libs = " \
 libasyncns \
 systemd-libs \
 libxcb \
 glibc \
 dbus-libs \
 libsndfile \
"

URI_pulseaudio-libs-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pulseaudio-libs-devel-17.0-6.el10.x86_64_v2.rpm;name=pulseaudio-libs-devel;unpack=0"
SRC_URI += "${URI_pulseaudio-libs-devel}"
SRC_URI[pulseaudio-libs-devel.sha256sum] = "2e2bb3d461ccbc89b751c4d366662eb5176dbcfea60a3cc15f404ccf7e0fe156"
RDEPENDS:pulseaudio-libs-devel = " \
 glib2-devel \
 pulseaudio-libs \
 pulseaudio-libs-devel \
 pulseaudio-libs-glib2 \
 pkgconf-pkg-config \
"

URI_pulseaudio-libs-glib2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pulseaudio-libs-glib2-17.0-6.el10.x86_64_v2.rpm;name=pulseaudio-libs-glib2;unpack=0"
SRC_URI += "${URI_pulseaudio-libs-glib2}"
SRC_URI[pulseaudio-libs-glib2.sha256sum] = "a1a0dc86b23e7fe42e1cb4af4ffa83307a220435be7461e1062b9bee5bd89661"
RDEPENDS:pulseaudio-libs-glib2 = " \
 glibc \
 pulseaudio-libs \
 glib2 \
"

URI_pulseaudio-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pulseaudio-utils-17.0-6.el10.x86_64_v2.rpm;name=pulseaudio-utils;unpack=0"
SRC_URI += "${URI_pulseaudio-utils}"
SRC_URI[pulseaudio-utils.sha256sum] = "0887b912fd3cfc1a53bd1fa1a195720b0181b98cb82f081d66cec2ce932f10a4"
RDEPENDS:pulseaudio-utils = " \
 pulseaudio-libs \
 libxcb \
 bash \
 glibc \
 libsndfile \
"
