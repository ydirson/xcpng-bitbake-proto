# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dotnet8.0"
PE = "0"
PV = "8.0.121"
PR = "1.el10_0"
PACKAGES = "aspnetcore-runtime-8.0 aspnetcore-runtime-dbg-8.0 aspnetcore-targeting-pack-8.0 dotnet-apphost-pack-8.0 dotnet-hostfxr-8.0 dotnet-runtime-8.0 dotnet-runtime-dbg-8.0 dotnet-sdk-8.0 dotnet-sdk-dbg-8.0 dotnet-targeting-pack-8.0 dotnet-templates-8.0 dotnet-sdk-8.0-source-built-artifacts"
PROVIDES = "rpm/aspnetcore-runtime-8.0 rpm/aspnetcore-runtime-dbg-8.0 rpm/aspnetcore-targeting-pack-8.0 rpm/dotnet-apphost-pack-8.0 rpm/dotnet-hostfxr-8.0 rpm/dotnet-runtime-8.0 rpm/dotnet-runtime-dbg-8.0 rpm/dotnet-sdk-8.0 rpm/dotnet-sdk-dbg-8.0 rpm/dotnet-targeting-pack-8.0 rpm/dotnet-templates-8.0 rpm/dotnet-sdk-8.0-source-built-artifacts"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/dotnet8.0-8.0.121-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f03e1694a4f957465b16936437647dadf069c6a88c7543fc21d722f98a0cde45"

URI_aspnetcore-runtime-8.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-8.0-8.0.21-1.el10_0.x86_64_v2.rpm;name=aspnetcore-runtime-8.0;unpack=0"
SRC_URI += "${URI_aspnetcore-runtime-8.0}"
SRC_URI[aspnetcore-runtime-8.0.sha256sum] = "86c4a3bcdb5d7c1110acf33b8fb9a7bcac249af1071b0f6d72b380b402740394"
RDEPENDS:aspnetcore-runtime-8.0 = " \
 dotnet-runtime-8.0 \
"

URI_aspnetcore-runtime-dbg-8.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-dbg-8.0-8.0.21-1.el10_0.x86_64_v2.rpm;name=aspnetcore-runtime-dbg-8.0;unpack=0"
SRC_URI += "${URI_aspnetcore-runtime-dbg-8.0}"
SRC_URI[aspnetcore-runtime-dbg-8.0.sha256sum] = "4c7eeff6bc5da42889120d908aec50096380affebf6e454037240fd16ed1aedf"
RDEPENDS:aspnetcore-runtime-dbg-8.0 = " \
 aspnetcore-runtime-8.0 \
"

URI_aspnetcore-targeting-pack-8.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/aspnetcore-targeting-pack-8.0-8.0.21-1.el10_0.x86_64_v2.rpm;name=aspnetcore-targeting-pack-8.0;unpack=0"
SRC_URI += "${URI_aspnetcore-targeting-pack-8.0}"
SRC_URI[aspnetcore-targeting-pack-8.0.sha256sum] = "731b3101b013373022d544d8aa4f72029dd060de3104db4ee4f5f9513cdf2f37"
RDEPENDS:aspnetcore-targeting-pack-8.0 = " \
 dotnet-host \
"

URI_dotnet-apphost-pack-8.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dotnet-apphost-pack-8.0-8.0.21-1.el10_0.x86_64_v2.rpm;name=dotnet-apphost-pack-8.0;unpack=0"
SRC_URI += "${URI_dotnet-apphost-pack-8.0}"
SRC_URI[dotnet-apphost-pack-8.0.sha256sum] = "5a8199baa999b8130df6c3afdd64a5379cf08fc2259e61a9a8b0021c2fc5236a"
RDEPENDS:dotnet-apphost-pack-8.0 = " \
 zlib-ng-compat \
 openssl-libs \
 libgcc \
 libstdc++ \
 glibc \
 dotnet-host \
"

URI_dotnet-hostfxr-8.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dotnet-hostfxr-8.0-8.0.21-1.el10_0.x86_64_v2.rpm;name=dotnet-hostfxr-8.0;unpack=0"
SRC_URI += "${URI_dotnet-hostfxr-8.0}"
SRC_URI[dotnet-hostfxr-8.0.sha256sum] = "4ad367311e59b9ab95658b5d814d942d6bacfe1d56e99989d99c47a9b1611326"
RDEPENDS:dotnet-hostfxr-8.0 = " \
 glibc \
 libgcc \
 libstdc++ \
 dotnet-host \
"

URI_dotnet-runtime-8.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dotnet-runtime-8.0-8.0.21-1.el10_0.x86_64_v2.rpm;name=dotnet-runtime-8.0;unpack=0"
SRC_URI += "${URI_dotnet-runtime-8.0}"
SRC_URI[dotnet-runtime-8.0.sha256sum] = "0a73b9b7ca193800b58cea2df7df70714f2014590161f1dcccbb08fc15d8a83d"
RDEPENDS:dotnet-runtime-8.0 = " \
 zlib-ng-compat \
 dotnet-hostfxr-8.0 \
 openssl-libs \
 libgcc \
 libstdc++ \
 glibc \
 libicu \
"

URI_dotnet-runtime-dbg-8.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dotnet-runtime-dbg-8.0-8.0.21-1.el10_0.x86_64_v2.rpm;name=dotnet-runtime-dbg-8.0;unpack=0"
SRC_URI += "${URI_dotnet-runtime-dbg-8.0}"
SRC_URI[dotnet-runtime-dbg-8.0.sha256sum] = "31a48ede0784436eb9733cab5abf459bd54c380fc6cffe010426fd41297f602a"
RDEPENDS:dotnet-runtime-dbg-8.0 = " \
 dotnet-runtime-8.0 \
"

URI_dotnet-sdk-8.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dotnet-sdk-8.0-8.0.121-1.el10_0.x86_64_v2.rpm;name=dotnet-sdk-8.0;unpack=0"
SRC_URI += "${URI_dotnet-sdk-8.0}"
SRC_URI[dotnet-sdk-8.0.sha256sum] = "14efdd98f913146e97bb7851c75152cd69f529dfe0a66b3b76527ef7049031fa"
RDEPENDS:dotnet-sdk-8.0 = " \
 libgcc \
 dotnet-targeting-pack-8.0 \
 dotnet-apphost-pack-8.0 \
 netstandard-targeting-pack-2.1 \
 libstdc++ \
 dotnet-templates-8.0 \
 aspnetcore-targeting-pack-8.0 \
 dotnet-runtime-8.0 \
 glibc \
 aspnetcore-runtime-8.0 \
"

URI_dotnet-sdk-dbg-8.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dotnet-sdk-dbg-8.0-8.0.121-1.el10_0.x86_64_v2.rpm;name=dotnet-sdk-dbg-8.0;unpack=0"
SRC_URI += "${URI_dotnet-sdk-dbg-8.0}"
SRC_URI[dotnet-sdk-dbg-8.0.sha256sum] = "8816a5b20ae8d1a2f9aa9b769eb2420db942c4470301fa2f2e621cfeb85c7411"
RDEPENDS:dotnet-sdk-dbg-8.0 = " \
 dotnet-sdk-8.0 \
"

URI_dotnet-targeting-pack-8.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dotnet-targeting-pack-8.0-8.0.21-1.el10_0.x86_64_v2.rpm;name=dotnet-targeting-pack-8.0;unpack=0"
SRC_URI += "${URI_dotnet-targeting-pack-8.0}"
SRC_URI[dotnet-targeting-pack-8.0.sha256sum] = "76b7b1cdd3569a9147a8f9c5c8e9846ba10f4db8539a3fe00de724d9533c08a6"
RDEPENDS:dotnet-targeting-pack-8.0 = " \
 dotnet-host \
"

URI_dotnet-templates-8.0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dotnet-templates-8.0-8.0.121-1.el10_0.x86_64_v2.rpm;name=dotnet-templates-8.0;unpack=0"
SRC_URI += "${URI_dotnet-templates-8.0}"
SRC_URI[dotnet-templates-8.0.sha256sum] = "b6558e935df5b29cc3d15ba475ed933d8281644641c0edff6a1826c39b1871d2"
RDEPENDS:dotnet-templates-8.0 = " \
 dotnet-host \
"

URI_dotnet-sdk-8.0-source-built-artifacts = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/dotnet-sdk-8.0-source-built-artifacts-8.0.121-1.el10_0.x86_64_v2.rpm;name=dotnet-sdk-8.0-source-built-artifacts;unpack=0"
SRC_URI += "${URI_dotnet-sdk-8.0-source-built-artifacts}"
SRC_URI[dotnet-sdk-8.0-source-built-artifacts.sha256sum] = "49cf99c68d57c1c48d0e527c1007ab0bc9814a936330204000dd0b5b41eb9327"
RDEPENDS:dotnet-sdk-8.0-source-built-artifacts = ""
