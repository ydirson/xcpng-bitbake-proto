# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "maven-wagon"
PE = "0"
PV = "3.5.3"
PR = "9.el10"
PACKAGES = "maven-wagon maven-wagon-javadoc"
PROVIDES = "rpm/maven-wagon rpm/maven-wagon-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/maven-wagon-3.5.3-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d97af45160bbac0a1ccbb4ff3ca3dcd1771cad37e065afdb8373ecae5f878a7b"

URI_maven-wagon = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/maven-wagon-3.5.3-9.el10.noarch.rpm;name=maven-wagon;unpack=0"
SRC_URI += "${URI_maven-wagon}"
SRC_URI[maven-wagon.sha256sum] = "c19bcb2722d2f5da0e7f5d9bc3a3b822294212eba7e302f947a97cbe9de2d7ee"
RDEPENDS:maven-wagon = " \
 httpcomponents-client \
 httpcomponents-core \
 plexus-utils \
 javapackages-filesystem \
 slf4j \
 jcl-over-slf4j \
"

URI_maven-wagon-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-wagon-javadoc-3.5.3-9.el10.noarch.rpm;name=maven-wagon-javadoc;unpack=0"
SRC_URI += "${URI_maven-wagon-javadoc}"
SRC_URI[maven-wagon-javadoc.sha256sum] = "b3bb338565dd0b5c243fe47763f3da30c23e5af0b5021c759e2d1df4e9daf976"
RDEPENDS:maven-wagon-javadoc = " \
 javapackages-filesystem \
"
