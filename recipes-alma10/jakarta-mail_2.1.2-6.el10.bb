# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jakarta-mail"
PE = "0"
PV = "2.1.2"
PR = "6.el10"
PACKAGES = "jakarta-mail jakarta-mail-javadoc"
PROVIDES = "rpm/jakarta-mail rpm/jakarta-mail-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/jakarta-mail-2.1.2-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "349733024cab92d35d3aa8c3fbbf7dfba6a03fd411e33fa54d5e02d5cef52406"

URI_jakarta-mail = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jakarta-mail-2.1.2-6.el10.noarch.rpm;name=jakarta-mail;unpack=0"
SRC_URI += "${URI_jakarta-mail}"
SRC_URI[jakarta-mail.sha256sum] = "fe535bceb4fe529735bdbed81f9479003443d75a8f0aad389e7ee07a853ce0f4"
RDEPENDS:jakarta-mail = " \
 jakarta-activation \
 javapackages-filesystem \
"

URI_jakarta-mail-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jakarta-mail-javadoc-2.1.2-6.el10.noarch.rpm;name=jakarta-mail-javadoc;unpack=0"
SRC_URI += "${URI_jakarta-mail-javadoc}"
SRC_URI[jakarta-mail-javadoc.sha256sum] = "2e5fd31535ebe52a9d7ed2fb0f825b30997c9f74062524296a50e59662838507"
RDEPENDS:jakarta-mail-javadoc = " \
 javapackages-filesystem \
"
