# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lzop"
PE = "0"
PV = "1.04"
PR = "16.el10"
PACKAGES = "lzop"
PROVIDES = "rpm/lzop"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/lzop-1.04-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b5f7f3ac78952c39210c049c117959d2254a0a03ee1aa1cef4b511348f75d5f"

URI_lzop = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/lzop-1.04-16.el10.x86_64_v2.rpm;name=lzop;unpack=0"
SRC_URI += "${URI_lzop}"
SRC_URI[lzop.sha256sum] = "f2e20c749afc690e0986ba56e58f37884ce0444c0bf48fc0d1182826cf2ebf4d"
RDEPENDS:lzop = " \
 glibc \
 lzo \
"
