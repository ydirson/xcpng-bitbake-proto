# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libadwaita"
PE = "0"
PV = "1.6.1"
PR = "1.el10"
PACKAGES = "libadwaita libadwaita-devel libadwaita-doc libadwaita-demo"
PROVIDES = "rpm/libadwaita rpm/libadwaita-devel rpm/libadwaita-doc rpm/libadwaita-demo"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libadwaita-1.6.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84bdc29629d519b7e01f8205e4e06ff6dac372048ed45710b57007071a26829b"

URI_libadwaita = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libadwaita-1.6.1-1.el10.x86_64_v2.rpm;name=libadwaita;unpack=0"
SRC_URI += "${URI_libadwaita}"
SRC_URI[libadwaita.sha256sum] = "9f966123b0e8f3d1c5516b650befa36e003cadc5a92c2bec69be57b91a1bf864"
RDEPENDS:libadwaita = " \
 appstream \
 fribidi \
 pango \
 glib2 \
 graphene \
 glibc \
 gtk4 \
"

URI_libadwaita-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libadwaita-devel-1.6.1-1.el10.x86_64_v2.rpm;name=libadwaita-devel;unpack=0"
SRC_URI += "${URI_libadwaita-devel}"
SRC_URI[libadwaita-devel.sha256sum] = "6ee1b43c6f0ec822663d04d6a82f2e0740f7bd411ebdadb98aa6c2f5cd72def1"
RDEPENDS:libadwaita-devel = " \
 glib2-devel \
 vala \
 fribidi-devel \
 pkgconf-pkg-config \
 appstream-devel \
 libadwaita \
 gtk4-devel \
"

URI_libadwaita-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libadwaita-doc-1.6.1-1.el10.noarch.rpm;name=libadwaita-doc;unpack=0"
SRC_URI += "${URI_libadwaita-doc}"
SRC_URI[libadwaita-doc.sha256sum] = "bff62cb0ff2fdc0b1394ae6860edd5a99c699e6d959ad0c700fc069ae9f3c47c"
RDEPENDS:libadwaita-doc = ""

URI_libadwaita-demo = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libadwaita-demo-1.6.1-1.el10.noarch.rpm;name=libadwaita-demo;unpack=0"
SRC_URI += "${URI_libadwaita-demo}"
SRC_URI[libadwaita-demo.sha256sum] = "cff479778c9c79e111fe91eab679a27a5171fea3471177d7107c1c7beb3277e5"
RDEPENDS:libadwaita-demo = " \
 libadwaita \
"
