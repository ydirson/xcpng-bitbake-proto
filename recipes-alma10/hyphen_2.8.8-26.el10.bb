# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen"
PE = "0"
PV = "2.8.8"
PR = "26.el10"
PACKAGES = "hyphen hyphen-devel hyphen-en"
PROVIDES = "rpm/hyphen rpm/hyphen-devel rpm/hyphen-en"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-2.8.8-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "614dc0fcff9b51fe4e41c37bade338f29db76b5dcf8204231557e0da02715315"

URI_hyphen = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-2.8.8-26.el10.x86_64_v2.rpm;name=hyphen;unpack=0"
SRC_URI += "${URI_hyphen}"
SRC_URI[hyphen.sha256sum] = "bff67dfec22a8223663163fe28912b5e56869ebd0ba98a9b05745553b18469ab"
RDEPENDS:hyphen = " \
 glibc \
"

URI_hyphen-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-devel-2.8.8-26.el10.x86_64_v2.rpm;name=hyphen-devel;unpack=0"
SRC_URI += "${URI_hyphen-devel}"
SRC_URI[hyphen-devel.sha256sum] = "1da322bca5bb5e771f21e1a6e31f5c3eb98bb8c0c85dfe1b914e543f42238aab"
RDEPENDS:hyphen-devel = " \
 hyphen \
 perl-interpreter \
"

URI_hyphen-en = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-en-2.8.8-26.el10.noarch.rpm;name=hyphen-en;unpack=0"
SRC_URI += "${URI_hyphen-en}"
SRC_URI[hyphen-en.sha256sum] = "b14ad4a3309bc4018c74e12f4425eeedbe31e9b8e6eebd7918b0667ec1484ef8"
RDEPENDS:hyphen-en = " \
 hyphen \
"
