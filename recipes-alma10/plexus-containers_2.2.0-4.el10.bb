# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "plexus-containers"
PE = "0"
PV = "2.2.0"
PR = "4.el10"
PACKAGES = "plexus-containers-component-annotations plexus-containers-component-metadata plexus-containers-javadoc"
PROVIDES = "rpm/plexus-containers-component-annotations rpm/plexus-containers-component-metadata rpm/plexus-containers-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/plexus-containers-2.2.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b660b3e6a20b442f364a57590b780737c2cd16ef2530e934d87147cbe106438f"

URI_plexus-containers-component-annotations = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/plexus-containers-component-annotations-2.2.0-4.el10.noarch.rpm;name=plexus-containers-component-annotations;unpack=0"
SRC_URI += "${URI_plexus-containers-component-annotations}"
SRC_URI[plexus-containers-component-annotations.sha256sum] = "27f168d6f44219d504d0790a2671d81be4f20d4c4262540a73b2df964116c60f"
RDEPENDS:plexus-containers-component-annotations = " \
 javapackages-filesystem \
"

URI_plexus-containers-component-metadata = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-containers-component-metadata-2.2.0-4.el10.noarch.rpm;name=plexus-containers-component-metadata;unpack=0"
SRC_URI += "${URI_plexus-containers-component-metadata}"
SRC_URI[plexus-containers-component-metadata.sha256sum] = "bf9f7d8ed6df55f5cfde9451392bee21ac53871afd5ee5b1195aee382664bc38"
RDEPENDS:plexus-containers-component-metadata = " \
 jdom2 \
 objectweb-asm \
 plexus-containers-component-annotations \
 plexus-utils \
 javapackages-filesystem \
 qdox \
"

URI_plexus-containers-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-containers-javadoc-2.2.0-4.el10.noarch.rpm;name=plexus-containers-javadoc;unpack=0"
SRC_URI += "${URI_plexus-containers-javadoc}"
SRC_URI[plexus-containers-javadoc.sha256sum] = "0332ea01fc67b8acb4f8a19a878e8a0399cfd164b0690ec0ca59fc02fc08775c"
RDEPENDS:plexus-containers-javadoc = " \
 javapackages-filesystem \
"
