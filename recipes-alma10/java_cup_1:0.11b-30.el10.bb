# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "java_cup"
PE = "1"
PV = "0.11b"
PR = "30.el10"
PACKAGES = "java_cup java_cup-javadoc java_cup-manual"
PROVIDES = "rpm/java_cup rpm/java_cup-javadoc rpm/java_cup-manual"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/java_cup-0.11b-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5588ca115c53d38bd63d9f6684c5d76a5a84904bb4c96179314e0f1f63233336"

URI_java_cup = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/java_cup-0.11b-30.el10.noarch.rpm;name=java_cup;unpack=0"
SRC_URI += "${URI_java_cup}"
SRC_URI[java_cup.sha256sum] = "191984b6a59ea2731638cf167d31c259cf6863e8f1ee3a4f89623f6d088ff466"
RDEPENDS:java_cup = " \
 bash \
 javapackages-filesystem \
 javapackages-tools \
"

URI_java_cup-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/java_cup-javadoc-0.11b-30.el10.noarch.rpm;name=java_cup-javadoc;unpack=0"
SRC_URI += "${URI_java_cup-javadoc}"
SRC_URI[java_cup-javadoc.sha256sum] = "355dd96bb318852b96c8a28dc6775416f9848cd360e7b65bd538ecba78bb4e06"
RDEPENDS:java_cup-javadoc = " \
 javapackages-filesystem \
"

URI_java_cup-manual = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/java_cup-manual-0.11b-30.el10.noarch.rpm;name=java_cup-manual;unpack=0"
SRC_URI += "${URI_java_cup-manual}"
SRC_URI[java_cup-manual.sha256sum] = "373f53d3ef38173a67ef24eb71a97dc8530eee29f7f038735679777b970400e2"
RDEPENDS:java_cup-manual = ""
