# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "make"
PE = "1"
PV = "4.4.1"
PR = "9.el10"
PACKAGES = "make make-devel"
PROVIDES = "rpm/make rpm/make-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/make-4.4.1-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50df7869980464ca91c642ad37ec57eb0c36401066fbed344cf4d3666a8a061a"

URI_make = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/make-4.4.1-9.el10.x86_64_v2.rpm;name=make;unpack=0"
SRC_URI += "${URI_make}"
SRC_URI[make.sha256sum] = "6e1dce95ec84dd2f727abb78a936cbd754bd7ecc6c9ce63098c76f01a350121f"
RDEPENDS:make = " \
 glibc \
"

URI_make-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/make-devel-4.4.1-9.el10.x86_64_v2.rpm;name=make-devel;unpack=0"
SRC_URI += "${URI_make-devel}"
SRC_URI[make-devel.sha256sum] = "4f9983fb3fb824a11e3e7931c6d9df0c8b24f31149a03d0aa57623c38c48e2d6"
RDEPENDS:make-devel = ""
