# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rubygem-thread_order"
PE = "0"
PV = "1.1.1"
PR = "13.el10"
PACKAGES = "rubygem-thread_order rubygem-thread_order-doc"
PROVIDES = "rpm/rubygem-thread_order rpm/rubygem-thread_order-doc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/rubygem-thread_order-1.1.1-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7e4e3391d7dad2a83f2ea9e64da6a6039d5ae6718f55385684fa3c654e4d95b"

URI_rubygem-thread_order = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/rubygem-thread_order-1.1.1-13.el10.noarch.rpm;name=rubygem-thread_order;unpack=0"
SRC_URI += "${URI_rubygem-thread_order}"
SRC_URI[rubygem-thread_order.sha256sum] = "fa949e04fb511e648fcfc3cd8b8da2e055f8dec883bc965791afe24b813c6871"
RDEPENDS:rubygem-thread_order = " \
 rubygems \
"

URI_rubygem-thread_order-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-thread_order-doc-1.1.1-13.el10.noarch.rpm;name=rubygem-thread_order-doc;unpack=0"
SRC_URI += "${URI_rubygem-thread_order-doc}"
SRC_URI[rubygem-thread_order-doc.sha256sum] = "2d3efcb98480cc08dbf4ea27ad45ccd2f64a547c831a25aa66925415f6644486"
RDEPENDS:rubygem-thread_order-doc = " \
 rubygem-thread_order \
"
