# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libportal"
PE = "0"
PV = "0.9.0"
PR = "1.el10"
PACKAGES = "libportal libportal-gtk3 libportal-gtk4 libportal-qt6 libportal-devel libportal-devel-doc libportal-gtk3-devel libportal-gtk4-devel libportal-qt6-devel"
PROVIDES = "rpm/libportal rpm/libportal-gtk3 rpm/libportal-gtk4 rpm/libportal-qt6 rpm/libportal-devel rpm/libportal-devel-doc rpm/libportal-gtk3-devel rpm/libportal-gtk4-devel rpm/libportal-qt6-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libportal-0.9.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f744b37fcb0e56126049caf1542a657b3862f6864a515d3801fb40f81bcbe408"

URI_libportal = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libportal-0.9.0-1.el10.x86_64_v2.rpm;name=libportal;unpack=0"
SRC_URI += "${URI_libportal}"
SRC_URI[libportal.sha256sum] = "d6cdce7a9d9659e62a26da78f5aa7d16df88350604dd5eb525106822c546467e"
RDEPENDS:libportal = " \
 glibc \
 libgcc \
 glib2 \
"

URI_libportal-gtk3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libportal-gtk3-0.9.0-1.el10.x86_64_v2.rpm;name=libportal-gtk3;unpack=0"
SRC_URI += "${URI_libportal-gtk3}"
SRC_URI[libportal-gtk3.sha256sum] = "5677f88f293131b6f09972fcfa7a60dec04041a63cac2aebd17b8f0f731419a5"
RDEPENDS:libportal-gtk3 = " \
 libgcc \
 glib2 \
 libportal \
 gtk3 \
 glibc \
"

URI_libportal-gtk4 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libportal-gtk4-0.9.0-1.el10.x86_64_v2.rpm;name=libportal-gtk4;unpack=0"
SRC_URI += "${URI_libportal-gtk4}"
SRC_URI[libportal-gtk4.sha256sum] = "c8128bcb7dfb05150f946f3824f928e54b6c000fc155461296e8afd07a8dea32"
RDEPENDS:libportal-gtk4 = " \
 libgcc \
 glib2 \
 libportal \
 glibc \
 gtk4 \
"

URI_libportal-qt6 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libportal-qt6-0.9.0-1.el10.x86_64_v2.rpm;name=libportal-qt6;unpack=0"
SRC_URI += "${URI_libportal-qt6}"
SRC_URI[libportal-qt6.sha256sum] = "b50132dc3cbb2356a189e42e3fba9746f15c0d792db7b459441c27610e4d015d"
RDEPENDS:libportal-qt6 = " \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glib2 \
 libportal \
 glibc \
"

URI_libportal-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libportal-devel-0.9.0-1.el10.x86_64_v2.rpm;name=libportal-devel;unpack=0"
SRC_URI += "${URI_libportal-devel}"
SRC_URI[libportal-devel.sha256sum] = "a90cdb46a6fd83a36fbf555865c24efd1b5edcf9278a0e144029c39fe1e2f90e"
RDEPENDS:libportal-devel = " \
 libportal \
 glib2-devel \
 pkgconf-pkg-config \
"

URI_libportal-devel-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libportal-devel-doc-0.9.0-1.el10.noarch.rpm;name=libportal-devel-doc;unpack=0"
SRC_URI += "${URI_libportal-devel-doc}"
SRC_URI[libportal-devel-doc.sha256sum] = "28d777d3656fa06ee5278c106ba35b219f6ff2d4571c8a41902668942800a3bf"
RDEPENDS:libportal-devel-doc = ""

URI_libportal-gtk3-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libportal-gtk3-devel-0.9.0-1.el10.x86_64_v2.rpm;name=libportal-gtk3-devel;unpack=0"
SRC_URI += "${URI_libportal-gtk3-devel}"
SRC_URI[libportal-gtk3-devel.sha256sum] = "d4c6d9276503684f8262ca396dfeafb00b0cc697ac76575ee37cd21f5eb52cd8"
RDEPENDS:libportal-gtk3-devel = " \
 glib2-devel \
 libportal-devel \
 pkgconf-pkg-config \
 gtk3-devel \
 libportal-gtk3 \
"

URI_libportal-gtk4-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libportal-gtk4-devel-0.9.0-1.el10.x86_64_v2.rpm;name=libportal-gtk4-devel;unpack=0"
SRC_URI += "${URI_libportal-gtk4-devel}"
SRC_URI[libportal-gtk4-devel.sha256sum] = "5b2a495bf12b37054177c1f711146dfa578aafae9f6ec4651b25ed69a27cb1ae"
RDEPENDS:libportal-gtk4-devel = " \
 glib2-devel \
 libportal-devel \
 pkgconf-pkg-config \
 libportal-gtk4 \
 gtk4-devel \
"

URI_libportal-qt6-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libportal-qt6-devel-0.9.0-1.el10.x86_64_v2.rpm;name=libportal-qt6-devel;unpack=0"
SRC_URI += "${URI_libportal-qt6-devel}"
SRC_URI[libportal-qt6-devel.sha256sum] = "c05c7d2bb5a2a670b7b5040098ccf75ba751b44fbef4d59896908590a2380a7d"
RDEPENDS:libportal-qt6-devel = " \
 glib2-devel \
 libportal-devel \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 libportal-qt6 \
"
