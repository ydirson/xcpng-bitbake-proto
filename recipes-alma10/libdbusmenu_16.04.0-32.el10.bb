# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libdbusmenu"
PE = "0"
PV = "16.04.0"
PR = "32.el10"
PACKAGES = "libdbusmenu libdbusmenu-devel libdbusmenu-gtk3 libdbusmenu-gtk3-devel libdbusmenu-doc libdbusmenu-gtk3-tests libdbusmenu-jsonloader libdbusmenu-jsonloader-devel libdbusmenu-tools"
PROVIDES = "rpm/libdbusmenu rpm/libdbusmenu-devel rpm/libdbusmenu-gtk3 rpm/libdbusmenu-gtk3-devel rpm/libdbusmenu-doc rpm/libdbusmenu-gtk3-tests rpm/libdbusmenu-jsonloader rpm/libdbusmenu-jsonloader-devel rpm/libdbusmenu-tools"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/libdbusmenu-16.04.0-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6df774db353d23722cdd61a60fbbf782ef22b3b2b347aba5b8454d0336f20c86"

URI_libdbusmenu = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libdbusmenu-16.04.0-32.el10.x86_64_v2.rpm;name=libdbusmenu;unpack=0"
SRC_URI += "${URI_libdbusmenu}"
SRC_URI[libdbusmenu.sha256sum] = "6c4e458891fd53bea17d9da3002cfbdf3d8040602cf8ac167c39686b8183797c"
RDEPENDS:libdbusmenu = " \
 glibc \
 glib2 \
"

URI_libdbusmenu-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libdbusmenu-devel-16.04.0-32.el10.x86_64_v2.rpm;name=libdbusmenu-devel;unpack=0"
SRC_URI += "${URI_libdbusmenu-devel}"
SRC_URI[libdbusmenu-devel.sha256sum] = "c3f42787344150b41061f5979c0f38885c68abebbe4cdd1b3cba9620c18adedc"
RDEPENDS:libdbusmenu-devel = " \
 libdbusmenu \
 pkgconf-pkg-config \
"

URI_libdbusmenu-gtk3 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libdbusmenu-gtk3-16.04.0-32.el10.x86_64_v2.rpm;name=libdbusmenu-gtk3;unpack=0"
SRC_URI += "${URI_libdbusmenu-gtk3}"
SRC_URI[libdbusmenu-gtk3.sha256sum] = "5198e773b00752f812f43548ece466fcc150d7125122f8a3db6cd42cff13c1ac"
RDEPENDS:libdbusmenu-gtk3 = " \
 atk \
 cairo-gobject \
 harfbuzz \
 libdbusmenu \
 pango \
 gdk-pixbuf2 \
 cairo \
 glib2 \
 gtk3 \
 glibc \
"

URI_libdbusmenu-gtk3-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libdbusmenu-gtk3-devel-16.04.0-32.el10.x86_64_v2.rpm;name=libdbusmenu-gtk3-devel;unpack=0"
SRC_URI += "${URI_libdbusmenu-gtk3-devel}"
SRC_URI[libdbusmenu-gtk3-devel.sha256sum] = "15a468279fac7ce7fe77d29248922fc1cc2f52f1e452661b645b424f7282506a"
RDEPENDS:libdbusmenu-gtk3-devel = " \
 libdbusmenu \
 libdbusmenu-devel \
 pkgconf-pkg-config \
 libdbusmenu-gtk3 \
 gdk-pixbuf2-devel \
 gtk3-devel \
"

URI_libdbusmenu-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdbusmenu-doc-16.04.0-32.el10.noarch.rpm;name=libdbusmenu-doc;unpack=0"
SRC_URI += "${URI_libdbusmenu-doc}"
SRC_URI[libdbusmenu-doc.sha256sum] = "8c269162706f84efbf584b7cf2dd61c192dc8726bbcf604a7855bd96d160dfd5"
RDEPENDS:libdbusmenu-doc = ""

URI_libdbusmenu-gtk3-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdbusmenu-gtk3-tests-16.04.0-32.el10.x86_64_v2.rpm;name=libdbusmenu-gtk3-tests;unpack=0"
SRC_URI += "${URI_libdbusmenu-gtk3-tests}"
SRC_URI[libdbusmenu-gtk3-tests.sha256sum] = "37225b469a2561c2644a3814db2483a375c0cf27f597a0105f5921ca0fc8fa99"
RDEPENDS:libdbusmenu-gtk3-tests = " \
 libdbusmenu \
 libdbusmenu-gtk3 \
 bash \
 glib2 \
 glibc \
"

URI_libdbusmenu-jsonloader = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdbusmenu-jsonloader-16.04.0-32.el10.x86_64_v2.rpm;name=libdbusmenu-jsonloader;unpack=0"
SRC_URI += "${URI_libdbusmenu-jsonloader}"
SRC_URI[libdbusmenu-jsonloader.sha256sum] = "7600895a2d940a298dee8b8d33e409b5e4ac83ff5ce022e3f329b94b8ad31f4f"
RDEPENDS:libdbusmenu-jsonloader = " \
 libdbusmenu \
 libdbusmenu-devel \
 json-glib \
 glib2 \
 glibc \
"

URI_libdbusmenu-jsonloader-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdbusmenu-jsonloader-devel-16.04.0-32.el10.x86_64_v2.rpm;name=libdbusmenu-jsonloader-devel;unpack=0"
SRC_URI += "${URI_libdbusmenu-jsonloader-devel}"
SRC_URI[libdbusmenu-jsonloader-devel.sha256sum] = "c7daf9d8ed817e1b10c1f734a582f55681d2fd5d3e908e5f21d9c3fe5adeaa29"
RDEPENDS:libdbusmenu-jsonloader-devel = " \
 json-glib-devel \
 libdbusmenu \
 libdbusmenu-devel \
 libdbusmenu-jsonloader \
 pkgconf-pkg-config \
"

URI_libdbusmenu-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdbusmenu-tools-16.04.0-32.el10.x86_64_v2.rpm;name=libdbusmenu-tools;unpack=0"
SRC_URI += "${URI_libdbusmenu-tools}"
SRC_URI[libdbusmenu-tools.sha256sum] = "fca6a5751dfe721fa0e5772d9c89192d78a2876da4fa8c37c341c863ca4f2233"
RDEPENDS:libdbusmenu-tools = " \
 glibc \
 libdbusmenu \
 glib2 \
 json-glib \
"
