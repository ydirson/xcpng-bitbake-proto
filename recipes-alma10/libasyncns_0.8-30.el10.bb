# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libasyncns"
PE = "0"
PV = "0.8"
PR = "30.el10"
PACKAGES = "libasyncns libasyncns-devel"
PROVIDES = "rpm/libasyncns rpm/libasyncns-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libasyncns-0.8-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42f23752877467160c3cd501f2ce27c534ae9e12ff4a5cb775a0c85c5ae00bc7"

URI_libasyncns = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libasyncns-0.8-30.el10.x86_64_v2.rpm;name=libasyncns;unpack=0"
SRC_URI += "${URI_libasyncns}"
SRC_URI[libasyncns.sha256sum] = "1351e31f85e49b98b733f6e20ca34f53b12c8e28724be8d74bc6d77f9249ba6f"
RDEPENDS:libasyncns = " \
 glibc \
"

URI_libasyncns-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libasyncns-devel-0.8-30.el10.x86_64_v2.rpm;name=libasyncns-devel;unpack=0"
SRC_URI += "${URI_libasyncns-devel}"
SRC_URI[libasyncns-devel.sha256sum] = "f9fd6b4b90944499129ea9ed795ee9d88999c8ab28af57eac83e956f90d51d0e"
RDEPENDS:libasyncns-devel = " \
 libasyncns \
 pkgconf-pkg-config \
"
