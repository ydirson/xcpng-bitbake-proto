# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "catatonit"
PE = "5"
PV = "0.2.1"
PR = "1.el10"
PACKAGES = "catatonit"
PROVIDES = "rpm/catatonit"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/catatonit-0.2.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09e7a8da8440d12ed104f701006761469158254d29e18065b015cfe3e02b402a"

URI_catatonit = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/catatonit-0.2.1-1.el10.x86_64_v2.rpm;name=catatonit;unpack=0"
SRC_URI += "${URI_catatonit}"
SRC_URI[catatonit.sha256sum] = "19ab0ad8da3e231b7bb36f553c42eb4e529832b3a45fec6b00ca5aa989925399"
RDEPENDS:catatonit = ""
