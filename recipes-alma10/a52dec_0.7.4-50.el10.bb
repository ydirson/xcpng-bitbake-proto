# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "a52dec"
PE = "0"
PV = "0.7.4"
PR = "50.el10"
PACKAGES = "a52dec liba52 liba52-devel"
PROVIDES = "rpm/a52dec rpm/liba52 rpm/liba52-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/a52dec-0.7.4-50.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "461491b5518f254e37c91eb60352ae25430ad526673fa65fa2bdf0cb15a7bc67"

URI_a52dec = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/a52dec-0.7.4-50.el10.x86_64_v2.rpm;name=a52dec;unpack=0"
SRC_URI += "${URI_a52dec}"
SRC_URI[a52dec.sha256sum] = "b637c135d602d85a94f5d55f48668f2aeae04b5ea2837d5d1b0b8625ead808f6"
RDEPENDS:a52dec = " \
 glibc \
 liba52 \
"

URI_liba52 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/liba52-0.7.4-50.el10.x86_64_v2.rpm;name=liba52;unpack=0"
SRC_URI += "${URI_liba52}"
SRC_URI[liba52.sha256sum] = "b833e35aa67f59187af3abefd5a6d5a24caa1605825942e2b03520c6e01213aa"
RDEPENDS:liba52 = " \
 glibc \
"

URI_liba52-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/liba52-devel-0.7.4-50.el10.x86_64_v2.rpm;name=liba52-devel;unpack=0"
SRC_URI += "${URI_liba52-devel}"
SRC_URI[liba52-devel.sha256sum] = "51389b9b0b417e36ef0c2ed2c6b492ddf5428e680286b407f5829283f452daf6"
RDEPENDS:liba52-devel = " \
 liba52 \
"
