# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-wcwidth"
PE = "0"
PV = "0.2.6"
PR = "6.el10"
PACKAGES = "python3-wcwidth"
PROVIDES = "rpm/python3-wcwidth"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/python-wcwidth-0.2.6-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eafacb2eb4f4b063c91c5ee9cd96d31aa7ac66fcc636bcd08a505479799d76b2"

URI_python3-wcwidth = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-wcwidth-0.2.6-6.el10.noarch.rpm;name=python3-wcwidth;unpack=0"
SRC_URI += "${URI_python3-wcwidth}"
SRC_URI[python3-wcwidth.sha256sum] = "9ce2e99b4e9c2df1ec81e1235345b4941e57bdfdd66785ec65ebfb342a99e02f"
RDEPENDS:python3-wcwidth = " \
 python3 \
"
