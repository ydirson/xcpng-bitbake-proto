# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xdg-dbus-proxy"
PE = "0"
PV = "0.1.5"
PR = "4.el10"
PACKAGES = "xdg-dbus-proxy"
PROVIDES = "rpm/xdg-dbus-proxy"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xdg-dbus-proxy-0.1.5-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a886ca0025a042a8ed95d87255acf1cfdc745ced8c0452d4e95a32369431385"

URI_xdg-dbus-proxy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xdg-dbus-proxy-0.1.5-4.el10.x86_64_v2.rpm;name=xdg-dbus-proxy;unpack=0"
SRC_URI += "${URI_xdg-dbus-proxy}"
SRC_URI[xdg-dbus-proxy.sha256sum] = "a096d504190610f939c9cdc75c841723aaad6d882f7fb2c22110cce23bd30a0f"
RDEPENDS:xdg-dbus-proxy = " \
 glibc \
 libgcc \
 glib2 \
 dbus \
"
