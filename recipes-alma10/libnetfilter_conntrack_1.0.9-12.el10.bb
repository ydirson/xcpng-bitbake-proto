# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libnetfilter_conntrack"
PE = "0"
PV = "1.0.9"
PR = "12.el10"
PACKAGES = "libnetfilter_conntrack libnetfilter_conntrack-devel"
PROVIDES = "rpm/libnetfilter_conntrack rpm/libnetfilter_conntrack-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libnetfilter_conntrack-1.0.9-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea66a5b1267a1c683549845ed6e3585975f0a7796e6e6d1453f9e38fe0460c41"

URI_libnetfilter_conntrack = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libnetfilter_conntrack-1.0.9-12.el10.x86_64_v2.rpm;name=libnetfilter_conntrack;unpack=0"
SRC_URI += "${URI_libnetfilter_conntrack}"
SRC_URI[libnetfilter_conntrack.sha256sum] = "5edc0843bcddc1a12774f1b19e9d58651fcb7ebbfa65f3785cc74d8c79e035e1"
RDEPENDS:libnetfilter_conntrack = " \
 glibc \
 libmnl \
 libnfnetlink \
"

URI_libnetfilter_conntrack-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libnetfilter_conntrack-devel-1.0.9-12.el10.x86_64_v2.rpm;name=libnetfilter_conntrack-devel;unpack=0"
SRC_URI += "${URI_libnetfilter_conntrack-devel}"
SRC_URI[libnetfilter_conntrack-devel.sha256sum] = "d5d2f9ebc611895043d976b383613ed09cfa45d5d53e9c2b1e08cd64e30dde39"
RDEPENDS:libnetfilter_conntrack-devel = " \
 libnfnetlink-devel \
 libnetfilter_conntrack \
 kernel-headers \
 pkgconf-pkg-config \
"
