# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-rpm-generators"
PE = "0"
PV = "14"
PR = "12.el10"
PACKAGES = "python3-rpm-generators"
PROVIDES = "rpm/python3-rpm-generators"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-rpm-generators-14-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd26054b654b014b1baacb94805b44fb1789ffce0a64035dd39c7c7ad98978bf"

URI_python3-rpm-generators = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-rpm-generators-14-12.el10.noarch.rpm;name=python3-rpm-generators;unpack=0"
SRC_URI += "${URI_python3-rpm-generators}"
SRC_URI[python3-rpm-generators.sha256sum] = "7da63389710cf49d11225ffec042726cbe2221e1e963607416ef95d7a32c9572"
RDEPENDS:python3-rpm-generators = " \
 python3 \
 python3-packaging \
 python-srpm-macros \
 rpm \
"
