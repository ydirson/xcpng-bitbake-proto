# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "nginx"
PE = "2"
PV = "1.26.3"
PR = "1.el10"
PACKAGES = "nginx nginx-all-modules nginx-core nginx-filesystem nginx-mod-http-image-filter nginx-mod-http-perl nginx-mod-http-xslt-filter nginx-mod-mail nginx-mod-stream nginx-mod-devel"
PROVIDES = "rpm/nginx rpm/nginx-all-modules rpm/nginx-core rpm/nginx-filesystem rpm/nginx-mod-http-image-filter rpm/nginx-mod-http-perl rpm/nginx-mod-http-xslt-filter rpm/nginx-mod-mail rpm/nginx-mod-stream rpm/nginx-mod-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/nginx-1.26.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f65c9da51df25408d5c6869ad6428430d8466d756f69db5f63c06f67178e29ae"

URI_nginx = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nginx-1.26.3-1.el10.x86_64_v2.rpm;name=nginx;unpack=0"
SRC_URI += "${URI_nginx}"
SRC_URI[nginx.sha256sum] = "9016c02d498b0f4cc3e2ee8cf977815464f2846d5987216a1b1b6c4c87e4d700"
RDEPENDS:nginx = " \
 systemd \
 almalinux-logos-httpd \
 bash \
 nginx-core \
 nginx-filesystem \
"

URI_nginx-all-modules = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nginx-all-modules-1.26.3-1.el10.noarch.rpm;name=nginx-all-modules;unpack=0"
SRC_URI += "${URI_nginx-all-modules}"
SRC_URI[nginx-all-modules.sha256sum] = "f4948f1a6d238656fd0b33b46a619344316507808459be0edb0200c18c636f31"
RDEPENDS:nginx-all-modules = " \
 nginx-mod-stream \
 nginx-mod-http-image-filter \
 nginx-mod-http-perl \
 nginx-mod-http-xslt-filter \
 nginx-mod-mail \
"

URI_nginx-core = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nginx-core-1.26.3-1.el10.x86_64_v2.rpm;name=nginx-core;unpack=0"
SRC_URI += "${URI_nginx-core}"
SRC_URI[nginx-core.sha256sum] = "2007e5e7169f1ae432e3f5e10ca2bba535e7fb49692626a5155d59a6c297a65c"
RDEPENDS:nginx-core = " \
 zlib-ng-compat \
 libxcrypt \
 openssl-libs \
 pcre2 \
 glibc \
 nginx-filesystem \
"

URI_nginx-filesystem = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nginx-filesystem-1.26.3-1.el10.noarch.rpm;name=nginx-filesystem;unpack=0"
SRC_URI += "${URI_nginx-filesystem}"
SRC_URI[nginx-filesystem.sha256sum] = "ab05f6d7b541261a74c072bb572662581ee467da797cca93300d5ffb855e1bc3"
RDEPENDS:nginx-filesystem = " \
 shadow-utils \
 bash \
"

URI_nginx-mod-http-image-filter = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nginx-mod-http-image-filter-1.26.3-1.el10.x86_64_v2.rpm;name=nginx-mod-http-image-filter;unpack=0"
SRC_URI += "${URI_nginx-mod-http-image-filter}"
SRC_URI[nginx-mod-http-image-filter.sha256sum] = "035f90228b28f80a2412477d648ee13e671b0701136746be5ea377b4a894fdb3"
RDEPENDS:nginx-mod-http-image-filter = " \
 glibc \
 gd \
 nginx \
 bash \
"

URI_nginx-mod-http-perl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nginx-mod-http-perl-1.26.3-1.el10.x86_64_v2.rpm;name=nginx-mod-http-perl;unpack=0"
SRC_URI += "${URI_nginx-mod-http-perl}"
SRC_URI[nginx-mod-http-perl.sha256sum] = "5061ba46e8d740e9684317b3385c965f1d780602e410307d65cc4eb6ca3cd02b"
RDEPENDS:nginx-mod-http-perl = " \
 perl-constant \
 nginx \
 perl-libs \
 bash \
 glibc \
 perl-Exporter \
"

URI_nginx-mod-http-xslt-filter = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nginx-mod-http-xslt-filter-1.26.3-1.el10.x86_64_v2.rpm;name=nginx-mod-http-xslt-filter;unpack=0"
SRC_URI += "${URI_nginx-mod-http-xslt-filter}"
SRC_URI[nginx-mod-http-xslt-filter.sha256sum] = "84a6ad3d0eaed127245fa229d7922c90e0c4413c2ee8e51d0610ed04f26e256f"
RDEPENDS:nginx-mod-http-xslt-filter = " \
 nginx \
 libxslt \
 libxml2 \
 bash \
 glibc \
"

URI_nginx-mod-mail = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nginx-mod-mail-1.26.3-1.el10.x86_64_v2.rpm;name=nginx-mod-mail;unpack=0"
SRC_URI += "${URI_nginx-mod-mail}"
SRC_URI[nginx-mod-mail.sha256sum] = "332a092032a5a8273a47f24ecdc79fca29ee9b0327ed873525110c69ec4dc98f"
RDEPENDS:nginx-mod-mail = " \
 glibc \
 nginx \
 bash \
"

URI_nginx-mod-stream = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nginx-mod-stream-1.26.3-1.el10.x86_64_v2.rpm;name=nginx-mod-stream;unpack=0"
SRC_URI += "${URI_nginx-mod-stream}"
SRC_URI[nginx-mod-stream.sha256sum] = "4e3fc40bf3fc880224c437f22203a6af09c5925b00f31a31aadc7d409aedb064"
RDEPENDS:nginx-mod-stream = " \
 glibc \
 nginx \
 bash \
"

URI_nginx-mod-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/nginx-mod-devel-1.26.3-1.el10.x86_64_v2.rpm;name=nginx-mod-devel;unpack=0"
SRC_URI += "${URI_nginx-mod-devel}"
SRC_URI[nginx-mod-devel.sha256sum] = "71c21b0141f9dc55a72bd9c869ce62ce3961ec295d3ad8ad45cbcc4f22acc31e"
RDEPENDS:nginx-mod-devel = " \
 perl-constant \
 perl-ExtUtils-Embed \
 gd-devel \
 perl-libs \
 perl-interpreter \
 libxslt-devel \
 perl-devel \
 zlib-ng-compat-devel \
 make \
 pcre2-devel \
 openssl-devel \
 bash \
 gcc \
 nginx \
 perl-Exporter \
"
