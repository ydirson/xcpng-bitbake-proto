# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libdb"
PE = "0"
PV = "5.3.28"
PR = "61.el10"
PACKAGES = "libdb libdb-convert-util libdb-cxx libdb-cxx-devel libdb-devel libdb-devel-doc libdb-devel-static libdb-sql libdb-sql-devel libdb-tcl libdb-tcl-devel libdb-utils"
PROVIDES = "rpm/libdb rpm/libdb-convert-util rpm/libdb-cxx rpm/libdb-cxx-devel rpm/libdb-devel rpm/libdb-devel-doc rpm/libdb-devel-static rpm/libdb-sql rpm/libdb-sql-devel rpm/libdb-tcl rpm/libdb-tcl-devel rpm/libdb-utils"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/libdb-5.3.28-61.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f61861c54b033c090dd4a57bf7914e69c3f1eea9902e04e558f43a6fca3eed1"

URI_libdb = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdb-5.3.28-61.el10.x86_64_v2.rpm;name=libdb;unpack=0"
SRC_URI += "${URI_libdb}"
SRC_URI[libdb.sha256sum] = "4edbeb23353503e304b8018255933e56cc5f348f89cbe02ce1700c30be0ab994"
RDEPENDS:libdb = " \
 glibc \
"

URI_libdb-convert-util = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdb-convert-util-5.3.28-61.el10.x86_64_v2.rpm;name=libdb-convert-util;unpack=0"
SRC_URI += "${URI_libdb-convert-util}"
SRC_URI[libdb-convert-util.sha256sum] = "3c36bee43babe689059b1b4b001e49dc1dc863d1e08193b9a9126ff21884caad"
RDEPENDS:libdb-convert-util = " \
 libgcc \
 gdbm-libs \
 libstdc++ \
 glibc \
 lmdb-libs \
"

URI_libdb-cxx = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdb-cxx-5.3.28-61.el10.x86_64_v2.rpm;name=libdb-cxx;unpack=0"
SRC_URI += "${URI_libdb-cxx}"
SRC_URI[libdb-cxx.sha256sum] = "9645981749aeb0c97fa0755fe9bd208c143032a221d5795c3c5ebaab29e3a2ee"
RDEPENDS:libdb-cxx = " \
 glibc \
 libgcc \
 libstdc++ \
 libdb \
"

URI_libdb-cxx-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdb-cxx-devel-5.3.28-61.el10.x86_64_v2.rpm;name=libdb-cxx-devel;unpack=0"
SRC_URI += "${URI_libdb-cxx-devel}"
SRC_URI[libdb-cxx-devel.sha256sum] = "95680d370a835ddf6627b6e0b920d99b1c6a0cf81daac59e914957143ff01afe"
RDEPENDS:libdb-cxx-devel = " \
 libdb-cxx \
 libdb-devel \
"

URI_libdb-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdb-devel-5.3.28-61.el10.x86_64_v2.rpm;name=libdb-devel;unpack=0"
SRC_URI += "${URI_libdb-devel}"
SRC_URI[libdb-devel.sha256sum] = "f4051bba7e792a05c8fcb71f50250d4ee5178ad50ec4f52fcfcd51613960e7ba"
RDEPENDS:libdb-devel = " \
 libdb \
"

URI_libdb-devel-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdb-devel-doc-5.3.28-61.el10.noarch.rpm;name=libdb-devel-doc;unpack=0"
SRC_URI += "${URI_libdb-devel-doc}"
SRC_URI[libdb-devel-doc.sha256sum] = "c575816e1feee90eb40282c72ffcabb9f74eda55aca8e00d17fade55f1dc1105"
RDEPENDS:libdb-devel-doc = " \
 libdb-devel \
 libdb \
"

URI_libdb-devel-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdb-devel-static-5.3.28-61.el10.x86_64_v2.rpm;name=libdb-devel-static;unpack=0"
SRC_URI += "${URI_libdb-devel-static}"
SRC_URI[libdb-devel-static.sha256sum] = "cb1c940182ad9d7031691cf70b4c80e98925275bf41c77c943421bf2182d2131"
RDEPENDS:libdb-devel-static = " \
 libdb-devel \
"

URI_libdb-sql = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdb-sql-5.3.28-61.el10.x86_64_v2.rpm;name=libdb-sql;unpack=0"
SRC_URI += "${URI_libdb-sql}"
SRC_URI[libdb-sql.sha256sum] = "dd82021cb15ab5874244a42be928820979516b2972bb4af196d4666e2f6a8086"
RDEPENDS:libdb-sql = " \
 glibc \
 libdb \
"

URI_libdb-sql-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdb-sql-devel-5.3.28-61.el10.x86_64_v2.rpm;name=libdb-sql-devel;unpack=0"
SRC_URI += "${URI_libdb-sql-devel}"
SRC_URI[libdb-sql-devel.sha256sum] = "8edde6f3962b8fd3dfa58516c066754fb242160670f32ef019abcdeb1f51fe56"
RDEPENDS:libdb-sql-devel = " \
 glibc \
 libdb-sql \
"

URI_libdb-tcl = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdb-tcl-5.3.28-61.el10.x86_64_v2.rpm;name=libdb-tcl;unpack=0"
SRC_URI += "${URI_libdb-tcl}"
SRC_URI[libdb-tcl.sha256sum] = "c013ea7e759820b983e1b34d1236143cda04968ee553c6e689dfaf2e23e7b7fe"
RDEPENDS:libdb-tcl = " \
 glibc \
 libdb \
"

URI_libdb-tcl-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdb-tcl-devel-5.3.28-61.el10.x86_64_v2.rpm;name=libdb-tcl-devel;unpack=0"
SRC_URI += "${URI_libdb-tcl-devel}"
SRC_URI[libdb-tcl-devel.sha256sum] = "2ec12110cabd82a49bfa503feb6b6f0755b231c29380c938572b504d2ad8b62c"
RDEPENDS:libdb-tcl-devel = " \
 libdb-tcl \
"

URI_libdb-utils = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdb-utils-5.3.28-61.el10.x86_64_v2.rpm;name=libdb-utils;unpack=0"
SRC_URI += "${URI_libdb-utils}"
SRC_URI[libdb-utils.sha256sum] = "708bef1d69b7a20b980a26298add4c9e7e51be3df314678ef74ffdc6351a2cc7"
RDEPENDS:libdb-utils = " \
 glibc \
 libdb \
"
