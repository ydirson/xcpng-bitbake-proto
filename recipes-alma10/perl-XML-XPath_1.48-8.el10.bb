# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-XML-XPath"
PE = "0"
PV = "1.48"
PR = "8.el10"
PACKAGES = "perl-XML-XPath perl-XML-XPath-tests"
PROVIDES = "rpm/perl-XML-XPath rpm/perl-XML-XPath-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-XML-XPath-1.48-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ccca41862e9d56dcb9305caf2ba9e77adde543a131976cd8d01a5e5fa9eacec"

URI_perl-XML-XPath = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-XML-XPath-1.48-8.el10.noarch.rpm;name=perl-XML-XPath;unpack=0"
SRC_URI += "${URI_perl-XML-XPath}"
SRC_URI[perl-XML-XPath.sha256sum] = "a9114b7b00d18589b90d40cd20f7e4d9dbce2a39fc40339be90a3cde29358f3a"
RDEPENDS:perl-XML-XPath = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-interpreter \
 perl-IO \
 perl-I18N-Langinfo \
 perl-POSIX \
 perl-open \
 perl-Encode \
 perl-overload \
 perl-XML-Parser \
 perl-parent \
 perl-XML-XPath \
 perl-Exporter \
 perl-Data-Dumper \
"

URI_perl-XML-XPath-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-XML-XPath-tests-1.48-8.el10.noarch.rpm;name=perl-XML-XPath-tests;unpack=0"
SRC_URI += "${URI_perl-XML-XPath-tests}"
SRC_URI[perl-XML-XPath-tests.sha256sum] = "0b60e8639ce92a36616c40432a83b0cca253dc0bddea13ea9424b6ab4cf86f6f"
RDEPENDS:perl-XML-XPath-tests = " \
 perl-constant \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-I18N-Langinfo \
 perl-open \
 perl-Encode \
 bash \
 perl-XML-XPath \
 perl-interpreter \
 perl-Data-Dumper \
"
