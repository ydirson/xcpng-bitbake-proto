# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gdk-pixbuf2"
PE = "0"
PV = "2.42.12"
PR = "4.el10_0"
PACKAGES = "gdk-pixbuf2 gdk-pixbuf2-devel gdk-pixbuf2-modules gdk-pixbuf2-tests"
PROVIDES = "rpm/gdk-pixbuf2 rpm/gdk-pixbuf2-devel rpm/gdk-pixbuf2-modules rpm/gdk-pixbuf2-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gdk-pixbuf2-2.42.12-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffc87e0f298659cee80abd3273e8fcd90c38d5985d0514ae5b8b9c0155535bfe"

URI_gdk-pixbuf2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gdk-pixbuf2-2.42.12-4.el10_0.x86_64_v2.rpm;name=gdk-pixbuf2;unpack=0"
SRC_URI += "${URI_gdk-pixbuf2}"
SRC_URI[gdk-pixbuf2.sha256sum] = "47e80bc11ef408764a2a8f07f1d66853d481e58e8357dab991a371a440f6650f"
RDEPENDS:gdk-pixbuf2 = " \
 libpng \
 shared-mime-info \
 bash \
 glib2 \
 glibc \
 libjpeg-turbo \
"

URI_gdk-pixbuf2-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gdk-pixbuf2-devel-2.42.12-4.el10_0.x86_64_v2.rpm;name=gdk-pixbuf2-devel;unpack=0"
SRC_URI += "${URI_gdk-pixbuf2-devel}"
SRC_URI[gdk-pixbuf2-devel.sha256sum] = "782e2e76ce4890c511a5b80f04adfec724e451be9bcc30b04ae9c4bbfecff70c"
RDEPENDS:gdk-pixbuf2-devel = " \
 libtiff-devel \
 glib2-devel \
 shared-mime-info \
 pkgconf-pkg-config \
 gdk-pixbuf2 \
 glib2 \
 libpng-devel \
 glibc \
 libjpeg-turbo-devel \
"

URI_gdk-pixbuf2-modules = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gdk-pixbuf2-modules-2.42.12-4.el10_0.x86_64_v2.rpm;name=gdk-pixbuf2-modules;unpack=0"
SRC_URI += "${URI_gdk-pixbuf2-modules}"
SRC_URI[gdk-pixbuf2-modules.sha256sum] = "b8b8e7c3f7a5b0cdb459afd4b0bc0ebe7bc0bb91db793e844c4c40982aaf6725"
RDEPENDS:gdk-pixbuf2-modules = " \
 glibc \
 libtiff \
 glib2 \
 gdk-pixbuf2 \
"

URI_gdk-pixbuf2-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gdk-pixbuf2-tests-2.42.12-4.el10_0.x86_64_v2.rpm;name=gdk-pixbuf2-tests;unpack=0"
SRC_URI += "${URI_gdk-pixbuf2-tests}"
SRC_URI[gdk-pixbuf2-tests.sha256sum] = "cf41b47ac5429783dd529fe521375729031bd7ab1ce6e392552c604197a4b648"
RDEPENDS:gdk-pixbuf2-tests = " \
 glibc \
 glib2 \
 gdk-pixbuf2 \
"
