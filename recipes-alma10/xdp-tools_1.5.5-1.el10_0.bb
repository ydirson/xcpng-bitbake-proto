# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xdp-tools"
PE = "0"
PV = "1.5.5"
PR = "1.el10_0"
PACKAGES = "libxdp xdp-tools libxdp-devel libxdp-static"
PROVIDES = "rpm/libxdp rpm/xdp-tools rpm/libxdp-devel rpm/libxdp-static"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xdp-tools-1.5.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4824270a0cfa93ea635cd7aeafb32600b19fa6dd4d8cd915ac292f91a39d8691"

URI_libxdp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libxdp-1.5.5-1.el10_0.x86_64_v2.rpm;name=libxdp;unpack=0"
SRC_URI += "${URI_libxdp}"
SRC_URI[libxdp.sha256sum] = "16dc74dbf2dd954359042137a6ba55cbf8bffd708ed1df4b8d676eaadbf3ddc9"
RDEPENDS:libxdp = " \
 glibc \
 libbpf \
"

URI_xdp-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xdp-tools-1.5.5-1.el10_0.x86_64_v2.rpm;name=xdp-tools;unpack=0"
SRC_URI += "${URI_xdp-tools}"
SRC_URI[xdp-tools.sha256sum] = "9476de1ec42dc6c3ca62ceb2c41565bb522ffd3fbbfe28154c96a14c64652115"
RDEPENDS:xdp-tools = " \
 libpcap \
 libbpf \
 bash \
 glibc \
 libxdp \
"

URI_libxdp-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libxdp-devel-1.5.5-1.el10_0.x86_64_v2.rpm;name=libxdp-devel;unpack=0"
SRC_URI += "${URI_libxdp-devel}"
SRC_URI[libxdp-devel.sha256sum] = "eb834bff460fcc507acf647edfa5a9c84f829711096d61cae2c4b93fa5a66165"
RDEPENDS:libxdp-devel = " \
 libbpf-devel \
 libxdp \
 kernel-headers \
 pkgconf-pkg-config \
"

URI_libxdp-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libxdp-static-1.5.5-1.el10_0.x86_64_v2.rpm;name=libxdp-static;unpack=0"
SRC_URI += "${URI_libxdp-static}"
SRC_URI[libxdp-static.sha256sum] = "fee057f38938cb22f3181c7d80d888aa29a2d38ad456fd58c96f313773741239"
RDEPENDS:libxdp-static = " \
 libxdp-devel \
"
