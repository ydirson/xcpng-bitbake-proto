# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-zstandard"
PE = "0"
PV = "0.22.0"
PR = "4.el10"
PACKAGES = "python3-zstandard"
PROVIDES = "rpm/python3-zstandard"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/python-zstandard-0.22.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0523d84cc2eeed9bdcab42ad62867a0bc44de698aa6984ccede7c852e55e6aa2"

URI_python3-zstandard = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-zstandard-0.22.0-4.el10.x86_64_v2.rpm;name=python3-zstandard;unpack=0"
SRC_URI += "${URI_python3-zstandard}"
SRC_URI[python3-zstandard.sha256sum] = "2d9cae6dcb4fb89ca19330ec175454c1593863ba93672760ded31a77d4e2a3ed"
RDEPENDS:python3-zstandard = " \
 glibc \
 python3 \
"
