# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "totem-pl-parser"
PE = "0"
PV = "3.26.6"
PR = "10.el10"
PACKAGES = "totem-pl-parser totem-pl-parser-devel"
PROVIDES = "rpm/totem-pl-parser rpm/totem-pl-parser-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/totem-pl-parser-3.26.6-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ae46132b9b4c7a19bf1f099de0788cf3d2fb6ad1731ca93260287447674dbc0"

URI_totem-pl-parser = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/totem-pl-parser-3.26.6-10.el10.x86_64_v2.rpm;name=totem-pl-parser;unpack=0"
SRC_URI += "${URI_totem-pl-parser}"
SRC_URI[totem-pl-parser.sha256sum] = "e0b0f954b415f6964cc4e5a1a9979020730fb4ccce685d9e3e29f74cbc0e3f5d"
RDEPENDS:totem-pl-parser = " \
 libarchive \
 libgcc \
 libgcrypt \
 libxml2 \
 glib2 \
 glibc \
 uchardet \
"

URI_totem-pl-parser-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/totem-pl-parser-devel-3.26.6-10.el10.x86_64_v2.rpm;name=totem-pl-parser-devel;unpack=0"
SRC_URI += "${URI_totem-pl-parser-devel}"
SRC_URI[totem-pl-parser-devel.sha256sum] = "07cf937d46614caf4325bb85fac011ba2d7def17e00ee5eaf2f461abce19e59e"
RDEPENDS:totem-pl-parser-devel = " \
 libxml2-devel \
 libarchive-devel \
 glib2-devel \
 pkgconf-pkg-config \
 totem-pl-parser \
"
