# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-into-dbus-python"
PE = "0"
PV = "0.8.2"
PR = "7.el10"
PACKAGES = "python3-into-dbus-python"
PROVIDES = "rpm/python3-into-dbus-python"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-into-dbus-python-0.8.2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "690f198ca8ce64a62c73c5c7300fd90f9880a71c154f8c2416792a9b2ecbc907"

URI_python3-into-dbus-python = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-into-dbus-python-0.8.2-7.el10.noarch.rpm;name=python3-into-dbus-python;unpack=0"
SRC_URI += "${URI_python3-into-dbus-python}"
SRC_URI[python3-into-dbus-python.sha256sum] = "00b6324b021810482a0ac32fe4ac5c4aaf5098465666558eabf5b70a470e90f9"
RDEPENDS:python3-into-dbus-python = " \
 python3 \
 python3-dbus \
 python3-dbus-signature-pyparsing \
"
