# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-ldap"
PE = "0"
PV = "3.4.4"
PR = "9.el10"
PACKAGES = "python3-ldap"
PROVIDES = "rpm/python3-ldap"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-ldap-3.4.4-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4570e1f04762502046b93e576e561382e5f77b9fb7ff4f2b4ffd434710dbcc8"

URI_python3-ldap = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-ldap-3.4.4-9.el10.x86_64_v2.rpm;name=python3-ldap;unpack=0"
SRC_URI += "${URI_python3-ldap}"
SRC_URI[python3-ldap.sha256sum] = "bf074980ca026578fbf40d46b2619727c81da952586ff2f1c8b3edda0b56cec3"
RDEPENDS:python3-ldap = " \
 python3 \
 python3-pyasn1 \
 python3-pyasn1-modules \
 python3-setuptools \
 bash \
 glibc \
 openldap \
"
