# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cim-schema"
PE = "0"
PV = "2.54.1"
PR = "6.el10"
PACKAGES = "cim-schema cim-schema-docs"
PROVIDES = "rpm/cim-schema rpm/cim-schema-docs"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/cim-schema-2.54.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "666f2f51f8daef4334e97df6ff375353cbf3bbfecedc171360f11cc0962c0a20"

URI_cim-schema = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cim-schema-2.54.1-6.el10.noarch.rpm;name=cim-schema;unpack=0"
SRC_URI += "${URI_cim-schema}"
SRC_URI[cim-schema.sha256sum] = "08f391d2220a4a03cbf41662aec2e7330aca8a6e54fef06e649d38fc9fba5197"
RDEPENDS:cim-schema = ""

URI_cim-schema-docs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/cim-schema-docs-2.54.1-6.el10.noarch.rpm;name=cim-schema-docs;unpack=0"
SRC_URI += "${URI_cim-schema-docs}"
SRC_URI[cim-schema-docs.sha256sum] = "d601ec12b7c56f376c9b0369a880f0b50d25f2bc3330565c5164edd1d7c7fd5a"
RDEPENDS:cim-schema-docs = ""
