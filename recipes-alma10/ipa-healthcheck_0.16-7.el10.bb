# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ipa-healthcheck"
PE = "0"
PV = "0.16"
PR = "7.el10"
PACKAGES = "ipa-healthcheck ipa-healthcheck-core"
PROVIDES = "rpm/ipa-healthcheck rpm/ipa-healthcheck-core"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ipa-healthcheck-0.16-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb3011b7ea3e44ce48f4ed8b6fd7702d186e13604c547549fdc54607ae1911ce"

URI_ipa-healthcheck = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ipa-healthcheck-0.16-7.el10.noarch.rpm;name=ipa-healthcheck;unpack=0"
SRC_URI += "${URI_ipa-healthcheck}"
SRC_URI[ipa-healthcheck.sha256sum] = "d2cb9e82a416142c777deb0e8910d3c67a0b354575ab688ef8ac6cf6ef319355"
RDEPENDS:ipa-healthcheck = " \
 python3 \
 logrotate \
 ipa-server \
 systemd \
 cronie-anacron \
 python3-lib389 \
 python3-ipalib \
 python3-ipaserver \
 bash \
 ipa-healthcheck-core \
"

URI_ipa-healthcheck-core = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ipa-healthcheck-core-0.16-7.el10.noarch.rpm;name=ipa-healthcheck-core;unpack=0"
SRC_URI += "${URI_ipa-healthcheck-core}"
SRC_URI[ipa-healthcheck-core.sha256sum] = "2e122978491bcbf27ff7fe58df2e51b43b133cbe138690fd7dd3a1dcb9029698"
RDEPENDS:ipa-healthcheck-core = " \
 python3 \
"
