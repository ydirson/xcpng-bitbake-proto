# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lua-rpm-macros"
PE = "0"
PV = "1"
PR = "15.el10"
PACKAGES = "lua-rpm-macros lua-srpm-macros"
PROVIDES = "rpm/lua-rpm-macros rpm/lua-srpm-macros"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/lua-rpm-macros-1-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3706ff7e8b0880cfaff9347f317d1d44918a1a7d084751a87be4bab25d7fd0ac"

URI_lua-rpm-macros = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lua-rpm-macros-1-15.el10.noarch.rpm;name=lua-rpm-macros;unpack=0"
SRC_URI += "${URI_lua-rpm-macros}"
SRC_URI[lua-rpm-macros.sha256sum] = "d828b280afb9ee6e2ad06b26ac7da9d8e5086b14c82a79e1d8d0407e29a87f29"
RDEPENDS:lua-rpm-macros = " \
 lua-srpm-macros \
"

URI_lua-srpm-macros = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lua-srpm-macros-1-15.el10.noarch.rpm;name=lua-srpm-macros;unpack=0"
SRC_URI += "${URI_lua-srpm-macros}"
SRC_URI[lua-srpm-macros.sha256sum] = "fabbbdf4425d90ccd25458e3b16b0f698427be88eeefaf78b6a081daf60de2bb"
RDEPENDS:lua-srpm-macros = " \
 rpm \
"
