# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-urllib-gssapi"
PE = "0"
PV = "1.0.2"
PR = "14.el10"
PACKAGES = "python3-urllib-gssapi"
PROVIDES = "rpm/python3-urllib-gssapi"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-urllib-gssapi-1.0.2-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c51e5baa85ee6803275dc4cbf6d7de371b354804fa0951f1efd5d4a4f4619a2"

URI_python3-urllib-gssapi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-urllib-gssapi-1.0.2-14.el10.noarch.rpm;name=python3-urllib-gssapi;unpack=0"
SRC_URI += "${URI_python3-urllib-gssapi}"
SRC_URI[python3-urllib-gssapi.sha256sum] = "3c06b5eac0211cfba9bcd312e6c010e4df9e6ef4cd03b570acaee6792d7d6b2b"
RDEPENDS:python3-urllib-gssapi = " \
 python3 \
 python3-gssapi \
"
