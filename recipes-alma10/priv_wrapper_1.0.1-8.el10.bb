# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "priv_wrapper"
PE = "0"
PV = "1.0.1"
PR = "8.el10"
PACKAGES = "priv_wrapper"
PROVIDES = "rpm/priv_wrapper"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/priv_wrapper-1.0.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4737677af9fc9795ecd3ec542fb2e2dec11d405bcd651c39beb0fb7d701dda1"

URI_priv_wrapper = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/priv_wrapper-1.0.1-8.el10.x86_64_v2.rpm;name=priv_wrapper;unpack=0"
SRC_URI += "${URI_priv_wrapper}"
SRC_URI[priv_wrapper.sha256sum] = "c7ceb6c9dbad9494b7c3be2bbbc3696328edc8286e46af8589a5161b945d75d2"
RDEPENDS:priv_wrapper = " \
 glibc \
 cmake-filesystem \
 pkgconf-pkg-config \
"
