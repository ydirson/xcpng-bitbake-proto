# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "exfatprogs"
PE = "0"
PV = "1.2.2"
PR = "6.el10"
PACKAGES = "exfatprogs"
PROVIDES = "rpm/exfatprogs"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/exfatprogs-1.2.2-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39cf36fa1954a2018fc751a91b0c46a49599ff4efb4186160f451a0826a3e578"

URI_exfatprogs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/exfatprogs-1.2.2-6.el10.x86_64_v2.rpm;name=exfatprogs;unpack=0"
SRC_URI += "${URI_exfatprogs}"
SRC_URI[exfatprogs.sha256sum] = "33778fee8bc70a338b3af8fb537bf90c35e222f91be4a192a5006550a9572a24"
RDEPENDS:exfatprogs = " \
 glibc \
"
