# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gcr"
PE = "0"
PV = "4.3.0"
PR = "1.el10"
PACKAGES = "gcr gcr-devel gcr-libs"
PROVIDES = "rpm/gcr rpm/gcr-devel rpm/gcr-libs"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gcr-4.3.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1426abd9f86a710af6ad426d585377bca33d3519b825d9366f2bf7c4daad90c"

URI_gcr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gcr-4.3.0-1.el10.x86_64_v2.rpm;name=gcr;unpack=0"
SRC_URI += "${URI_gcr}"
SRC_URI[gcr.sha256sum] = "05c2aa5afaeb967f3105f42ee866ab3784172e850866e61230217b6ebde2f943"
RDEPENDS:gcr = " \
 gnupg2 \
 systemd-libs \
 openssh-clients \
 pango \
 libsecret \
 bash \
 glib2 \
 glibc \
 gtk4 \
 gcr-libs \
"

URI_gcr-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gcr-devel-4.3.0-1.el10.x86_64_v2.rpm;name=gcr-devel;unpack=0"
SRC_URI += "${URI_gcr-devel}"
SRC_URI[gcr-devel.sha256sum] = "9d8c58a8e6e76f2dfc2594c5a8fab3ad33bddfb2cf6a4acf67d3430aa1dedf48"
RDEPENDS:gcr-devel = " \
 p11-kit-devel \
 glib2-devel \
 pkgconf-pkg-config \
 gcr-devel \
 gcr-libs \
"

URI_gcr-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gcr-libs-4.3.0-1.el10.x86_64_v2.rpm;name=gcr-libs;unpack=0"
SRC_URI += "${URI_gcr-libs}"
SRC_URI[gcr-libs.sha256sum] = "0f3caf7930806943b01c5a7475c5a65090555225a4175a3f59edd51567997cf8"
RDEPENDS:gcr-libs = " \
 glibc \
 gnutls \
 glib2 \
 p11-kit \
"
