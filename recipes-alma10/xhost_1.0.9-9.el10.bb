# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xhost"
PE = "0"
PV = "1.0.9"
PR = "9.el10"
PACKAGES = "xhost"
PROVIDES = "rpm/xhost"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xhost-1.0.9-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d9b7c6185382e5d5a962f5f1d60926249240a6d599f70807ecb2251a9f0507b"

URI_xhost = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xhost-1.0.9-9.el10.x86_64_v2.rpm;name=xhost;unpack=0"
SRC_URI += "${URI_xhost}"
SRC_URI[xhost.sha256sum] = "c0331c43fd421372f303723ba1e01b598cd2eb6762b654db054320d62663a678"
RDEPENDS:xhost = " \
 glibc \
 libXmu \
 libX11 \
"
