# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "alsa-tools"
PE = "0"
PV = "1.2.11"
PR = "5.el10"
PACKAGES = "alsa-tools-firmware"
PROVIDES = "rpm/alsa-tools-firmware"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/alsa-tools-1.2.11-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90c83d06fc72cb422ef51acfa0645c6eecd253a65a2e1c2c2915430f77b72d94"

URI_alsa-tools-firmware = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/alsa-tools-firmware-1.2.11-5.el10.x86_64_v2.rpm;name=alsa-tools-firmware;unpack=0"
SRC_URI += "${URI_alsa-tools-firmware}"
SRC_URI[alsa-tools-firmware.sha256sum] = "4df151e5b1c1bd0918c3e72ecf4ec865d52c53135298d3521620337b98df68bf"
RDEPENDS:alsa-tools-firmware = " \
 alsa-lib \
 systemd-udev \
 bash \
 fxload \
 glibc \
 alsa-firmware \
"
