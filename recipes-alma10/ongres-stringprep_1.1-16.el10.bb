# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ongres-stringprep"
PE = "0"
PV = "1.1"
PR = "16.el10"
PACKAGES = "ongres-stringprep ongres-stringprep-javadoc"
PROVIDES = "rpm/ongres-stringprep rpm/ongres-stringprep-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ongres-stringprep-1.1-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30d47c58db642ec12a36a060d85e0a648b4d8bdf80e29314e47ef71c37793c62"

URI_ongres-stringprep = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ongres-stringprep-1.1-16.el10.noarch.rpm;name=ongres-stringprep;unpack=0"
SRC_URI += "${URI_ongres-stringprep}"
SRC_URI[ongres-stringprep.sha256sum] = "bb67d2b90eb9d67cb1caa991d005d008fce84a144fbe421f3df870414986a8b4"
RDEPENDS:ongres-stringprep = " \
 javapackages-filesystem \
"

URI_ongres-stringprep-javadoc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ongres-stringprep-javadoc-1.1-16.el10.noarch.rpm;name=ongres-stringprep-javadoc;unpack=0"
SRC_URI += "${URI_ongres-stringprep-javadoc}"
SRC_URI[ongres-stringprep-javadoc.sha256sum] = "47bdf4a5e5dedf4d73810cfb4aff7050401212879cee64827e4a509fcf49e64d"
RDEPENDS:ongres-stringprep-javadoc = " \
 javapackages-filesystem \
"
