# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libocxl"
PE = "0"
PV = "1.2.1"
PR = "11.el10"
PACKAGES = ""
PROVIDES = ""


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libocxl-1.2.1-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0e80977f39c45b83630183f1db2389a0ce5c68684a594362d2dbf818ff2a0ff"
