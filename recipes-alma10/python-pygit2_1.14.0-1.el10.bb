# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-pygit2"
PE = "0"
PV = "1.14.0"
PR = "1.el10"
PACKAGES = "python-pygit2-doc python3-pygit2"
PROVIDES = "rpm/python-pygit2-doc rpm/python3-pygit2"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/python-pygit2-1.14.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a3acffab9a24638235d0136aaf4950973c6fee60a1e8a0a3351f6f8f57feecf"

URI_python-pygit2-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python-pygit2-doc-1.14.0-1.el10.noarch.rpm;name=python-pygit2-doc;unpack=0"
SRC_URI += "${URI_python-pygit2-doc}"
SRC_URI[python-pygit2-doc.sha256sum] = "78414967c5a1f37f5d5249331722f79666d6700b8b9f8568fa0e5fdfc6990690"
RDEPENDS:python-pygit2-doc = ""

URI_python3-pygit2 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-pygit2-1.14.0-1.el10.x86_64_v2.rpm;name=python3-pygit2;unpack=0"
SRC_URI += "${URI_python3-pygit2}"
SRC_URI[python3-pygit2.sha256sum] = "a51a8d86a0df8973eb4c79e1cdc9b5d8359ce2112a3f33cc7c1ef4a006fdc720"
RDEPENDS:python3-pygit2 = " \
 python3 \
 python3-cffi \
 libgit2 \
 python3-setuptools \
 glibc \
"
