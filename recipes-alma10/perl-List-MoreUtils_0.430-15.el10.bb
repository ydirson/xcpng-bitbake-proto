# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-List-MoreUtils"
PE = "0"
PV = "0.430"
PR = "15.el10"
PACKAGES = "perl-List-MoreUtils perl-List-MoreUtils-tests"
PROVIDES = "rpm/perl-List-MoreUtils rpm/perl-List-MoreUtils-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-List-MoreUtils-0.430-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1dabdb15091ad691bdef67fc7f5433e394f0fd53e8eae746a43ec5f23f720054"

URI_perl-List-MoreUtils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-List-MoreUtils-0.430-15.el10.noarch.rpm;name=perl-List-MoreUtils;unpack=0"
SRC_URI += "${URI_perl-List-MoreUtils}"
SRC_URI[perl-List-MoreUtils.sha256sum] = "cd1ca19e99d5d12b625ab67a30b88f590ebc7fe518f8edc579154c9307e07696"
RDEPENDS:perl-List-MoreUtils = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-List-MoreUtils-XS \
 perl-parent \
 perl-List-MoreUtils \
 perl-Exporter-Tiny \
"

URI_perl-List-MoreUtils-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-List-MoreUtils-tests-0.430-15.el10.noarch.rpm;name=perl-List-MoreUtils-tests;unpack=0"
SRC_URI += "${URI_perl-List-MoreUtils-tests}"
SRC_URI[perl-List-MoreUtils-tests.sha256sum] = "74d6d29dff9b2b91f43ddfa61fbea481e96bc224a6fd9b8bc1c18dea9590f6b0"
RDEPENDS:perl-List-MoreUtils-tests = " \
 perl-List-MoreUtils \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-Scalar-List-Utils \
 perl-Math-Complex \
 perl-POSIX \
 perl-overload \
 bash \
 perl-base \
 perl-Tie \
 perl-interpreter \
 perl-Exporter \
 perl-lib \
"
