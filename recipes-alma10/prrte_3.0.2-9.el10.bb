# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "prrte"
PE = "0"
PV = "3.0.2"
PR = "9.el10"
PACKAGES = "prrte prrte-libs prrte-devel"
PROVIDES = "rpm/prrte rpm/prrte-libs rpm/prrte-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/prrte-3.0.2-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5f8eaba3ce7b33534feaf61001c02fa208309768da03ba6f6fd28367b20282d"

URI_prrte = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/prrte-3.0.2-9.el10.x86_64_v2.rpm;name=prrte;unpack=0"
SRC_URI += "${URI_prrte}"
SRC_URI[prrte.sha256sum] = "d0a78d47b17de5cbde363b11db1028f2e6cd4432028c5b0111d3dc027414f3a5"
RDEPENDS:prrte = " \
 prrte-libs \
 libevent \
 hwloc-libs \
 pmix \
 glibc \
"

URI_prrte-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/prrte-libs-3.0.2-9.el10.x86_64_v2.rpm;name=prrte-libs;unpack=0"
SRC_URI += "${URI_prrte-libs}"
SRC_URI[prrte-libs.sha256sum] = "2fdf6eb1f7ff139bc4d1786e86c687192a8bde540868b798fa724e85a032cb24"
RDEPENDS:prrte-libs = " \
 libevent \
 hwloc-libs \
 torque-libs \
 glibc \
 pmix \
"

URI_prrte-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/prrte-devel-3.0.2-9.el10.x86_64_v2.rpm;name=prrte-devel;unpack=0"
SRC_URI += "${URI_prrte-devel}"
SRC_URI[prrte-devel.sha256sum] = "1ac62a1168fbbb98464a86d84a9a87db095276873699615e7afb4d2c5e8d92df"
RDEPENDS:prrte-devel = " \
 prrte-libs \
"
