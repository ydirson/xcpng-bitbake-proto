# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-pytest-lazy-fixture"
PE = "0"
PV = "0.6.3"
PR = "17.el10"
PACKAGES = "python3-pytest-lazy-fixture"
PROVIDES = "rpm/python3-pytest-lazy-fixture"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/python-pytest-lazy-fixture-0.6.3-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6cda7ad4ee7423e6e9fdc80cc074c27b844b99e0d839fb290e9e4e5ccd865e1"

URI_python3-pytest-lazy-fixture = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-pytest-lazy-fixture-0.6.3-17.el10.noarch.rpm;name=python3-pytest-lazy-fixture;unpack=0"
SRC_URI += "${URI_python3-pytest-lazy-fixture}"
SRC_URI[python3-pytest-lazy-fixture.sha256sum] = "b1e1192d85958b585f2ed2a2b0afcf9cc2cdfbeda8c56892f0e697e5bebbca3a"
RDEPENDS:python3-pytest-lazy-fixture = " \
 python3 \
 python3-pytest \
"
