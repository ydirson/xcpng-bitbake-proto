# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rpm"
PE = "0"
PV = "4.19.1.1"
PR = "12.el10.alma.1"
PACKAGES = "python3-rpm rpm rpm-build-libs rpm-libs rpm-plugin-audit rpm-plugin-selinux rpm-sign rpm-sign-libs rpm-apidocs rpm-build rpm-cron rpm-devel rpm-plugin-fapolicyd rpm-plugin-ima rpm-plugin-syslog rpm-plugin-systemd-inhibit rpm-plugin-dbus-announce rpm-plugin-prioreset"
PROVIDES = "rpm/python3-rpm rpm/rpm rpm/rpm-build-libs rpm/rpm-libs rpm/rpm-plugin-audit rpm/rpm-plugin-selinux rpm/rpm-sign rpm/rpm-sign-libs rpm/rpm-apidocs rpm/rpm-build rpm/rpm-cron rpm/rpm-devel rpm/rpm-plugin-fapolicyd rpm/rpm-plugin-ima rpm/rpm-plugin-syslog rpm/rpm-plugin-systemd-inhibit rpm/rpm-plugin-dbus-announce rpm/rpm-plugin-prioreset"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/rpm-4.19.1.1-12.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b134c69223b95c73be8ecb5501fb13cf360e5599fb29011053f1bf6d71fadae8"

URI_python3-rpm = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-rpm-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=python3-rpm;unpack=0"
SRC_URI += "${URI_python3-rpm}"
SRC_URI[python3-rpm.sha256sum] = "d97cd39037ed805780be77a8891181357afd4021c4cc63c30dc3b5e2e04b134c"
RDEPENDS:python3-rpm = " \
 python3 \
 rpm-sign-libs \
 glibc \
 rpm-build-libs \
 rpm-libs \
"

URI_rpm = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/rpm-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=rpm;unpack=0"
SRC_URI += "${URI_rpm}"
SRC_URI[rpm.sha256sum] = "aa29f473abc55deb4c0bb500dd4c5c2c8a85c12d52a8a56449da5f862d14514c"
RDEPENDS:rpm = " \
 glibc \
 libarchive \
 curl \
 rpm-libs \
 bash \
 popt \
 sed \
 coreutils \
 findutils \
"

URI_rpm-build-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/rpm-build-libs-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=rpm-build-libs;unpack=0"
SRC_URI += "${URI_rpm-build-libs}"
SRC_URI[rpm-build-libs.sha256sum] = "8dfbe5174c3d31e380c1c17168f1b130a3d7b6238bf43d83c3a9dc1cc211ae0f"
RDEPENDS:rpm-build-libs = " \
 lua-libs \
 libgcc \
 elfutils-libelf \
 libcap \
 elfutils-libs \
 libgomp \
 popt \
 glibc \
 file-libs \
 rpm-libs \
"

URI_rpm-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/rpm-libs-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=rpm-libs;unpack=0"
SRC_URI += "${URI_rpm-libs}"
SRC_URI[rpm-libs.sha256sum] = "47352996dd1ea501c695f855892ff23a7fa3e1dfcf9aa4258f916ba4e69cdb19"
RDEPENDS:rpm-libs = " \
 rpm-sequoia \
 libacl \
 zlib-ng-compat \
 bzip2-libs \
 lua-libs \
 libcap \
 libzstd \
 sqlite-libs \
 popt \
 glibc \
 rpm \
 xz-libs \
"

URI_rpm-plugin-audit = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/rpm-plugin-audit-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=rpm-plugin-audit;unpack=0"
SRC_URI += "${URI_rpm-plugin-audit}"
SRC_URI[rpm-plugin-audit.sha256sum] = "ac737963c3a06737cfac9f67e97e86f8c78d3ea1c844c204812ddf47af2bc802"
RDEPENDS:rpm-plugin-audit = " \
 glibc \
 audit-libs \
 rpm-libs \
"

URI_rpm-plugin-selinux = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/rpm-plugin-selinux-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=rpm-plugin-selinux;unpack=0"
SRC_URI += "${URI_rpm-plugin-selinux}"
SRC_URI[rpm-plugin-selinux.sha256sum] = "a9d59bb4fe5eeec649bc88b91e4e1d154fdfab69ce9867276e7a226f6e55b1e5"
RDEPENDS:rpm-plugin-selinux = " \
 glibc \
 libselinux \
 rpm-libs \
 selinux-policy \
"

URI_rpm-sign = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/rpm-sign-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=rpm-sign;unpack=0"
SRC_URI += "${URI_rpm-sign}"
SRC_URI[rpm-sign.sha256sum] = "b4979ef95901d0737703badea48f15d60430a1210a7783d61b0d248cd19b6597"
RDEPENDS:rpm-sign = " \
 glibc \
 rpm-libs \
 rpm-sign-libs \
 popt \
"

URI_rpm-sign-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/rpm-sign-libs-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=rpm-sign-libs;unpack=0"
SRC_URI += "${URI_rpm-sign-libs}"
SRC_URI[rpm-sign-libs.sha256sum] = "7d1eabe7ae2d2118f952584b5b03163bbd2e693a411a49f8c83d1596b802be9f"
RDEPENDS:rpm-sign-libs = " \
 glibc \
 rpm-libs \
 ima-evm-utils \
 popt \
"

URI_rpm-apidocs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rpm-apidocs-4.19.1.1-12.el10.alma.1.noarch.rpm;name=rpm-apidocs;unpack=0"
SRC_URI += "${URI_rpm-apidocs}"
SRC_URI[rpm-apidocs.sha256sum] = "eb45c998d532ef6bddeb40760613f14b5d872858b1b4d125e676144af3f878a8"
RDEPENDS:rpm-apidocs = ""

URI_rpm-build = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rpm-build-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=rpm-build;unpack=0"
SRC_URI += "${URI_rpm-build}"
SRC_URI[rpm-build.sha256sum] = "2730b293a82441f5255f45b46e69c7632abba5bbdfb4205d8032e85da15bd5d7"
RDEPENDS:rpm-build = " \
 tar \
 patch \
 unzip \
 diffutils \
 rpm-build-libs \
 sed \
 debugedit \
 xz \
 zstd \
 redhat-rpm-config \
 elfutils \
 gdb-headless \
 grep \
 elfutils-libelf \
 bash \
 binutils \
 file \
 findutils \
 bzip2 \
 gzip \
 gawk \
 readline \
 pkgconf-pkg-config \
 popt \
 glibc \
 rpm \
 cpio \
 rpm-libs \
"

URI_rpm-cron = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rpm-cron-4.19.1.1-12.el10.alma.1.noarch.rpm;name=rpm-cron;unpack=0"
SRC_URI += "${URI_rpm-cron}"
SRC_URI[rpm-cron.sha256sum] = "a8754978a4eacb3c99574481f63fc318fbc61d84cfc64ee72dd7ac49e1951b6d"
RDEPENDS:rpm-cron = " \
 logrotate \
 crontabs \
 rpm \
 bash \
"

URI_rpm-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rpm-devel-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=rpm-devel;unpack=0"
SRC_URI += "${URI_rpm-devel}"
SRC_URI[rpm-devel.sha256sum] = "a0aea9cc198fb629efbc6fa95167368f5f3b39e4a944498650a9cf8062e47716"
RDEPENDS:rpm-devel = " \
 rpm-sign-libs \
 cmake-filesystem \
 pkgconf-pkg-config \
 popt-devel \
 popt \
 glibc \
 rpm \
 rpm-build-libs \
 rpm-libs \
"

URI_rpm-plugin-fapolicyd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rpm-plugin-fapolicyd-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=rpm-plugin-fapolicyd;unpack=0"
SRC_URI += "${URI_rpm-plugin-fapolicyd}"
SRC_URI[rpm-plugin-fapolicyd.sha256sum] = "93529ee66ac05e59d32230b41563773b33295208c3aea8de0b1eceef5df64edd"
RDEPENDS:rpm-plugin-fapolicyd = " \
 glibc \
 rpm-libs \
"

URI_rpm-plugin-ima = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rpm-plugin-ima-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=rpm-plugin-ima;unpack=0"
SRC_URI += "${URI_rpm-plugin-ima}"
SRC_URI[rpm-plugin-ima.sha256sum] = "7066151abe94938b354d4285bbd256ed23dc11ecd96fa4b5f7746566090781db"
RDEPENDS:rpm-plugin-ima = " \
 glibc \
 rpm-libs \
"

URI_rpm-plugin-syslog = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rpm-plugin-syslog-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=rpm-plugin-syslog;unpack=0"
SRC_URI += "${URI_rpm-plugin-syslog}"
SRC_URI[rpm-plugin-syslog.sha256sum] = "e4f2cbe9961c29bb8fda9e804c2390c44f2568650f685a373706d984de13d6c9"
RDEPENDS:rpm-plugin-syslog = " \
 glibc \
 rpm-libs \
"

URI_rpm-plugin-systemd-inhibit = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rpm-plugin-systemd-inhibit-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=rpm-plugin-systemd-inhibit;unpack=0"
SRC_URI += "${URI_rpm-plugin-systemd-inhibit}"
SRC_URI[rpm-plugin-systemd-inhibit.sha256sum] = "9443641f6d556db92c0e99cba11470711e36eb0aa841e7f81035df93c349908b"
RDEPENDS:rpm-plugin-systemd-inhibit = " \
 glibc \
 rpm-libs \
 dbus-libs \
"

URI_rpm-plugin-dbus-announce = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rpm-plugin-dbus-announce-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=rpm-plugin-dbus-announce;unpack=0"
SRC_URI += "${URI_rpm-plugin-dbus-announce}"
SRC_URI[rpm-plugin-dbus-announce.sha256sum] = "5aca291f72c4b900ec7fdcc74ce2a1ab376dd8462c39681e96943e5e019a50c3"
RDEPENDS:rpm-plugin-dbus-announce = " \
 glibc \
 rpm-libs \
 dbus-libs \
"

URI_rpm-plugin-prioreset = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rpm-plugin-prioreset-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=rpm-plugin-prioreset;unpack=0"
SRC_URI += "${URI_rpm-plugin-prioreset}"
SRC_URI[rpm-plugin-prioreset.sha256sum] = "de6474a10817a28d24d222c32aa66ef975595441872183ee27d0f00520da7294"
RDEPENDS:rpm-plugin-prioreset = " \
 glibc \
 rpm-libs \
"
