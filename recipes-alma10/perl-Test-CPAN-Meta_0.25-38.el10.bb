# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Test-CPAN-Meta"
PE = "0"
PV = "0.25"
PR = "38.el10"
PACKAGES = "perl-Test-CPAN-Meta perl-Test-CPAN-Meta-tests"
PROVIDES = "rpm/perl-Test-CPAN-Meta rpm/perl-Test-CPAN-Meta-tests"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-Test-CPAN-Meta-0.25-38.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32ecd5549d4ee03fb9808e18a5bfda38c8126606b036b791ea22f16ab659f5fd"

URI_perl-Test-CPAN-Meta = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Test-CPAN-Meta-0.25-38.el10.noarch.rpm;name=perl-Test-CPAN-Meta;unpack=0"
SRC_URI += "${URI_perl-Test-CPAN-Meta}"
SRC_URI[perl-Test-CPAN-Meta.sha256sum] = "071e61ebf632f18f2565bda41dd9cec7393dea6bb664345cd63694dfd99c48d3"
RDEPENDS:perl-Test-CPAN-Meta = " \
 perl-CPAN-Meta \
 perl-libs \
 perl-Test-Simple \
 perl-vars \
 perl-Test-CPAN-Meta \
"

URI_perl-Test-CPAN-Meta-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Test-CPAN-Meta-tests-0.25-38.el10.noarch.rpm;name=perl-Test-CPAN-Meta-tests;unpack=0"
SRC_URI += "${URI_perl-Test-CPAN-Meta-tests}"
SRC_URI[perl-Test-CPAN-Meta-tests.sha256sum] = "edd7cc8e3cd75dd4253ead71fd3f389529faf0000de6df4060a481657e272185"
RDEPENDS:perl-Test-CPAN-Meta-tests = " \
 perl-CPAN-Meta \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-IO \
 perl-Test-CPAN-Meta \
 bash \
 perl-interpreter \
"
