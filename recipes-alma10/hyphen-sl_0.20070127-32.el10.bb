# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-sl"
PE = "0"
PV = "0.20070127"
PR = "32.el10"
PACKAGES = "hyphen-sl"
PROVIDES = "rpm/hyphen-sl"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-sl-0.20070127-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48cee381dbedac2d7efcf2c616317914b7d633ad290a4109d1f2e584f166b6fb"

URI_hyphen-sl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-sl-0.20070127-32.el10.noarch.rpm;name=hyphen-sl;unpack=0"
SRC_URI += "${URI_hyphen-sl}"
SRC_URI[hyphen-sl.sha256sum] = "14c8c358728ad1b5b4354eb2f70941c80947e775dee330a0645c8e0e6fdb48c6"
RDEPENDS:hyphen-sl = " \
 hyphen \
"
