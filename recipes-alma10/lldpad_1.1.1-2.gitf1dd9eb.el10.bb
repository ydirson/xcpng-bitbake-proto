# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lldpad"
PE = "0"
PV = "1.1.1"
PR = "2.gitf1dd9eb.el10"
PACKAGES = "lldpad lldpad-devel"
PROVIDES = "rpm/lldpad rpm/lldpad-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/lldpad-1.1.1-2.gitf1dd9eb.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "887ec057c1d2b4a236f62fe0bf8348c4c709001749b73dab3bb79d6e89dd96fb"

URI_lldpad = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/lldpad-1.1.1-2.gitf1dd9eb.el10.x86_64_v2.rpm;name=lldpad;unpack=0"
SRC_URI += "${URI_lldpad}"
SRC_URI[lldpad.sha256sum] = "727384252d07a092d8e41aba78cbdace03cfb606588b664cd4d57c7508d03cf2"
RDEPENDS:lldpad = " \
 systemd \
 libnl3 \
 readline \
 bash \
 libconfig \
 glibc \
"

URI_lldpad-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/lldpad-devel-1.1.1-2.gitf1dd9eb.el10.x86_64_v2.rpm;name=lldpad-devel;unpack=0"
SRC_URI += "${URI_lldpad-devel}"
SRC_URI[lldpad-devel.sha256sum] = "143c9ae26b202a866cb26a1eda110feb969c4d1245cf9aead002f117d7ad7877"
RDEPENDS:lldpad-devel = " \
 lldpad \
 pkgconf-pkg-config \
"
