# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "systemtap"
PE = "0"
PV = "5.2"
PR = "2.el10"
PACKAGES = "systemtap systemtap-client systemtap-devel systemtap-exporter systemtap-initscript systemtap-runtime systemtap-runtime-java systemtap-runtime-python3 systemtap-runtime-virtguest systemtap-runtime-virthost systemtap-sdt-devel systemtap-sdt-dtrace systemtap-server systemtap-jupyter systemtap-testsuite"
PROVIDES = "rpm/systemtap rpm/systemtap-client rpm/systemtap-devel rpm/systemtap-exporter rpm/systemtap-initscript rpm/systemtap-runtime rpm/systemtap-runtime-java rpm/systemtap-runtime-python3 rpm/systemtap-runtime-virtguest rpm/systemtap-runtime-virthost rpm/systemtap-sdt-devel rpm/systemtap-sdt-dtrace rpm/systemtap-server rpm/systemtap-jupyter rpm/systemtap-testsuite"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/systemtap-5.2-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f1ff6d42b2be08442c37967ee4253ab100550426154ec7d5ba95b5d62f4c4fd"

URI_systemtap = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/systemtap-5.2-2.el10.x86_64_v2.rpm;name=systemtap;unpack=0"
SRC_URI += "${URI_systemtap}"
SRC_URI[systemtap.sha256sum] = "0421411e96e86bed61a5465ae1e2511c48065042308453b12c16de88391463fe"
RDEPENDS:systemtap = " \
 bash \
 systemtap-client \
 systemtap-devel \
"

URI_systemtap-client = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/systemtap-client-5.2-2.el10.x86_64_v2.rpm;name=systemtap-client;unpack=0"
SRC_URI += "${URI_systemtap-client}"
SRC_URI[systemtap-client.sha256sum] = "afc953d371ad1f067b08da274aeb88a6808dea6747120c6cb498fd465293571e"
RDEPENDS:systemtap-client = " \
 mokutil \
 nss \
 dyninst \
 systemtap-runtime \
 unzip \
 json-c \
 libstdc++ \
 sed \
 zip \
 openssh-clients \
 elfutils-debuginfod-client \
 libgcc \
 grep \
 elfutils-libelf \
 elfutils-libs \
 sqlite-libs \
 avahi-libs \
 bash \
 boost-system \
 readline \
 glibc \
 coreutils \
 perl-interpreter \
 rpm-libs \
 nspr \
"

URI_systemtap-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/systemtap-devel-5.2-2.el10.x86_64_v2.rpm;name=systemtap-devel;unpack=0"
SRC_URI += "${URI_systemtap-devel}"
SRC_URI[systemtap-devel.sha256sum] = "190a0a25444166f4d5cef154ac92ff00c5324c10d6aa0f6264ff5fd721ac7f21"
RDEPENDS:systemtap-devel = " \
 python3 \
 nss \
 dyninst \
 elfutils-devel \
 json-c \
 libstdc++ \
 gcc \
 elfutils-debuginfod-client \
 libgcc \
 elfutils-libelf \
 elfutils-libs \
 sqlite-libs \
 avahi-libs \
 bash \
 boost-system \
 readline \
 make \
 glibc \
 rpm-libs \
 nspr \
"

URI_systemtap-exporter = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/systemtap-exporter-5.2-2.el10.x86_64_v2.rpm;name=systemtap-exporter;unpack=0"
SRC_URI += "${URI_systemtap-exporter}"
SRC_URI[systemtap-exporter.sha256sum] = "127bd38dc68d95157c9ef0dbad2d2bb942bc446e7b149e7961c6a5b9336823ab"
RDEPENDS:systemtap-exporter = " \
 python3 \
 systemtap-runtime \
 bash \
"

URI_systemtap-initscript = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/systemtap-initscript-5.2-2.el10.x86_64_v2.rpm;name=systemtap-initscript;unpack=0"
SRC_URI += "${URI_systemtap-initscript}"
SRC_URI[systemtap-initscript.sha256sum] = "0c380e8eea950bcd9deb0d1d4ee3899455bd5ce4808978d28b10bde397b4f1a6"
RDEPENDS:systemtap-initscript = " \
 systemd \
 bash \
 systemtap \
"

URI_systemtap-runtime = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/systemtap-runtime-5.2-2.el10.x86_64_v2.rpm;name=systemtap-runtime;unpack=0"
SRC_URI += "${URI_systemtap-runtime}"
SRC_URI[systemtap-runtime.sha256sum] = "723fdf14d49520b10ff119aad9fe314fb9f7b6a7804310082765fb5da53ba9c1"
RDEPENDS:systemtap-runtime = " \
 shadow-utils \
 nss \
 elfutils-debuginfod-client \
 libgcc \
 json-c \
 elfutils-libelf \
 dyninst \
 libstdc++ \
 bash \
 ncurses-libs \
 glibc \
 libselinux \
 boost-system \
 nspr \
"

URI_systemtap-runtime-java = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/systemtap-runtime-java-5.2-2.el10.x86_64_v2.rpm;name=systemtap-runtime-java;unpack=0"
SRC_URI += "${URI_systemtap-runtime-java}"
SRC_URI[systemtap-runtime-java.sha256sum] = "2d2376e4831e0d669863cb6dd8814a9950eacdaf0c79a6dac71bd722bd4d1d34"
RDEPENDS:systemtap-runtime-java = " \
 iproute \
 byteman \
 systemtap-runtime \
 java-21-openjdk-devel \
 bash \
 glibc \
"

URI_systemtap-runtime-python3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/systemtap-runtime-python3-5.2-2.el10.x86_64_v2.rpm;name=systemtap-runtime-python3;unpack=0"
SRC_URI += "${URI_systemtap-runtime-python3}"
SRC_URI[systemtap-runtime-python3.sha256sum] = "40d9f3bdbdae1702cf2ccf8aeba31682b1ab3ae1ecbfb91c946617a8709355ec"
RDEPENDS:systemtap-runtime-python3 = " \
 glibc \
 systemtap-runtime \
 python3 \
"

URI_systemtap-runtime-virtguest = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/systemtap-runtime-virtguest-5.2-2.el10.x86_64_v2.rpm;name=systemtap-runtime-virtguest;unpack=0"
SRC_URI += "${URI_systemtap-runtime-virtguest}"
SRC_URI[systemtap-runtime-virtguest.sha256sum] = "2a3048b1964a1d1e98e82c3ebc5ef0bc50ed7b557f940be01c884915954c0494"
RDEPENDS:systemtap-runtime-virtguest = " \
 grep \
 systemtap-runtime \
 bash \
 coreutils \
 findutils \
"

URI_systemtap-runtime-virthost = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/systemtap-runtime-virthost-5.2-2.el10.x86_64_v2.rpm;name=systemtap-runtime-virthost;unpack=0"
SRC_URI += "${URI_systemtap-runtime-virthost}"
SRC_URI[systemtap-runtime-virthost.sha256sum] = "171deb6634171cbd340f6b23f8e2e9e20a6b1faf7e7b2a7bed418c1eca9c197e"
RDEPENDS:systemtap-runtime-virthost = " \
 glibc \
 libvirt-libs \
 libxml2 \
"

URI_systemtap-sdt-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/systemtap-sdt-devel-5.2-2.el10.x86_64_v2.rpm;name=systemtap-sdt-devel;unpack=0"
SRC_URI += "${URI_systemtap-sdt-devel}"
SRC_URI[systemtap-sdt-devel.sha256sum] = "0061e0e83f0c907cf8b6b58249e364239e41342455d05793a70da8d7dd94d608"
RDEPENDS:systemtap-sdt-devel = " \
 python3 \
"

URI_systemtap-sdt-dtrace = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/systemtap-sdt-dtrace-5.2-2.el10.x86_64_v2.rpm;name=systemtap-sdt-dtrace;unpack=0"
SRC_URI += "${URI_systemtap-sdt-dtrace}"
SRC_URI[systemtap-sdt-dtrace.sha256sum] = "f1ab58cb45b2a9a793bad90d4ff853f768939c25760b9d488d04476e0a11f1c4"
RDEPENDS:systemtap-sdt-dtrace = " \
 python3 \
 python3-pyparsing \
"

URI_systemtap-server = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/systemtap-server-5.2-2.el10.x86_64_v2.rpm;name=systemtap-server;unpack=0"
SRC_URI += "${URI_systemtap-server}"
SRC_URI[systemtap-server.sha256sum] = "fae8700a0b9c739baaba3b1f21f1afcbe1583beff95e49c5bd9f764c594f904a"
RDEPENDS:systemtap-server = " \
 zip \
 shadow-utils \
 systemd \
 nss \
 unzip \
 openssl \
 libgcc \
 systemtap-devel \
 avahi-libs \
 libstdc++ \
 bash \
 glibc \
 coreutils \
 nspr \
"

URI_systemtap-jupyter = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/systemtap-jupyter-5.2-2.el10.x86_64_v2.rpm;name=systemtap-jupyter;unpack=0"
SRC_URI += "${URI_systemtap-jupyter}"
SRC_URI[systemtap-jupyter.sha256sum] = "e4c19fa0685857fbcf5bd83d54e01878102881fe3a4f99aaa44e28fc0e14e7db"
RDEPENDS:systemtap-jupyter = " \
 bash \
 systemtap \
"

URI_systemtap-testsuite = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/systemtap-testsuite-5.2-2.el10.x86_64_v2.rpm;name=systemtap-testsuite;unpack=0"
SRC_URI += "${URI_systemtap-testsuite}"
SRC_URI[systemtap-testsuite.sha256sum] = "702c77b6df39f7063ea428abc538c72d8f787fe13909c17a01d5cb25c3d2f13c"
RDEPENDS:systemtap-testsuite = " \
 perf \
 glibc-devel \
 crash \
 systemtap \
 systemtap-client \
 tcl \
 systemtap-runtime-java \
 systemtap-runtime-python3 \
 systemtap-sdt-devel \
 systemtap-server \
 elfutils-debuginfod \
 tk \
 which \
 gcc \
 gcc-c++ \
 elfutils \
 grep \
 avahi \
 bash \
 coreutils \
 nmap-ncat \
 wget \
 gawk \
 make \
 strace \
 dejagnu \
 perl-interpreter \
"
