# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Capture-Tiny"
PE = "0"
PV = "0.48"
PR = "23.el10"
PACKAGES = "perl-Capture-Tiny perl-Capture-Tiny-tests"
PROVIDES = "rpm/perl-Capture-Tiny rpm/perl-Capture-Tiny-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Capture-Tiny-0.48-23.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ff57b9b10a913a4624351b7eed75c5c74d570ed93271e0843399736428fa309"

URI_perl-Capture-Tiny = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Capture-Tiny-0.48-23.el10.noarch.rpm;name=perl-Capture-Tiny;unpack=0"
SRC_URI += "${URI_perl-Capture-Tiny}"
SRC_URI[perl-Capture-Tiny.sha256sum] = "ab4c3a78c468a19f14ae22aeeee3e9c44e214e145ab5b4ef0d35e8438f8585d2"
RDEPENDS:perl-Capture-Tiny = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-IO \
 perl-PathTools \
 perl-Exporter \
 perl-File-Temp \
"

URI_perl-Capture-Tiny-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Capture-Tiny-tests-0.48-23.el10.noarch.rpm;name=perl-Capture-Tiny-tests;unpack=0"
SRC_URI += "${URI_perl-Capture-Tiny-tests}"
SRC_URI[perl-Capture-Tiny-tests.sha256sum] = "8e94f91d0586d23a1204cc393526d14095ec6e7cf2b325bf527486ffa7bcebce"
RDEPENDS:perl-Capture-Tiny-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Carp \
 perl-ExtUtils-MakeMaker \
 perl-IO \
 perl-Test-Simple \
 perl-Capture-Tiny \
 perl-File-Temp \
 perl-PathTools \
 bash \
 perl-interpreter \
 perl-Exporter \
 perl-lib \
"
