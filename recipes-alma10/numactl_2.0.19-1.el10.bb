# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "numactl"
PE = "0"
PV = "2.0.19"
PR = "1.el10"
PACKAGES = "numactl numactl-libs numactl-devel"
PROVIDES = "rpm/numactl rpm/numactl-libs rpm/numactl-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/numactl-2.0.19-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6334c00fe8b580ae36825ddc9fcb3bb3d116d5e08d02d9713f5a45751f7da159"

URI_numactl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/numactl-2.0.19-1.el10.x86_64_v2.rpm;name=numactl;unpack=0"
SRC_URI += "${URI_numactl}"
SRC_URI[numactl.sha256sum] = "2617a54bdba758062f3c061320692194fbbe8f6536b8e8ee47c87ed28cb458e3"
RDEPENDS:numactl = " \
 glibc \
 numactl-libs \
"

URI_numactl-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/numactl-libs-2.0.19-1.el10.x86_64_v2.rpm;name=numactl-libs;unpack=0"
SRC_URI += "${URI_numactl-libs}"
SRC_URI[numactl-libs.sha256sum] = "5154fde3174f422ead162482d0de3e05ceca4628fe3ecdd345f95c2c64a7f2d5"
RDEPENDS:numactl-libs = " \
 glibc \
"

URI_numactl-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/numactl-devel-2.0.19-1.el10.x86_64_v2.rpm;name=numactl-devel;unpack=0"
SRC_URI += "${URI_numactl-devel}"
SRC_URI[numactl-devel.sha256sum] = "49e42fa1aa114de8da64c55c745467e2e923717578130a0ab18ef9933ae73d18"
RDEPENDS:numactl-devel = " \
 pkgconf-pkg-config \
 numactl-libs \
"
