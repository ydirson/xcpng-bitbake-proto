# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dialog"
PE = "0"
PV = "1.3"
PR = "52.20240101.el10"
PACKAGES = "dialog dialog-devel"
PROVIDES = "rpm/dialog rpm/dialog-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/dialog-1.3-52.20240101.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5189e27db2d730e78bc346428e6c3aae9f23705c5b1ba080b863552c1e36f072"

URI_dialog = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dialog-1.3-52.20240101.el10.x86_64_v2.rpm;name=dialog;unpack=0"
SRC_URI += "${URI_dialog}"
SRC_URI[dialog.sha256sum] = "1ae590648d7490deb80003a7da3d8b4cec23591970fac305685bfc67807fbf61"
RDEPENDS:dialog = " \
 glibc \
 ncurses-libs \
"

URI_dialog-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/dialog-devel-1.3-52.20240101.el10.x86_64_v2.rpm;name=dialog-devel;unpack=0"
SRC_URI += "${URI_dialog-devel}"
SRC_URI[dialog-devel.sha256sum] = "5745dbbda01baf447e602d1c709af4809cbd0e465a2461a768916e9d7b0fff3f"
RDEPENDS:dialog-devel = " \
 ncurses-devel \
 dialog \
 bash \
 pkgconf-pkg-config \
"
