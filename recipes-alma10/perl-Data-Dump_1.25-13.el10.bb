# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Data-Dump"
PE = "0"
PV = "1.25"
PR = "13.el10"
PACKAGES = "perl-Data-Dump perl-Data-Dump-tests"
PROVIDES = "rpm/perl-Data-Dump rpm/perl-Data-Dump-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Data-Dump-1.25-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85e0faae849c8c9f5bb23830af34c4a85c2fb1465624fb6065cde4df62105eda"

URI_perl-Data-Dump = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Data-Dump-1.25-13.el10.noarch.rpm;name=perl-Data-Dump;unpack=0"
SRC_URI += "${URI_perl-Data-Dump}"
SRC_URI[perl-Data-Dump.sha256sum] = "193b7b11e3ab919d14f30e7ab8f35b28c45571badc57e4f197ff86a5525f3a99"
RDEPENDS:perl-Data-Dump = " \
 perl-subs \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-overload \
 perl-Term-ANSIColor \
 perl-Exporter \
 perl-Data-Dump \
 perl-base \
"

URI_perl-Data-Dump-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Data-Dump-tests-1.25-13.el10.noarch.rpm;name=perl-Data-Dump-tests;unpack=0"
SRC_URI += "${URI_perl-Data-Dump-tests}"
SRC_URI[perl-Data-Dump-tests.sha256sum] = "0d2c5faef2451af9e94adb36b2cf7c5786912649c103c81661ef4fa1baf6a1b0"
RDEPENDS:perl-Data-Dump-tests = " \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-vars \
 perl-IO \
 perl-Symbol \
 bash \
 perl-interpreter \
 perl-Data-Dump \
"
