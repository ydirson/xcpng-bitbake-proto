# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Test-Output"
PE = "0"
PV = "1.03.4"
PR = "5.el10"
PACKAGES = "perl-Test-Output perl-Test-Output-tests"
PROVIDES = "rpm/perl-Test-Output rpm/perl-Test-Output-tests"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-Test-Output-1.03.4-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7734d7a4d958355c566c9dce95ccdb2ee8150857ddd2e77060ecc5cd205f155e"

URI_perl-Test-Output = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Test-Output-1.03.4-5.el10.noarch.rpm;name=perl-Test-Output;unpack=0"
SRC_URI += "${URI_perl-Test-Output}"
SRC_URI[perl-Test-Output.sha256sum] = "ea4c8404113013f39d22265a3ec5d77e10214f231ee0705ed6df8137a4fe6876"
RDEPENDS:perl-Test-Output = " \
 perl-Exporter \
 perl-libs \
 perl-Test-Simple \
 perl-Capture-Tiny \
"

URI_perl-Test-Output-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Test-Output-tests-1.03.4-5.el10.noarch.rpm;name=perl-Test-Output-tests;unpack=0"
SRC_URI += "${URI_perl-Test-Output-tests}"
SRC_URI[perl-Test-Output-tests.sha256sum] = "868c4fefbb1b5623328800bf89e954b4bfdc14abff5bdf9c61ed4dddf05aca1c"
RDEPENDS:perl-Test-Output-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 bash \
 perl-Test-Output \
 perl-interpreter \
"
