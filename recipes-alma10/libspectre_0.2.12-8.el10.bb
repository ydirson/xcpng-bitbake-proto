# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libspectre"
PE = "0"
PV = "0.2.12"
PR = "8.el10"
PACKAGES = "libspectre libspectre-devel"
PROVIDES = "rpm/libspectre rpm/libspectre-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libspectre-0.2.12-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6eceedcf0e42f0c44b4e1e16d2e2c9b127eb287f9bfc7a0426f6d925b5e9fe6f"

URI_libspectre = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libspectre-0.2.12-8.el10.x86_64_v2.rpm;name=libspectre;unpack=0"
SRC_URI += "${URI_libspectre}"
SRC_URI[libspectre.sha256sum] = "a2a69188aa6e52f093b305589e2b71496292bad1fcfb0222a155d2eef96fcdf0"
RDEPENDS:libspectre = " \
 glibc \
 libgs \
"

URI_libspectre-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libspectre-devel-0.2.12-8.el10.x86_64_v2.rpm;name=libspectre-devel;unpack=0"
SRC_URI += "${URI_libspectre-devel}"
SRC_URI[libspectre-devel.sha256sum] = "0b96d4a567e771b666b72b1c7e88b1ab5c3b4304d6acb9aa90bf37b5857a5731"
RDEPENDS:libspectre-devel = " \
 libspectre \
 pkgconf-pkg-config \
"
