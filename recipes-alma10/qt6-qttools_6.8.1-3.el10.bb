# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qttools"
PE = "0"
PV = "6.8.1"
PR = "3.el10"
PACKAGES = "qt6-assistant qt6-designer qt6-doctools qt6-linguist qt6-qdbusviewer qt6-qttools qt6-qttools-common qt6-qttools-devel qt6-qttools-libs-designer qt6-qttools-libs-designercomponents qt6-qttools-libs-help qt6-qttools-examples qt6-qttools-static qt6-qttools-tests"
PROVIDES = "rpm/qt6-assistant rpm/qt6-designer rpm/qt6-doctools rpm/qt6-linguist rpm/qt6-qdbusviewer rpm/qt6-qttools rpm/qt6-qttools-common rpm/qt6-qttools-devel rpm/qt6-qttools-libs-designer rpm/qt6-qttools-libs-designercomponents rpm/qt6-qttools-libs-help rpm/qt6-qttools-examples rpm/qt6-qttools-static rpm/qt6-qttools-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qttools-6.8.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7694ced407690ac5318a4af1888d2b8a8c96a9f6767e4156a162e19e0b2717a"

URI_qt6-assistant = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-assistant-6.8.1-3.el10.x86_64_v2.rpm;name=qt6-assistant;unpack=0"
SRC_URI += "${URI_qt6-assistant}"
SRC_URI[qt6-assistant.sha256sum] = "d05a8895f9e02cff5cde082bd5eefc33b9e4df0bc36cbb8ba822d0bc31a5c6d7"
RDEPENDS:qt6-assistant = " \
 qt6-qttools-common \
 libgcc \
 qt6-qttools-libs-help \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-designer = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-designer-6.8.1-3.el10.x86_64_v2.rpm;name=qt6-designer;unpack=0"
SRC_URI += "${URI_qt6-designer}"
SRC_URI[qt6-designer.sha256sum] = "29b66685e59fea6eb8b02cbcbefdaf7c2c01f4d75c5dfaeca1f22f41bff372cd"
RDEPENDS:qt6-designer = " \
 qt6-qttools-libs-designer \
 qt6-qttools-libs-designercomponents \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-doctools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-doctools-6.8.1-3.el10.x86_64_v2.rpm;name=qt6-doctools;unpack=0"
SRC_URI += "${URI_qt6-doctools}"
SRC_URI[qt6-doctools.sha256sum] = "070b6d8435332b0e846188a9c8cb2362e64670cfffe7ac5c8ae5a36abc157a73"
RDEPENDS:qt6-doctools = " \
 qt6-qtdeclarative \
 qt6-qttools-libs-help \
 clang-libs \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
 llvm-libs \
"

URI_qt6-linguist = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-linguist-6.8.1-3.el10.x86_64_v2.rpm;name=qt6-linguist;unpack=0"
SRC_URI += "${URI_qt6-linguist}"
SRC_URI[qt6-linguist.sha256sum] = "e6f113be7aee47a75a79c338d314bcc8854c723123033d0a301b904a7491de94"
RDEPENDS:qt6-linguist = " \
 qt6-qtdeclarative \
 qt6-qttools \
 qt6-qttools-common \
 clang-libs \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
 llvm-libs \
"

URI_qt6-qdbusviewer = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qdbusviewer-6.8.1-3.el10.x86_64_v2.rpm;name=qt6-qdbusviewer;unpack=0"
SRC_URI += "${URI_qt6-qdbusviewer}"
SRC_URI[qt6-qdbusviewer.sha256sum] = "0cb419f96a5b6df61df9b4f26b2347471668e171e74aa0f190e83a4a6e0666fa"
RDEPENDS:qt6-qdbusviewer = " \
 qt6-qttools-common \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qttools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qttools-6.8.1-3.el10.x86_64_v2.rpm;name=qt6-qttools;unpack=0"
SRC_URI += "${URI_qt6-qttools}"
SRC_URI[qt6-qttools.sha256sum] = "05e8ef62a6266235241cd0d6ca28980c5845142326bb15824266d46a4b99e80b"
RDEPENDS:qt6-qttools = " \
 qt6-qttools-common \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qttools-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qttools-common-6.8.1-3.el10.noarch.rpm;name=qt6-qttools-common;unpack=0"
SRC_URI += "${URI_qt6-qttools-common}"
SRC_URI[qt6-qttools-common.sha256sum] = "bcf9998384d7149d2f4ec5fb2441d4a18c1cd7d4f19781ff5493e2d7840b2b18"
RDEPENDS:qt6-qttools-common = ""

URI_qt6-qttools-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qttools-devel-6.8.1-3.el10.x86_64_v2.rpm;name=qt6-qttools-devel;unpack=0"
SRC_URI += "${URI_qt6-qttools-devel}"
SRC_URI[qt6-qttools-devel.sha256sum] = "e65a9b6b56d456e9cc7e0d54801b705223522a711c964081ae30d37733aaed0a"
RDEPENDS:qt6-qttools-devel = " \
 cmake-filesystem \
 qt6-designer \
 qt6-doctools \
 qt6-qttools \
 qt6-linguist \
 qt6-qttools-devel \
 qt6-qttools-libs-designer \
 qt6-qttools-libs-designercomponents \
 qt6-qttools-libs-help \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtbase-devel \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qttools-libs-designer = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qttools-libs-designer-6.8.1-3.el10.x86_64_v2.rpm;name=qt6-qttools-libs-designer;unpack=0"
SRC_URI += "${URI_qt6-qttools-libs-designer}"
SRC_URI[qt6-qttools-libs-designer.sha256sum] = "f94a8306e22204b4885fd5c1261759dde97f462efda70e42054e4e983d7f83b2"
RDEPENDS:qt6-qttools-libs-designer = " \
 qt6-qtdeclarative \
 qt6-qttools-common \
 libgcc \
 qt6-qtbase \
 libzstd \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qttools-libs-designercomponents = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qttools-libs-designercomponents-6.8.1-3.el10.x86_64_v2.rpm;name=qt6-qttools-libs-designercomponents;unpack=0"
SRC_URI += "${URI_qt6-qttools-libs-designercomponents}"
SRC_URI[qt6-qttools-libs-designercomponents.sha256sum] = "5ca9575600c93fde821bc18acf423716b0835807d2e56b05facc86a2d22ae26d"
RDEPENDS:qt6-qttools-libs-designercomponents = " \
 qt6-qttools-common \
 qt6-qttools-libs-designer \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qttools-libs-help = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qttools-libs-help-6.8.1-3.el10.x86_64_v2.rpm;name=qt6-qttools-libs-help;unpack=0"
SRC_URI += "${URI_qt6-qttools-libs-help}"
SRC_URI[qt6-qttools-libs-help.sha256sum] = "6fef914c72e9d010926569a3ef6c7701e8644992dc39ad0a0195eaed6c494d1e"
RDEPENDS:qt6-qttools-libs-help = " \
 qt6-qttools-common \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qttools-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qttools-examples-6.8.1-3.el10.x86_64_v2.rpm;name=qt6-qttools-examples;unpack=0"
SRC_URI += "${URI_qt6-qttools-examples}"
SRC_URI[qt6-qttools-examples.sha256sum] = "752cdf54e4169322f2e8d0720835e25c3259b12dd9b414ac826949f34280468a"
RDEPENDS:qt6-qttools-examples = " \
 qt6-qttools \
 qt6-qttools-common \
 libgcc \
 qt6-qttools-libs-help \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qttools-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qttools-static-6.8.1-3.el10.x86_64_v2.rpm;name=qt6-qttools-static;unpack=0"
SRC_URI += "${URI_qt6-qttools-static}"
SRC_URI[qt6-qttools-static.sha256sum] = "dcbf0a58f6d4c413ebe5a657a01fc78f4c42646dbd95c3d1257f991f231e65e4"
RDEPENDS:qt6-qttools-static = " \
 qt6-qttools-devel \
"

URI_qt6-qttools-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qttools-tests-6.8.1-3.el10.x86_64_v2.rpm;name=qt6-qttools-tests;unpack=0"
SRC_URI += "${URI_qt6-qttools-tests}"
SRC_URI[qt6-qttools-tests.sha256sum] = "acf4548b32832ae73948e3adea7423c27096f59103dabbc150f92766be017f29"
RDEPENDS:qt6-qttools-tests = " \
 qt6-qttools \
 libgcc \
 qt6-qttools-libs-help \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
 perl-interpreter \
"
