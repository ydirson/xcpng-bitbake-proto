# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-xkbregistry"
PE = "0"
PV = "0.3"
PR = "3.el10"
PACKAGES = "python3-xkbregistry"
PROVIDES = "rpm/python3-xkbregistry"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-xkbregistry-0.3-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f77ebac972ec60f8d8d3c0fdcf1f6376003f5c64ca1e22cb17ef56275a36d9a7"

URI_python3-xkbregistry = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-xkbregistry-0.3-3.el10.x86_64_v2.rpm;name=python3-xkbregistry;unpack=0"
SRC_URI += "${URI_python3-xkbregistry}"
SRC_URI[python3-xkbregistry.sha256sum] = "4ffd866a91ea9cbaa87a5133e9fa1608391ff9ee007d17ef2db1c2b8c00800dd"
RDEPENDS:python3-xkbregistry = " \
 glibc \
 libxkbcommon \
 python3-cffi \
 python3 \
"
