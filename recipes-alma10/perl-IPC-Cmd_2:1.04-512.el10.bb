# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-IPC-Cmd"
PE = "2"
PV = "1.04"
PR = "512.el10"
PACKAGES = "perl-IPC-Cmd perl-IPC-Cmd-tests"
PROVIDES = "rpm/perl-IPC-Cmd rpm/perl-IPC-Cmd-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-IPC-Cmd-1.04-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9137b796f36864ada8d3846071185453b55a44467275b5cdf8a7fd57a8bb491b"

URI_perl-IPC-Cmd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-IPC-Cmd-1.04-512.el10.noarch.rpm;name=perl-IPC-Cmd;unpack=0"
SRC_URI += "${URI_perl-IPC-Cmd}"
SRC_URI[perl-IPC-Cmd.sha256sum] = "3ccc494901ce2e9d8962854853f53c1ea8dbd03f865bb03e411d68b87a6d1123"
RDEPENDS:perl-IPC-Cmd = " \
 perl-constant \
 perl-ExtUtils-MM-Utils \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-IO \
 perl-FileHandle \
 perl-Socket \
 perl-Text-ParseWords \
 perl-Module-Load-Conditional \
 perl-POSIX \
 perl-Params-Check \
 perl-Symbol \
 perl-IPC-Open3 \
 perl-PathTools \
 perl-Locale-Maketext-Simple \
 perl-Exporter \
 perl-Time-HiRes \
"

URI_perl-IPC-Cmd-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-IPC-Cmd-tests-1.04-512.el10.noarch.rpm;name=perl-IPC-Cmd-tests;unpack=0"
SRC_URI += "${URI_perl-IPC-Cmd-tests}"
SRC_URI[perl-IPC-Cmd-tests.sha256sum] = "6d7c11d8881329c2477c2519175b3bf9ee70464c5110bfe851d8e5134e31f6e6"
RDEPENDS:perl-IPC-Cmd-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-IPC-Cmd \
 perl-File-Temp \
 bash \
 perl-PathTools \
 perl-interpreter \
 perl-Data-Dumper \
 perl-lib \
"
