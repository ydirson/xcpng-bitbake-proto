# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-quh"
PE = "0"
PV = "0.20110816"
PR = "31.el10"
PACKAGES = "hunspell-quh"
PROVIDES = "rpm/hunspell-quh"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-quh-0.20110816-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad909b6ce674f9bc0d7687559b5133e159cca16248d6108c89194483616526e0"

URI_hunspell-quh = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-quh-0.20110816-31.el10.noarch.rpm;name=hunspell-quh;unpack=0"
SRC_URI += "${URI_hunspell-quh}"
SRC_URI[hunspell-quh.sha256sum] = "8b70e9f62db81d8c92031337de5d89abd6043a029552b10d4a560e27aaaf134f"
RDEPENDS:hunspell-quh = " \
 hunspell \
"
