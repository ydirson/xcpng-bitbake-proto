# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "logrotate"
PE = "0"
PV = "3.22.0"
PR = "4.el10"
PACKAGES = "logrotate"
PROVIDES = "rpm/logrotate"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/logrotate-3.22.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b89738208cf8b853f7da113c1b17b952166f5be4bcb6bc9b9b45491e0aa6cdf"

URI_logrotate = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/logrotate-3.22.0-4.el10.x86_64_v2.rpm;name=logrotate;unpack=0"
SRC_URI += "${URI_logrotate}"
SRC_URI[logrotate.sha256sum] = "f320191aae7ddf020394629bb003b2e86ed9394b329b32a05d92f666d9aa925a"
RDEPENDS:logrotate = " \
 libacl \
 systemd \
 libselinux \
 bash \
 popt \
 glibc \
 coreutils \
"
