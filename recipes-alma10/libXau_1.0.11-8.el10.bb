# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libXau"
PE = "0"
PV = "1.0.11"
PR = "8.el10"
PACKAGES = "libXau libXau-devel"
PROVIDES = "rpm/libXau rpm/libXau-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libXau-1.0.11-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f91097805549c260b10ecb573ed1e450d31bf7778faa0bcdbc7f3047bfe8d5d6"

URI_libXau = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXau-1.0.11-8.el10.x86_64_v2.rpm;name=libXau;unpack=0"
SRC_URI += "${URI_libXau}"
SRC_URI[libXau.sha256sum] = "9e94d413a2855f3bff9b74c6a1ac61afb2249b965c3e2b18531b4e896d9fee8e"
RDEPENDS:libXau = " \
 glibc \
"

URI_libXau-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXau-devel-1.0.11-8.el10.x86_64_v2.rpm;name=libXau-devel;unpack=0"
SRC_URI += "${URI_libXau-devel}"
SRC_URI[libXau-devel.sha256sum] = "400a1bde64584160f21623d56e960c07aa1cad6196d025bb01b59b09d345f35e"
RDEPENDS:libXau-devel = " \
 xorg-x11-proto-devel \
 libXau \
 pkgconf-pkg-config \
"
