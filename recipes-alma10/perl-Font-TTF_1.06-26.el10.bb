# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Font-TTF"
PE = "0"
PV = "1.06"
PR = "26.el10"
PACKAGES = "perl-Font-TTF perl-Font-TTF-XMLparse perl-Font-TTF-tests"
PROVIDES = "rpm/perl-Font-TTF rpm/perl-Font-TTF-XMLparse rpm/perl-Font-TTF-tests"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-Font-TTF-1.06-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b06d51a9a013b5dddbe32f500ee2a9214934c4f395b4c066d0ae952bacd5d6a6"

URI_perl-Font-TTF = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Font-TTF-1.06-26.el10.noarch.rpm;name=perl-Font-TTF;unpack=0"
SRC_URI += "${URI_perl-Font-TTF}"
SRC_URI[perl-Font-TTF.sha256sum] = "d60c8901800492fa05baafab833e09c4328d22ac907aaf174a43af969df52c45"
RDEPENDS:perl-Font-TTF = " \
 perl-libs \
 perl-Font-TTF \
 perl-vars \
 perl-IO \
 perl-Symbol \
 perl-Exporter \
 perl-Data-Dumper \
 perl-IO-String \
"

URI_perl-Font-TTF-XMLparse = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Font-TTF-XMLparse-1.06-26.el10.noarch.rpm;name=perl-Font-TTF-XMLparse;unpack=0"
SRC_URI += "${URI_perl-Font-TTF-XMLparse}"
SRC_URI[perl-Font-TTF-XMLparse.sha256sum] = "cd6dcab22ba17f92b4c95bde75e1ce7bcbc046d16f441066df119617a45d8f09"
RDEPENDS:perl-Font-TTF-XMLparse = " \
 perl-Exporter \
 perl-libs \
 perl-XML-Parser \
 perl-vars \
"

URI_perl-Font-TTF-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Font-TTF-tests-1.06-26.el10.noarch.rpm;name=perl-Font-TTF-tests;unpack=0"
SRC_URI += "${URI_perl-Font-TTF-tests}"
SRC_URI[perl-Font-TTF-tests.sha256sum] = "4eeecda4b81aa96f2fe81f09befbeb0e67e29eca72c7776d3f42d46f32c04da3"
RDEPENDS:perl-Font-TTF-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Font-TTF \
 perl-IO-Compress \
 perl-File-Compare \
 bash \
 perl-interpreter \
"
