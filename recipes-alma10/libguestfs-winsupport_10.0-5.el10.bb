# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libguestfs-winsupport"
PE = "0"
PV = "10.0"
PR = "5.el10"
PACKAGES = "libguestfs-winsupport"
PROVIDES = "rpm/libguestfs-winsupport"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libguestfs-winsupport-10.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da1af870102f51ccab3ffa07ae941180514eb6d49d7a035fb6048f2ebdc8f5b6"

URI_libguestfs-winsupport = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libguestfs-winsupport-10.0-5.el10.x86_64_v2.rpm;name=libguestfs-winsupport;unpack=0"
SRC_URI += "${URI_libguestfs-winsupport}"
SRC_URI[libguestfs-winsupport.sha256sum] = "c82de9d22bb8a5f47ab2d566b0d133efd77d57417caec3cb9b93dc2c4e7e8a00"
RDEPENDS:libguestfs-winsupport = " \
 fuse-libs \
 libguestfs \
"
