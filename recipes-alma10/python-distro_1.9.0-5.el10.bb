# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-distro"
PE = "0"
PV = "1.9.0"
PR = "5.el10"
PACKAGES = "python3-distro"
PROVIDES = "rpm/python3-distro"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-distro-1.9.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bce7ed391ce1cf2db9bf66abb16be098057359fc39e1bbdf96718e83628e57fa"

URI_python3-distro = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-distro-1.9.0-5.el10.noarch.rpm;name=python3-distro;unpack=0"
SRC_URI += "${URI_python3-distro}"
SRC_URI[python3-distro.sha256sum] = "bd6ca26d98a0cfb27817fa33a1750a950a5149c43fdcf129b936950e19859613"
RDEPENDS:python3-distro = " \
 python3 \
"
