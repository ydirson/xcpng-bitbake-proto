# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "exec-maven-plugin"
PE = "0"
PV = "3.3.0"
PR = "3.el10"
PACKAGES = "exec-maven-plugin exec-maven-plugin-javadoc"
PROVIDES = "rpm/exec-maven-plugin rpm/exec-maven-plugin-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/exec-maven-plugin-3.3.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da056421f135e631c4d7d1d6ab5dec0a53bbeaa25e65eabbdcb9303ee09b645f"

URI_exec-maven-plugin = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/exec-maven-plugin-3.3.0-3.el10.noarch.rpm;name=exec-maven-plugin;unpack=0"
SRC_URI += "${URI_exec-maven-plugin}"
SRC_URI[exec-maven-plugin.sha256sum] = "eeb5bdabb1f97606666dac3f09bdd84b887e45ea3992c3f245a3bd6d67df7f30"
RDEPENDS:exec-maven-plugin = " \
 objectweb-asm \
 plexus-utils \
 javapackages-filesystem \
 apache-commons-exec \
 maven-resolver \
"

URI_exec-maven-plugin-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/exec-maven-plugin-javadoc-3.3.0-3.el10.noarch.rpm;name=exec-maven-plugin-javadoc;unpack=0"
SRC_URI += "${URI_exec-maven-plugin-javadoc}"
SRC_URI[exec-maven-plugin-javadoc.sha256sum] = "00aeef0f084a6bbec0a48b627cb7d21c83191dedc781beb43bf33f6da6f86289"
RDEPENDS:exec-maven-plugin-javadoc = " \
 javapackages-filesystem \
"
