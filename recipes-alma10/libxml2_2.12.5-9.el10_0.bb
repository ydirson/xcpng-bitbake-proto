# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libxml2"
PE = "0"
PV = "2.12.5"
PR = "9.el10_0"
PACKAGES = "libxml2 python3-libxml2 libxml2-devel libxml2-static"
PROVIDES = "rpm/libxml2 rpm/python3-libxml2 rpm/libxml2-devel rpm/libxml2-static"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libxml2-2.12.5-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "486125c6f01f6fca73946e15addd063c783af3dc6ea2d9758e9cc93985634f14"

URI_libxml2 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libxml2-2.12.5-9.el10_0.x86_64_v2.rpm;name=libxml2;unpack=0"
SRC_URI += "${URI_libxml2}"
SRC_URI[libxml2.sha256sum] = "b76be575eacfc40a390b54a9e082831bb02a3736ab90187d42dfa3c7845e4187"
RDEPENDS:libxml2 = " \
 glibc \
 zlib-ng-compat \
 xz-libs \
"

URI_python3-libxml2 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-libxml2-2.12.5-9.el10_0.x86_64_v2.rpm;name=python3-libxml2;unpack=0"
SRC_URI += "${URI_python3-libxml2}"
SRC_URI[python3-libxml2.sha256sum] = "ff68980bc49b71083ab652451a5fa86298d095bdaf8db74ac8196d4d2173e92d"
RDEPENDS:python3-libxml2 = " \
 glibc \
 python3 \
 libxml2 \
"

URI_libxml2-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libxml2-devel-2.12.5-9.el10_0.x86_64_v2.rpm;name=libxml2-devel;unpack=0"
SRC_URI += "${URI_libxml2-devel}"
SRC_URI[libxml2-devel.sha256sum] = "c76d33854620fdfe682c93accccf65c11fb411a28d86e23de0747333937ab472"
RDEPENDS:libxml2-devel = " \
 xz-devel \
 cmake-filesystem \
 zlib-ng-compat-devel \
 libxml2 \
 pkgconf-pkg-config \
 bash \
"

URI_libxml2-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libxml2-static-2.12.5-9.el10_0.x86_64_v2.rpm;name=libxml2-static;unpack=0"
SRC_URI += "${URI_libxml2-static}"
SRC_URI[libxml2-static.sha256sum] = "c2503f96ef5590b310ef1dffbe1be19ba65f9722d83dbf1433c405201ccadc5f"
RDEPENDS:libxml2-static = ""
