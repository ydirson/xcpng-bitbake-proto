# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnupg2"
PE = "0"
PV = "2.4.5"
PR = "2.el10"
PACKAGES = "gnupg2 gnupg2-smime"
PROVIDES = "rpm/gnupg2 rpm/gnupg2-smime"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/gnupg2-2.4.5-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01b1828fdd46826e77da2ef5a924aea8203f4d4ba05934c608edb060bf6d1a13"

URI_gnupg2 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/gnupg2-2.4.5-2.el10.x86_64_v2.rpm;name=gnupg2;unpack=0"
SRC_URI += "${URI_gnupg2}"
SRC_URI[gnupg2.sha256sum] = "724d68767c8ea3141292c3af3f4b0a7c6ab422fc1f393146c6889513a06cf560"
RDEPENDS:gnupg2 = " \
 zlib-ng-compat \
 libksba \
 gnutls \
 bzip2-libs \
 libassuan \
 npth \
 readline \
 libgcrypt \
 libgpg-error \
 sqlite-libs \
 bash \
 tpm2-tss \
 glibc \
 openldap \
"

URI_gnupg2-smime = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnupg2-smime-2.4.5-2.el10.x86_64_v2.rpm;name=gnupg2-smime;unpack=0"
SRC_URI += "${URI_gnupg2-smime}"
SRC_URI[gnupg2-smime.sha256sum] = "f19c98ad9fcbb0b2965808516288a9b9fe4d723432e55b13084f1c90bb130fa9"
RDEPENDS:gnupg2-smime = " \
 gnupg2 \
 libksba \
 npth \
 libassuan \
 readline \
 libgcrypt \
 libgpg-error \
 glibc \
"
