# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-LWP-Protocol-https"
PE = "0"
PV = "6.13"
PR = "3.el10"
PACKAGES = "perl-LWP-Protocol-https perl-LWP-Protocol-https-tests"
PROVIDES = "rpm/perl-LWP-Protocol-https rpm/perl-LWP-Protocol-https-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-LWP-Protocol-https-6.13-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "941eb4e6f6bdd5571fb2fa20a94ffb1ac63a6deaefc0e387c5592a2d50dcbd58"

URI_perl-LWP-Protocol-https = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-LWP-Protocol-https-6.13-3.el10.noarch.rpm;name=perl-LWP-Protocol-https;unpack=0"
SRC_URI += "${URI_perl-LWP-Protocol-https}"
SRC_URI[perl-LWP-Protocol-https.sha256sum] = "1b67b13dd6a4688907673b62a20d3382b99e0d81b173effd1cdd81ecf43e45b0"
RDEPENDS:perl-LWP-Protocol-https = " \
 perl-libs \
 perl-libwww-perl \
 perl-IO-Socket-SSL \
 perl-Mozilla-CA \
 perl-Net-HTTP \
 perl-base \
"

URI_perl-LWP-Protocol-https-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-LWP-Protocol-https-tests-6.13-3.el10.noarch.rpm;name=perl-LWP-Protocol-https-tests;unpack=0"
SRC_URI += "${URI_perl-LWP-Protocol-https-tests}"
SRC_URI[perl-LWP-Protocol-https-tests.sha256sum] = "c636818a1d61406c50e7da8d4e8a554fa27f3f92683c7610de17db0ef82aa76e"
RDEPENDS:perl-LWP-Protocol-https-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Try-Tiny \
 perl-IO \
 perl-libwww-perl \
 perl-Socket \
 perl-IO-Socket-SSL \
 bash \
 perl-Test-Needs \
 perl-LWP-Protocol-https \
 perl-interpreter \
 perl-File-Temp \
"
