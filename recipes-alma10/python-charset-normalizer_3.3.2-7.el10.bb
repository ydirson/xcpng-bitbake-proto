# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-charset-normalizer"
PE = "0"
PV = "3.3.2"
PR = "7.el10"
PACKAGES = "python3-charset-normalizer"
PROVIDES = "rpm/python3-charset-normalizer"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/python-charset-normalizer-3.3.2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1770ced80d2004cd2e4de6c9912da1a5948f13a4115062a1ac721845d1e5c702"

URI_python3-charset-normalizer = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-charset-normalizer-3.3.2-7.el10.noarch.rpm;name=python3-charset-normalizer;unpack=0"
SRC_URI += "${URI_python3-charset-normalizer}"
SRC_URI[python3-charset-normalizer.sha256sum] = "ace9ad40e571f36d572bb4a5a033b3713ac1b2d7d7eacda1458e2ba9ff4df4a6"
RDEPENDS:python3-charset-normalizer = " \
 python3 \
"
