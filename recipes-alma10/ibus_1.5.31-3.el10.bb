# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ibus"
PE = "0"
PV = "1.5.31"
PR = "3.el10"
PACKAGES = "ibus ibus-gtk3 ibus-gtk4 ibus-libs ibus-setup ibus-wayland ibus-devel ibus-devel-docs ibus-panel ibus-desktop-testing ibus-tests ibus-xinit"
PROVIDES = "rpm/ibus rpm/ibus-gtk3 rpm/ibus-gtk4 rpm/ibus-libs rpm/ibus-setup rpm/ibus-wayland rpm/ibus-devel rpm/ibus-devel-docs rpm/ibus-panel rpm/ibus-desktop-testing rpm/ibus-tests rpm/ibus-xinit"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ibus-1.5.31-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4aabd458f962d072612e3909a892d358a44871290abd51c8b07dad193f65f1dd"

URI_ibus = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ibus-1.5.31-3.el10.x86_64_v2.rpm;name=ibus;unpack=0"
SRC_URI += "${URI_ibus}"
SRC_URI[ibus.sha256sum] = "246309a4a5691b5c94264e69b2385e83e871ad08b995f1e7efc3b35244acaa83"
RDEPENDS:ibus = " \
 python3 \
 libXfixes \
 python3-gobject \
 desktop-file-utils \
 ibus-setup \
 libXi \
 pango \
 gdk-pixbuf2 \
 libX11 \
 ibus-gtk3 \
 bash \
 glib2 \
 gtk3 \
 ibus-libs \
 glibc \
 alternatives \
 dconf \
 iso-codes \
"

URI_ibus-gtk3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ibus-gtk3-1.5.31-3.el10.x86_64_v2.rpm;name=ibus-gtk3;unpack=0"
SRC_URI += "${URI_ibus-gtk3}"
SRC_URI[ibus-gtk3.sha256sum] = "61a16840d409f19f4bbeb0879737b67fba7aaf7c7d40c8b289daa819cf685ed9"
RDEPENDS:ibus-gtk3 = " \
 atk \
 cairo-gobject \
 harfbuzz \
 pango \
 gdk-pixbuf2 \
 ibus-libs \
 cairo \
 glib2 \
 gtk3 \
 glibc \
 dbus-libs \
"

URI_ibus-gtk4 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ibus-gtk4-1.5.31-3.el10.x86_64_v2.rpm;name=ibus-gtk4;unpack=0"
SRC_URI += "${URI_ibus-gtk4}"
SRC_URI[ibus-gtk4.sha256sum] = "2b4da6b4a6d6398e132a629f0e66f271755eeb2a064a012dedc2abb5bfb00278"
RDEPENDS:ibus-gtk4 = " \
 vulkan-loader \
 harfbuzz \
 pango \
 gdk-pixbuf2 \
 ibus-libs \
 cairo \
 glib2 \
 cairo-gobject \
 glibc \
 graphene \
 gtk4 \
 dbus-libs \
"

URI_ibus-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ibus-libs-1.5.31-3.el10.x86_64_v2.rpm;name=ibus-libs;unpack=0"
SRC_URI += "${URI_ibus-libs}"
SRC_URI[ibus-libs.sha256sum] = "33e8b900b7e6e0fdbb59eff3849f4034c7edc2f3ade3182d878813d395cc3a54"
RDEPENDS:ibus-libs = " \
 glibc \
 glib2 \
 gobject-introspection \
 dbus \
"

URI_ibus-setup = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ibus-setup-1.5.31-3.el10.noarch.rpm;name=ibus-setup;unpack=0"
SRC_URI += "${URI_ibus-setup}"
SRC_URI[ibus-setup.sha256sum] = "4147b3e73bd17c9b2d4d3ea9fc476c28872a64d3d7e8eb5e6d1b2635e9965ea5"
RDEPENDS:ibus-setup = " \
 python3 \
 ibus \
 python3-gobject \
 bash \
"

URI_ibus-wayland = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ibus-wayland-1.5.31-3.el10.x86_64_v2.rpm;name=ibus-wayland;unpack=0"
SRC_URI += "${URI_ibus-wayland}"
SRC_URI[ibus-wayland.sha256sum] = "c2bc8ede3523e371e56f59d7e49d55e4d43266edd04c9224d7ad156f6cb2dc7f"
RDEPENDS:ibus-wayland = " \
 libwayland-client \
 glib2 \
 ibus-libs \
 glibc \
 libxkbcommon \
"

URI_ibus-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ibus-devel-1.5.31-3.el10.x86_64_v2.rpm;name=ibus-devel;unpack=0"
SRC_URI += "${URI_ibus-devel}"
SRC_URI[ibus-devel.sha256sum] = "de2818f82a4b321ca0a517db8bc819cffb3a23297fb123f73601d23cc51d0321"
RDEPENDS:ibus-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 gettext-runtime \
 dbus-devel \
 ibus-libs \
"

URI_ibus-devel-docs = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ibus-devel-docs-1.5.31-3.el10.noarch.rpm;name=ibus-devel-docs;unpack=0"
SRC_URI += "${URI_ibus-devel-docs}"
SRC_URI[ibus-devel-docs.sha256sum] = "dae8307f76cb599e1a767f3a8e6db531915681d90640c63722573f18005269d1"
RDEPENDS:ibus-devel-docs = ""

URI_ibus-panel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ibus-panel-1.5.31-3.el10.x86_64_v2.rpm;name=ibus-panel;unpack=0"
SRC_URI += "${URI_ibus-panel}"
SRC_URI[ibus-panel.sha256sum] = "3ca54c776c8eca368b551d215d65a1aaa140cc6259476cffcc982e23b4780bc8"
RDEPENDS:ibus-panel = " \
 atk \
 libXi \
 libwayland-client \
 libdbusmenu \
 pango \
 gdk-pixbuf2 \
 libX11 \
 libdbusmenu-gtk3 \
 ibus \
 ibus-libs \
 cairo \
 glib2 \
 gtk3 \
 glibc \
 libxkbcommon \
 libnotify \
"

URI_ibus-desktop-testing = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ibus-desktop-testing-1.5.31-3.el10.noarch.rpm;name=ibus-desktop-testing;unpack=0"
SRC_URI += "${URI_ibus-desktop-testing}"
SRC_URI[ibus-desktop-testing.sha256sum] = "b327bd94c2d71292d110b582ca2347b03439e01ece465436446d23ba7aa0eaf9"
RDEPENDS:ibus-desktop-testing = " \
 ibus \
 bash \
 gnome-shell-extension-no-overview \
"

URI_ibus-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ibus-tests-1.5.31-3.el10.x86_64_v2.rpm;name=ibus-tests;unpack=0"
SRC_URI += "${URI_ibus-tests}"
SRC_URI[ibus-tests.sha256sum] = "c86d0881b2ff6a43bd9492c98230e9048501286c5fdbab7e2b7648d2badab6f7"
RDEPENDS:ibus-tests = " \
 libX11 \
 ibus \
 bash \
 glib2 \
 libXtst \
 ibus-libs \
 glibc \
 gtk4 \
 dbus-libs \
"

URI_ibus-xinit = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ibus-xinit-1.5.31-3.el10.noarch.rpm;name=ibus-xinit;unpack=0"
SRC_URI += "${URI_ibus-xinit}"
SRC_URI[ibus-xinit.sha256sum] = "65e41f92c149e1ad88ed98dc224e45766b9b03f5d5c7ec7c146daa80f8412f8b"
RDEPENDS:ibus-xinit = " \
 ibus \
 bash \
"
