# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-pyproject-metadata"
PE = "0"
PV = "0.7.1"
PR = "7.el10"
PACKAGES = "python3-pyproject-metadata"
PROVIDES = "rpm/python3-pyproject-metadata"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/python-pyproject-metadata-0.7.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0eec023fa68c67ee0735199325cb4c88d68158304d8790c5861a007825949987"

URI_python3-pyproject-metadata = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-pyproject-metadata-0.7.1-7.el10.noarch.rpm;name=python3-pyproject-metadata;unpack=0"
SRC_URI += "${URI_python3-pyproject-metadata}"
SRC_URI[python3-pyproject-metadata.sha256sum] = "d19662772a8eeee3035ace2d60107c917c14576d3a1ef8e479cc1dbc385afa32"
RDEPENDS:python3-pyproject-metadata = " \
 python3 \
 python3-packaging \
"
