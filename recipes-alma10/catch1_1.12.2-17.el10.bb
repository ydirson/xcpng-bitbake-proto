# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "catch1"
PE = "0"
PV = "1.12.2"
PR = "17.el10"
PACKAGES = "catch1-devel"
PROVIDES = "rpm/catch1-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/catch1-1.12.2-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "312e2a5692a1e241f5a3333fdc61f8e3d42c87340caac8aa8b8521cbb4871f9a"

URI_catch1-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/catch1-devel-1.12.2-17.el10.x86_64_v2.rpm;name=catch1-devel;unpack=0"
SRC_URI += "${URI_catch1-devel}"
SRC_URI[catch1-devel.sha256sum] = "fde7d675629ecbbef72aa83e2f0df58c966207af7b9f4b678acb6a0bcccade33"
RDEPENDS:catch1-devel = ""
