# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libvpx"
PE = "0"
PV = "1.14.1"
PR = "3.el10_0"
PACKAGES = "libvpx libvpx-devel libvpx-utils"
PROVIDES = "rpm/libvpx rpm/libvpx-devel rpm/libvpx-utils"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libvpx-1.14.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22e53846d7a0573575935655bc9fd6a7170cf7baa6b6ee87408cf52266f386d3"

URI_libvpx = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvpx-1.14.1-3.el10_0.x86_64_v2.rpm;name=libvpx;unpack=0"
SRC_URI += "${URI_libvpx}"
SRC_URI[libvpx.sha256sum] = "9275756c9d23101bc0dfc5616f6e662e00233224681e4ca3f0412ed208cee2f1"
RDEPENDS:libvpx = " \
 glibc \
"

URI_libvpx-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libvpx-devel-1.14.1-3.el10_0.x86_64_v2.rpm;name=libvpx-devel;unpack=0"
SRC_URI += "${URI_libvpx-devel}"
SRC_URI[libvpx-devel.sha256sum] = "76bd2cea56481318f50bb7c3d817496138e2af39a53933ac84476d8b50b2733d"
RDEPENDS:libvpx-devel = " \
 libvpx \
 pkgconf-pkg-config \
"

URI_libvpx-utils = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libvpx-utils-1.14.1-3.el10_0.x86_64_v2.rpm;name=libvpx-utils;unpack=0"
SRC_URI += "${URI_libvpx-utils}"
SRC_URI[libvpx-utils.sha256sum] = "2a9d4e2c9bb9421dc7f696c619350d6b980dae5558add7c6a9f093db2b1cd91f"
RDEPENDS:libvpx-utils = " \
 glibc \
 libvpx \
 libgcc \
 libstdc++ \
"
