# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-LWP-MediaTypes"
PE = "0"
PV = "6.04"
PR = "19.el10"
PACKAGES = "perl-LWP-MediaTypes perl-LWP-MediaTypes-tests"
PROVIDES = "rpm/perl-LWP-MediaTypes rpm/perl-LWP-MediaTypes-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-LWP-MediaTypes-6.04-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edd6b8952198ec0af64e86c1656a7a4d82d4602d9abc3bf5ffdd6717753ebc47"

URI_perl-LWP-MediaTypes = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-LWP-MediaTypes-6.04-19.el10.noarch.rpm;name=perl-LWP-MediaTypes;unpack=0"
SRC_URI += "${URI_perl-LWP-MediaTypes}"
SRC_URI[perl-LWP-MediaTypes.sha256sum] = "3f6a08f7163022c3e27d16fbf10e27d256ac5341940267d3259a65fb9638372f"
RDEPENDS:perl-LWP-MediaTypes = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 mailcap \
 perl-File-Basename \
 perl-Exporter \
"

URI_perl-LWP-MediaTypes-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-LWP-MediaTypes-tests-6.04-19.el10.noarch.rpm;name=perl-LWP-MediaTypes-tests;unpack=0"
SRC_URI += "${URI_perl-LWP-MediaTypes-tests}"
SRC_URI[perl-LWP-MediaTypes-tests.sha256sum] = "0c9c92e2519f3079c9f0ff61e02fe7ec50cb1a2388bf593d75a3c87043d38ca8"
RDEPENDS:perl-LWP-MediaTypes-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-overload \
 bash \
 perl-LWP-MediaTypes \
 perl-interpreter \
 perl-Test-Fatal \
"
