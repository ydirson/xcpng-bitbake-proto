# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qat-zstd-plugin"
PE = "0"
PV = "0.2.0"
PR = "3.el10"
PACKAGES = "qat-zstd-plugin qat-zstd-plugin-devel qat-zstd-plugin-static"
PROVIDES = "rpm/qat-zstd-plugin rpm/qat-zstd-plugin-devel rpm/qat-zstd-plugin-static"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qat-zstd-plugin-0.2.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b92b91da826af669f6f03236bdc018f983409ede647cdca1b436663e438d4c2d"

URI_qat-zstd-plugin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qat-zstd-plugin-0.2.0-3.el10.x86_64_v2.rpm;name=qat-zstd-plugin;unpack=0"
SRC_URI += "${URI_qat-zstd-plugin}"
SRC_URI[qat-zstd-plugin.sha256sum] = "27df0588c06061dad57f57bb065e930cee3bbf1622b2d42b704703c86c990c55"
RDEPENDS:qat-zstd-plugin = " \
 glibc \
 qatlib \
"

URI_qat-zstd-plugin-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qat-zstd-plugin-devel-0.2.0-3.el10.x86_64_v2.rpm;name=qat-zstd-plugin-devel;unpack=0"
SRC_URI += "${URI_qat-zstd-plugin-devel}"
SRC_URI[qat-zstd-plugin-devel.sha256sum] = "6a39e864b88db5d58755940bcfd5de664c63a5f2ab1f562b0fac90468d5e7502"
RDEPENDS:qat-zstd-plugin-devel = " \
 qat-zstd-plugin \
"

URI_qat-zstd-plugin-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qat-zstd-plugin-static-0.2.0-3.el10.x86_64_v2.rpm;name=qat-zstd-plugin-static;unpack=0"
SRC_URI += "${URI_qat-zstd-plugin-static}"
SRC_URI[qat-zstd-plugin-static.sha256sum] = "ab0e977cbafe6a910af6fb00a3598aa725b729e619a2878d940d6f6ff00ba51c"
RDEPENDS:qat-zstd-plugin-static = " \
 qat-zstd-plugin-devel \
"
