# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pps-tools"
PE = "0"
PV = "1.0.3"
PR = "10.el10"
PACKAGES = "pps-tools-devel pps-tools"
PROVIDES = "rpm/pps-tools-devel rpm/pps-tools"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/pps-tools-1.0.3-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "094d8d83eae6bde762841d33474dbfc30f1d285d75e7fd479bf1132c9924dba5"

URI_pps-tools-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/pps-tools-devel-1.0.3-10.el10.x86_64_v2.rpm;name=pps-tools-devel;unpack=0"
SRC_URI += "${URI_pps-tools-devel}"
SRC_URI[pps-tools-devel.sha256sum] = "6c85b7a89b7ca3dde3736a7c2a05a47a716d045ae564cb05aa917385ca7cde6d"
RDEPENDS:pps-tools-devel = ""

URI_pps-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/pps-tools-1.0.3-10.el10.x86_64_v2.rpm;name=pps-tools;unpack=0"
SRC_URI += "${URI_pps-tools}"
SRC_URI[pps-tools.sha256sum] = "1f01ef1faf193ceb9b86eebb34097373532c44130fa5d4304dc18cb7bf588125"
RDEPENDS:pps-tools = " \
 glibc \
 bash \
"
