# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-threads"
PE = "1"
PV = "2.40"
PR = "511.el10"
PACKAGES = "perl-threads perl-threads-tests"
PROVIDES = "rpm/perl-threads rpm/perl-threads-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-threads-2.40-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f318939d143e05b4841cac644dd6ebdaeae02e6d5ca4f2ae70e0ca0d4250b76e"

URI_perl-threads = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-threads-2.40-511.el10.x86_64_v2.rpm;name=perl-threads;unpack=0"
SRC_URI += "${URI_perl-threads}"
SRC_URI[perl-threads.sha256sum] = "a0b59829795f525f419da8d228cf2d93e091ee329a3d8bfb9f7cadf67c3d31f3"
RDEPENDS:perl-threads = " \
 glibc \
 perl-overload \
 perl-libs \
 perl-Carp \
"

URI_perl-threads-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-threads-tests-2.40-511.el10.x86_64_v2.rpm;name=perl-threads-tests;unpack=0"
SRC_URI += "${URI_perl-threads-tests}"
SRC_URI[perl-threads-tests.sha256sum] = "3e4986750b4b93667dfec8492440c161f1b8362de13698e9752a1d8e315f6e14"
RDEPENDS:perl-threads-tests = " \
 perl-threads \
 perl-threads-shared \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-ExtUtils-MakeMaker \
 perl-IO \
 perl-Thread-Queue \
 bash \
 perl-PathTools \
 perl-Thread-Semaphore \
 procps-ng \
 perl-interpreter \
 perl-File-Path \
 perl-Data-Dumper \
 perl-Hash-Util \
"
