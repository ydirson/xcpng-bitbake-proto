# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rtkit"
PE = "0"
PV = "0.11"
PR = "68.el10"
PACKAGES = "rtkit"
PROVIDES = "rpm/rtkit"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/rtkit-0.11-68.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7eac68b8ebaf8e678958e81b3135e6aa294c0a130abab5757626af59d46c308"

URI_rtkit = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rtkit-0.11-68.el10.x86_64_v2.rpm;name=rtkit;unpack=0"
SRC_URI += "${URI_rtkit}"
SRC_URI[rtkit.sha256sum] = "99e7225e51d3f46e51340b9ff91cfdb8f6d952f49f2567104b5a6eef39a6ce10"
RDEPENDS:rtkit = " \
 shadow-utils \
 systemd-libs \
 libcap \
 polkit \
 bash \
 dbus \
 glibc \
 dbus-libs \
"
