# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Compress-Raw-Lzma"
PE = "0"
PV = "2.212"
PR = "3.el10"
PACKAGES = "perl-Compress-Raw-Lzma perl-Compress-Raw-Lzma-tests"
PROVIDES = "rpm/perl-Compress-Raw-Lzma rpm/perl-Compress-Raw-Lzma-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Compress-Raw-Lzma-2.212-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d4a3c36d3276616c464d63cc3afb0e75995075c60f214e1d653cc731a0f1bbe"

URI_perl-Compress-Raw-Lzma = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Compress-Raw-Lzma-2.212-3.el10.x86_64_v2.rpm;name=perl-Compress-Raw-Lzma;unpack=0"
SRC_URI += "${URI_perl-Compress-Raw-Lzma}"
SRC_URI[perl-Compress-Raw-Lzma.sha256sum] = "173da6840df5c589ba007c94c161c99373659e70b21745aaf02822061cc38b63"
RDEPENDS:perl-Compress-Raw-Lzma = " \
 perl-constant \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-AutoLoader \
 glibc \
 perl-Exporter \
 xz-libs \
"

URI_perl-Compress-Raw-Lzma-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Compress-Raw-Lzma-tests-2.212-3.el10.x86_64_v2.rpm;name=perl-Compress-Raw-Lzma-tests;unpack=0"
SRC_URI += "${URI_perl-Compress-Raw-Lzma-tests}"
SRC_URI[perl-Compress-Raw-Lzma-tests.sha256sum] = "e575a647c69cc65d5dc96173373fda4e8e7f7e46028fa15752c058a9c4da3b7b"
RDEPENDS:perl-Compress-Raw-Lzma-tests = " \
 perl-constant \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-Compress-Raw-Lzma \
 bash \
 perl-interpreter \
 perl-File-Path \
 perl-lib \
"
