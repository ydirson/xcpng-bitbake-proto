# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cdi-api"
PE = "0"
PV = "2.0.2"
PR = "15.el10"
PACKAGES = "cdi-api cdi-api-javadoc"
PROVIDES = "rpm/cdi-api rpm/cdi-api-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/cdi-api-2.0.2-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e98f1b327ffb35d79d6943e868748aaeb81789ba3a6263fe39dc1c6b1b2e85a3"

URI_cdi-api = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cdi-api-2.0.2-15.el10.noarch.rpm;name=cdi-api;unpack=0"
SRC_URI += "${URI_cdi-api}"
SRC_URI[cdi-api.sha256sum] = "56a3e83e1eb9243fa41c4b3e3d17575268da673a6d744c67db12ae59147d61f3"
RDEPENDS:cdi-api = " \
 atinject \
 javapackages-filesystem \
"

URI_cdi-api-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/cdi-api-javadoc-2.0.2-15.el10.noarch.rpm;name=cdi-api-javadoc;unpack=0"
SRC_URI += "${URI_cdi-api-javadoc}"
SRC_URI[cdi-api-javadoc.sha256sum] = "9d021e0d8288181ece2055ad035da1fe09809b92323ea1d2156d5f6b0fd434f4"
RDEPENDS:cdi-api-javadoc = " \
 javapackages-filesystem \
"
