# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Term-Table"
PE = "0"
PV = "0.018"
PR = "513.el10"
PACKAGES = "perl-Term-Table perl-Term-Table-tests"
PROVIDES = "rpm/perl-Term-Table rpm/perl-Term-Table-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Term-Table-0.018-513.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d25c6bf6603b857e35f64a37349299de3fbd9f7ec26bc5da072496ac015e0291"

URI_perl-Term-Table = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Term-Table-0.018-513.el10.noarch.rpm;name=perl-Term-Table;unpack=0"
SRC_URI += "${URI_perl-Term-Table}"
SRC_URI[perl-Term-Table.sha256sum] = "54d4b0d6a536a56a7e70c80cc43760684f43fcd140e3127d329e2a831f35d9bf"
RDEPENDS:perl-Term-Table = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-Exporter \
 perl-base \
 perl-Term-Table \
"

URI_perl-Term-Table-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Term-Table-tests-0.018-513.el10.noarch.rpm;name=perl-Term-Table-tests;unpack=0"
SRC_URI += "${URI_perl-Term-Table-tests}"
SRC_URI[perl-Term-Table-tests.sha256sum] = "f5eb996f821b1d5452588c887d5c537eb33ed21608a3e628a9499c47416a20c4"
RDEPENDS:perl-Term-Table-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 bash \
 perl-interpreter \
 perl-base \
 perl-Term-Table \
"
