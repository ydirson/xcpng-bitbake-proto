# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gutenprint"
PE = "0"
PV = "5.3.4"
PR = "18.el10"
PACKAGES = "gutenprint gutenprint-cups gutenprint-doc gutenprint-libs gutenprint-devel"
PROVIDES = "rpm/gutenprint rpm/gutenprint-cups rpm/gutenprint-doc rpm/gutenprint-libs rpm/gutenprint-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gutenprint-5.3.4-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "342cf675e5e656bdb6cdbf30e33353927dcc00b4e3046152c4cd44365e6fe0dd"

URI_gutenprint = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gutenprint-5.3.4-18.el10.x86_64_v2.rpm;name=gutenprint;unpack=0"
SRC_URI += "${URI_gutenprint}"
SRC_URI[gutenprint.sha256sum] = "2131b34e20fc98a16298e4d0619d0d962ad5b071612fcc5cbc05b79f98da2c29"
RDEPENDS:gutenprint = " \
 glibc \
 cups-client \
 gutenprint-libs \
"

URI_gutenprint-cups = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gutenprint-cups-5.3.4-18.el10.x86_64_v2.rpm;name=gutenprint-cups;unpack=0"
SRC_URI += "${URI_gutenprint-cups}"
SRC_URI[gutenprint-cups.sha256sum] = "7b353e0cf79f6e617f28aa8115f24f9feba44663e7f15123720aa8ef1d470842"
RDEPENDS:gutenprint-cups = " \
 python3 \
 gutenprint \
 zlib-ng-compat \
 python3-charset-normalizer \
 gutenprint-libs \
 cups-libs \
 cups \
 bash \
 glibc \
 libusb1 \
"

URI_gutenprint-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gutenprint-doc-5.3.4-18.el10.x86_64_v2.rpm;name=gutenprint-doc;unpack=0"
SRC_URI += "${URI_gutenprint-doc}"
SRC_URI[gutenprint-doc.sha256sum] = "08168c2a40120322fc4828f677820cc388de8445a2d034c540e5cd02267f3505"
RDEPENDS:gutenprint-doc = ""

URI_gutenprint-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gutenprint-libs-5.3.4-18.el10.x86_64_v2.rpm;name=gutenprint-libs;unpack=0"
SRC_URI += "${URI_gutenprint-libs}"
SRC_URI[gutenprint-libs.sha256sum] = "40426940ac76491d396b4e10f8f8695805cc9032518125de6add1ba87e2a2752"
RDEPENDS:gutenprint-libs = " \
 glibc \
"

URI_gutenprint-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gutenprint-devel-5.3.4-18.el10.x86_64_v2.rpm;name=gutenprint-devel;unpack=0"
SRC_URI += "${URI_gutenprint-devel}"
SRC_URI[gutenprint-devel.sha256sum] = "51c36465b989dd89ce0328ffa36ef10c4bba137aa73531cc8bc638ee6adb009d"
RDEPENDS:gutenprint-devel = " \
 gutenprint \
 gutenprint-libs \
 pkgconf-pkg-config \
"
