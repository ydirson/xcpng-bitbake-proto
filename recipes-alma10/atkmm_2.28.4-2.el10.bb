# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "atkmm"
PE = "0"
PV = "2.28.4"
PR = "2.el10"
PACKAGES = "atkmm atkmm-devel atkmm-doc"
PROVIDES = "rpm/atkmm rpm/atkmm-devel rpm/atkmm-doc"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/atkmm-2.28.4-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4fec0964581ddaf8ab359ede157bcb282a7935f5d32bc0295528e248a394563"

URI_atkmm = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/atkmm-2.28.4-2.el10.x86_64_v2.rpm;name=atkmm;unpack=0"
SRC_URI += "${URI_atkmm}"
SRC_URI[atkmm.sha256sum] = "5474443dda8e8eaa3de868d4b66cebd33fd996148b254d71256fd87abd68c3cf"
RDEPENDS:atkmm = " \
 atk \
 libgcc \
 libsigc++20 \
 libstdc++ \
 glib2 \
 glibc \
 glibmm2.4 \
"

URI_atkmm-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/atkmm-devel-2.28.4-2.el10.x86_64_v2.rpm;name=atkmm-devel;unpack=0"
SRC_URI += "${URI_atkmm-devel}"
SRC_URI[atkmm-devel.sha256sum] = "ab3ba94dc33b607191df55cd929dc93fb11eb5847307226ced6c5232dccfeda6"
RDEPENDS:atkmm-devel = " \
 atkmm \
 atk-devel \
 pkgconf-pkg-config \
 glibmm2.4-devel \
"

URI_atkmm-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/atkmm-doc-2.28.4-2.el10.noarch.rpm;name=atkmm-doc;unpack=0"
SRC_URI += "${URI_atkmm-doc}"
SRC_URI[atkmm-doc.sha256sum] = "6bd1cf85211817e118b03cebf841672ad8696572f755876791fec3c36d40473c"
RDEPENDS:atkmm-doc = " \
 atkmm \
 glibmm2.4-doc \
"
