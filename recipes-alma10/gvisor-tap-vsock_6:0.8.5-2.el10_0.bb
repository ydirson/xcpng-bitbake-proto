# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gvisor-tap-vsock"
PE = "6"
PV = "0.8.5"
PR = "2.el10_0"
PACKAGES = "gvisor-tap-vsock gvisor-tap-vsock-gvforwarder"
PROVIDES = "rpm/gvisor-tap-vsock rpm/gvisor-tap-vsock-gvforwarder"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gvisor-tap-vsock-0.8.5-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc291eb473dd397cb30ba37938db41972bc28ba680a39c8fb816b276d416453e"

URI_gvisor-tap-vsock = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gvisor-tap-vsock-0.8.5-2.el10_0.x86_64_v2.rpm;name=gvisor-tap-vsock;unpack=0"
SRC_URI += "${URI_gvisor-tap-vsock}"
SRC_URI[gvisor-tap-vsock.sha256sum] = "e5073cd2a559260b30e1d3ce8ca22009290b1148ba5238b848fc509927596dc9"
RDEPENDS:gvisor-tap-vsock = " \
 glibc \
 gvisor-tap-vsock-gvforwarder \
"

URI_gvisor-tap-vsock-gvforwarder = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gvisor-tap-vsock-gvforwarder-0.8.5-2.el10_0.x86_64_v2.rpm;name=gvisor-tap-vsock-gvforwarder;unpack=0"
SRC_URI += "${URI_gvisor-tap-vsock-gvforwarder}"
SRC_URI[gvisor-tap-vsock-gvforwarder.sha256sum] = "4c9ad813f38f82e20a695eadd8cdd14766895cd658b96905127e84e141a98a4c"
RDEPENDS:gvisor-tap-vsock-gvforwarder = " \
 glibc \
"
