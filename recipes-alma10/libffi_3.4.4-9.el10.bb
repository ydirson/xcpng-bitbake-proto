# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libffi"
PE = "0"
PV = "3.4.4"
PR = "9.el10"
PACKAGES = "libffi libffi-devel"
PROVIDES = "rpm/libffi rpm/libffi-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libffi-3.4.4-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f919f86ab2273a4874e6448627c569adb84a4c503689d9dd7a98f39ff8ad3a02"

URI_libffi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libffi-3.4.4-9.el10.x86_64_v2.rpm;name=libffi;unpack=0"
SRC_URI += "${URI_libffi}"
SRC_URI[libffi.sha256sum] = "c76ec65a4e4fcb8e4aff0c382cbea2ea78655bc18126df671d210d70c525fea9"
RDEPENDS:libffi = " \
 glibc \
"

URI_libffi-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libffi-devel-3.4.4-9.el10.x86_64_v2.rpm;name=libffi-devel;unpack=0"
SRC_URI += "${URI_libffi-devel}"
SRC_URI[libffi-devel.sha256sum] = "a4e70cf5eb6988207bb68d77bc909f4741a919883e1d77d322d92aca4f83772d"
RDEPENDS:libffi-devel = " \
 libffi \
 pkgconf-pkg-config \
"
