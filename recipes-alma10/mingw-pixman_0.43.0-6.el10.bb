# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mingw-pixman"
PE = "0"
PV = "0.43.0"
PR = "6.el10"
PACKAGES = "mingw32-pixman mingw64-pixman mingw32-pixman-static mingw64-pixman-static"
PROVIDES = "rpm/mingw32-pixman rpm/mingw64-pixman rpm/mingw32-pixman-static rpm/mingw64-pixman-static"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/mingw-pixman-0.43.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a2b0c2b43f211b3e55e2a597be6ea65b2289e8e0136a27482f92b60340a9f31"

URI_mingw32-pixman = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw32-pixman-0.43.0-6.el10.noarch.rpm;name=mingw32-pixman;unpack=0"
SRC_URI += "${URI_mingw32-pixman}"
SRC_URI[mingw32-pixman.sha256sum] = "df64156812c13fbdb981bf92c9131f8d7ff9199238fb21ad02b4df4af29ad55e"
RDEPENDS:mingw32-pixman = " \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-libgcc \
"

URI_mingw64-pixman = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw64-pixman-0.43.0-6.el10.noarch.rpm;name=mingw64-pixman;unpack=0"
SRC_URI += "${URI_mingw64-pixman}"
SRC_URI[mingw64-pixman.sha256sum] = "95e6a65b28f505ec8c521e4d53f34a56c8bcda892d5fa542c483aae9dac90954"
RDEPENDS:mingw64-pixman = " \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-libgcc \
"

URI_mingw32-pixman-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mingw32-pixman-static-0.43.0-6.el10.noarch.rpm;name=mingw32-pixman-static;unpack=0"
SRC_URI += "${URI_mingw32-pixman-static}"
SRC_URI[mingw32-pixman-static.sha256sum] = "48623345b497d83a82c39b225f7701fce6de082f13cef25c9efb1576d574986e"
RDEPENDS:mingw32-pixman-static = " \
 mingw32-pixman \
"

URI_mingw64-pixman-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mingw64-pixman-static-0.43.0-6.el10.noarch.rpm;name=mingw64-pixman-static;unpack=0"
SRC_URI += "${URI_mingw64-pixman-static}"
SRC_URI[mingw64-pixman-static.sha256sum] = "5c35a716ce12110896237f9ac949ef98b770aa429550edb308124bebf11d2f13"
RDEPENDS:mingw64-pixman-static = " \
 mingw64-pixman \
"
