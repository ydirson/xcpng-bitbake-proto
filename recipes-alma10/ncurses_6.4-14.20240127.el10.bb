# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ncurses"
PE = "0"
PV = "6.4"
PR = "14.20240127.el10"
PACKAGES = "ncurses ncurses-base ncurses-libs ncurses-c++-libs ncurses-devel ncurses-term ncurses-static"
PROVIDES = "rpm/ncurses rpm/ncurses-base rpm/ncurses-libs rpm/ncurses-c++-libs rpm/ncurses-devel rpm/ncurses-term rpm/ncurses-static"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/ncurses-6.4-14.20240127.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4f2d6593ef2bd6bfc7a2c9f0ae4659d3fc24a15a84041305aad3e99d2419593"

URI_ncurses = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/ncurses-6.4-14.20240127.el10.x86_64_v2.rpm;name=ncurses;unpack=0"
SRC_URI += "${URI_ncurses}"
SRC_URI[ncurses.sha256sum] = "7a4e0995bfc9f238743999de6e12d97ae82d184f756714cc5100fbfbfe0124a7"
RDEPENDS:ncurses = " \
 glibc \
 ncurses-libs \
"

URI_ncurses-base = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/ncurses-base-6.4-14.20240127.el10.noarch.rpm;name=ncurses-base;unpack=0"
SRC_URI += "${URI_ncurses-base}"
SRC_URI[ncurses-base.sha256sum] = "b02d6198626d507fe2a25e5b3e03065b50cbd5a2e6f4f469663856cb51907ed3"
RDEPENDS:ncurses-base = ""

URI_ncurses-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/ncurses-libs-6.4-14.20240127.el10.x86_64_v2.rpm;name=ncurses-libs;unpack=0"
SRC_URI += "${URI_ncurses-libs}"
SRC_URI[ncurses-libs.sha256sum] = "8a5282b6aa1febea5d7adbd33a81195fdb77375c80c6f611381620476e7fa693"
RDEPENDS:ncurses-libs = " \
 glibc \
 ncurses-base \
"

URI_ncurses-c++-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ncurses-c++-libs-6.4-14.20240127.el10.x86_64_v2.rpm;name=ncurses-c++-libs;unpack=0"
SRC_URI += "${URI_ncurses-c++-libs}"
SRC_URI[ncurses-c++-libs.sha256sum] = "f6b8be082471d259020c1707656db664c2631f6aef94e7f52ff6d9fb9b7e25b4"
RDEPENDS:ncurses-c++-libs = " \
 glibc \
 libgcc \
 ncurses-libs \
 libstdc++ \
"

URI_ncurses-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ncurses-devel-6.4-14.20240127.el10.x86_64_v2.rpm;name=ncurses-devel;unpack=0"
SRC_URI += "${URI_ncurses-devel}"
SRC_URI[ncurses-devel.sha256sum] = "464ea640ea01faf152ea2718456c8d9d1b76c9d86d4b59b6292fbe17c45cddef"
RDEPENDS:ncurses-devel = " \
 ncurses-devel \
 pkgconf-pkg-config \
 ncurses-libs \
 bash \
 ncurses-c++-libs \
"

URI_ncurses-term = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ncurses-term-6.4-14.20240127.el10.noarch.rpm;name=ncurses-term;unpack=0"
SRC_URI += "${URI_ncurses-term}"
SRC_URI[ncurses-term.sha256sum] = "6dc263325cae6f91f7e93cfbdacaf48bc82d6ccf57d40b55b9dfa1703645d6a5"
RDEPENDS:ncurses-term = " \
 ncurses-base \
"

URI_ncurses-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ncurses-static-6.4-14.20240127.el10.x86_64_v2.rpm;name=ncurses-static;unpack=0"
SRC_URI += "${URI_ncurses-static}"
SRC_URI[ncurses-static.sha256sum] = "24d5672519608d3a231ebd6345741f80e348d13dffb33f7745d9d64cfcbb1824"
RDEPENDS:ncurses-static = " \
 ncurses-devel \
"
