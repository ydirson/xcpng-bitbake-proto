# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "coreutils"
PE = "0"
PV = "9.5"
PR = "6.el10"
PACKAGES = "coreutils coreutils-common coreutils-single"
PROVIDES = "rpm/coreutils rpm/coreutils-common rpm/coreutils-single"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/coreutils-9.5-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e75d8b0917806f17e46a454e0a150188f7dcddf4f8a99a2949836ac9d18859e"

URI_coreutils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/coreutils-9.5-6.el10.x86_64_v2.rpm;name=coreutils;unpack=0"
SRC_URI += "${URI_coreutils}"
SRC_URI[coreutils.sha256sum] = "7fda6a0eaf8837cc26f5c52892a97d57b8e28fc2829f180bdcb06f18bda56b90"
RDEPENDS:coreutils = " \
 libacl \
 gmp \
 libattr \
 openssl-libs \
 libcap \
 glibc \
 libselinux \
 coreutils-common \
"

URI_coreutils-common = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/coreutils-common-9.5-6.el10.x86_64_v2.rpm;name=coreutils-common;unpack=0"
SRC_URI += "${URI_coreutils-common}"
SRC_URI[coreutils-common.sha256sum] = "8bbf741a9df35da2147170ea623988bd8fde307f36da28b912c2049e88db3fbd"
RDEPENDS:coreutils-common = ""

URI_coreutils-single = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/coreutils-single-9.5-6.el10.x86_64_v2.rpm;name=coreutils-single;unpack=0"
SRC_URI += "${URI_coreutils-single}"
SRC_URI[coreutils-single.sha256sum] = "1580f14bbeb180c309ece5d82e40dffec2b60088cfb021dc7c0b3a8915bb9e23"
RDEPENDS:coreutils-single = " \
 libacl \
 libattr \
 libcap \
 glibc \
 libselinux \
"
