# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Pod-Coverage"
PE = "0"
PV = "0.23"
PR = "36.el10"
PACKAGES = "perl-Pod-Coverage perl-Pod-Coverage-tests"
PROVIDES = "rpm/perl-Pod-Coverage rpm/perl-Pod-Coverage-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Pod-Coverage-0.23-36.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d89a3677a5d9949b8f4fbfe3218dd12040afe73fda8c4d8e527721a6a002544d"

URI_perl-Pod-Coverage = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Pod-Coverage-0.23-36.el10.noarch.rpm;name=perl-Pod-Coverage;unpack=0"
SRC_URI += "${URI_perl-Pod-Coverage}"
SRC_URI[perl-Pod-Coverage.sha256sum] = "1312fdeb24edcca2fccb24fe10a331181efef854465993afad4d17a395216de4"
RDEPENDS:perl-Pod-Coverage = " \
 perl-constant \
 perl-libs \
 perl-vars \
 perl-Pod-Coverage \
 perl-Pod-Parser \
 perl-Devel-Symdump \
 perl-B \
 perl-interpreter \
 perl-base \
"

URI_perl-Pod-Coverage-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Pod-Coverage-tests-0.23-36.el10.noarch.rpm;name=perl-Pod-Coverage-tests;unpack=0"
SRC_URI += "${URI_perl-Pod-Coverage-tests}"
SRC_URI[perl-Pod-Coverage-tests.sha256sum] = "de88c81c72e66e874fd1bc5f9716180497c7de6c8aebffdfbeb372259e9896a9"
RDEPENDS:perl-Pod-Coverage-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-vars \
 perl-Pod-Coverage \
 bash \
 perl-base \
 perl-interpreter \
 perl-Exporter \
 perl-lib \
"
