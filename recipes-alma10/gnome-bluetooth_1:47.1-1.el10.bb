# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-bluetooth"
PE = "1"
PV = "47.1"
PR = "1.el10"
PACKAGES = "gnome-bluetooth gnome-bluetooth-libs gnome-bluetooth-libs-devel"
PROVIDES = "rpm/gnome-bluetooth rpm/gnome-bluetooth-libs rpm/gnome-bluetooth-libs-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-bluetooth-47.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "975dd5aee7b33ca13f1b129f2c75aa986684de18e04c90320211762ff291cc9e"

URI_gnome-bluetooth = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-bluetooth-47.1-1.el10.x86_64_v2.rpm;name=gnome-bluetooth;unpack=0"
SRC_URI += "${URI_gnome-bluetooth}"
SRC_URI[gnome-bluetooth.sha256sum] = "bdf80325cf01c79b8fa410d1956c01e39046b53edc2cae7f5e7d629ee22d673a"
RDEPENDS:gnome-bluetooth = " \
 gnome-bluetooth-libs \
 bluez \
 libgcc \
 bluez-obexd \
 pipewire-pulseaudio \
 glib2 \
 glibc \
 gtk4 \
 libadwaita \
"

URI_gnome-bluetooth-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-bluetooth-libs-47.1-1.el10.x86_64_v2.rpm;name=gnome-bluetooth-libs;unpack=0"
SRC_URI += "${URI_gnome-bluetooth-libs}"
SRC_URI[gnome-bluetooth-libs.sha256sum] = "309e172d91f17bf9555ae5a6a9b91f9a1664d986a775570621a9eb62412b0801"
RDEPENDS:gnome-bluetooth-libs = " \
 systemd-libs \
 gsound \
 libgcc \
 glib2 \
 upower-libs \
 glibc \
 gtk4 \
 libadwaita \
 libnotify \
"

URI_gnome-bluetooth-libs-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gnome-bluetooth-libs-devel-47.1-1.el10.x86_64_v2.rpm;name=gnome-bluetooth-libs-devel;unpack=0"
SRC_URI += "${URI_gnome-bluetooth-libs-devel}"
SRC_URI[gnome-bluetooth-libs-devel.sha256sum] = "3df7934228d0b7b4f95b754b66083de2360e4482fe4cbea644332eea4fa092f2"
RDEPENDS:gnome-bluetooth-libs-devel = " \
 gnome-bluetooth-libs \
 glib2-devel \
 pkgconf-pkg-config \
 libadwaita-devel \
 gtk4-devel \
 gnome-bluetooth \
"
