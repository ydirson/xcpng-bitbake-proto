# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tix"
PE = "1"
PV = "8.4.3"
PR = "42.el10"
PACKAGES = "tix tix-devel tix-doc"
PROVIDES = "rpm/tix rpm/tix-devel rpm/tix-doc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/tix-8.4.3-42.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "337a430a664a5653eacca8247e2d71e9fb380291683eea4537a2cabfafa13941"

URI_tix = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/tix-8.4.3-42.el10.x86_64_v2.rpm;name=tix;unpack=0"
SRC_URI += "${URI_tix}"
SRC_URI[tix.sha256sum] = "94a521d2aaa9812bde2dd907165b90cb071940cc49d98459708cee195d3d6e7c"
RDEPENDS:tix = " \
 glibc \
 tk \
 libX11 \
 tcl \
"

URI_tix-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/tix-devel-8.4.3-42.el10.x86_64_v2.rpm;name=tix-devel;unpack=0"
SRC_URI += "${URI_tix-devel}"
SRC_URI[tix-devel.sha256sum] = "eff0b06842dbbe083e265885f71fed70bed0bbacaa29d311c433ecf233c7d42f"
RDEPENDS:tix-devel = " \
 tix \
"

URI_tix-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/tix-doc-8.4.3-42.el10.x86_64_v2.rpm;name=tix-doc;unpack=0"
SRC_URI += "${URI_tix-doc}"
SRC_URI[tix-doc.sha256sum] = "3af634761b0ce5f018bfff2c827a7fa3f1ace29c75b999f8d4cc12bed38a49d8"
RDEPENDS:tix-doc = " \
 tix \
"
