# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pyusb"
PE = "0"
PV = "1.2.1"
PR = "11.el10"
PACKAGES = "python3-pyusb"
PROVIDES = "rpm/python3-pyusb"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/pyusb-1.2.1-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be635740d69762216e3be55690a10da35fffc47b07f48e272b5358915be12c17"

URI_python3-pyusb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-pyusb-1.2.1-11.el10.noarch.rpm;name=python3-pyusb;unpack=0"
SRC_URI += "${URI_python3-pyusb}"
SRC_URI[python3-pyusb.sha256sum] = "374bf9c3fa87947df85dd0a8a701e26a7609aed6a558fd07c036cbd2495e6f9b"
RDEPENDS:python3-pyusb = " \
 python3 \
 libusb1 \
"
