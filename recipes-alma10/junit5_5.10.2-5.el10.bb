# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "junit5"
PE = "0"
PV = "5.10.2"
PR = "5.el10"
PACKAGES = "junit5 junit5-guide junit5-javadoc"
PROVIDES = "rpm/junit5 rpm/junit5-guide rpm/junit5-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/junit5-5.10.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dcb0cd65c486c9a77bb6fb59fca226923a1db714e8793fb7aae15683f71e345c"

URI_junit5 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/junit5-5.10.2-5.el10.noarch.rpm;name=junit5;unpack=0"
SRC_URI += "${URI_junit5}"
SRC_URI[junit5.sha256sum] = "35d98c412c9266cbd4e95ced39260b86fc63cd64ecb1a07ba1572ce966ca6afd"
RDEPENDS:junit5 = " \
 junit \
 javapackages-filesystem \
 univocity-parsers \
 opentest4j \
 assertj-core \
"

URI_junit5-guide = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/junit5-guide-5.10.2-5.el10.noarch.rpm;name=junit5-guide;unpack=0"
SRC_URI += "${URI_junit5-guide}"
SRC_URI[junit5-guide.sha256sum] = "a5ba91e6a8e76bce329ce27c9347f6430acfefb14a04acacf07c92c7e4184b6e"
RDEPENDS:junit5-guide = " \
 junit5-javadoc \
"

URI_junit5-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/junit5-javadoc-5.10.2-5.el10.noarch.rpm;name=junit5-javadoc;unpack=0"
SRC_URI += "${URI_junit5-javadoc}"
SRC_URI[junit5-javadoc.sha256sum] = "69842aa0b0d62c5b90951724dd7f24bc32ebe0ff89359ac8b3565e12bcb710e8"
RDEPENDS:junit5-javadoc = " \
 javapackages-filesystem \
"
