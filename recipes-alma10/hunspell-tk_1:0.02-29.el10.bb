# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-tk"
PE = "1"
PV = "0.02"
PR = "29.el10"
PACKAGES = "hunspell-tk"
PROVIDES = "rpm/hunspell-tk"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-tk-0.02-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78549690750043e3ff659e98da13207a33485a6996f40d5d58d831a82d9741a5"

URI_hunspell-tk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-tk-0.02-29.el10.noarch.rpm;name=hunspell-tk;unpack=0"
SRC_URI += "${URI_hunspell-tk}"
SRC_URI[hunspell-tk.sha256sum] = "9a84f445c3835c451145464cbeef7e8408c649e0bb8324a4efdfa6eab13d8047"
RDEPENDS:hunspell-tk = " \
 hunspell-filesystem \
"
