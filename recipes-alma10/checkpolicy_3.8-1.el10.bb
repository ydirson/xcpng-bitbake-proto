# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "checkpolicy"
PE = "0"
PV = "3.8"
PR = "1.el10"
PACKAGES = "checkpolicy"
PROVIDES = "rpm/checkpolicy"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/checkpolicy-3.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15a4aa51ffee351b7fcfe81e271276e003dd71994ea351732feba449263e7e52"

URI_checkpolicy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/checkpolicy-3.8-1.el10.x86_64_v2.rpm;name=checkpolicy;unpack=0"
SRC_URI += "${URI_checkpolicy}"
SRC_URI[checkpolicy.sha256sum] = "1e438aa0ef5f7bfa5e21b2c7dd84ef4b986f41d54af70a80979781ea715df9e8"
RDEPENDS:checkpolicy = " \
 glibc \
"
