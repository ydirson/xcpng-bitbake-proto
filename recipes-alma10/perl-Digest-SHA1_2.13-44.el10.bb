# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Digest-SHA1"
PE = "0"
PV = "2.13"
PR = "44.el10"
PACKAGES = "perl-Digest-SHA1 perl-Digest-SHA1-tests"
PROVIDES = "rpm/perl-Digest-SHA1 rpm/perl-Digest-SHA1-tests"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-Digest-SHA1-2.13-44.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0354cdb18240b5ca3992f8c92896109cd0a719c80a6b5e84b0c72a37a63b5e7"

URI_perl-Digest-SHA1 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Digest-SHA1-2.13-44.el10.x86_64_v2.rpm;name=perl-Digest-SHA1;unpack=0"
SRC_URI += "${URI_perl-Digest-SHA1}"
SRC_URI[perl-Digest-SHA1.sha256sum] = "e40ff0442e749c8dd29699e810faca80dd9c4daaf4b7dad302177ba808047bcc"
RDEPENDS:perl-Digest-SHA1 = " \
 perl-libs \
 perl-vars \
 perl-libs \
 perl-DynaLoader \
 glibc \
 perl-Exporter \
"

URI_perl-Digest-SHA1-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Digest-SHA1-tests-2.13-44.el10.x86_64_v2.rpm;name=perl-Digest-SHA1-tests;unpack=0"
SRC_URI += "${URI_perl-Digest-SHA1-tests}"
SRC_URI[perl-Digest-SHA1-tests.sha256sum] = "90a0da96ae6103dd4ce598b61687861e36b0b37c43620b40d5f100986069c8c4"
RDEPENDS:perl-Digest-SHA1-tests = " \
 perl-Test \
 perl-Test-Harness \
 perl-vars \
 bash \
 perl-Digest-SHA1 \
 perl-interpreter \
"
