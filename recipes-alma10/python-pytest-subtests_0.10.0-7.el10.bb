# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-pytest-subtests"
PE = "0"
PV = "0.10.0"
PR = "7.el10"
PACKAGES = "python3-pytest-subtests"
PROVIDES = "rpm/python3-pytest-subtests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/python-pytest-subtests-0.10.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14ed28953f33b487d3b1609fe5b0cf734595938e5e3152f29fd732a9acacdd4d"

URI_python3-pytest-subtests = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-pytest-subtests-0.10.0-7.el10.noarch.rpm;name=python3-pytest-subtests;unpack=0"
SRC_URI += "${URI_python3-pytest-subtests}"
SRC_URI[python3-pytest-subtests.sha256sum] = "cd8d3963f94b91d9ca64f0d280e90713acbc7445c3e13c88da3ba5a63cb0d10e"
RDEPENDS:python3-pytest-subtests = " \
 python3 \
 python3-attrs \
 python3-pytest \
"
