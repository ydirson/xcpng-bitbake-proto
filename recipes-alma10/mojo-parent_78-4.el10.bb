# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mojo-parent"
PE = "0"
PV = "78"
PR = "4.el10"
PACKAGES = "mojo-parent"
PROVIDES = "rpm/mojo-parent"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/mojo-parent-78-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f319441f514d363f70a5ddef4d3ac4ba5adf75bffc785524b2787ad9a0f0ec83"

URI_mojo-parent = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mojo-parent-78-4.el10.noarch.rpm;name=mojo-parent;unpack=0"
SRC_URI += "${URI_mojo-parent}"
SRC_URI[mojo-parent.sha256sum] = "ec1c3291df78c7025aefe22a01fdf3ec29fea03c662e836fbefc44376e086857"
RDEPENDS:mojo-parent = " \
 maven-assembly-plugin \
 javapackages-filesystem \
"
