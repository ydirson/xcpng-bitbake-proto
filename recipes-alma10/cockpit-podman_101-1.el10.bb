# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cockpit-podman"
PE = "0"
PV = "101"
PR = "1.el10"
PACKAGES = "cockpit-podman"
PROVIDES = "rpm/cockpit-podman"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/cockpit-podman-101-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3e06d2565b3dcfa31aaf23b4fff144108723c73c6c5dc82d771b6a659e6a90c"

URI_cockpit-podman = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cockpit-podman-101-1.el10.noarch.rpm;name=cockpit-podman;unpack=0"
SRC_URI += "${URI_cockpit-podman}"
SRC_URI[cockpit-podman.sha256sum] = "f5d89521d344997d6a693aebed0d1883814848590649e07319abc351c42f0516"
RDEPENDS:cockpit-podman = " \
 podman \
 cockpit-bridge \
"
