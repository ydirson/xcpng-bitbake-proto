# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "maven-filtering"
PE = "0"
PV = "3.3.1"
PR = "7.el10"
PACKAGES = "maven-filtering maven-filtering-javadoc"
PROVIDES = "rpm/maven-filtering rpm/maven-filtering-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/maven-filtering-3.3.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8fc11a6b8d24d088be5ee985c5771850fc2e4f9d31ff29a3b47da6d21d974a0e"

URI_maven-filtering = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-filtering-3.3.1-7.el10.noarch.rpm;name=maven-filtering;unpack=0"
SRC_URI += "${URI_maven-filtering}"
SRC_URI[maven-filtering.sha256sum] = "181d79503c6ab81296c467bc6261f37258abe839782ef0879ff5121cb15baf91"
RDEPENDS:maven-filtering = " \
 atinject \
 plexus-interpolation \
 apache-commons-io \
 plexus-utils \
 javapackages-filesystem \
 plexus-build-api0 \
 slf4j \
"

URI_maven-filtering-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-filtering-javadoc-3.3.1-7.el10.noarch.rpm;name=maven-filtering-javadoc;unpack=0"
SRC_URI += "${URI_maven-filtering-javadoc}"
SRC_URI[maven-filtering-javadoc.sha256sum] = "44ebdd8bde0ed4d98c03bf7144adbac31cc2e1c80bbd1c4c11053a90fb87fe28"
RDEPENDS:maven-filtering-javadoc = " \
 javapackages-filesystem \
"
