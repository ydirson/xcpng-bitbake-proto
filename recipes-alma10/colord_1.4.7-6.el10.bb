# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "colord"
PE = "0"
PV = "1.4.7"
PR = "6.el10"
PACKAGES = "colord colord-libs colord-devel colord-devel-docs colord-extra-profiles colord-tests"
PROVIDES = "rpm/colord rpm/colord-libs rpm/colord-devel rpm/colord-devel-docs rpm/colord-extra-profiles rpm/colord-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/colord-1.4.7-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8e2fc08d2a25a61343184ceec844939fa2472d3e5f48c2467f3bab12e204690"

URI_colord = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/colord-1.4.7-6.el10.x86_64_v2.rpm;name=colord;unpack=0"
SRC_URI += "${URI_colord}"
SRC_URI[colord.sha256sum] = "aff8d712471ec9ab8ea1b0b76b48fc839ef432da8b560d3195a16233de102198"
RDEPENDS:colord = " \
 shadow-utils \
 systemd \
 systemd-libs \
 lcms2 \
 libgcc \
 libgudev \
 sqlite-libs \
 libgusb \
 polkit-libs \
 bash \
 glib2 \
 colord-libs \
 color-filesystem \
 glibc \
"

URI_colord-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/colord-libs-1.4.7-6.el10.x86_64_v2.rpm;name=colord-libs;unpack=0"
SRC_URI += "${URI_colord-libs}"
SRC_URI[colord-libs.sha256sum] = "c99fa827e465b1588957555047441b0973c8cf56d213b4cddcd8ba4fcdb61fa5"
RDEPENDS:colord-libs = " \
 lcms2 \
 systemd-libs \
 libgcc \
 libgusb \
 glib2 \
 glibc \
"

URI_colord-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/colord-devel-1.4.7-6.el10.x86_64_v2.rpm;name=colord-devel;unpack=0"
SRC_URI += "${URI_colord-devel}"
SRC_URI[colord-devel.sha256sum] = "4407191d25a5612ef507e0c4682c21c5756b26c0a5bf9c11a994f9db9efd6573"
RDEPENDS:colord-devel = " \
 glib2-devel \
 colord-devel \
 pkgconf-pkg-config \
 libgusb-devel \
 colord \
 colord-libs \
"

URI_colord-devel-docs = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/colord-devel-docs-1.4.7-6.el10.noarch.rpm;name=colord-devel-docs;unpack=0"
SRC_URI += "${URI_colord-devel-docs}"
SRC_URI[colord-devel-docs.sha256sum] = "c74eed313e24bee4acd1f7f4af65c77073f2d3024790247bc98c542c5de5f70e"
RDEPENDS:colord-devel-docs = " \
 colord \
"

URI_colord-extra-profiles = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/colord-extra-profiles-1.4.7-6.el10.noarch.rpm;name=colord-extra-profiles;unpack=0"
SRC_URI += "${URI_colord-extra-profiles}"
SRC_URI[colord-extra-profiles.sha256sum] = "f94433482026a0ae837c5701f2b44023f93dc5782f7fa70beb02a3925df42db9"
RDEPENDS:colord-extra-profiles = " \
 colord \
"

URI_colord-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/colord-tests-1.4.7-6.el10.x86_64_v2.rpm;name=colord-tests;unpack=0"
SRC_URI += "${URI_colord-tests}"
SRC_URI[colord-tests.sha256sum] = "57af2dcec461f8591d35f892fe23fde7dfbc4dd2026c743c6f89155b484ada2d"
RDEPENDS:colord-tests = " \
 lcms2 \
 libgcc \
 glib2 \
 colord-libs \
 glibc \
"
