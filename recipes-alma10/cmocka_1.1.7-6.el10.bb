# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cmocka"
PE = "0"
PV = "1.1.7"
PR = "6.el10"
PACKAGES = "libcmocka libcmocka-devel cmocka-doc"
PROVIDES = "rpm/libcmocka rpm/libcmocka-devel rpm/cmocka-doc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/cmocka-1.1.7-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbcf0dc3e9ab68ffe30395c3e3b69c1585925d3878f02b2594f48066e9ebe985"

URI_libcmocka = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libcmocka-1.1.7-6.el10.x86_64_v2.rpm;name=libcmocka;unpack=0"
SRC_URI += "${URI_libcmocka}"
SRC_URI[libcmocka.sha256sum] = "79b36696d618399a77466ab3d0f64dbbd0c7c860c80a4bca63b7fe602917031c"
RDEPENDS:libcmocka = " \
 glibc \
"

URI_libcmocka-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libcmocka-devel-1.1.7-6.el10.x86_64_v2.rpm;name=libcmocka-devel;unpack=0"
SRC_URI += "${URI_libcmocka-devel}"
SRC_URI[libcmocka-devel.sha256sum] = "40b1d11229aee661c02ee4d51d674fc36d67af0df2ed9de50ac0e824764ebe99"
RDEPENDS:libcmocka-devel = " \
 libcmocka \
 cmake-filesystem \
 pkgconf-pkg-config \
"

URI_cmocka-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/cmocka-doc-1.1.7-6.el10.noarch.rpm;name=cmocka-doc;unpack=0"
SRC_URI += "${URI_cmocka-doc}"
SRC_URI[cmocka-doc.sha256sum] = "306fc88f7d592f7d8ad71ceb3b2304fa9d1c7efc3dbd0fde9580b677db330862"
RDEPENDS:cmocka-doc = ""
