# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "nss_wrapper"
PE = "0"
PV = "1.1.15"
PR = "7.el10"
PACKAGES = "nss_wrapper nss_wrapper-libs"
PROVIDES = "rpm/nss_wrapper rpm/nss_wrapper-libs"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/nss_wrapper-1.1.15-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0a24d7337ffe9883687d6c92ed9280002bfe66037e60c695cfaa761c3f7b7c3"

URI_nss_wrapper = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nss_wrapper-1.1.15-7.el10.x86_64_v2.rpm;name=nss_wrapper;unpack=0"
SRC_URI += "${URI_nss_wrapper}"
SRC_URI[nss_wrapper.sha256sum] = "58e10ca4722de500f92982da14a5da856b43b143d1077a7b9f3cece7a53cb3fc"
RDEPENDS:nss_wrapper = " \
 cmake-filesystem \
 perl-libs \
 pkgconf-pkg-config \
 perl-Getopt-Long \
 perl-PathTools \
 nss_wrapper-libs \
 perl-interpreter \
"

URI_nss_wrapper-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nss_wrapper-libs-1.1.15-7.el10.x86_64_v2.rpm;name=nss_wrapper-libs;unpack=0"
SRC_URI += "${URI_nss_wrapper-libs}"
SRC_URI[nss_wrapper-libs.sha256sum] = "35566c2503c168002180ec58e8a2bba1905e7cc5b2a996030724c2e7ead83071"
RDEPENDS:nss_wrapper-libs = " \
 glibc \
"
