# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "google-noto-serif-cjk-vf-fonts"
PE = "1"
PV = "2.002"
PR = "6.el10"
PACKAGES = "google-noto-serif-cjk-vf-fonts"
PROVIDES = "rpm/google-noto-serif-cjk-vf-fonts"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/google-noto-serif-cjk-vf-fonts-2.002-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eadd75b250b6ab941403771908bbc31569ae9f60728431ad876716ef7adcf6a0"

URI_google-noto-serif-cjk-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-cjk-vf-fonts-2.002-6.el10.noarch.rpm;name=google-noto-serif-cjk-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-cjk-vf-fonts}"
SRC_URI[google-noto-serif-cjk-vf-fonts.sha256sum] = "0a278cd1bc3aefed34cca57cc420f974cfff8b4b993cd41bbb653dd4c9474f85"
RDEPENDS:google-noto-serif-cjk-vf-fonts = " \
 fonts-filesystem \
"
