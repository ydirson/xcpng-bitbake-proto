# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-augeas"
PE = "0"
PV = "1.1.0"
PR = "14.el10"
PACKAGES = "python3-augeas"
PROVIDES = "rpm/python3-augeas"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-augeas-1.1.0-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6b19d214c9016a0afb86ef9a9a599d71cedc9e69f056ce2fafed3eeee07bf1d"

URI_python3-augeas = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-augeas-1.1.0-14.el10.noarch.rpm;name=python3-augeas;unpack=0"
SRC_URI += "${URI_python3-augeas}"
SRC_URI[python3-augeas.sha256sum] = "835df9445dcc8dfef16e01ae0a3445b9bd0e63fb1216e2c49b0009674d6e25d5"
RDEPENDS:python3-augeas = " \
 python3 \
 python3-cffi \
 augeas-libs \
"
