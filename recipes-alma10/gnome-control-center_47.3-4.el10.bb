# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-control-center"
PE = "0"
PV = "47.3"
PR = "4.el10"
PACKAGES = "gnome-control-center gnome-control-center-filesystem"
PROVIDES = "rpm/gnome-control-center rpm/gnome-control-center-filesystem"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-control-center-47.3-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5bdb15028d170348bd07dc4dc4880c725db5ef5eeb95aca7fb64d1e3b7a4ea42"

URI_gnome-control-center = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-control-center-47.3-4.el10.x86_64_v2.rpm;name=gnome-control-center;unpack=0"
SRC_URI += "${URI_gnome-control-center}"
SRC_URI[gnome-control-center.sha256sum] = "186eba7479fff3dfcb938063a0829e47514b2b1a727d52a526bebf37633d71db"
RDEPENDS:gnome-control-center = " \
 ModemManager-glib \
 libpwquality \
 cups-libs \
 pango \
 fontconfig \
 libX11 \
 krb5-libs \
 libudisks2 \
 dbus \
 upower-libs \
 ibus-libs \
 upower \
 NetworkManager-libnm \
 libnma-gtk4 \
 gnome-bluetooth-libs \
 libsmbclient \
 cups-pk-helper \
 libXi \
 accountsservice \
 accountsservice-libs \
 tecla \
 libepoxy \
 gnome-desktop4 \
 gnome-control-center-filesystem \
 json-glib \
 cairo \
 gnome-online-accounts \
 libadwaita \
 gcr-libs \
 alsa-lib \
 gnome-settings-daemon \
 libwacom \
 gnutls \
 pulseaudio-libs \
 libgcc \
 pulseaudio-libs-glib2 \
 libxml2 \
 gdk-pixbuf2 \
 libgudev \
 libsecret \
 libgtop2 \
 graphene \
 libsoup3 \
 gsound \
 gsettings-desktop-schemas \
 pkgconf-pkg-config \
 polkit-libs \
 colord \
 glib2 \
 colord-libs \
 colord-gtk4 \
 glibc \
 gtk4 \
 iso-codes \
"

URI_gnome-control-center-filesystem = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-control-center-filesystem-47.3-4.el10.noarch.rpm;name=gnome-control-center-filesystem;unpack=0"
SRC_URI += "${URI_gnome-control-center-filesystem}"
SRC_URI[gnome-control-center-filesystem.sha256sum] = "045900891b4af093bf3183bfc620c5a97e5228076f692ebec5e2c7360969a25f"
RDEPENDS:gnome-control-center-filesystem = ""
