# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "kyotocabinet"
PE = "0"
PV = "1.2.80"
PR = "7.el10"
PACKAGES = "kyotocabinet-libs kyotocabinet kyotocabinet-apidocs kyotocabinet-devel"
PROVIDES = "rpm/kyotocabinet-libs rpm/kyotocabinet rpm/kyotocabinet-apidocs rpm/kyotocabinet-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/kyotocabinet-1.2.80-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b16b26daf9475e4cdde56e3907d9816540beb18894a73a5b4358103c9787da3"

URI_kyotocabinet-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/kyotocabinet-libs-1.2.80-7.el10.x86_64_v2.rpm;name=kyotocabinet-libs;unpack=0"
SRC_URI += "${URI_kyotocabinet-libs}"
SRC_URI[kyotocabinet-libs.sha256sum] = "b8ea964954a2c0a7de6f2e9f1ee7823330612dc7b06e436cf93091d1affb61a5"
RDEPENDS:kyotocabinet-libs = " \
 zlib-ng-compat \
 lzo \
 libgcc \
 libstdc++ \
 glibc \
 xz-libs \
"

URI_kyotocabinet = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/kyotocabinet-1.2.80-7.el10.x86_64_v2.rpm;name=kyotocabinet;unpack=0"
SRC_URI += "${URI_kyotocabinet}"
SRC_URI[kyotocabinet.sha256sum] = "c6ea0de6248a2db59558c79645d27ab9f0479a0631af93af313b959494282311"
RDEPENDS:kyotocabinet = " \
 glibc \
 libgcc \
 kyotocabinet-libs \
 libstdc++ \
"

URI_kyotocabinet-apidocs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/kyotocabinet-apidocs-1.2.80-7.el10.noarch.rpm;name=kyotocabinet-apidocs;unpack=0"
SRC_URI += "${URI_kyotocabinet-apidocs}"
SRC_URI[kyotocabinet-apidocs.sha256sum] = "498b46f6e28342f45927d524db8e932de408aa556c0f98e0597bedb32d3015f8"
RDEPENDS:kyotocabinet-apidocs = ""

URI_kyotocabinet-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/kyotocabinet-devel-1.2.80-7.el10.x86_64_v2.rpm;name=kyotocabinet-devel;unpack=0"
SRC_URI += "${URI_kyotocabinet-devel}"
SRC_URI[kyotocabinet-devel.sha256sum] = "8d6297d9bac78213eb735a862a90b5369160c05b05afc2f75f3ba7a90950c66f"
RDEPENDS:kyotocabinet-devel = " \
 kyotocabinet-libs \
 pkgconf-pkg-config \
"
