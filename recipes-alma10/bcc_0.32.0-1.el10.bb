# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "bcc"
PE = "0"
PV = "0.32.0"
PR = "1.el10"
PACKAGES = "bcc bcc-tools libbpf-tools python3-bcc bcc-devel bcc-doc"
PROVIDES = "rpm/bcc rpm/bcc-tools rpm/libbpf-tools rpm/python3-bcc rpm/bcc-devel rpm/bcc-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/bcc-0.32.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d87f2bdcbffc7d3bf1bb5cae4c564bb7895e8df91e00f984168a9e6bce3ee045"

URI_bcc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/bcc-0.32.0-1.el10.x86_64_v2.rpm;name=bcc;unpack=0"
SRC_URI += "${URI_bcc}"
SRC_URI[bcc.sha256sum] = "d8082b523d3aca00e39380c9f7c8fd0bfe45c821c4bb9ea785343718a88eac93"
RDEPENDS:bcc = " \
 elfutils-debuginfod-client \
 libgcc \
 libbpf \
 tar \
 elfutils-libelf \
 clang-libs \
 libstdc++ \
 glibc \
 llvm-libs \
 xz-libs \
"

URI_bcc-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/bcc-tools-0.32.0-1.el10.x86_64_v2.rpm;name=bcc-tools;unpack=0"
SRC_URI += "${URI_bcc-tools}"
SRC_URI[bcc-tools.sha256sum] = "c158e89b04f955b117ed7b0162cfa021d5bd696d7a1baa48df4590bc41faa7df"
RDEPENDS:bcc-tools = " \
 python3 \
 python3-bcc \
 libbpf \
 bash \
 bcc \
 glibc \
 python3-netaddr \
"

URI_libbpf-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libbpf-tools-0.32.0-1.el10.x86_64_v2.rpm;name=libbpf-tools;unpack=0"
SRC_URI += "${URI_libbpf-tools}"
SRC_URI[libbpf-tools.sha256sum] = "0e7487eebbe938ccb8d39a060fe2704ec0de9ef3c8c23bcfda877aea127de6ec"
RDEPENDS:libbpf-tools = " \
 glibc \
 zlib-ng-compat \
 elfutils-libelf \
"

URI_python3-bcc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-bcc-0.32.0-1.el10.noarch.rpm;name=python3-bcc;unpack=0"
SRC_URI += "${URI_python3-bcc}"
SRC_URI[python3-bcc.sha256sum] = "f08ad77d4dc1f72841b161aa6241268bf76c8121566907b96023cac6ecd5d092"
RDEPENDS:python3-bcc = " \
 python3 \
 bcc \
"

URI_bcc-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/bcc-devel-0.32.0-1.el10.x86_64_v2.rpm;name=bcc-devel;unpack=0"
SRC_URI += "${URI_bcc-devel}"
SRC_URI[bcc-devel.sha256sum] = "a09a5a164ca6cb8baf9b9b470ca1bb85c8a3ec0e39f858397192dc4ccdadbfb4"
RDEPENDS:bcc-devel = " \
 pkgconf-pkg-config \
 bcc \
"

URI_bcc-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/bcc-doc-0.32.0-1.el10.noarch.rpm;name=bcc-doc;unpack=0"
SRC_URI += "${URI_bcc-doc}"
SRC_URI[bcc-doc.sha256sum] = "717e63db7f3ad0dfae4b88a02e565ebf7d713089badad7be7150c46381e29aac"
RDEPENDS:bcc-doc = ""
