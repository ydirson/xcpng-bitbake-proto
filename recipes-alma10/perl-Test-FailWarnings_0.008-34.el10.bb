# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Test-FailWarnings"
PE = "0"
PV = "0.008"
PR = "34.el10"
PACKAGES = "perl-Test-FailWarnings"
PROVIDES = "rpm/perl-Test-FailWarnings"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-Test-FailWarnings-0.008-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2ccf6348270fec54490b3697893e22b30df957bf267940b5a17989720424b25"

URI_perl-Test-FailWarnings = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Test-FailWarnings-0.008-34.el10.noarch.rpm;name=perl-Test-FailWarnings;unpack=0"
SRC_URI += "${URI_perl-Test-FailWarnings}"
SRC_URI[perl-Test-FailWarnings.sha256sum] = "197ed92754d24be8404dd5a00fa68571a2203acf97e9eef42f1cfadc17dde490"
RDEPENDS:perl-Test-FailWarnings = " \
 perl-PathTools \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
"
