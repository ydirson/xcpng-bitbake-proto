# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "shim"
PE = "0"
PV = "15.8"
PR = "5.el10_0.alma.1"
PACKAGES = "shim-x64"
PROVIDES = "rpm/shim-x64"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/shim-15.8-5.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32c0094e1531b12c47892fdf485d82036bee6ede001c66713b2a508df86c7f43"

URI_shim-x64 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/shim-x64-15.8-5.el10_0.alma.1.x86_64_v2.rpm;name=shim-x64;unpack=0"
SRC_URI += "${URI_shim-x64}"
SRC_URI[shim-x64.sha256sum] = "35e95d08c2d3ce7da90c38ace20f2c730a06ef7439a630536a5c570ad0622c73"
RDEPENDS:shim-x64 = " \
 fwupd \
 mokutil \
 efi-filesystem \
"
