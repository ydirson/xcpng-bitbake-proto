# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libqb"
PE = "0"
PV = "2.0.8"
PR = "6.el10"
PACKAGES = "libqb doxygen2man"
PROVIDES = "rpm/libqb rpm/doxygen2man"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libqb-2.0.8-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa8b67201d44bfd3ba38aa0ff303143f83cd28fad8d81aef0d950ba3c754840c"

URI_libqb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libqb-2.0.8-6.el10.x86_64_v2.rpm;name=libqb;unpack=0"
SRC_URI += "${URI_libqb}"
SRC_URI[libqb.sha256sum] = "33033d0dc3de2cc3321244c00a6e56a8c4cc72327b510b297243a28ca265e4e4"
RDEPENDS:libqb = " \
 glibc \
"

URI_doxygen2man = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/doxygen2man-2.0.8-6.el10.x86_64_v2.rpm;name=doxygen2man;unpack=0"
SRC_URI += "${URI_doxygen2man}"
SRC_URI[doxygen2man.sha256sum] = "88f5f385ab9b67c85edf34ba5e89665f8e3f4868d253fca3aeccf563b99203fd"
RDEPENDS:doxygen2man = " \
 glibc \
 libxml2 \
 libqb \
"
