# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "yara"
PE = "0"
PV = "4.5.2"
PR = "2.el10"
PACKAGES = "yara yara-devel yara-doc"
PROVIDES = "rpm/yara rpm/yara-devel rpm/yara-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/yara-4.5.2-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85768e0f243ceb078acddde33ff21ce763b936c3c257b92549673186e94548a8"

URI_yara = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/yara-4.5.2-2.el10.x86_64_v2.rpm;name=yara;unpack=0"
SRC_URI += "${URI_yara}"
SRC_URI[yara.sha256sum] = "cd0546e52b8f09db556fc1ce2ddcb6f7eb14a155aaa43badb87d498134580b11"
RDEPENDS:yara = " \
 jansson \
 openssl-libs \
 glibc \
 protobuf-c \
 file-libs \
"

URI_yara-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/yara-devel-4.5.2-2.el10.x86_64_v2.rpm;name=yara-devel;unpack=0"
SRC_URI += "${URI_yara-devel}"
SRC_URI[yara-devel.sha256sum] = "283e7ca086569dc4ff02828b34904190cbcc1a026cac9d6c5cd02e2b7ba902ae"
RDEPENDS:yara-devel = " \
 yara \
 pkgconf-pkg-config \
 openssl-devel \
 jansson-devel \
 protobuf-c-devel \
"

URI_yara-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/yara-doc-4.5.2-2.el10.noarch.rpm;name=yara-doc;unpack=0"
SRC_URI += "${URI_yara-doc}"
SRC_URI[yara-doc.sha256sum] = "7d8bddceb5cdc8339890ecd49035b0246d2d4833eb9aa355b51d2c5ae88a7985"
RDEPENDS:yara-doc = ""
