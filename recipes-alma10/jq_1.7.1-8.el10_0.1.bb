# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jq"
PE = "0"
PV = "1.7.1"
PR = "8.el10_0.1"
PACKAGES = "jq jq-devel"
PROVIDES = "rpm/jq rpm/jq-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/jq-1.7.1-8.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5fe717cd8aef5917ffb19b131d1fce0038011c6b238555be863977a7061b053"

URI_jq = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/jq-1.7.1-8.el10_0.1.x86_64_v2.rpm;name=jq;unpack=0"
SRC_URI += "${URI_jq}"
SRC_URI[jq.sha256sum] = "52904b1888d3ddb16602c27fcdce95f92b0c0592323d36359cfe03184ef24ba1"
RDEPENDS:jq = " \
 glibc \
 oniguruma \
"

URI_jq-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jq-devel-1.7.1-8.el10_0.1.x86_64_v2.rpm;name=jq-devel;unpack=0"
SRC_URI += "${URI_jq-devel}"
SRC_URI[jq-devel.sha256sum] = "0a49b6f2d1f4e1292afbf149bf4dfb6c46ddb1aaa4979280a27af991ad66999a"
RDEPENDS:jq-devel = " \
 jq \
 pkgconf-pkg-config \
"
