# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tmpwatch"
PE = "0"
PV = "2.11"
PR = "28.el10"
PACKAGES = "tmpwatch"
PROVIDES = "rpm/tmpwatch"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tmpwatch-2.11-28.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "488f092e429f652ef8f0f0ac8ef7718c9a99a63a2fa829a9e8ab59ba35925a8e"

URI_tmpwatch = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tmpwatch-2.11-28.el10.x86_64_v2.rpm;name=tmpwatch;unpack=0"
SRC_URI += "${URI_tmpwatch}"
SRC_URI[tmpwatch.sha256sum] = "5e893b2464c60a98e8063257bc59d0f0b60b6a86641368e085929d6b4a6b7d16"
RDEPENDS:tmpwatch = " \
 glibc \
 psmisc \
"
