# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "udev-hid-bpf"
PE = "0"
PV = "2.1.0.20240704"
PR = "5.el10"
PACKAGES = "udev-hid-bpf udev-hid-bpf-stable"
PROVIDES = "rpm/udev-hid-bpf rpm/udev-hid-bpf-stable"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/udev-hid-bpf-2.1.0.20240704-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65b31cbeecac15e8c3852039f3125042654c51a8b2f89d27da7180a7ac887468"

URI_udev-hid-bpf = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/udev-hid-bpf-2.1.0.20240704-5.el10.x86_64_v2.rpm;name=udev-hid-bpf;unpack=0"
SRC_URI += "${URI_udev-hid-bpf}"
SRC_URI[udev-hid-bpf.sha256sum] = "fccec0b11bfdfcaa59c55819798d37edd83de9efc97c12e72ee90b868ef7e371"
RDEPENDS:udev-hid-bpf = " \
 zlib-ng-compat \
 systemd-libs \
 systemd-udev \
 libgcc \
 elfutils-libelf \
 glibc \
 udev-hid-bpf-stable \
"

URI_udev-hid-bpf-stable = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/udev-hid-bpf-stable-2.1.0.20240704-5.el10.x86_64_v2.rpm;name=udev-hid-bpf-stable;unpack=0"
SRC_URI += "${URI_udev-hid-bpf-stable}"
SRC_URI[udev-hid-bpf-stable.sha256sum] = "2ca64248c137170b4282c331218632b57f8b6aef5f6970ae737b6304d73f10ac"
RDEPENDS:udev-hid-bpf-stable = " \
 udev-hid-bpf \
"
