# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ksc"
PE = "0"
PV = "1.12"
PR = "7.git869a25c.el10"
PACKAGES = "ksc"
PROVIDES = "rpm/ksc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/ksc-1.12-7.git869a25c.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "caeb8abe1e3f20026c3de3091378afba566c11024bfc3b974cc8815568932054"

URI_ksc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ksc-1.12-7.git869a25c.el10.noarch.rpm;name=ksc;unpack=0"
SRC_URI += "${URI_ksc}"
SRC_URI[ksc.sha256sum] = "8be5d6ffadde49457a302c1a1b9f3d2b49d7099110430598ea9dcc5593964b62"
RDEPENDS:ksc = " \
 kmod \
 python3-requests \
 kernel-devel \
 binutils \
"
