# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "docbook-style-dsssl"
PE = "0"
PV = "1.79"
PR = "43.el10_0"
PACKAGES = "docbook-style-dsssl"
PROVIDES = "rpm/docbook-style-dsssl"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/docbook-style-dsssl-1.79-43.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7b7b1d1dc57628b85f50c839de19ad0346588e62d71298b79247ce99bcb233c"

URI_docbook-style-dsssl = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/docbook-style-dsssl-1.79-43.el10_0.noarch.rpm;name=docbook-style-dsssl;unpack=0"
SRC_URI += "${URI_docbook-style-dsssl}"
SRC_URI[docbook-style-dsssl.sha256sum] = "34062788b9aae30b9346ca38cd40a80fcf353361620fe98c1eb6facef463bf6f"
RDEPENDS:docbook-style-dsssl = " \
 sgml-common \
 perl-File-Basename \
 openjade \
 perl-Getopt-Std \
 docbook-dtds \
 bash \
 perl-interpreter \
"
