# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cairomm1.16"
PE = "0"
PV = "1.18.0"
PR = "6.el10"
PACKAGES = "cairomm1.16 cairomm1.16-devel cairomm1.16-doc"
PROVIDES = "rpm/cairomm1.16 rpm/cairomm1.16-devel rpm/cairomm1.16-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/cairomm1.16-1.18.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f24481458b644956f60e0bc5e3ac15807573f9df5526a17a0f5a049ff2b3779a"

URI_cairomm1.16 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cairomm1.16-1.18.0-6.el10.x86_64_v2.rpm;name=cairomm1.16;unpack=0"
SRC_URI += "${URI_cairomm1.16}"
SRC_URI[cairomm1.16.sha256sum] = "006aeba8ec89ec4e217ff7cbc3c1527a91a09423fbfa92bd884c3edee2d4e693"
RDEPENDS:cairomm1.16 = " \
 libgcc \
 libstdc++ \
 cairo \
 glibc \
 libsigc++30 \
"

URI_cairomm1.16-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/cairomm1.16-devel-1.18.0-6.el10.x86_64_v2.rpm;name=cairomm1.16-devel;unpack=0"
SRC_URI += "${URI_cairomm1.16-devel}"
SRC_URI[cairomm1.16-devel.sha256sum] = "234fa180e688f4b72d3ff7dd561af4130d675e94cbc9631118987ee6fcdbef83"
RDEPENDS:cairomm1.16-devel = " \
 libsigc++30-devel \
 pkgconf-pkg-config \
 cairo-devel \
 cairomm1.16 \
 cairomm1.16-devel \
"

URI_cairomm1.16-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/cairomm1.16-doc-1.18.0-6.el10.noarch.rpm;name=cairomm1.16-doc;unpack=0"
SRC_URI += "${URI_cairomm1.16-doc}"
SRC_URI[cairomm1.16-doc.sha256sum] = "f659e29bdbc0759cc159bae5309cea4583af97493b6d447f330692374cc08313"
RDEPENDS:cairomm1.16-doc = ""
