# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "twolame"
PE = "0"
PV = "0.4.0"
PR = "6.el10"
PACKAGES = "twolame twolame-libs twolame-devel"
PROVIDES = "rpm/twolame rpm/twolame-libs rpm/twolame-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/twolame-0.4.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6ab385342eebcd50588555678aa2a978b949656f98587f7aa946a9488003815"

URI_twolame = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/twolame-0.4.0-6.el10.x86_64_v2.rpm;name=twolame;unpack=0"
SRC_URI += "${URI_twolame}"
SRC_URI[twolame.sha256sum] = "fd15a332c3fb9b642653f0c7f09c4ea366dffdd179c00811c767501f777cabdc"
RDEPENDS:twolame = " \
 glibc \
 twolame-libs \
 libsndfile \
"

URI_twolame-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/twolame-libs-0.4.0-6.el10.x86_64_v2.rpm;name=twolame-libs;unpack=0"
SRC_URI += "${URI_twolame-libs}"
SRC_URI[twolame-libs.sha256sum] = "fe4ce0254d0d6b7d60faa590db9f0558d16a4c3c22e0b060d25ab21470da20fe"
RDEPENDS:twolame-libs = " \
 glibc \
"

URI_twolame-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/twolame-devel-0.4.0-6.el10.x86_64_v2.rpm;name=twolame-devel;unpack=0"
SRC_URI += "${URI_twolame-devel}"
SRC_URI[twolame-devel.sha256sum] = "2cf81a9df155e3ec509064cb3cc112f371f2805bd4d18e4f8da3b9fe46e1d395"
RDEPENDS:twolame-devel = " \
 twolame-libs \
 pkgconf-pkg-config \
"
