# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libev"
PE = "0"
PV = "4.33"
PR = "14.el10"
PACKAGES = "libev libev-devel libev-libevent-devel libev-source"
PROVIDES = "rpm/libev rpm/libev-devel rpm/libev-libevent-devel rpm/libev-source"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libev-4.33-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a196fe3454923ed98d9c806a110e2c45e2fabf7dad335b7af687ca0671daaff"

URI_libev = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libev-4.33-14.el10.x86_64_v2.rpm;name=libev;unpack=0"
SRC_URI += "${URI_libev}"
SRC_URI[libev.sha256sum] = "7fc570220fba69dfcb652e38aa86bbf649fdcb12031c80eb1f1ddd5fbf6a13a5"
RDEPENDS:libev = " \
 glibc \
"

URI_libev-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libev-devel-4.33-14.el10.x86_64_v2.rpm;name=libev-devel;unpack=0"
SRC_URI += "${URI_libev-devel}"
SRC_URI[libev-devel.sha256sum] = "2200b3b7dac5d9249debc6bc76609d40e424e509ae4ad8e6707c9c77751bbc0a"
RDEPENDS:libev-devel = " \
 libev \
"

URI_libev-libevent-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libev-libevent-devel-4.33-14.el10.x86_64_v2.rpm;name=libev-libevent-devel;unpack=0"
SRC_URI += "${URI_libev-libevent-devel}"
SRC_URI[libev-libevent-devel.sha256sum] = "7728592a6f92b491ca87425f91918cb3f408a2f110173c03d75a6026b7d02a6d"
RDEPENDS:libev-libevent-devel = " \
 libev-devel \
"

URI_libev-source = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libev-source-4.33-14.el10.noarch.rpm;name=libev-source;unpack=0"
SRC_URI += "${URI_libev-source}"
SRC_URI[libev-source.sha256sum] = "c06a6c41f6bbf077c29390cd8879da84f1b5adbcece26bbf4ec5abac1049a9c9"
RDEPENDS:libev-source = ""
