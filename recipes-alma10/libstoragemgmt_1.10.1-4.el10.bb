# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libstoragemgmt"
PE = "0"
PV = "1.10.1"
PR = "4.el10"
PACKAGES = "libstoragemgmt libstoragemgmt-arcconf-plugin libstoragemgmt-hpsa-plugin libstoragemgmt-local-plugin libstoragemgmt-megaraid-plugin libstoragemgmt-nfs-plugin libstoragemgmt-targetd-plugin libstoragemgmt-udev python3-libstoragemgmt libstoragemgmt-devel"
PROVIDES = "rpm/libstoragemgmt rpm/libstoragemgmt-arcconf-plugin rpm/libstoragemgmt-hpsa-plugin rpm/libstoragemgmt-local-plugin rpm/libstoragemgmt-megaraid-plugin rpm/libstoragemgmt-nfs-plugin rpm/libstoragemgmt-targetd-plugin rpm/libstoragemgmt-udev rpm/python3-libstoragemgmt rpm/libstoragemgmt-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libstoragemgmt-1.10.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a57ac0cfa31a73d62195263aa7526f9240d77aad95eceab62495bc242f6d04eb"

URI_libstoragemgmt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libstoragemgmt-1.10.1-4.el10.x86_64_v2.rpm;name=libstoragemgmt;unpack=0"
SRC_URI += "${URI_libstoragemgmt}"
SRC_URI[libstoragemgmt.sha256sum] = "2fe4dff8022f2806e430c19883bc6a6c6a6fffb5e6976d8439bce23c77aa8b46"
RDEPENDS:libstoragemgmt = " \
 python3 \
 sg3_utils-libs \
 systemd \
 systemd-libs \
 ledmon-libs \
 libgcc \
 python3-libstoragemgmt \
 sqlite-libs \
 libstdc++ \
 bash \
 glib2 \
 libconfig \
 glibc \
"

URI_libstoragemgmt-arcconf-plugin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libstoragemgmt-arcconf-plugin-1.10.1-4.el10.noarch.rpm;name=libstoragemgmt-arcconf-plugin;unpack=0"
SRC_URI += "${URI_libstoragemgmt-arcconf-plugin}"
SRC_URI[libstoragemgmt-arcconf-plugin.sha256sum] = "30de68774ddb624c5805510a11731abff7da76ad9dec7396394d1a2ce1bd7d55"
RDEPENDS:libstoragemgmt-arcconf-plugin = " \
 python3-libstoragemgmt \
 bash \
 python3 \
"

URI_libstoragemgmt-hpsa-plugin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libstoragemgmt-hpsa-plugin-1.10.1-4.el10.noarch.rpm;name=libstoragemgmt-hpsa-plugin;unpack=0"
SRC_URI += "${URI_libstoragemgmt-hpsa-plugin}"
SRC_URI[libstoragemgmt-hpsa-plugin.sha256sum] = "d67f7a89af97285d8d13ea186f414ec53397dabe3ddb808261f062c887ef3151"
RDEPENDS:libstoragemgmt-hpsa-plugin = " \
 python3-libstoragemgmt \
 bash \
 python3 \
"

URI_libstoragemgmt-local-plugin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libstoragemgmt-local-plugin-1.10.1-4.el10.noarch.rpm;name=libstoragemgmt-local-plugin;unpack=0"
SRC_URI += "${URI_libstoragemgmt-local-plugin}"
SRC_URI[libstoragemgmt-local-plugin.sha256sum] = "5322915996e6a37d05e60960d0f3faa5b0b9a926c6620d9558a5ea0dc3682fe6"
RDEPENDS:libstoragemgmt-local-plugin = " \
 python3 \
 python3-libstoragemgmt \
 libstoragemgmt-arcconf-plugin \
 libstoragemgmt-hpsa-plugin \
 bash \
"

URI_libstoragemgmt-megaraid-plugin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libstoragemgmt-megaraid-plugin-1.10.1-4.el10.noarch.rpm;name=libstoragemgmt-megaraid-plugin;unpack=0"
SRC_URI += "${URI_libstoragemgmt-megaraid-plugin}"
SRC_URI[libstoragemgmt-megaraid-plugin.sha256sum] = "a3a4ad3818fe8b26c6aef60bebd0e47119d421cdadad4cbc6aefb45ec68ef637"
RDEPENDS:libstoragemgmt-megaraid-plugin = " \
 python3-libstoragemgmt \
 bash \
 python3 \
"

URI_libstoragemgmt-nfs-plugin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libstoragemgmt-nfs-plugin-1.10.1-4.el10.x86_64_v2.rpm;name=libstoragemgmt-nfs-plugin;unpack=0"
SRC_URI += "${URI_libstoragemgmt-nfs-plugin}"
SRC_URI[libstoragemgmt-nfs-plugin.sha256sum] = "d3cb578625a959aa30e1359efef47cdee3c0e4caf0b5d99c537b9e58365b94b6"
RDEPENDS:libstoragemgmt-nfs-plugin = " \
 python3 \
 nfs-utils \
 sg3_utils-libs \
 systemd-libs \
 ledmon-libs \
 python3-libstoragemgmt \
 libstoragemgmt \
 bash \
 glib2 \
 glibc \
"

URI_libstoragemgmt-targetd-plugin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libstoragemgmt-targetd-plugin-1.10.1-4.el10.noarch.rpm;name=libstoragemgmt-targetd-plugin;unpack=0"
SRC_URI += "${URI_libstoragemgmt-targetd-plugin}"
SRC_URI[libstoragemgmt-targetd-plugin.sha256sum] = "31860b6843b5fc2d119c0e45464ed986932035178105951a491338f479af3d3a"
RDEPENDS:libstoragemgmt-targetd-plugin = " \
 python3-libstoragemgmt \
 bash \
 python3 \
"

URI_libstoragemgmt-udev = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libstoragemgmt-udev-1.10.1-4.el10.x86_64_v2.rpm;name=libstoragemgmt-udev;unpack=0"
SRC_URI += "${URI_libstoragemgmt-udev}"
SRC_URI[libstoragemgmt-udev.sha256sum] = "5e48c54c50290494083fef2327b8eb3898acb8b236151852a71bed5fc2278191"
RDEPENDS:libstoragemgmt-udev = " \
 glibc \
"

URI_python3-libstoragemgmt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-libstoragemgmt-1.10.1-4.el10.x86_64_v2.rpm;name=python3-libstoragemgmt;unpack=0"
SRC_URI += "${URI_python3-libstoragemgmt}"
SRC_URI[python3-libstoragemgmt.sha256sum] = "62acb9ec26ef78f244d3dee8355878700407affe6f81695ed472438776cebcf9"
RDEPENDS:python3-libstoragemgmt = " \
 python3 \
 sg3_utils-libs \
 systemd-libs \
 ledmon-libs \
 libstoragemgmt \
 python3-six \
 glib2 \
 glibc \
"

URI_libstoragemgmt-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libstoragemgmt-devel-1.10.1-4.el10.x86_64_v2.rpm;name=libstoragemgmt-devel;unpack=0"
SRC_URI += "${URI_libstoragemgmt-devel}"
SRC_URI[libstoragemgmt-devel.sha256sum] = "4570d60fbf8a764456823cf52a35cf2f3a487fb9e82441771c752d7b92a42706"
RDEPENDS:libstoragemgmt-devel = " \
 libstoragemgmt \
 pkgconf-pkg-config \
"
