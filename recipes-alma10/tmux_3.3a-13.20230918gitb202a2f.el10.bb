# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tmux"
PE = "0"
PV = "3.3a"
PR = "13.20230918gitb202a2f.el10"
PACKAGES = "tmux"
PROVIDES = "rpm/tmux"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/tmux-3.3a-13.20230918gitb202a2f.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ef85c3eea100cb8881e674a24a8cc08968e29fa9895e800005d2e804bf2e1b4"

URI_tmux = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/tmux-3.3a-13.20230918gitb202a2f.el10.x86_64_v2.rpm;name=tmux;unpack=0"
SRC_URI += "${URI_tmux}"
SRC_URI[tmux.sha256sum] = "8de6cc986b38436f4a852165e7c391cb5ada15936342e67fa134e80a1d79cf47"
RDEPENDS:tmux = " \
 systemd-libs \
 libevent \
 ncurses-libs \
 bash \
 glibc \
"
