# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "giflib"
PE = "0"
PV = "5.2.1"
PR = "22.el10"
PACKAGES = "giflib giflib-devel giflib-utils mingw32-giflib mingw32-giflib-tools mingw64-giflib mingw64-giflib-tools"
PROVIDES = "rpm/giflib rpm/giflib-devel rpm/giflib-utils rpm/mingw32-giflib rpm/mingw32-giflib-tools rpm/mingw64-giflib rpm/mingw64-giflib-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/giflib-5.2.1-22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c545f3caf5b4f0bb4f6d80c4260d8f8b4f1db1ce115e026e77e8e53a9480c1f5"

URI_giflib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/giflib-5.2.1-22.el10.x86_64_v2.rpm;name=giflib;unpack=0"
SRC_URI += "${URI_giflib}"
SRC_URI[giflib.sha256sum] = "93f0769bf5dd0a8cac0f288000db80325fad17af8646885eff26f5d36dbc9faf"
RDEPENDS:giflib = " \
 glibc \
"

URI_giflib-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/giflib-devel-5.2.1-22.el10.x86_64_v2.rpm;name=giflib-devel;unpack=0"
SRC_URI += "${URI_giflib-devel}"
SRC_URI[giflib-devel.sha256sum] = "ee6a17c7a9a0827409d5ed8c86974139f0d64a64916381ae6e46eb482a082ece"
RDEPENDS:giflib-devel = " \
 giflib \
"

URI_giflib-utils = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/giflib-utils-5.2.1-22.el10.x86_64_v2.rpm;name=giflib-utils;unpack=0"
SRC_URI += "${URI_giflib-utils}"
SRC_URI[giflib-utils.sha256sum] = "5ee6357f7b782a45e51c3214d19713fe22675742750602731c19af444f5636cd"
RDEPENDS:giflib-utils = " \
 glibc \
 giflib \
"

URI_mingw32-giflib = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mingw32-giflib-5.2.1-22.el10.noarch.rpm;name=mingw32-giflib;unpack=0"
SRC_URI += "${URI_mingw32-giflib}"
SRC_URI[mingw32-giflib.sha256sum] = "1204dbd348d28b9d7ea4a4855b3ecf148597c202215fec5b422f3741dbd47d3c"
RDEPENDS:mingw32-giflib = " \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-libgcc \
"

URI_mingw32-giflib-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mingw32-giflib-tools-5.2.1-22.el10.noarch.rpm;name=mingw32-giflib-tools;unpack=0"
SRC_URI += "${URI_mingw32-giflib-tools}"
SRC_URI[mingw32-giflib-tools.sha256sum] = "0c91e2adf7f6d81bcef19194636f1e9e269f84c1d3542c7a77cc3c0c49c81642"
RDEPENDS:mingw32-giflib-tools = " \
 mingw32-filesystem \
 mingw32-crt \
 mingw32-giflib \
"

URI_mingw64-giflib = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mingw64-giflib-5.2.1-22.el10.noarch.rpm;name=mingw64-giflib;unpack=0"
SRC_URI += "${URI_mingw64-giflib}"
SRC_URI[mingw64-giflib.sha256sum] = "be7ecb057368fc22b2df2e2fa507164c4cdf06c12615a15c391de93da3ea4169"
RDEPENDS:mingw64-giflib = " \
 mingw64-crt \
 mingw64-filesystem \
"

URI_mingw64-giflib-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mingw64-giflib-tools-5.2.1-22.el10.noarch.rpm;name=mingw64-giflib-tools;unpack=0"
SRC_URI += "${URI_mingw64-giflib-tools}"
SRC_URI[mingw64-giflib-tools.sha256sum] = "d94200cbadefbd24e64a53518ffe5b17d1b6b6f5ad35ae3872ae0f56ebdd13a9"
RDEPENDS:mingw64-giflib-tools = " \
 mingw64-giflib \
 mingw64-crt \
 mingw64-filesystem \
"
