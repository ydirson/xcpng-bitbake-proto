# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libdaemon"
PE = "0"
PV = "0.14"
PR = "31.el10"
PACKAGES = "libdaemon libdaemon-devel"
PROVIDES = "rpm/libdaemon rpm/libdaemon-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libdaemon-0.14-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e32a37cf79138b527e3397e0e9aa6153b2dd81bdf0dcfe0e6629541a7af6688c"

URI_libdaemon = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libdaemon-0.14-31.el10.x86_64_v2.rpm;name=libdaemon;unpack=0"
SRC_URI += "${URI_libdaemon}"
SRC_URI[libdaemon.sha256sum] = "27ec2574b78eed27bd9a6c383db67f4446d523d17ba76c4be967b2657243fbfd"
RDEPENDS:libdaemon = " \
 glibc \
"

URI_libdaemon-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libdaemon-devel-0.14-31.el10.x86_64_v2.rpm;name=libdaemon-devel;unpack=0"
SRC_URI += "${URI_libdaemon-devel}"
SRC_URI[libdaemon-devel.sha256sum] = "6c186190fe9adabadc0a0b731b0cede897e4db68301e67d49de228194750ae62"
RDEPENDS:libdaemon-devel = " \
 libdaemon \
 pkgconf-pkg-config \
"
