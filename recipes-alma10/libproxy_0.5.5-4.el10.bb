# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libproxy"
PE = "0"
PV = "0.5.5"
PR = "4.el10"
PACKAGES = "libproxy libproxy-bin libproxy-devel"
PROVIDES = "rpm/libproxy rpm/libproxy-bin rpm/libproxy-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libproxy-0.5.5-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee878151b8a1cceef2f4778eb19eb291f27154755ed29602b51869e9b8ad938b"

URI_libproxy = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libproxy-0.5.5-4.el10.x86_64_v2.rpm;name=libproxy;unpack=0"
SRC_URI += "${URI_libproxy}"
SRC_URI[libproxy.sha256sum] = "3dda310efec28f7d658cd87ee44ac1fb3746618ba783e36c3d139d9232d3b888"
RDEPENDS:libproxy = " \
 libgcc \
 glib2 \
 libcurl \
 glibc \
 duktape \
"

URI_libproxy-bin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libproxy-bin-0.5.5-4.el10.x86_64_v2.rpm;name=libproxy-bin;unpack=0"
SRC_URI += "${URI_libproxy-bin}"
SRC_URI[libproxy-bin.sha256sum] = "3c20697668ef80a32b541521ac69bb7d3e89e53a6362bc06b8de0506e60a5220"
RDEPENDS:libproxy-bin = " \
 glibc \
 libproxy \
"

URI_libproxy-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libproxy-devel-0.5.5-4.el10.x86_64_v2.rpm;name=libproxy-devel;unpack=0"
SRC_URI += "${URI_libproxy-devel}"
SRC_URI[libproxy-devel.sha256sum] = "631574b9801676cfcb34206b3873ddf375ba2a4e8dd9d7be23cba8d261c27859"
RDEPENDS:libproxy-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 libproxy \
"
