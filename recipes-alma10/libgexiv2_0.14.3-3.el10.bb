# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libgexiv2"
PE = "0"
PV = "0.14.3"
PR = "3.el10"
PACKAGES = "libgexiv2 libgexiv2-devel"
PROVIDES = "rpm/libgexiv2 rpm/libgexiv2-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libgexiv2-0.14.3-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6292c059e3ee55dc1170b3a2669542ca7dbb3698869b8734b64954c485b400c"

URI_libgexiv2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libgexiv2-0.14.3-3.el10.x86_64_v2.rpm;name=libgexiv2;unpack=0"
SRC_URI += "${URI_libgexiv2}"
SRC_URI[libgexiv2.sha256sum] = "b036f2dbaa0c765100964714774dd02d11711e4a5e5f400b9bc7a15de3e34d71"
RDEPENDS:libgexiv2 = " \
 libgcc \
 exiv2-libs \
 libstdc++ \
 glib2 \
 glibc \
"

URI_libgexiv2-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libgexiv2-devel-0.14.3-3.el10.x86_64_v2.rpm;name=libgexiv2-devel;unpack=0"
SRC_URI += "${URI_libgexiv2-devel}"
SRC_URI[libgexiv2-devel.sha256sum] = "aabb847d86edbc43c5e254ca88616a83d4f80ef71ca3451309efb899872ed80a"
RDEPENDS:libgexiv2-devel = " \
 libgexiv2 \
 glib2-devel \
 pkgconf-pkg-config \
 exiv2-devel \
"
