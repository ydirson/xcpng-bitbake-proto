# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "librabbitmq"
PE = "0"
PV = "0.14.0"
PR = "3.el10"
PACKAGES = "librabbitmq librabbitmq-tools librabbitmq-devel"
PROVIDES = "rpm/librabbitmq rpm/librabbitmq-tools rpm/librabbitmq-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/librabbitmq-0.14.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66f22509d513d3651f77e07bf00a3471cd13b808941c8da8abd1fb52964e0d37"

URI_librabbitmq = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/librabbitmq-0.14.0-3.el10.x86_64_v2.rpm;name=librabbitmq;unpack=0"
SRC_URI += "${URI_librabbitmq}"
SRC_URI[librabbitmq.sha256sum] = "3e7f9e55c40fc91778b475921f02c07b586f170bcb34caab08276fc6264145f7"
RDEPENDS:librabbitmq = " \
 glibc \
 openssl-libs \
"

URI_librabbitmq-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/librabbitmq-tools-0.14.0-3.el10.x86_64_v2.rpm;name=librabbitmq-tools;unpack=0"
SRC_URI += "${URI_librabbitmq-tools}"
SRC_URI[librabbitmq-tools.sha256sum] = "ac4ab378315781b03b0203dc23d4b18e3f1d7513289dad8c0b9ef4e5f83c4891"
RDEPENDS:librabbitmq-tools = " \
 glibc \
 librabbitmq \
 popt \
"

URI_librabbitmq-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/librabbitmq-devel-0.14.0-3.el10.x86_64_v2.rpm;name=librabbitmq-devel;unpack=0"
SRC_URI += "${URI_librabbitmq-devel}"
SRC_URI[librabbitmq-devel.sha256sum] = "f12cc43e261f3e983a7504c78d533f55de28b2c00f8e281f66412d9830e209d3"
RDEPENDS:librabbitmq-devel = " \
 librabbitmq \
 cmake-filesystem \
 pkgconf-pkg-config \
"
