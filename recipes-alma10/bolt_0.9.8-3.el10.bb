# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "bolt"
PE = "0"
PV = "0.9.8"
PR = "3.el10"
PACKAGES = "bolt"
PROVIDES = "rpm/bolt"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/bolt-0.9.8-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9690ebf5fb577e76b642a410c2d6ff296c1e3f1c0791450e905a17e81a6f6159"

URI_bolt = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/bolt-0.9.8-3.el10.x86_64_v2.rpm;name=bolt;unpack=0"
SRC_URI += "${URI_bolt}"
SRC_URI[bolt.sha256sum] = "cc14a90a4d752dc42b81f8b2f30b0c52f35b9079f232f30921e087d22600dfd7"
RDEPENDS:bolt = " \
 systemd \
 systemd-libs \
 libgcc \
 polkit-libs \
 bash \
 glib2 \
 glibc \
"
