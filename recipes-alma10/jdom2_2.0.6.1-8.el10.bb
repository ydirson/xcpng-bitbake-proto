# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jdom2"
PE = "0"
PV = "2.0.6.1"
PR = "8.el10"
PACKAGES = "jdom2 jdom2-javadoc"
PROVIDES = "rpm/jdom2 rpm/jdom2-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/jdom2-2.0.6.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a150b534ee829864f5516f7f2c3b146c022cca9164c3fb0a7affd033e6475e0"

URI_jdom2 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jdom2-2.0.6.1-8.el10.noarch.rpm;name=jdom2;unpack=0"
SRC_URI += "${URI_jdom2}"
SRC_URI[jdom2.sha256sum] = "799341b1590988eef3236d7599243426df8677d925e0f08ad41a66b1f44571dd"
RDEPENDS:jdom2 = " \
 javapackages-filesystem \
"

URI_jdom2-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jdom2-javadoc-2.0.6.1-8.el10.noarch.rpm;name=jdom2-javadoc;unpack=0"
SRC_URI += "${URI_jdom2-javadoc}"
SRC_URI[jdom2-javadoc.sha256sum] = "d2ac7c17bd0fd16aea1944740e329af89ee73f8dd44be27834cb0bff886dd55d"
RDEPENDS:jdom2-javadoc = " \
 javapackages-filesystem \
"
