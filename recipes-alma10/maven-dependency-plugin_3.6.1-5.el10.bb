# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "maven-dependency-plugin"
PE = "0"
PV = "3.6.1"
PR = "5.el10"
PACKAGES = "maven-dependency-plugin maven-dependency-plugin-javadoc"
PROVIDES = "rpm/maven-dependency-plugin rpm/maven-dependency-plugin-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/maven-dependency-plugin-3.6.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7045a2b4bd2d3cffa20a3989b2ff7e7394f1794d9e0da0d212eca00902194230"

URI_maven-dependency-plugin = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-dependency-plugin-3.6.1-5.el10.noarch.rpm;name=maven-dependency-plugin;unpack=0"
SRC_URI += "${URI_maven-dependency-plugin}"
SRC_URI[maven-dependency-plugin.sha256sum] = "62ff37e9c1c79bc42ae2f462e5532607f0d9b2a271afe50e4120a876dcd45abc"
RDEPENDS:maven-dependency-plugin = " \
 plexus-utils \
 javapackages-filesystem \
 apache-commons-lang3 \
 maven-artifact-transfer \
 apache-commons-collections \
 maven-common-artifact-filters \
 plexus-archiver \
 plexus-build-api0 \
 maven-dependency-analyzer \
 maven-dependency-tree \
 maven-shared-utils \
 plexus-io \
"

URI_maven-dependency-plugin-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-dependency-plugin-javadoc-3.6.1-5.el10.noarch.rpm;name=maven-dependency-plugin-javadoc;unpack=0"
SRC_URI += "${URI_maven-dependency-plugin-javadoc}"
SRC_URI[maven-dependency-plugin-javadoc.sha256sum] = "09d293b35b5e64b57fd9636c34a6d320e68394239a422357073826d363d2982e"
RDEPENDS:maven-dependency-plugin-javadoc = " \
 javapackages-filesystem \
"
