# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "apr"
PE = "0"
PV = "1.7.5"
PR = "2.el10"
PACKAGES = "apr apr-devel"
PROVIDES = "rpm/apr rpm/apr-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/apr-1.7.5-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8cd7fe715a6c4548d3eb0a2a21771af1cc779258e9003ad49d057d09db549d95"

URI_apr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/apr-1.7.5-2.el10.x86_64_v2.rpm;name=apr;unpack=0"
SRC_URI += "${URI_apr}"
SRC_URI[apr.sha256sum] = "53a09aeb274797e42bab4bfb46785ade4eda627ece9a5df5bf9469eca7a5dab5"
RDEPENDS:apr = " \
 glibc \
 libxcrypt \
 libuuid \
"

URI_apr-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/apr-devel-1.7.5-2.el10.x86_64_v2.rpm;name=apr-devel;unpack=0"
SRC_URI += "${URI_apr-devel}"
SRC_URI[apr-devel.sha256sum] = "4620a072a43d0f304249eaf101b67832c1f3aebf5d360a75c2645ff60e11d403"
RDEPENDS:apr-devel = " \
 python3 \
 apr \
 bash \
 pkgconf-pkg-config \
"
