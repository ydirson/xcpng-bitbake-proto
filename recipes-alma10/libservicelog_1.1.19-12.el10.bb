# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libservicelog"
PE = "0"
PV = "1.1.19"
PR = "12.el10"
PACKAGES = ""
PROVIDES = ""


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libservicelog-1.1.19-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6167684a142ea9abf11179171bcf19516788269423c3bc26cf73b10369bb37d1"
