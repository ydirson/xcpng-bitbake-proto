# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libICE"
PE = "0"
PV = "1.1.1"
PR = "5.el10"
PACKAGES = "libICE libICE-devel"
PROVIDES = "rpm/libICE rpm/libICE-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libICE-1.1.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c970f137fd1739d1b80ee50a7002d160ce6b4be1e04ca35e63c7794ad4baf1f"

URI_libICE = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libICE-1.1.1-5.el10.x86_64_v2.rpm;name=libICE;unpack=0"
SRC_URI += "${URI_libICE}"
SRC_URI[libICE.sha256sum] = "0f03281958e4d23d47e7e75cc5fd69bc1610b0b6d5c305ea97a55ffd7d935137"
RDEPENDS:libICE = " \
 glibc \
"

URI_libICE-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libICE-devel-1.1.1-5.el10.x86_64_v2.rpm;name=libICE-devel;unpack=0"
SRC_URI += "${URI_libICE-devel}"
SRC_URI[libICE-devel.sha256sum] = "0c89b5036f1446d83bdd54cde78cad2f4adeaf3c9195a82afc23e3247ce75a9c"
RDEPENDS:libICE-devel = " \
 xorg-x11-proto-devel \
 libICE \
 pkgconf-pkg-config \
"
