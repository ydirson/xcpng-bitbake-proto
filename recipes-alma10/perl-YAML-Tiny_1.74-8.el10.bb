# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-YAML-Tiny"
PE = "0"
PV = "1.74"
PR = "8.el10"
PACKAGES = "perl-YAML-Tiny perl-YAML-Tiny-tests"
PROVIDES = "rpm/perl-YAML-Tiny rpm/perl-YAML-Tiny-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-YAML-Tiny-1.74-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e7940a4e8a1f813282a82e4b4535e48744c674b643cbd0317649db34269a491"

URI_perl-YAML-Tiny = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-YAML-Tiny-1.74-8.el10.noarch.rpm;name=perl-YAML-Tiny;unpack=0"
SRC_URI += "${URI_perl-YAML-Tiny}"
SRC_URI[perl-YAML-Tiny.sha256sum] = "19afed3b82db8ca67a1203204da0210f8fd1b714548d8367a494d422b402032f"
RDEPENDS:perl-YAML-Tiny = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-Fcntl \
 perl-B \
 perl-Exporter \
"

URI_perl-YAML-Tiny-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-YAML-Tiny-tests-1.74-8.el10.noarch.rpm;name=perl-YAML-Tiny-tests;unpack=0"
SRC_URI += "${URI_perl-YAML-Tiny-tests}"
SRC_URI[perl-YAML-Tiny-tests.sha256sum] = "a0a0c7d6ad509de9cde204fc16d400d584b168c0a2b952da20662b9d64f529a2"
RDEPENDS:perl-YAML-Tiny-tests = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Getopt-Long \
 perl-open \
 perl-Test-Harness \
 perl-Carp \
 perl-Test-Simple \
 perl-vars \
 perl-IO \
 perl-YAML-Tiny \
 perl-File-Temp \
 bash \
 perl-Exporter \
 perl-base \
 perl-ExtUtils-MakeMaker \
 perl-File-Basename \
 perl-PathTools \
 perl-File-Find \
 perl-interpreter \
 perl-lib \
"
