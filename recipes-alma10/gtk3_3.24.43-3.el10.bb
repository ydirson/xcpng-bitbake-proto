# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gtk3"
PE = "0"
PV = "3.24.43"
PR = "3.el10"
PACKAGES = "gtk-update-icon-cache gtk3 gtk3-devel gtk3-immodule-xim gtk3-immodules gtk3-devel-docs gtk3-tests"
PROVIDES = "rpm/gtk-update-icon-cache rpm/gtk3 rpm/gtk3-devel rpm/gtk3-immodule-xim rpm/gtk3-immodules rpm/gtk3-devel-docs rpm/gtk3-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gtk3-3.24.43-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fbf2ae0f2988dde740784345ed15cdb3141970829ecdcba03741f526a20135e2"

URI_gtk-update-icon-cache = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gtk-update-icon-cache-3.24.43-3.el10.x86_64_v2.rpm;name=gtk-update-icon-cache;unpack=0"
SRC_URI += "${URI_gtk-update-icon-cache}"
SRC_URI[gtk-update-icon-cache.sha256sum] = "9698765cc3b60862890a6b830357380ab2c1999566dca6f038bb2c61fb0797e9"
RDEPENDS:gtk-update-icon-cache = " \
 glibc \
 glib2 \
 gdk-pixbuf2 \
"

URI_gtk3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gtk3-3.24.43-3.el10.x86_64_v2.rpm;name=gtk3;unpack=0"
SRC_URI += "${URI_gtk3}"
SRC_URI[gtk3.sha256sum] = "87f219119a528cc41ac79a53e311366a370954035bf4e8f79b116ffcaa5bb127"
RDEPENDS:gtk3 = " \
 libtracker-sparql \
 cups-libs \
 pango \
 fontconfig \
 libX11 \
 libXcomposite \
 hicolor-icon-theme \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libepoxy \
 fribidi \
 adwaita-icon-theme \
 libXrandr \
 cairo \
 cairo-gobject \
 at-spi2-atk \
 atk \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 gdk-pixbuf2 \
 gdk-pixbuf2-modules \
 bash \
 libxkbcommon \
 harfbuzz \
 gtk-update-icon-cache \
 glib2 \
 colord-libs \
 glibc \
"

URI_gtk3-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gtk3-devel-3.24.43-3.el10.x86_64_v2.rpm;name=gtk3-devel;unpack=0"
SRC_URI += "${URI_gtk3-devel}"
SRC_URI[gtk3-devel.sha256sum] = "d044907363eafa0c4a1e5dbe6ff092f57c371831320292f63d8e125ca136fbdf"
RDEPENDS:gtk3-devel = " \
 glib2-devel \
 pango \
 fontconfig-devel \
 pango-devel \
 libX11-devel \
 libXcomposite-devel \
 libXcursor-devel \
 libXdamage-devel \
 libXext-devel \
 libXfixes-devel \
 libXi-devel \
 libXinerama-devel \
 libepoxy \
 libepoxy-devel \
 fribidi-devel \
 libXrandr-devel \
 cairo \
 cairo-devel \
 cairo-gobject-devel \
 at-spi2-atk-devel \
 atk \
 atk-devel \
 gdk-pixbuf2 \
 gdk-pixbuf2-devel \
 libxkbcommon-devel \
 wayland-devel \
 harfbuzz \
 pkgconf-pkg-config \
 glib2 \
 gtk3 \
 gtk3-devel \
 glibc \
"

URI_gtk3-immodule-xim = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gtk3-immodule-xim-3.24.43-3.el10.x86_64_v2.rpm;name=gtk3-immodule-xim;unpack=0"
SRC_URI += "${URI_gtk3-immodule-xim}"
SRC_URI[gtk3-immodule-xim.sha256sum] = "e12efd74798057971d1350e9f3e52f93280b3f37d9e19a9795fcab4a29d53d1c"
RDEPENDS:gtk3-immodule-xim = " \
 pango \
 libX11 \
 glib2 \
 gtk3 \
 glibc \
"

URI_gtk3-immodules = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gtk3-immodules-3.24.43-3.el10.x86_64_v2.rpm;name=gtk3-immodules;unpack=0"
SRC_URI += "${URI_gtk3-immodules}"
SRC_URI[gtk3-immodules.sha256sum] = "a65acca99770b4f022548c2994c225e95e5a4c1a85d775f040fe7a00ee6454bd"
RDEPENDS:gtk3-immodules = " \
 glibc \
 gtk3 \
 glib2 \
 pango \
"

URI_gtk3-devel-docs = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gtk3-devel-docs-3.24.43-3.el10.x86_64_v2.rpm;name=gtk3-devel-docs;unpack=0"
SRC_URI += "${URI_gtk3-devel-docs}"
SRC_URI[gtk3-devel-docs.sha256sum] = "45585ee37bc2929dd49e27d08cc7feb598010a3a94b3a9b56bd68d884ce15f3e"
RDEPENDS:gtk3-devel-docs = " \
 gtk3 \
"

URI_gtk3-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gtk3-tests-3.24.43-3.el10.x86_64_v2.rpm;name=gtk3-tests;unpack=0"
SRC_URI += "${URI_gtk3-tests}"
SRC_URI[gtk3-tests.sha256sum] = "99f2521a6b30edf3074db49b89dc659af78ffe3034db680fc197692f40e2a0e6"
RDEPENDS:gtk3-tests = " \
 atk \
 pango \
 gdk-pixbuf2 \
 libX11 \
 bash \
 cairo \
 glib2 \
 gtk3 \
 glibc \
"
