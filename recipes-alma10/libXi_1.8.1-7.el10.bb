# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libXi"
PE = "0"
PV = "1.8.1"
PR = "7.el10"
PACKAGES = "libXi libXi-devel"
PROVIDES = "rpm/libXi rpm/libXi-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libXi-1.8.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ed2acedf56de591359e6348088f6791b43ba71c566156ccad5f3584b0e26913"

URI_libXi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXi-1.8.1-7.el10.x86_64_v2.rpm;name=libXi;unpack=0"
SRC_URI += "${URI_libXi}"
SRC_URI[libXi.sha256sum] = "5ad413d9a8c42d195fbf11a54add3e53cebf95be86b29a6f134087fa210e8502"
RDEPENDS:libXi = " \
 glibc \
 libX11 \
 libXext \
"

URI_libXi-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXi-devel-1.8.1-7.el10.x86_64_v2.rpm;name=libXi-devel;unpack=0"
SRC_URI += "${URI_libXi-devel}"
SRC_URI[libXi-devel.sha256sum] = "beabffbf05a5bc2e66cdcaacb710b24fd3b8d9e228914ce0ac8fdab6a3bffa36"
RDEPENDS:libXi-devel = " \
 libXext-devel \
 libXfixes-devel \
 libXi \
 pkgconf-pkg-config \
 libX11-devel \
 xorg-x11-proto-devel \
"
