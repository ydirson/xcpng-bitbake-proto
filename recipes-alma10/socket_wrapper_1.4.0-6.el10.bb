# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "socket_wrapper"
PE = "0"
PV = "1.4.0"
PR = "6.el10"
PACKAGES = "socket_wrapper libsocket_wrapper_noop libsocket_wrapper_noop-devel"
PROVIDES = "rpm/socket_wrapper rpm/libsocket_wrapper_noop rpm/libsocket_wrapper_noop-devel"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/socket_wrapper-1.4.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8db844d30f86154d6bb679e02f856b77914a3f5cc32725ab2f5f69c436e6fa67"

URI_socket_wrapper = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/socket_wrapper-1.4.0-6.el10.x86_64_v2.rpm;name=socket_wrapper;unpack=0"
SRC_URI += "${URI_socket_wrapper}"
SRC_URI[socket_wrapper.sha256sum] = "000d6596d442f1b93f7bc14b8698439b4329758a0744788f12b465519d9e9612"
RDEPENDS:socket_wrapper = " \
 glibc \
 cmake-filesystem \
 pkgconf-pkg-config \
"

URI_libsocket_wrapper_noop = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libsocket_wrapper_noop-1.4.0-6.el10.x86_64_v2.rpm;name=libsocket_wrapper_noop;unpack=0"
SRC_URI += "${URI_libsocket_wrapper_noop}"
SRC_URI[libsocket_wrapper_noop.sha256sum] = "b0754e956177d244620d99642fa98d21c8bd60a8d13f98b7165a1a4315c4053f"
RDEPENDS:libsocket_wrapper_noop = " \
 glibc \
"

URI_libsocket_wrapper_noop-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libsocket_wrapper_noop-devel-1.4.0-6.el10.x86_64_v2.rpm;name=libsocket_wrapper_noop-devel;unpack=0"
SRC_URI += "${URI_libsocket_wrapper_noop-devel}"
SRC_URI[libsocket_wrapper_noop-devel.sha256sum] = "4dd3216eccc22ed668218821d9fa7249ced7a0f85567210b107e13e94548d91c"
RDEPENDS:libsocket_wrapper_noop-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 libsocket_wrapper_noop \
"
