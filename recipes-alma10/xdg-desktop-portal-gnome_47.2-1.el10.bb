# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xdg-desktop-portal-gnome"
PE = "0"
PV = "47.2"
PR = "1.el10"
PACKAGES = "xdg-desktop-portal-gnome"
PROVIDES = "rpm/xdg-desktop-portal-gnome"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xdg-desktop-portal-gnome-47.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0395d2f1c879556480958c57ae485f9977a6057ff95a1f1c5a8c44fb482de66"

URI_xdg-desktop-portal-gnome = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xdg-desktop-portal-gnome-47.2-1.el10.x86_64_v2.rpm;name=xdg-desktop-portal-gnome;unpack=0"
SRC_URI += "${URI_xdg-desktop-portal-gnome}"
SRC_URI[xdg-desktop-portal-gnome.sha256sum] = "3d923247b16a6f3676ee349c3ffb9c95edcf7d95cfd0aea67b4c8d7c23e64c1b"
RDEPENDS:xdg-desktop-portal-gnome = " \
 xdg-desktop-portal \
 libwayland-client \
 libgcc \
 gnome-desktop4 \
 fontconfig \
 gdk-pixbuf2 \
 libX11 \
 bash \
 glib2 \
 cairo \
 dbus \
 glibc \
 graphene \
 gtk4 \
 libadwaita \
 dbus-common \
"
