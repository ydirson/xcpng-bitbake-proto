# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-rpmautospec"
PE = "0"
PV = "0.8.1"
PR = "11.el10.alma.1"
PACKAGES = "rpmautospec"
PROVIDES = "rpm/rpmautospec"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/python-rpmautospec-0.8.1-11.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c1da65bc93bd6c1691b0e9feff13e5896af1359ab387017a4e098903dfebea8"

URI_rpmautospec = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rpmautospec-0.8.1-11.el10.alma.1.noarch.rpm;name=rpmautospec;unpack=0"
SRC_URI += "${URI_rpmautospec}"
SRC_URI[rpmautospec.sha256sum] = "5e6ba8c32aa926521625d2809f3f5f2c726e94f962f6287a0bad6f69cd4b493d"
RDEPENDS:rpmautospec = " \
 python3 \
 libgit2 \
 rpm-build-libs \
 rpm-libs \
"
