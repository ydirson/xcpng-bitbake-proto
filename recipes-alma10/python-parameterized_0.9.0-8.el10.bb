# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-parameterized"
PE = "0"
PV = "0.9.0"
PR = "8.el10"
PACKAGES = "python3-parameterized"
PROVIDES = "rpm/python3-parameterized"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/python-parameterized-0.9.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7bf24eaa6fddb3c81e1e6a6562b58a221751c8ac8de6d7e67961eebf3c5349d"

URI_python3-parameterized = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-parameterized-0.9.0-8.el10.noarch.rpm;name=python3-parameterized;unpack=0"
SRC_URI += "${URI_python3-parameterized}"
SRC_URI[python3-parameterized.sha256sum] = "bbad1f9a66e5073756d5e634cbec4dc1bbe317107d417f3b1435eac9cb6ad95b"
RDEPENDS:python3-parameterized = " \
 python3 \
"
