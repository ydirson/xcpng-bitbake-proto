# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gtksourceview5"
PE = "0"
PV = "5.14.2"
PR = "1.el10"
PACKAGES = "gtksourceview5 gtksourceview5-devel gtksourceview5-tests"
PROVIDES = "rpm/gtksourceview5 rpm/gtksourceview5-devel rpm/gtksourceview5-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gtksourceview5-5.14.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9fab32aab18f79f374a0535e2b9400f336251e1f9e423cb1d4abb6eca041034e"

URI_gtksourceview5 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gtksourceview5-5.14.2-1.el10.x86_64_v2.rpm;name=gtksourceview5;unpack=0"
SRC_URI += "${URI_gtksourceview5}"
SRC_URI[gtksourceview5.sha256sum] = "73bd032c1013fc4766be4086be97563a17158a9c1f7717028bf592ab60325f8b"
RDEPENDS:gtksourceview5 = " \
 fribidi \
 libxml2 \
 pango \
 gdk-pixbuf2 \
 fontconfig \
 pcre2 \
 cairo \
 glib2 \
 glibc \
 gtk4 \
 hicolor-icon-theme \
"

URI_gtksourceview5-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gtksourceview5-devel-5.14.2-1.el10.x86_64_v2.rpm;name=gtksourceview5-devel;unpack=0"
SRC_URI += "${URI_gtksourceview5-devel}"
SRC_URI[gtksourceview5-devel.sha256sum] = "eac16600c3004e04d64b08b6a95e532d3a97bbe3f2bd53e6bba90a53e3d06104"
RDEPENDS:gtksourceview5-devel = " \
 libxml2-devel \
 sysprof-capture-devel \
 glib2-devel \
 fribidi-devel \
 pkgconf-pkg-config \
 pango-devel \
 fontconfig-devel \
 pcre2-devel \
 gtk4-devel \
 gtksourceview5 \
"

URI_gtksourceview5-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gtksourceview5-tests-5.14.2-1.el10.x86_64_v2.rpm;name=gtksourceview5-tests;unpack=0"
SRC_URI += "${URI_gtksourceview5-tests}"
SRC_URI[gtksourceview5-tests.sha256sum] = "10ae852339a7c467607c95b5b91dfb19900a206594feac2609fe07875d58eeeb"
RDEPENDS:gtksourceview5-tests = " \
 fribidi \
 libxml2 \
 pango \
 gdk-pixbuf2 \
 fontconfig \
 pcre2 \
 cairo \
 glib2 \
 glibc \
 gtk4 \
 gtksourceview5 \
"
