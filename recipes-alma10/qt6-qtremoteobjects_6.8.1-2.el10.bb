# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtremoteobjects"
PE = "0"
PV = "6.8.1"
PR = "2.el10"
PACKAGES = "qt6-qtremoteobjects qt6-qtremoteobjects-devel qt6-qtremoteobjects-examples qt6-qtremoteobjects-tests"
PROVIDES = "rpm/qt6-qtremoteobjects rpm/qt6-qtremoteobjects-devel rpm/qt6-qtremoteobjects-examples rpm/qt6-qtremoteobjects-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtremoteobjects-6.8.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2276e0dc390fd211efe96e73bfbc3779fd06e17d1d5b4bd2bc9c70735f9a2b8d"

URI_qt6-qtremoteobjects = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtremoteobjects-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtremoteobjects;unpack=0"
SRC_URI += "${URI_qt6-qtremoteobjects}"
SRC_URI[qt6-qtremoteobjects.sha256sum] = "5b61afacb4fd4d95b4ce655e35a0dd3b2110c021df707a0fdd25faf1f8f6abe6"
RDEPENDS:qt6-qtremoteobjects = " \
 glibc \
 qt6-qtdeclarative \
 libstdc++ \
 qt6-qtbase \
"

URI_qt6-qtremoteobjects-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtremoteobjects-devel-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtremoteobjects-devel;unpack=0"
SRC_URI += "${URI_qt6-qtremoteobjects-devel}"
SRC_URI[qt6-qtremoteobjects-devel.sha256sum] = "f524498d3b7119d367f1c30b6f6c9a53a0a5029ad67bf35e04b5d43ad48ae5c8"
RDEPENDS:qt6-qtremoteobjects-devel = " \
 qt6-qtdeclarative-devel \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtremoteobjects \
 qt6-qtremoteobjects-devel \
"

URI_qt6-qtremoteobjects-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtremoteobjects-examples-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtremoteobjects-examples;unpack=0"
SRC_URI += "${URI_qt6-qtremoteobjects-examples}"
SRC_URI[qt6-qtremoteobjects-examples.sha256sum] = "53ebd7eb3a1017181e7928e8513fd6d02f35e7d0f23af73071de8dcfc7b5876a"
RDEPENDS:qt6-qtremoteobjects-examples = " \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 qt6-qtremoteobjects \
 glibc \
"

URI_qt6-qtremoteobjects-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtremoteobjects-tests-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtremoteobjects-tests;unpack=0"
SRC_URI += "${URI_qt6-qtremoteobjects-tests}"
SRC_URI[qt6-qtremoteobjects-tests.sha256sum] = "f9b50a90c845500e136413ea8b90f4a5d314ab68610c6887a30957b0ff1839ab"
RDEPENDS:qt6-qtremoteobjects-tests = " \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 qt6-qtremoteobjects \
 glibc \
"
