# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "maven-shared-io"
PE = "1"
PV = "3.0.0"
PR = "27.el10"
PACKAGES = "maven-shared-io maven-shared-io-javadoc"
PROVIDES = "rpm/maven-shared-io rpm/maven-shared-io-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/maven-shared-io-3.0.0-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "995bbad1b0bfe49f70ccbf6778e38e298226d826bb88873f350f1073b6246415"

URI_maven-shared-io = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-shared-io-3.0.0-27.el10.noarch.rpm;name=maven-shared-io;unpack=0"
SRC_URI += "${URI_maven-shared-io}"
SRC_URI[maven-shared-io.sha256sum] = "45c99d16ad071d69d5149d43e789834db8b01588cd719bfc69b63884a877889c"
RDEPENDS:maven-shared-io = " \
 plexus-utils \
 javapackages-filesystem \
 maven-lib \
 maven-shared-utils \
 maven-wagon \
"

URI_maven-shared-io-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-shared-io-javadoc-3.0.0-27.el10.noarch.rpm;name=maven-shared-io-javadoc;unpack=0"
SRC_URI += "${URI_maven-shared-io-javadoc}"
SRC_URI[maven-shared-io-javadoc.sha256sum] = "a833695ce08b303337fb491200e11f6eb740c4c6d305618a4ae054702774a535"
RDEPENDS:maven-shared-io-javadoc = " \
 javapackages-filesystem \
"
