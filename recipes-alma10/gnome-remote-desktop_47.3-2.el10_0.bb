# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-remote-desktop"
PE = "0"
PV = "47.3"
PR = "2.el10_0"
PACKAGES = "gnome-remote-desktop"
PROVIDES = "rpm/gnome-remote-desktop"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-remote-desktop-47.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ef88ce1e18ef6ab0f9f4711109da991e215a8f8612eaad4fa781f5ad34e211c"

URI_gnome-remote-desktop = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-remote-desktop-47.3-2.el10_0.x86_64_v2.rpm;name=gnome-remote-desktop;unpack=0"
SRC_URI += "${URI_gnome-remote-desktop}"
SRC_URI[gnome-remote-desktop.sha256sum] = "71e60c73d27b1ce4dc779644b51a98b4e2e69a8d489bb6b594b3cfd1ec0a7e2e"
RDEPENDS:gnome-remote-desktop = " \
 systemd-libs \
 tpm2-tss \
 libnotify \
 libei \
 freerdp-libs \
 libepoxy \
 cairo \
 fdk-aac-free \
 libgcc \
 libwinpr \
 libsecret \
 pipewire \
 bash \
 pipewire-libs \
 libxkbcommon \
 opus \
 fuse3-libs \
 polkit-libs \
 glib2 \
 glibc \
"
