# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-IO-Multiplex"
PE = "0"
PV = "1.16"
PR = "30.el10"
PACKAGES = "perl-IO-Multiplex perl-IO-Multiplex-tests"
PROVIDES = "rpm/perl-IO-Multiplex rpm/perl-IO-Multiplex-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-IO-Multiplex-1.16-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62e8518615f4d6080131f76c9428888165e87495974b84936c595cf6d7a1e953"

URI_perl-IO-Multiplex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-IO-Multiplex-1.16-30.el10.noarch.rpm;name=perl-IO-Multiplex;unpack=0"
SRC_URI += "${URI_perl-IO-Multiplex}"
SRC_URI[perl-IO-Multiplex.sha256sum] = "4479bfc81696c991a7772100acf4faeea18aa17bff8d15dbe4a1e763a1b9d6e8"
RDEPENDS:perl-IO-Multiplex = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-IO \
 perl-FileHandle \
 perl-Socket \
 perl-Fcntl \
 perl-POSIX \
 perl-Tie \
 perl-Time-HiRes \
"

URI_perl-IO-Multiplex-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-IO-Multiplex-tests-1.16-30.el10.noarch.rpm;name=perl-IO-Multiplex-tests;unpack=0"
SRC_URI += "${URI_perl-IO-Multiplex-tests}"
SRC_URI[perl-IO-Multiplex-tests.sha256sum] = "550cf6553f812273c562897b6d00bc7f5587518da0987d7b97720d781d2f9775"
RDEPENDS:perl-IO-Multiplex-tests = " \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 perl-IO \
 perl-IO-Multiplex \
 perl-Fcntl \
 perl-POSIX \
 bash \
 perl-interpreter \
"
