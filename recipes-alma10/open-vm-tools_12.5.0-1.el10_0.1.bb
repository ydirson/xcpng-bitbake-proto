# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "open-vm-tools"
PE = "0"
PV = "12.5.0"
PR = "1.el10_0.1"
PACKAGES = "open-vm-tools open-vm-tools-desktop open-vm-tools-salt-minion open-vm-tools-sdmp open-vm-tools-test open-vm-tools-devel"
PROVIDES = "rpm/open-vm-tools rpm/open-vm-tools-desktop rpm/open-vm-tools-salt-minion rpm/open-vm-tools-sdmp rpm/open-vm-tools-test rpm/open-vm-tools-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/open-vm-tools-12.5.0-1.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb58ac2f8f957d38ef13777870b20d0e1d6035ede9e457e23cfca45a2ef07387"

URI_open-vm-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/open-vm-tools-12.5.0-1.el10_0.1.x86_64_v2.rpm;name=open-vm-tools;unpack=0"
SRC_URI += "${URI_open-vm-tools}"
SRC_URI[open-vm-tools.sha256sum] = "51e865b8a84a34c6188b0dc14b2a41b3366e3ccb196448b26762fae3ff661667"
RDEPENDS:open-vm-tools = " \
 systemd \
 systemd-libs \
 iproute \
 tar \
 libmspack \
 dbus-tools \
 xmlsec1 \
 xmlsec1-openssl \
 libdrm \
 util-linux \
 which \
 sed \
 libtirpc \
 openssl-libs \
 libgcc \
 libxml2 \
 grep \
 pciutils \
 bash \
 fuse3 \
 fuse3-libs \
 glib2 \
 glibc \
 coreutils \
"

URI_open-vm-tools-desktop = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/open-vm-tools-desktop-12.5.0-1.el10_0.1.x86_64_v2.rpm;name=open-vm-tools-desktop;unpack=0"
SRC_URI += "${URI_open-vm-tools-desktop}"
SRC_URI[open-vm-tools-desktop.sha256sum] = "da20b9bc3e5246a8e092d741388aac38344abe54575772c2cb348c575de4d3ca"
RDEPENDS:open-vm-tools-desktop = " \
 systemd-libs \
 pango \
 libX11 \
 libdrm \
 libXext \
 libXi \
 libXinerama \
 open-vm-tools \
 libXrandr \
 libstdc++ \
 cairo \
 libXtst \
 libtirpc \
 atk \
 libgcc \
 gdk-pixbuf2 \
 bash \
 fuse3-libs \
 glib2 \
 gtk3 \
 glibc \
"

URI_open-vm-tools-salt-minion = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/open-vm-tools-salt-minion-12.5.0-1.el10_0.1.x86_64_v2.rpm;name=open-vm-tools-salt-minion;unpack=0"
SRC_URI += "${URI_open-vm-tools-salt-minion}"
SRC_URI[open-vm-tools-salt-minion.sha256sum] = "680c148350e75eca4f673b3a6ee8299801035e6fa7fc16a9cc1510054eead4ef"
RDEPENDS:open-vm-tools-salt-minion = " \
 systemd \
 gawk \
 grep \
 curl \
 open-vm-tools \
 bash \
 coreutils \
"

URI_open-vm-tools-sdmp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/open-vm-tools-sdmp-12.5.0-1.el10_0.1.x86_64_v2.rpm;name=open-vm-tools-sdmp;unpack=0"
SRC_URI += "${URI_open-vm-tools-sdmp}"
SRC_URI[open-vm-tools-sdmp.sha256sum] = "72c1e4f2a9f40862d8c1aa9dc902eff199c4cabf3bc3868042dae71d9443a07a"
RDEPENDS:open-vm-tools-sdmp = " \
 glibc-common \
 iproute \
 gawk \
 grep \
 open-vm-tools \
 bash \
 glib2 \
 procps-ng \
 glibc \
 coreutils \
"

URI_open-vm-tools-test = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/open-vm-tools-test-12.5.0-1.el10_0.1.x86_64_v2.rpm;name=open-vm-tools-test;unpack=0"
SRC_URI += "${URI_open-vm-tools-test}"
SRC_URI[open-vm-tools-test.sha256sum] = "81d94f92be2f728a58f70e4132a5e750345e9064313151a867b77e4b795929b2"
RDEPENDS:open-vm-tools-test = " \
 glibc \
 glib2 \
 open-vm-tools \
"

URI_open-vm-tools-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/open-vm-tools-devel-12.5.0-1.el10_0.1.x86_64_v2.rpm;name=open-vm-tools-devel;unpack=0"
SRC_URI += "${URI_open-vm-tools-devel}"
SRC_URI[open-vm-tools-devel.sha256sum] = "f838a5a0a5c96781a548c1c1e24f108b7503992515e2da37aaa35533aaf34bdb"
RDEPENDS:open-vm-tools-devel = " \
 pkgconf-pkg-config \
 open-vm-tools \
"
