# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "nodejs20"
PE = "1"
PV = "20.11.0"
PR = "7.el10"
PACKAGES = "nodejs nodejs-devel nodejs-libs v8-11.3-devel"
PROVIDES = "rpm/nodejs rpm/nodejs-devel rpm/nodejs-libs rpm/v8-11.3-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/nodejs20-20.11.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "436f9773afd5b9de0ee4cf5f21af049a2447b24e8f552cf463783647cc09a529"

URI_nodejs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/nodejs-20.11.0-7.el10.x86_64_v2.rpm;name=nodejs;unpack=0"
SRC_URI += "${URI_nodejs}"
SRC_URI[nodejs.sha256sum] = "72c0eb66121becf253d2add638cc51564e13dfea0703eb20cce624b7e553efb8"
RDEPENDS:nodejs = " \
 nodejs-libs \
 nodejs-undici \
 ca-certificates \
 openssl \
 libuv \
 glibc \
 nodejs-cjs-module-lexer \
"

URI_nodejs-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/nodejs-devel-20.11.0-7.el10.x86_64_v2.rpm;name=nodejs-devel;unpack=0"
SRC_URI += "${URI_nodejs-devel}"
SRC_URI[nodejs-devel.sha256sum] = "cccb6eb85b9590094502284217278a1a24d0133894f303a978fcc97eab037b29"
RDEPENDS:nodejs-devel = " \
 nodejs-libs \
 brotli-devel \
 zlib-ng-compat-devel \
 pkgconf-pkg-config \
 openssl-devel \
 libuv-devel \
 nodejs-packaging \
 nodejs \
"

URI_nodejs-libs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/nodejs-libs-20.11.0-7.el10.x86_64_v2.rpm;name=nodejs-libs;unpack=0"
SRC_URI += "${URI_nodejs-libs}"
SRC_URI[nodejs-libs.sha256sum] = "1f91ebe990591a9ca65b5ca99a2412bd1f1b2895b6dc5ac17db62b0ecc5798f0"
RDEPENDS:nodejs-libs = " \
 zlib-ng-compat \
 openssl-libs \
 libbrotli \
 libstdc++ \
 libuv \
 glibc \
"

URI_v8-11.3-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/v8-11.3-devel-11.3.244.8-1.20.11.0.7.el10.x86_64_v2.rpm;name=v8-11.3-devel;unpack=0"
SRC_URI += "${URI_v8-11.3-devel}"
SRC_URI[v8-11.3-devel.sha256sum] = "58dd31f144d51e67457f57026ebb5219f28249d1612a0203a1140e9af50bb7f7"
RDEPENDS:v8-11.3-devel = " \
 nodejs-devel \
 nodejs-libs \
 pkgconf-pkg-config \
"
