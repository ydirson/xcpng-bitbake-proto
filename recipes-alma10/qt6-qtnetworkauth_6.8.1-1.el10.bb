# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtnetworkauth"
PE = "0"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = "qt6-qtnetworkauth qt6-qtnetworkauth-devel qt6-qtnetworkauth-examples qt6-qtnetworkauth-tests"
PROVIDES = "rpm/qt6-qtnetworkauth rpm/qt6-qtnetworkauth-devel rpm/qt6-qtnetworkauth-examples rpm/qt6-qtnetworkauth-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtnetworkauth-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26a5e57bd1bbf59838eea56332bcebef2480525bc4909b7dc68b49c1d7658b83"

URI_qt6-qtnetworkauth = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtnetworkauth-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtnetworkauth;unpack=0"
SRC_URI += "${URI_qt6-qtnetworkauth}"
SRC_URI[qt6-qtnetworkauth.sha256sum] = "c9e45a08296d1240d099909e542c39638768f5c5047799f1cccfaa9de2d609f3"
RDEPENDS:qt6-qtnetworkauth = " \
 glibc \
 libstdc++ \
 qt6-qtbase-gui \
 qt6-qtbase \
"

URI_qt6-qtnetworkauth-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtnetworkauth-devel-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtnetworkauth-devel;unpack=0"
SRC_URI += "${URI_qt6-qtnetworkauth-devel}"
SRC_URI[qt6-qtnetworkauth-devel.sha256sum] = "93501edc55928abc00da9824a02d1b48c0b15549e2f90664e09057bcd8bdc27c"
RDEPENDS:qt6-qtnetworkauth-devel = " \
 qt6-qtnetworkauth \
 qt6-qtbase-devel \
 cmake-filesystem \
 pkgconf-pkg-config \
"

URI_qt6-qtnetworkauth-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtnetworkauth-examples-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtnetworkauth-examples;unpack=0"
SRC_URI += "${URI_qt6-qtnetworkauth-examples}"
SRC_URI[qt6-qtnetworkauth-examples.sha256sum] = "529f8c41effe97d4234cc8d15ad3b64d8c526fa808cc0fa0dcf93e50f93569a3"
RDEPENDS:qt6-qtnetworkauth-examples = " \
 libgcc \
 qt6-qtnetworkauth \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qtnetworkauth-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtnetworkauth-tests-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtnetworkauth-tests;unpack=0"
SRC_URI += "${URI_qt6-qtnetworkauth-tests}"
SRC_URI[qt6-qtnetworkauth-tests.sha256sum] = "267df21382453e24120af1cade812993a280754a5113fcec0587d41ad5ac2371"
RDEPENDS:qt6-qtnetworkauth-tests = " \
 libgcc \
 qt6-qtnetworkauth \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"
