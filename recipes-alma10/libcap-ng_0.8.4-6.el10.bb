# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libcap-ng"
PE = "0"
PV = "0.8.4"
PR = "6.el10"
PACKAGES = "libcap-ng libcap-ng-utils libcap-ng-devel libcap-ng-python3"
PROVIDES = "rpm/libcap-ng rpm/libcap-ng-utils rpm/libcap-ng-devel rpm/libcap-ng-python3"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libcap-ng-0.8.4-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5d5ffe9aa35da49583680d4e4167a13412bd949d1229a09e07eda483d7abb28"

URI_libcap-ng = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libcap-ng-0.8.4-6.el10.x86_64_v2.rpm;name=libcap-ng;unpack=0"
SRC_URI += "${URI_libcap-ng}"
SRC_URI[libcap-ng.sha256sum] = "a652a668464ee57a3f71c0fa396c1851c760099362b6066202c747ecc101e0d6"
RDEPENDS:libcap-ng = " \
 glibc \
"

URI_libcap-ng-utils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libcap-ng-utils-0.8.4-6.el10.x86_64_v2.rpm;name=libcap-ng-utils;unpack=0"
SRC_URI += "${URI_libcap-ng-utils}"
SRC_URI[libcap-ng-utils.sha256sum] = "94a2f74a042379ec223c729fec7b5339a505182a85ee39e7c06f1343ee426ad3"
RDEPENDS:libcap-ng-utils = " \
 glibc \
 libcap-ng \
"

URI_libcap-ng-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libcap-ng-devel-0.8.4-6.el10.x86_64_v2.rpm;name=libcap-ng-devel;unpack=0"
SRC_URI += "${URI_libcap-ng-devel}"
SRC_URI[libcap-ng-devel.sha256sum] = "ee7853ce21db03ad77ced89a0e06c628e80190fdc5f7a931b6f593e5dffb388a"
RDEPENDS:libcap-ng-devel = " \
 kernel-headers \
 pkgconf-pkg-config \
 libcap-ng \
"

URI_libcap-ng-python3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libcap-ng-python3-0.8.4-6.el10.x86_64_v2.rpm;name=libcap-ng-python3;unpack=0"
SRC_URI += "${URI_libcap-ng-python3}"
SRC_URI[libcap-ng-python3.sha256sum] = "a3de8822559117af55410e5860701598b46f33471e8d88e3a0c43d7708c04513"
RDEPENDS:libcap-ng-python3 = " \
 glibc \
 python3 \
 libcap-ng \
"
