# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-urllib3"
PE = "0"
PV = "1.26.19"
PR = "2.el10"
PACKAGES = "python3-urllib3"
PROVIDES = "rpm/python3-urllib3"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/python-urllib3-1.26.19-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6cdd2c85a3333c3c4f4efa1a8b5df385578b348044e3eb7c333c07153543e43a"

URI_python3-urllib3 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-urllib3-1.26.19-2.el10.noarch.rpm;name=python3-urllib3;unpack=0"
SRC_URI += "${URI_python3-urllib3}"
SRC_URI[python3-urllib3.sha256sum] = "759531e2e5a8a2254349ae91b046a3397e5633b31a562e252409a0aee4d7bc0f"
RDEPENDS:python3-urllib3 = " \
 ca-certificates \
 python3-idna \
 python3 \
"
