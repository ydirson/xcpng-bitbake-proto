# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ima-evm-utils"
PE = "0"
PV = "1.6.2"
PR = "1.el10"
PACKAGES = "ima-evm-utils ima-evm-utils-devel"
PROVIDES = "rpm/ima-evm-utils rpm/ima-evm-utils-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/ima-evm-utils-1.6.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2b71bab3dddfacf7fd669a1327d20e2287361c2374767d36837bba7f7b69153"

URI_ima-evm-utils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/ima-evm-utils-1.6.2-1.el10.x86_64_v2.rpm;name=ima-evm-utils;unpack=0"
SRC_URI += "${URI_ima-evm-utils}"
SRC_URI[ima-evm-utils.sha256sum] = "6e04502f7de9220145d62d303883cd64886a746e943a7a108f8d11971639ac24"
RDEPENDS:ima-evm-utils = " \
 attr \
 keyutils \
 keyutils-libs \
 openssl-libs \
 bash \
 tpm2-tss \
 glibc \
"

URI_ima-evm-utils-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ima-evm-utils-devel-1.6.2-1.el10.x86_64_v2.rpm;name=ima-evm-utils-devel;unpack=0"
SRC_URI += "${URI_ima-evm-utils-devel}"
SRC_URI[ima-evm-utils-devel.sha256sum] = "b8ea7d892490a2a7171ce26120e0fe2b740e48b0ee9d4019fb2235d40ac72ea1"
RDEPENDS:ima-evm-utils-devel = " \
 ima-evm-utils \
"
