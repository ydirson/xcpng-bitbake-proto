# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-argcomplete"
PE = "0"
PV = "3.2.2"
PR = "4.el10"
PACKAGES = "python3-argcomplete"
PROVIDES = "rpm/python3-argcomplete"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-argcomplete-3.2.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a80c4b9295286ccca9bcce21564c9ba3cafb3fdcc1f370703a8a3b3841ba6dce"

URI_python3-argcomplete = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-argcomplete-3.2.2-4.el10.noarch.rpm;name=python3-argcomplete;unpack=0"
SRC_URI += "${URI_python3-argcomplete}"
SRC_URI[python3-argcomplete.sha256sum] = "636d665e412142fc674b52827ca949820e71b37cce0a0f6f7a01a4adf1a42e08"
RDEPENDS:python3-argcomplete = " \
 python3 \
"
