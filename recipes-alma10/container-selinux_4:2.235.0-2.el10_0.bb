# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "container-selinux"
PE = "4"
PV = "2.235.0"
PR = "2.el10_0"
PACKAGES = "container-selinux"
PROVIDES = "rpm/container-selinux"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/container-selinux-2.235.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "807f238576348016fcc9c543e45305a59cc329fc5fd5943da42a792a075ab613"

URI_container-selinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/container-selinux-2.235.0-2.el10_0.noarch.rpm;name=container-selinux;unpack=0"
SRC_URI += "${URI_container-selinux}"
SRC_URI[container-selinux.sha256sum] = "985390d1e3f4090927b7433d1d975f2d3e388aff3ad41c2b9b2801c0d80d2c26"
RDEPENDS:container-selinux = " \
 policycoreutils \
 bash \
 selinux-policy-minimum \
 sed \
 selinux-policy \
 libselinux-utils \
"
