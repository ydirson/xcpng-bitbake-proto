# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libvirt-python"
PE = "0"
PV = "10.10.0"
PR = "1.el10"
PACKAGES = "python3-libvirt"
PROVIDES = "rpm/python3-libvirt"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libvirt-python-10.10.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2565806710d87f074bd3077279eb21eca40c030ff6f9e5bb317220e5a4d2bce"

URI_python3-libvirt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-libvirt-10.10.0-1.el10.x86_64_v2.rpm;name=python3-libvirt;unpack=0"
SRC_URI += "${URI_python3-libvirt}"
SRC_URI[python3-libvirt.sha256sum] = "a11f8d4039f97a914c471fcced6d4622ef1718a8a23b8bab84c520063dc5b7d4"
RDEPENDS:python3-libvirt = " \
 glibc \
 libvirt-libs \
 python3 \
"
