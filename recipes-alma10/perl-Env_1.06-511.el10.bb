# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Env"
PE = "0"
PV = "1.06"
PR = "511.el10"
PACKAGES = "perl-Env perl-Env-tests"
PROVIDES = "rpm/perl-Env rpm/perl-Env-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Env-1.06-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bba9ee97c41ac49279f267eb72a58691be748ada2ebeb3c5ecdad80ff05d5ce3"

URI_perl-Env = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Env-1.06-511.el10.noarch.rpm;name=perl-Env;unpack=0"
SRC_URI += "${URI_perl-Env}"
SRC_URI[perl-Env.sha256sum] = "453a4f4fa555ba7b5c99d836e4f38fa5ebd22157066a159dfcd7052ff7fd8d96"
RDEPENDS:perl-Env = " \
 perl-libs \
 perl-Tie \
"

URI_perl-Env-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Env-tests-1.06-511.el10.noarch.rpm;name=perl-Env-tests;unpack=0"
SRC_URI += "${URI_perl-Env-tests}"
SRC_URI[perl-Env-tests.sha256sum] = "948b189f5edde66618e1397a6d7f076e262d7d0fe814bd899d62431b7171ef00"
RDEPENDS:perl-Env-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-vars \
 bash \
 perl-Env \
 perl-interpreter \
"
