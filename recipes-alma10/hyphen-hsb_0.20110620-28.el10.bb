# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-hsb"
PE = "0"
PV = "0.20110620"
PR = "28.el10"
PACKAGES = "hyphen-hsb"
PROVIDES = "rpm/hyphen-hsb"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-hsb-0.20110620-28.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66c2c26d64abce03fa700825bfab95628ec3f398e855129763f6929c32aa919c"

URI_hyphen-hsb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-hsb-0.20110620-28.el10.noarch.rpm;name=hyphen-hsb;unpack=0"
SRC_URI += "${URI_hyphen-hsb}"
SRC_URI[hyphen-hsb.sha256sum] = "c899410379126ec194d674e747b739e6c9f31396723622c1b31c058bbeb32460"
RDEPENDS:hyphen-hsb = " \
 hyphen \
"
