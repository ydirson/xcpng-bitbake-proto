# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "appstream"
PE = "0"
PV = "1.0.2"
PR = "5.el10"
PACKAGES = "appstream appstream-compose appstream-compose-devel appstream-devel appstream-qt appstream-qt-devel"
PROVIDES = "rpm/appstream rpm/appstream-compose rpm/appstream-compose-devel rpm/appstream-devel rpm/appstream-qt rpm/appstream-qt-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/appstream-1.0.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "929196f6966d16e479f345efd49b743a7cb08db17493bf3f3c1ab60779ac9ea5"

URI_appstream = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/appstream-1.0.2-5.el10.x86_64_v2.rpm;name=appstream;unpack=0"
SRC_URI += "${URI_appstream}"
SRC_URI[appstream.sha256sum] = "ac602732606ff9b21b1acdb0d7b6739233f9520f281c4ceb4762400616f92984"
RDEPENDS:appstream = " \
 systemd-libs \
 libgcc \
 appstream-data \
 libxml2 \
 libxmlb \
 libyaml \
 libzstd \
 bash \
 glib2 \
 libcurl \
 glibc \
"

URI_appstream-compose = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/appstream-compose-1.0.2-5.el10.x86_64_v2.rpm;name=appstream-compose;unpack=0"
SRC_URI += "${URI_appstream-compose}"
SRC_URI[appstream-compose.sha256sum] = "92759f47ab7136393e582dedf67056ccf7e4e985fc3a9eed1d57bed2a16db614"
RDEPENDS:appstream-compose = " \
 freetype \
 librsvg2 \
 appstream \
 libgcc \
 pango \
 gdk-pixbuf2 \
 fontconfig \
 libyaml \
 cairo \
 glib2 \
 glibc \
"

URI_appstream-compose-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/appstream-compose-devel-1.0.2-5.el10.x86_64_v2.rpm;name=appstream-compose-devel;unpack=0"
SRC_URI += "${URI_appstream-compose-devel}"
SRC_URI[appstream-compose-devel.sha256sum] = "43557bee25350bbb60f4fd0a8184cb305ac663c769966a6e829acccdbb40f17b"
RDEPENDS:appstream-compose-devel = " \
 glib2-devel \
 appstream-compose \
 pkgconf-pkg-config \
 gdk-pixbuf2-devel \
 appstream-devel \
"

URI_appstream-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/appstream-devel-1.0.2-5.el10.x86_64_v2.rpm;name=appstream-devel;unpack=0"
SRC_URI += "${URI_appstream-devel}"
SRC_URI[appstream-devel.sha256sum] = "df1cad6f5fda100ad55cadb438eac6d52c1ade487a9aefd6d8484302e45b9c68"
RDEPENDS:appstream-devel = " \
 appstream \
 glib2-devel \
 pkgconf-pkg-config \
"

URI_appstream-qt = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/appstream-qt-1.0.2-5.el10.x86_64_v2.rpm;name=appstream-qt;unpack=0"
SRC_URI += "${URI_appstream-qt}"
SRC_URI[appstream-qt.sha256sum] = "ecbce5a887ec0cc1d53516c8f063e4a6e4b87d79da8d0d5d4c5a7d6c53b5d2a6"
RDEPENDS:appstream-qt = " \
 appstream \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 glib2 \
 glibc \
"

URI_appstream-qt-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/appstream-qt-devel-1.0.2-5.el10.x86_64_v2.rpm;name=appstream-qt-devel;unpack=0"
SRC_URI += "${URI_appstream-qt-devel}"
SRC_URI[appstream-qt-devel.sha256sum] = "c6d232d37a0e27b983652d4d7f7d0c5f574bf7a8ae75af412dd2f9dcdb08e174"
RDEPENDS:appstream-qt-devel = " \
 qt6-qtbase-devel \
 cmake-filesystem \
 appstream-qt \
"
