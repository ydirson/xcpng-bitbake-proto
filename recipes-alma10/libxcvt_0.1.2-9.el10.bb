# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libxcvt"
PE = "0"
PV = "0.1.2"
PR = "9.el10"
PACKAGES = "libxcvt libxcvt-devel cvt"
PROVIDES = "rpm/libxcvt rpm/libxcvt-devel rpm/cvt"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libxcvt-0.1.2-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "830c31c81c128f3f6c0b5e4474ba16f7d7992d2eaba483324abeeb1a6bd54c71"

URI_libxcvt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libxcvt-0.1.2-9.el10.x86_64_v2.rpm;name=libxcvt;unpack=0"
SRC_URI += "${URI_libxcvt}"
SRC_URI[libxcvt.sha256sum] = "fce8fb8615256e6c7e8b88dd375d580ba3d97f3520155b59b025baba85c690a2"
RDEPENDS:libxcvt = " \
 glibc \
"

URI_libxcvt-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libxcvt-devel-0.1.2-9.el10.x86_64_v2.rpm;name=libxcvt-devel;unpack=0"
SRC_URI += "${URI_libxcvt-devel}"
SRC_URI[libxcvt-devel.sha256sum] = "c1f4639f5b63f85f010101de22111645131f16d0d68db8fc9c7f21a10c45f128"
RDEPENDS:libxcvt-devel = " \
 libxcvt \
 pkgconf-pkg-config \
"

URI_cvt = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/cvt-0.1.2-9.el10.x86_64_v2.rpm;name=cvt;unpack=0"
SRC_URI += "${URI_cvt}"
SRC_URI[cvt.sha256sum] = "7c89c1846a893c0627c478f14b75e70f644e58149766ac792280ce1202537c60"
RDEPENDS:cvt = " \
 glibc \
 libxcvt \
"
