# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dnf"
PE = "0"
PV = "4.20.0"
PR = "14.el10_0.alma.1"
PACKAGES = "dnf dnf-automatic dnf-data python3-dnf yum dnf-bootc"
PROVIDES = "rpm/dnf rpm/dnf-automatic rpm/dnf-data rpm/python3-dnf rpm/yum rpm/dnf-bootc"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/dnf-4.20.0-14.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b57f5a0d900de3b81f9aa038e0bcf0567c794c7168a6d1a8f5d99e3079a8eb97"

URI_dnf = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/dnf-4.20.0-14.el10_0.alma.1.noarch.rpm;name=dnf;unpack=0"
SRC_URI += "${URI_dnf}"
SRC_URI[dnf.sha256sum] = "441c575feef3a6a26fb7b294248efaa03c98293fb066f0d47be05eacb582fa84"
RDEPENDS:dnf = " \
 coreutils \
 bash \
 python3-dnf \
"

URI_dnf-automatic = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/dnf-automatic-4.20.0-14.el10_0.alma.1.noarch.rpm;name=dnf-automatic;unpack=0"
SRC_URI += "${URI_dnf-automatic}"
SRC_URI[dnf-automatic.sha256sum] = "d24c0bc6d8abd364904a74b45de95a8d55f120e02c1da7579c88157a3503fa86"
RDEPENDS:dnf-automatic = " \
 python3 \
 systemd \
 bash \
 python3-dnf \
"

URI_dnf-data = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/dnf-data-4.20.0-14.el10_0.alma.1.noarch.rpm;name=dnf-data;unpack=0"
SRC_URI += "${URI_dnf-data}"
SRC_URI[dnf-data.sha256sum] = "ead127c692f2d1fa2ceec591783e1c9b55e789bca637ceea83685bdfea4646fd"
RDEPENDS:dnf-data = ""

URI_python3-dnf = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-dnf-4.20.0-14.el10_0.alma.1.noarch.rpm;name=python3-dnf;unpack=0"
SRC_URI += "${URI_python3-dnf}"
SRC_URI[python3-dnf.sha256sum] = "b176a04a3112cef26ddd9e9e8696218e289f8349ebfc8cd8d46aeaf62ef3f649"
RDEPENDS:python3-dnf = " \
 python3 \
 python3-libcomps \
 python3-libdnf \
 python3-rpm \
 libmodulemd \
 dnf-data \
 python3-hawkey \
"

URI_yum = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/yum-4.20.0-14.el10_0.alma.1.noarch.rpm;name=yum;unpack=0"
SRC_URI += "${URI_yum}"
SRC_URI[yum.sha256sum] = "b294e9dc801aeb27c54f8d3a822a5c463d9ead50701ef524a27bd6ad3be4796b"
RDEPENDS:yum = " \
 dnf \
"

URI_dnf-bootc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dnf-bootc-4.20.0-14.el10_0.alma.1.noarch.rpm;name=dnf-bootc;unpack=0"
SRC_URI += "${URI_dnf-bootc}"
SRC_URI[dnf-bootc.sha256sum] = "6741e74408702ae89ba4332781b631422b2857654c7737114afc5e0f0b191f4b"
RDEPENDS:dnf-bootc = " \
 ostree-libs \
 util-linux-core \
 python3-dnf \
 python3-gobject-base \
 ostree \
"
