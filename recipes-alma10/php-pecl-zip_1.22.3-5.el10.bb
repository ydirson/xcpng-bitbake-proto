# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "php-pecl-zip"
PE = "0"
PV = "1.22.3"
PR = "5.el10"
PACKAGES = "php-pecl-zip"
PROVIDES = "rpm/php-pecl-zip"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/php-pecl-zip-1.22.3-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cbe30bcd744c1642a1f900476511d3ba15f93f849b732cceef7102b31bbab83d"

URI_php-pecl-zip = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-pecl-zip-1.22.3-5.el10.x86_64_v2.rpm;name=php-pecl-zip;unpack=0"
SRC_URI += "${URI_php-pecl-zip}"
SRC_URI[php-pecl-zip.sha256sum] = "5871d03d8da8757475de01d586ccc91b36c129717d9c0253ffc9c813c07962d1"
RDEPENDS:php-pecl-zip = " \
 glibc \
 libzip \
 php-common \
"
