# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "less"
PE = "0"
PV = "661"
PR = "3.el10"
PACKAGES = "less"
PROVIDES = "rpm/less"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/less-661-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ab1f54197add456b588044fbe40b1922c9e22466d9a6a1d2abc1912d6e19321"

URI_less = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/less-661-3.el10.x86_64_v2.rpm;name=less;unpack=0"
SRC_URI += "${URI_less}"
SRC_URI[less.sha256sum] = "e6c0cc1d4578bcdfe5ac028a53e3ebaae446b2a39256641938c94a65b1e353fa"
RDEPENDS:less = " \
 glibc \
 bash \
 ncurses-libs \
"
