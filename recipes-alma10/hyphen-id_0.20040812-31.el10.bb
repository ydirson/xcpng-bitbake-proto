# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-id"
PE = "0"
PV = "0.20040812"
PR = "31.el10"
PACKAGES = "hyphen-id"
PROVIDES = "rpm/hyphen-id"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-id-0.20040812-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06b404895760a39e69163baaeba1920d7ef98563426d1c90c17efd4c143493e9"

URI_hyphen-id = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-id-0.20040812-31.el10.noarch.rpm;name=hyphen-id;unpack=0"
SRC_URI += "${URI_hyphen-id}"
SRC_URI[hyphen-id.sha256sum] = "aeb3586e56a31d972e6bd27deae22380a9b65ede7b440ad214163f1c2c1e3b95"
RDEPENDS:hyphen-id = " \
 hyphen \
"
