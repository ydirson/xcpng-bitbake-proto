# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tboot"
PE = "1"
PV = "1.11.9"
PR = "1.el10"
PACKAGES = "tboot"
PROVIDES = "rpm/tboot"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/tboot-1.11.9-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74609dd1e2dd31bfd345c0e01360939dba8cf41582ac21e1602bddfa9beca4dd"

URI_tboot = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/tboot-1.11.9-1.el10.x86_64_v2.rpm;name=tboot;unpack=0"
SRC_URI += "${URI_tboot}"
SRC_URI[tboot.sha256sum] = "8fe1440b598943430c77b2ef69362273a96d0fc0014e10726cfcfe011b4b2856"
RDEPENDS:tboot = " \
 zlib-ng-compat \
 openssl-libs \
 bash \
 glibc \
 grub2-efi-x64-modules \
"
