# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dwarves"
PE = "0"
PV = "1.27"
PR = "3.el10"
PACKAGES = "dwarves libdwarves1 libdwarves1-devel"
PROVIDES = "rpm/dwarves rpm/libdwarves1 rpm/libdwarves1-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/dwarves-1.27-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b1e19230b70245571aae3a19d80821d5c890a1dd8a333a7ab77c07a76ebb35d"

URI_dwarves = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dwarves-1.27-3.el10.x86_64_v2.rpm;name=dwarves;unpack=0"
SRC_URI += "${URI_dwarves}"
SRC_URI[dwarves.sha256sum] = "6613fce4bf8a351d7f12be91110b50894d4507d4362dd22b4c8c1d1f39098a09"
RDEPENDS:dwarves = " \
 python3 \
 libdwarves1 \
 elfutils-libelf \
 bash \
 glibc \
"

URI_libdwarves1 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libdwarves1-1.27-3.el10.x86_64_v2.rpm;name=libdwarves1;unpack=0"
SRC_URI += "${URI_libdwarves1}"
SRC_URI[libdwarves1.sha256sum] = "2f11d12d538cfdd005306d574741d83ab341a45387ca19b0cc880226bc7e035b"
RDEPENDS:libdwarves1 = " \
 glibc \
 zlib-ng-compat \
 elfutils-libelf \
 elfutils-libs \
"

URI_libdwarves1-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdwarves1-devel-1.27-3.el10.x86_64_v2.rpm;name=libdwarves1-devel;unpack=0"
SRC_URI += "${URI_libdwarves1-devel}"
SRC_URI[libdwarves1-devel.sha256sum] = "df264f63246bbf232cf9d3d98f2b4f3f19fbc47db9c5818bdcaf6916cefa4e5c"
RDEPENDS:libdwarves1-devel = " \
 libdwarves1 \
"
