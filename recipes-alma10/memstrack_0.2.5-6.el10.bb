# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "memstrack"
PE = "0"
PV = "0.2.5"
PR = "6.el10"
PACKAGES = "memstrack"
PROVIDES = "rpm/memstrack"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/memstrack-0.2.5-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73b5d59ca5f904c8acd25412679ab90ef88529e9d359c9abbdbb6efbe77f9531"

URI_memstrack = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/memstrack-0.2.5-6.el10.x86_64_v2.rpm;name=memstrack;unpack=0"
SRC_URI += "${URI_memstrack}"
SRC_URI[memstrack.sha256sum] = "b234c06d66cf10791ec04cf8b2f9cee6ab0e2fc361aeaf5d4368fd68cbb10540"
RDEPENDS:memstrack = " \
 glibc \
 ncurses-libs \
"
