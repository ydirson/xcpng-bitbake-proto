# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cjose"
PE = "0"
PV = "0.6.2.2"
PR = "7.el10"
PACKAGES = "cjose cjose-devel"
PROVIDES = "rpm/cjose rpm/cjose-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/cjose-0.6.2.2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e00078ed201a0d1ee80533c354843316e4e1ab57288c4a7f19ff7a4f9b3effc5"

URI_cjose = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cjose-0.6.2.2-7.el10.x86_64_v2.rpm;name=cjose;unpack=0"
SRC_URI += "${URI_cjose}"
SRC_URI[cjose.sha256sum] = "8907d7d3bd39cc783fd3ad5d3584470fdef0efb7c93c4bbcb601c009b0b605e2"
RDEPENDS:cjose = " \
 glibc \
 openssl-libs \
 jansson \
"

URI_cjose-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/cjose-devel-0.6.2.2-7.el10.x86_64_v2.rpm;name=cjose-devel;unpack=0"
SRC_URI += "${URI_cjose-devel}"
SRC_URI[cjose-devel.sha256sum] = "6840b0b6c91acd67127f48fc384537032321c68d4363ffab6a47675830a2ee6f"
RDEPENDS:cjose-devel = " \
 cjose \
 openssl-devel \
 jansson-devel \
 pkgconf-pkg-config \
"
