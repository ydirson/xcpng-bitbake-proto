# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jaxb-stax-ex"
PE = "0"
PV = "2.1.0"
PR = "9.el10"
PACKAGES = "jaxb-stax-ex jaxb-stax-ex-javadoc"
PROVIDES = "rpm/jaxb-stax-ex rpm/jaxb-stax-ex-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/jaxb-stax-ex-2.1.0-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71a83a4ce6310e45d93fa659edb9be7dce912eeb9385bd5c6f0cba6efce9c39a"

URI_jaxb-stax-ex = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jaxb-stax-ex-2.1.0-9.el10.noarch.rpm;name=jaxb-stax-ex;unpack=0"
SRC_URI += "${URI_jaxb-stax-ex}"
SRC_URI[jaxb-stax-ex.sha256sum] = "11f51f52b8cd52e1584204ab6a0d9621e7cbf86af27eaa40da60a60353f48264"
RDEPENDS:jaxb-stax-ex = " \
 jakarta-activation \
 javapackages-filesystem \
"

URI_jaxb-stax-ex-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jaxb-stax-ex-javadoc-2.1.0-9.el10.noarch.rpm;name=jaxb-stax-ex-javadoc;unpack=0"
SRC_URI += "${URI_jaxb-stax-ex-javadoc}"
SRC_URI[jaxb-stax-ex-javadoc.sha256sum] = "e090f4c8adbe1329aed3881523ec3bc7f16da9a1e100bfa437ebe34e77b24aaf"
RDEPENDS:jaxb-stax-ex-javadoc = " \
 javapackages-filesystem \
"
