# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "NetworkManager"
PE = "1"
PV = "1.52.0"
PR = "8.el10_0"
PACKAGES = "NetworkManager NetworkManager-adsl NetworkManager-bluetooth NetworkManager-config-server NetworkManager-libnm NetworkManager-tui NetworkManager-wifi NetworkManager-wwan NetworkManager-cloud-setup NetworkManager-config-connectivity-redhat NetworkManager-ovs NetworkManager-ppp NetworkManager-libnm-devel"
PROVIDES = "rpm/NetworkManager rpm/NetworkManager-adsl rpm/NetworkManager-bluetooth rpm/NetworkManager-config-server rpm/NetworkManager-libnm rpm/NetworkManager-tui rpm/NetworkManager-wifi rpm/NetworkManager-wwan rpm/NetworkManager-cloud-setup rpm/NetworkManager-config-connectivity-redhat rpm/NetworkManager-ovs rpm/NetworkManager-ppp rpm/NetworkManager-libnm-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/NetworkManager-1.52.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0e0341da77bea330aabf98c1627a38fd016096f81dcaeb491e4c45ccf8cc27e"

URI_NetworkManager = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/NetworkManager-1.52.0-8.el10_0.x86_64_v2.rpm;name=NetworkManager;unpack=0"
SRC_URI += "${URI_NetworkManager}"
SRC_URI[NetworkManager.sha256sum] = "e0c752db93cf0dc6a6ec0f98d3d468e67d8752f87edfc0187084b6483c3f7f4d"
RDEPENDS:NetworkManager = " \
 systemd \
 systemd-libs \
 gnutls \
 systemd-udev \
 libgcc \
 readline \
 audit-libs \
 libndp \
 libselinux \
 bash \
 glib2 \
 dbus \
 libcurl \
 glibc \
 alternatives \
 NetworkManager-libnm \
"

URI_NetworkManager-adsl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/NetworkManager-adsl-1.52.0-8.el10_0.x86_64_v2.rpm;name=NetworkManager-adsl;unpack=0"
SRC_URI += "${URI_NetworkManager-adsl}"
SRC_URI[NetworkManager-adsl.sha256sum] = "2ebf39b2c2650696e57ae026f3409038288c1fd662cad6aad194c3d4942a2b5a"
RDEPENDS:NetworkManager-adsl = " \
 glibc \
 NetworkManager \
 libgcc \
 glib2 \
"

URI_NetworkManager-bluetooth = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/NetworkManager-bluetooth-1.52.0-8.el10_0.x86_64_v2.rpm;name=NetworkManager-bluetooth;unpack=0"
SRC_URI += "${URI_NetworkManager-bluetooth}"
SRC_URI[NetworkManager-bluetooth.sha256sum] = "6c9835f0b555c3edd5fcf383f5de3461e9cc1fa20a35b9ac5899332bbcb1fffb"
RDEPENDS:NetworkManager-bluetooth = " \
 NetworkManager \
 NetworkManager-wwan \
 libgcc \
 glib2 \
 glibc \
 bluez \
 bluez-libs \
"

URI_NetworkManager-config-server = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/NetworkManager-config-server-1.52.0-8.el10_0.noarch.rpm;name=NetworkManager-config-server;unpack=0"
SRC_URI += "${URI_NetworkManager-config-server}"
SRC_URI[NetworkManager-config-server.sha256sum] = "d8860d3a7f9b0fd79257e259bc586619a9798b9fe5da3ff124af250824230bfb"
RDEPENDS:NetworkManager-config-server = ""

URI_NetworkManager-libnm = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/NetworkManager-libnm-1.52.0-8.el10_0.x86_64_v2.rpm;name=NetworkManager-libnm;unpack=0"
SRC_URI += "${URI_NetworkManager-libnm}"
SRC_URI[NetworkManager-libnm.sha256sum] = "5b32e8402c8e79b1095d22f028d1b6c6f671e2174efed516897ed27796686e15"
RDEPENDS:NetworkManager-libnm = " \
 gnutls \
 systemd-libs \
 libgcc \
 glib2 \
 glibc \
"

URI_NetworkManager-tui = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/NetworkManager-tui-1.52.0-8.el10_0.x86_64_v2.rpm;name=NetworkManager-tui;unpack=0"
SRC_URI += "${URI_NetworkManager-tui}"
SRC_URI[NetworkManager-tui.sha256sum] = "4619f234d31e447b4e8bf620a87b5afe432ad62b721f71240b815a2fab343d95"
RDEPENDS:NetworkManager-tui = " \
 newt \
 NetworkManager \
 libgcc \
 glib2 \
 glibc \
 NetworkManager-libnm \
"

URI_NetworkManager-wifi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/NetworkManager-wifi-1.52.0-8.el10_0.x86_64_v2.rpm;name=NetworkManager-wifi;unpack=0"
SRC_URI += "${URI_NetworkManager-wifi}"
SRC_URI[NetworkManager-wifi.sha256sum] = "3a1fea30232dee73620a70eca3addb5e08c2f4a61fc4a27f7475ccae1f662d9b"
RDEPENDS:NetworkManager-wifi = " \
 NetworkManager \
 libgcc \
 glib2 \
 wireless-regdb \
 glibc \
 wpa_supplicant \
"

URI_NetworkManager-wwan = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/NetworkManager-wwan-1.52.0-8.el10_0.x86_64_v2.rpm;name=NetworkManager-wwan;unpack=0"
SRC_URI += "${URI_NetworkManager-wwan}"
SRC_URI[NetworkManager-wwan.sha256sum] = "e6954811d42703ffd6fda3504cd7deb331d02dc03f39b68b62740dc2ac52b84a"
RDEPENDS:NetworkManager-wwan = " \
 ModemManager \
 ModemManager-glib \
 systemd-libs \
 NetworkManager \
 libgcc \
 glib2 \
 glibc \
"

URI_NetworkManager-cloud-setup = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/NetworkManager-cloud-setup-1.52.0-8.el10_0.x86_64_v2.rpm;name=NetworkManager-cloud-setup;unpack=0"
SRC_URI += "${URI_NetworkManager-cloud-setup}"
SRC_URI[NetworkManager-cloud-setup.sha256sum] = "fa4666bf8ea9664ef081a6fdef5febd57bda38385b5e530b6d2175278f674870"
RDEPENDS:NetworkManager-cloud-setup = " \
 jansson \
 NetworkManager \
 libgcc \
 bash \
 glib2 \
 libcurl \
 glibc \
 NetworkManager-libnm \
"

URI_NetworkManager-config-connectivity-redhat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/NetworkManager-config-connectivity-redhat-1.52.0-8.el10_0.noarch.rpm;name=NetworkManager-config-connectivity-redhat;unpack=0"
SRC_URI += "${URI_NetworkManager-config-connectivity-redhat}"
SRC_URI[NetworkManager-config-connectivity-redhat.sha256sum] = "425fe524670ccccbb3faef9043cdd9a37c24c28fae6217055d4900f29168deb8"
RDEPENDS:NetworkManager-config-connectivity-redhat = ""

URI_NetworkManager-ovs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/NetworkManager-ovs-1.52.0-8.el10_0.x86_64_v2.rpm;name=NetworkManager-ovs;unpack=0"
SRC_URI += "${URI_NetworkManager-ovs}"
SRC_URI[NetworkManager-ovs.sha256sum] = "0145067bb1b783dd1f93c496d9755d8e226efe46d7e3fb1b688542a5bd8d00d4"
RDEPENDS:NetworkManager-ovs = " \
 NetworkManager \
 jansson \
 libgcc \
 glib2 \
 glibc \
"

URI_NetworkManager-ppp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/NetworkManager-ppp-1.52.0-8.el10_0.x86_64_v2.rpm;name=NetworkManager-ppp;unpack=0"
SRC_URI += "${URI_NetworkManager-ppp}"
SRC_URI[NetworkManager-ppp.sha256sum] = "f1b136f72eb8c39e248028faa85e73636b28185a042e00d34fb5fdb83b8abc00"
RDEPENDS:NetworkManager-ppp = " \
 NetworkManager \
 libgcc \
 glib2 \
 ppp \
 glibc \
"

URI_NetworkManager-libnm-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/NetworkManager-libnm-devel-1.52.0-8.el10_0.x86_64_v2.rpm;name=NetworkManager-libnm-devel;unpack=0"
SRC_URI += "${URI_NetworkManager-libnm-devel}"
SRC_URI[NetworkManager-libnm-devel.sha256sum] = "3af71791895158c378b4d36f2374ec2fd4a5e7fea045b5d83a66952b221fb854"
RDEPENDS:NetworkManager-libnm-devel = " \
 glib2-devel \
 NetworkManager-libnm \
 pkgconf-pkg-config \
"
