# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-pkgconfig"
PE = "0"
PV = "1.5.5"
PR = "10.el10"
PACKAGES = "python3-pkgconfig"
PROVIDES = "rpm/python3-pkgconfig"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/python-pkgconfig-1.5.5-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6e03975bae917a73d564892cf38fbcb1ed7da9b49c4aa8b832e25cfd80357d0"

URI_python3-pkgconfig = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-pkgconfig-1.5.5-10.el10.noarch.rpm;name=python3-pkgconfig;unpack=0"
SRC_URI += "${URI_python3-pkgconfig}"
SRC_URI[python3-pkgconfig.sha256sum] = "c1a72c0e3749812a75a072855c3ffc5e9096f7e157bf3acc92f43ca6b8e3239e"
RDEPENDS:python3-pkgconfig = " \
 python3 \
 pkgconf-pkg-config \
"
