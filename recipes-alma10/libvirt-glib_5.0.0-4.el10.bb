# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libvirt-glib"
PE = "0"
PV = "5.0.0"
PR = "4.el10"
PACKAGES = "libvirt-glib libvirt-gconfig libvirt-gconfig-devel libvirt-glib-devel libvirt-gobject libvirt-gobject-devel"
PROVIDES = "rpm/libvirt-glib rpm/libvirt-gconfig rpm/libvirt-gconfig-devel rpm/libvirt-glib-devel rpm/libvirt-gobject rpm/libvirt-gobject-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libvirt-glib-5.0.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8344db00288c50ec71106f0647d282cd48943a6ce6bd299c04ee87a36266adea"

URI_libvirt-glib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-glib-5.0.0-4.el10.x86_64_v2.rpm;name=libvirt-glib;unpack=0"
SRC_URI += "${URI_libvirt-glib}"
SRC_URI[libvirt-glib.sha256sum] = "c54fc86800a368e6bbbdbdbd4ab20d70865eb2e93afb6e905581dd177625f48b"
RDEPENDS:libvirt-glib = " \
 glibc \
 libvirt-libs \
 glib2 \
"

URI_libvirt-gconfig = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libvirt-gconfig-5.0.0-4.el10.x86_64_v2.rpm;name=libvirt-gconfig;unpack=0"
SRC_URI += "${URI_libvirt-gconfig}"
SRC_URI[libvirt-gconfig.sha256sum] = "8038c1f10362fe829c7fa042eb1438b995e10574445122cefff678e19eeeddaa"
RDEPENDS:libvirt-gconfig = " \
 glibc \
 libxml2 \
 glib2 \
"

URI_libvirt-gconfig-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libvirt-gconfig-devel-5.0.0-4.el10.x86_64_v2.rpm;name=libvirt-gconfig-devel;unpack=0"
SRC_URI += "${URI_libvirt-gconfig-devel}"
SRC_URI[libvirt-gconfig-devel.sha256sum] = "c2436ac41220aafa0774b2aec4d61b776b8d86173700225db070ee7a6a17d1ff"
RDEPENDS:libvirt-gconfig-devel = " \
 libxml2-devel \
 libvirt-gconfig \
 glib2-devel \
 pkgconf-pkg-config \
"

URI_libvirt-glib-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libvirt-glib-devel-5.0.0-4.el10.x86_64_v2.rpm;name=libvirt-glib-devel;unpack=0"
SRC_URI += "${URI_libvirt-glib-devel}"
SRC_URI[libvirt-glib-devel.sha256sum] = "186ff491a717bcf0e055be032e4189a66f07bcd3eccb77bf4da78c5d4d1110be"
RDEPENDS:libvirt-glib-devel = " \
 libvirt-glib \
 glib2-devel \
 pkgconf-pkg-config \
"

URI_libvirt-gobject = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libvirt-gobject-5.0.0-4.el10.x86_64_v2.rpm;name=libvirt-gobject;unpack=0"
SRC_URI += "${URI_libvirt-gobject}"
SRC_URI[libvirt-gobject.sha256sum] = "ccc502fcf02d0fe8b36650dd16a703990c4ed2ccc5aca933fc53de2093fa1df9"
RDEPENDS:libvirt-gobject = " \
 libvirt-gconfig \
 glib2 \
 glibc \
 libvirt-glib \
 libvirt-libs \
"

URI_libvirt-gobject-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libvirt-gobject-devel-5.0.0-4.el10.x86_64_v2.rpm;name=libvirt-gobject-devel;unpack=0"
SRC_URI += "${URI_libvirt-gobject-devel}"
SRC_URI[libvirt-gobject-devel.sha256sum] = "f9501831337d187f33d0d7b3c3c60b38a90b0039d850b067dfbcd6e08ff3671e"
RDEPENDS:libvirt-gobject-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 libvirt-devel \
 libvirt-gconfig-devel \
 libvirt-glib-devel \
 libvirt-gobject \
"
