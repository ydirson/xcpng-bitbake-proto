# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mariadb-java-client"
PE = "0"
PV = "3.4.0"
PR = "2.el10"
PACKAGES = "mariadb-java-client mariadb-java-client-javadoc"
PROVIDES = "rpm/mariadb-java-client rpm/mariadb-java-client-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mariadb-java-client-3.4.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de4d007789b82276010d8c7edafb4504f618569772eed4e9d6db04670632bdac"

URI_mariadb-java-client = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mariadb-java-client-3.4.0-2.el10.noarch.rpm;name=mariadb-java-client;unpack=0"
SRC_URI += "${URI_mariadb-java-client}"
SRC_URI[mariadb-java-client.sha256sum] = "826efd7594ff2af87fe50f858b29a4f7066c2c69a059202c5d3846abebf5763b"
RDEPENDS:mariadb-java-client = " \
 jna \
 jna-contrib \
 javapackages-filesystem \
 slf4j \
"

URI_mariadb-java-client-javadoc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mariadb-java-client-javadoc-3.4.0-2.el10.noarch.rpm;name=mariadb-java-client-javadoc;unpack=0"
SRC_URI += "${URI_mariadb-java-client-javadoc}"
SRC_URI[mariadb-java-client-javadoc.sha256sum] = "5f8de1a84403254700ced9e7b94db0aa1cc9e899525447b8e1e27ad21c158105"
RDEPENDS:mariadb-java-client-javadoc = " \
 javapackages-filesystem \
"
