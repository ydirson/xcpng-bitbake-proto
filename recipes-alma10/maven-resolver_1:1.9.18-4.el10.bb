# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "maven-resolver"
PE = "1"
PV = "1.9.18"
PR = "4.el10"
PACKAGES = "maven-resolver maven-resolver-javadoc"
PROVIDES = "rpm/maven-resolver rpm/maven-resolver-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/maven-resolver-1.9.18-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e43648ad460935087af5c94257c8c7cd794b3dcbbbecf957a3c5509da108b93"

URI_maven-resolver = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/maven-resolver-1.9.18-4.el10.noarch.rpm;name=maven-resolver;unpack=0"
SRC_URI += "${URI_maven-resolver}"
SRC_URI[maven-resolver.sha256sum] = "320032f570a0b0fbe8e98481b0ee1fa11b68491c684acbe1a484ce82efd25d40"
RDEPENDS:maven-resolver = " \
 httpcomponents-client \
 apache-commons-codec \
 httpcomponents-core \
 javapackages-filesystem \
 slf4j \
 jcl-over-slf4j \
 maven-lib \
 maven-wagon \
"

URI_maven-resolver-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-resolver-javadoc-1.9.18-4.el10.noarch.rpm;name=maven-resolver-javadoc;unpack=0"
SRC_URI += "${URI_maven-resolver-javadoc}"
SRC_URI[maven-resolver-javadoc.sha256sum] = "38fb200ee9256e0fa9ff46188babcc18d0e680439620f1c6345c212097cc7920"
RDEPENDS:maven-resolver-javadoc = " \
 javapackages-filesystem \
"
