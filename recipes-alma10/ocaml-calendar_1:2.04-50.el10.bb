# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ocaml-calendar"
PE = "1"
PV = "2.04"
PR = "50.el10"
PACKAGES = "ocaml-calendar ocaml-calendar-devel"
PROVIDES = "rpm/ocaml-calendar rpm/ocaml-calendar-devel"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/ocaml-calendar-2.04-50.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81b111994ac03e7c03571c6d56cc065af8d51b1f47e11caaa1a06b510b169885"

URI_ocaml-calendar = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-calendar-2.04-50.el10.x86_64_v2.rpm;name=ocaml-calendar;unpack=0"
SRC_URI += "${URI_ocaml-calendar}"
SRC_URI[ocaml-calendar.sha256sum] = "7de688b25d7f6359b57075d21dbbd6b7c6e65555442f445f61e12ef1515f8af2"
RDEPENDS:ocaml-calendar = " \
 ocaml-runtime \
 ocaml \
"

URI_ocaml-calendar-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-calendar-devel-2.04-50.el10.x86_64_v2.rpm;name=ocaml-calendar-devel;unpack=0"
SRC_URI += "${URI_ocaml-calendar-devel}"
SRC_URI[ocaml-calendar-devel.sha256sum] = "5fdedf540d5b12a37ed94f5a5b2d2594529639370b73510f8b76ee672a168f11"
RDEPENDS:ocaml-calendar-devel = " \
 ocaml-runtime \
 ocaml \
 ocaml-calendar \
"
