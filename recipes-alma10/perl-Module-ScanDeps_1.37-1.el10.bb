# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Module-ScanDeps"
PE = "0"
PV = "1.37"
PR = "1.el10"
PACKAGES = "perl-Module-ScanDeps perl-Module-ScanDeps-tests"
PROVIDES = "rpm/perl-Module-ScanDeps rpm/perl-Module-ScanDeps-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Module-ScanDeps-1.37-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4116c024e4669adfa9f54a818138dbb0686e88b5048b15aa6373c44190f51c12"

URI_perl-Module-ScanDeps = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Module-ScanDeps-1.37-1.el10.noarch.rpm;name=perl-Module-ScanDeps;unpack=0"
SRC_URI += "${URI_perl-Module-ScanDeps}"
SRC_URI[perl-Module-ScanDeps.sha256sum] = "dda42cde2a8e49a5ee15a5f5bba3553bc63b1a7b979884f084f929bb4f534b84"
RDEPENDS:perl-Module-ScanDeps = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-FileHandle \
 perl-FindBin \
 perl-Module-ScanDeps \
 perl-Getopt-Long \
 perl-B \
 perl-subs \
 perl-vars \
 perl-version \
 perl-Text-ParseWords \
 perl-Data-Dumper \
 perl-DynaLoader \
 perl-Encode \
 perl-Module-Metadata \
 perl-Exporter \
 perl-constant \
 perl-ExtUtils-MakeMaker \
 perl-File-Basename \
 perl-PathTools \
 perl-File-Find \
 perl-interpreter \
 perl-File-Path \
 perl-File-Temp \
"

URI_perl-Module-ScanDeps-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Module-ScanDeps-tests-1.37-1.el10.noarch.rpm;name=perl-Module-ScanDeps-tests;unpack=0"
SRC_URI += "${URI_perl-Module-ScanDeps-tests}"
SRC_URI[perl-Module-ScanDeps-tests.sha256sum] = "cd1771c7c75a4f4b919fd410e432fde38997df0db44742bad62154a0e906bb15"
RDEPENDS:perl-Module-ScanDeps-tests = " \
 perl-libnet \
 perl-IPC-Run3 \
 perl-libs \
 perl-FindBin \
 perl-Module-ScanDeps \
 perl-AutoLoader \
 perl-Test-Requires \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Carp \
 perl-version \
 perl-lib \
 perl-Data-Dumper \
 perl-DynaLoader \
 bash \
 perl-Exporter \
 perl-autouse \
 perl-File-Basename \
 perl-PathTools \
 perl-if \
 perl-interpreter \
 perl-less \
 perl-File-Temp \
"
