# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Test-NoWarnings"
PE = "0"
PV = "1.06"
PR = "10.el10"
PACKAGES = "perl-Test-NoWarnings perl-Test-NoWarnings-tests"
PROVIDES = "rpm/perl-Test-NoWarnings rpm/perl-Test-NoWarnings-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Test-NoWarnings-1.06-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48ec2c7aca7cd2741a1f8c770bafed3cd6816f5ae12766f49b369a7d329a0e9c"

URI_perl-Test-NoWarnings = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Test-NoWarnings-1.06-10.el10.noarch.rpm;name=perl-Test-NoWarnings;unpack=0"
SRC_URI += "${URI_perl-Test-NoWarnings}"
SRC_URI[perl-Test-NoWarnings.sha256sum] = "bb0ceeafd3a5801c1b86b512702163baa58f6c6b11a9e838feed7ecbd3460c95"
RDEPENDS:perl-Test-NoWarnings = " \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-Exporter \
 perl-Test-NoWarnings \
"

URI_perl-Test-NoWarnings-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Test-NoWarnings-tests-1.06-10.el10.noarch.rpm;name=perl-Test-NoWarnings-tests;unpack=0"
SRC_URI += "${URI_perl-Test-NoWarnings-tests}"
SRC_URI[perl-Test-NoWarnings-tests.sha256sum] = "59197021e7848d9ac4d570b76bdbc339298605e57681df579b44d488e95c468a"
RDEPENDS:perl-Test-NoWarnings-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 bash \
 perl-interpreter \
 perl-Test-NoWarnings \
"
