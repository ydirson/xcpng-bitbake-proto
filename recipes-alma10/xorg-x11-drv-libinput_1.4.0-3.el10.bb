# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xorg-x11-drv-libinput"
PE = "0"
PV = "1.4.0"
PR = "3.el10"
PACKAGES = "xorg-x11-drv-libinput xorg-x11-drv-libinput-devel"
PROVIDES = "rpm/xorg-x11-drv-libinput rpm/xorg-x11-drv-libinput-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/xorg-x11-drv-libinput-1.4.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d7c8082d6045adcdb301a9095dda7dbb1a4fdd9cb9321567ef1d1cca8cd95ea"

URI_xorg-x11-drv-libinput = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/xorg-x11-drv-libinput-1.4.0-3.el10.x86_64_v2.rpm;name=xorg-x11-drv-libinput;unpack=0"
SRC_URI += "${URI_xorg-x11-drv-libinput}"
SRC_URI[xorg-x11-drv-libinput.sha256sum] = "994ccfecc4cfc80653670304f333b17299d527144f453c3b381f8b757e3f39c3"
RDEPENDS:xorg-x11-drv-libinput = " \
 glibc \
 libinput \
 xkeyboard-config \
 xorg-x11-server-Xorg \
"

URI_xorg-x11-drv-libinput-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/xorg-x11-drv-libinput-devel-1.4.0-3.el10.x86_64_v2.rpm;name=xorg-x11-drv-libinput-devel;unpack=0"
SRC_URI += "${URI_xorg-x11-drv-libinput-devel}"
SRC_URI[xorg-x11-drv-libinput-devel.sha256sum] = "e477fb39791c06d0dac20a35ac28ebedc97c9a6a7a70ce8f8dd88fe665613a26"
RDEPENDS:xorg-x11-drv-libinput-devel = " \
 pkgconf-pkg-config \
"
