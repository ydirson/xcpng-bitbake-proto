# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Term-ANSIColor"
PE = "0"
PV = "5.01"
PR = "512.el10"
PACKAGES = "perl-Term-ANSIColor perl-Term-ANSIColor-tests"
PROVIDES = "rpm/perl-Term-ANSIColor rpm/perl-Term-ANSIColor-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Term-ANSIColor-5.01-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5e485374b7d4bddd30dee63c353e70b117680b28c8339a3392c3d50f8ada9ff"

URI_perl-Term-ANSIColor = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Term-ANSIColor-5.01-512.el10.noarch.rpm;name=perl-Term-ANSIColor;unpack=0"
SRC_URI += "${URI_perl-Term-ANSIColor}"
SRC_URI[perl-Term-ANSIColor.sha256sum] = "c757e16b96fdca79291ff666856b382e77f79e771346bdca9d1506c3fae8453b"
RDEPENDS:perl-Term-ANSIColor = " \
 perl-Exporter \
 perl-libs \
"

URI_perl-Term-ANSIColor-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Term-ANSIColor-tests-5.01-512.el10.noarch.rpm;name=perl-Term-ANSIColor-tests;unpack=0"
SRC_URI += "${URI_perl-Term-ANSIColor-tests}"
SRC_URI[perl-Term-ANSIColor-tests.sha256sum] = "29cb0cb05c0b5804525d54f1d5ab8115ebce6693df52618eddec078c45534ff7"
RDEPENDS:perl-Term-ANSIColor-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-File-Temp \
 perl-overload \
 bash \
 perl-base \
 perl-Term-ANSIColor \
 perl-interpreter \
 perl-Exporter \
 perl-lib \
"
