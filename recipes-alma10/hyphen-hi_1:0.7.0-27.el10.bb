# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-hi"
PE = "1"
PV = "0.7.0"
PR = "27.el10"
PACKAGES = "hyphen-hi"
PROVIDES = "rpm/hyphen-hi"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-hi-0.7.0-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1fc4cbe33d1b7e74c1802a37eaab7e130d0c36d5889dc2de2097c5539272295"

URI_hyphen-hi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-hi-0.7.0-27.el10.noarch.rpm;name=hyphen-hi;unpack=0"
SRC_URI += "${URI_hyphen-hi}"
SRC_URI[hyphen-hi.sha256sum] = "74fb3f440412a786f80897b99f6b468b32070ae2a772591a9023423dacb84265"
RDEPENDS:hyphen-hi = " \
 hyphen \
"
