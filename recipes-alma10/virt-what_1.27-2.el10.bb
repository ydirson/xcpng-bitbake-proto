# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "virt-what"
PE = "0"
PV = "1.27"
PR = "2.el10"
PACKAGES = "virt-what"
PROVIDES = "rpm/virt-what"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/virt-what-1.27-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10f849a7757dff987f4bc6383ad381e6c5142ba240d61910d7faf15524fed174"

URI_virt-what = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/virt-what-1.27-2.el10.x86_64_v2.rpm;name=virt-what;unpack=0"
SRC_URI += "${URI_virt-what}"
SRC_URI[virt-what.sha256sum] = "0b6365c2211fcb965e0824140b22f562b3e52443fbed3ebbb0b42d3548ade911"
RDEPENDS:virt-what = " \
 util-linux \
 dmidecode \
 bash \
 which \
 glibc \
"
