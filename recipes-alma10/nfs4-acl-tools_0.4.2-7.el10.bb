# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "nfs4-acl-tools"
PE = "0"
PV = "0.4.2"
PR = "7.el10"
PACKAGES = "nfs4-acl-tools"
PROVIDES = "rpm/nfs4-acl-tools"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/nfs4-acl-tools-0.4.2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d4c2e3884b38d76ecc3284aa8716c4e1c0ad21f7436bc7db631a7f79de9c192"

URI_nfs4-acl-tools = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/nfs4-acl-tools-0.4.2-7.el10.x86_64_v2.rpm;name=nfs4-acl-tools;unpack=0"
SRC_URI += "${URI_nfs4-acl-tools}"
SRC_URI[nfs4-acl-tools.sha256sum] = "664082d35e05ebd81905cb0cca8c12d1676ea76727951ab696737e54371cfd18"
RDEPENDS:nfs4-acl-tools = " \
 glibc \
"
