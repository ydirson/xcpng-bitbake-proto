# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-oauthlib"
PE = "0"
PV = "3.2.2"
PR = "6.el10"
PACKAGES = "python3-oauthlib"
PROVIDES = "rpm/python3-oauthlib"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-oauthlib-3.2.2-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79608e0228732de06f560695ea77f8c83826529305499d8bd69cb82f18ee13e6"

URI_python3-oauthlib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-oauthlib-3.2.2-6.el10.noarch.rpm;name=python3-oauthlib;unpack=0"
SRC_URI += "${URI_python3-oauthlib}"
SRC_URI[python3-oauthlib.sha256sum] = "3279bf802ded9ff526c8041961af40759df787c94834e0685f7db84913301901"
RDEPENDS:python3-oauthlib = " \
 python3 \
"
