# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "iio-sensor-proxy"
PE = "0"
PV = "3.5"
PR = "5.el10"
PACKAGES = "iio-sensor-proxy iio-sensor-proxy-docs"
PROVIDES = "rpm/iio-sensor-proxy rpm/iio-sensor-proxy-docs"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/iio-sensor-proxy-3.5-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a0343d76179b6017175f80d4bc3f8fd7319eb825e46b0b2bcb8fc2fce73b403"

URI_iio-sensor-proxy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/iio-sensor-proxy-3.5-5.el10.x86_64_v2.rpm;name=iio-sensor-proxy;unpack=0"
SRC_URI += "${URI_iio-sensor-proxy}"
SRC_URI[iio-sensor-proxy.sha256sum] = "7a36d82964dff2f5b1903f77b33251650b829816ddddacca61d4cadcf389e494"
RDEPENDS:iio-sensor-proxy = " \
 systemd \
 libgcc \
 libgudev \
 polkit-libs \
 bash \
 glib2 \
 glibc \
"

URI_iio-sensor-proxy-docs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/iio-sensor-proxy-docs-3.5-5.el10.noarch.rpm;name=iio-sensor-proxy-docs;unpack=0"
SRC_URI += "${URI_iio-sensor-proxy-docs}"
SRC_URI[iio-sensor-proxy-docs.sha256sum] = "39f5d2a8bec303bb1aa01a668e2eb5500f8ce0b9fa88e8309bb8ffcf29545b4a"
RDEPENDS:iio-sensor-proxy-docs = ""
