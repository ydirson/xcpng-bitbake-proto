# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "glibmm2.4"
PE = "0"
PV = "2.66.6"
PR = "5.el10"
PACKAGES = "glibmm2.4 glibmm2.4-devel glibmm2.4-doc"
PROVIDES = "rpm/glibmm2.4 rpm/glibmm2.4-devel rpm/glibmm2.4-doc"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/glibmm2.4-2.66.6-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a417b95a68ee1f0f5e029f4fa5840cd1347a3e68a39b81353a521c9460d952e5"

URI_glibmm2.4 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/glibmm2.4-2.66.6-5.el10.x86_64_v2.rpm;name=glibmm2.4;unpack=0"
SRC_URI += "${URI_glibmm2.4}"
SRC_URI[glibmm2.4.sha256sum] = "bbaae88b36f9c75ef6ab78bfe877065cc2748e5f53875ab7a3ac5c6b1b62418d"
RDEPENDS:glibmm2.4 = " \
 libgcc \
 libsigc++20 \
 libstdc++ \
 glib2 \
 glibc \
"

URI_glibmm2.4-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/glibmm2.4-devel-2.66.6-5.el10.x86_64_v2.rpm;name=glibmm2.4-devel;unpack=0"
SRC_URI += "${URI_glibmm2.4-devel}"
SRC_URI[glibmm2.4-devel.sha256sum] = "97b5f84da4e12181385c1bdb55fb14c03d535cc758b22324e868e83688315ed4"
RDEPENDS:glibmm2.4-devel = " \
 perl-constant \
 glib2-devel \
 perl-libs \
 glibmm2.4 \
 pkgconf-pkg-config \
 perl-open \
 perl-XML-Parser \
 libsigc++20-devel \
 perl-interpreter \
 perl-Exporter \
 glibmm2.4-devel \
"

URI_glibmm2.4-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/glibmm2.4-doc-2.66.6-5.el10.noarch.rpm;name=glibmm2.4-doc;unpack=0"
SRC_URI += "${URI_glibmm2.4-doc}"
SRC_URI[glibmm2.4-doc.sha256sum] = "354f1a3f20206e9c8a1de9e869e4cc14b60af563f6f7fa53002215aa6fb54fcc"
RDEPENDS:glibmm2.4-doc = " \
 libsigc++20-doc \
 glibmm2.4 \
"
