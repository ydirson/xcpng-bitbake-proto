# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-bn"
PE = "1"
PV = "1.0.0"
PR = "27.el10"
PACKAGES = "hunspell-bn"
PROVIDES = "rpm/hunspell-bn"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-bn-1.0.0-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2aa88648d70dcef46856b0b94f161ae32e47c27443f0603614d6981a44f76799"

URI_hunspell-bn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-bn-1.0.0-27.el10.noarch.rpm;name=hunspell-bn;unpack=0"
SRC_URI += "${URI_hunspell-bn}"
SRC_URI[hunspell-bn.sha256sum] = "f9f8076d2407a701ca8ba5f5cbf4d94093e88b3aa34e9fd82d2e0cd9a9f31409"
RDEPENDS:hunspell-bn = " \
 hunspell-filesystem \
"
