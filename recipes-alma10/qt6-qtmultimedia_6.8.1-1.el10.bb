# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtmultimedia"
PE = "0"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = "qt6-qtmultimedia qt6-qtmultimedia-devel qt6-qtmultimedia-examples qt6-qtmultimedia-tests"
PROVIDES = "rpm/qt6-qtmultimedia rpm/qt6-qtmultimedia-devel rpm/qt6-qtmultimedia-examples rpm/qt6-qtmultimedia-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtmultimedia-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b202c1d8a1331701e4e1be9e590327365b41c2a4c4780b98e1a54eda71e023e"

URI_qt6-qtmultimedia = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtmultimedia-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtmultimedia;unpack=0"
SRC_URI += "${URI_qt6-qtmultimedia}"
SRC_URI[qt6-qtmultimedia.sha256sum] = "08d492b8a398b29cdf3eafc453170fa92a737352defefad65a5e263f341ca74a"
RDEPENDS:qt6-qtmultimedia = " \
 alsa-lib \
 qt6-qtdeclarative \
 gstreamer1 \
 libglvnd-egl \
 pulseaudio-libs \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base \
 qt6-qtbase \
 qt6-qtquick3d \
 libstdc++ \
 qt6-qtbase-gui \
 glib2 \
 glibc \
"

URI_qt6-qtmultimedia-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtmultimedia-devel-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtmultimedia-devel;unpack=0"
SRC_URI += "${URI_qt6-qtmultimedia-devel}"
SRC_URI[qt6-qtmultimedia-devel.sha256sum] = "38339932cfdfd980daaf78bb3f1d5e19cc988e7f61ccc680aaffb48b5aa737eb"
RDEPENDS:qt6-qtmultimedia-devel = " \
 qt6-qtdeclarative-devel \
 cmake-filesystem \
 qt6-qtmultimedia \
 qt6-qtmultimedia-devel \
 pulseaudio-libs-devel \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
"

URI_qt6-qtmultimedia-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtmultimedia-examples-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtmultimedia-examples;unpack=0"
SRC_URI += "${URI_qt6-qtmultimedia-examples}"
SRC_URI[qt6-qtmultimedia-examples.sha256sum] = "00a46700c67f219ae668b8cdebdb6c19c5266085cf0882ac35eff8bbc5ef703c"
RDEPENDS:qt6-qtmultimedia-examples = " \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qtmultimedia-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtmultimedia-tests-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtmultimedia-tests;unpack=0"
SRC_URI += "${URI_qt6-qtmultimedia-tests}"
SRC_URI[qt6-qtmultimedia-tests.sha256sum] = "708f9ccf3d48d6140062633eee20d082515f27743bc4fd034f0162244415179d"
RDEPENDS:qt6-qtmultimedia-tests = " \
 python3 \
 qt6-qtdeclarative \
 gstreamer1 \
 libglvnd-egl \
 pulseaudio-libs \
 qt6-qtmultimedia \
 libgcc \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base \
 qt6-qtbase \
 libstdc++ \
 bash \
 glib2 \
 qt6-qtbase-gui \
 glibc \
"
