# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "liblc3"
PE = "0"
PV = "1.0.4"
PR = "6.el10"
PACKAGES = "liblc3 liblc3-devel liblc3-utils"
PROVIDES = "rpm/liblc3 rpm/liblc3-devel rpm/liblc3-utils"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/liblc3-1.0.4-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4bddb587d4d43e5d702cb7959e7728f9fcc1ae8d74ef17e22a5c4a3626596b5"

URI_liblc3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/liblc3-1.0.4-6.el10.x86_64_v2.rpm;name=liblc3;unpack=0"
SRC_URI += "${URI_liblc3}"
SRC_URI[liblc3.sha256sum] = "ff738ceb9f0046d716d469e10ebfb4fad590bbe8033149317245feb8922457ff"
RDEPENDS:liblc3 = " \
 glibc \
"

URI_liblc3-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/liblc3-devel-1.0.4-6.el10.x86_64_v2.rpm;name=liblc3-devel;unpack=0"
SRC_URI += "${URI_liblc3-devel}"
SRC_URI[liblc3-devel.sha256sum] = "b2ed211e859efda9c179965ecd93037e827ab30b9f82837511c7de6e8bcff861"
RDEPENDS:liblc3-devel = " \
 liblc3 \
 pkgconf-pkg-config \
"

URI_liblc3-utils = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/liblc3-utils-1.0.4-6.el10.x86_64_v2.rpm;name=liblc3-utils;unpack=0"
SRC_URI += "${URI_liblc3-utils}"
SRC_URI[liblc3-utils.sha256sum] = "478d1cb2f7dd8fd88f2a5dd35c43b0d3a9b48d566f4c09102749b9508af2b6c9"
RDEPENDS:liblc3-utils = " \
 glibc \
 liblc3 \
"
