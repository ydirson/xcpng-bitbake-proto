# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "poppler-data"
PE = "0"
PV = "0.4.11"
PR = "9.el10"
PACKAGES = "poppler-data poppler-data-devel"
PROVIDES = "rpm/poppler-data rpm/poppler-data-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/poppler-data-0.4.11-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "142a78c04b0131925708f423b4d5187ecfcee3b07e8aae7f39a4143cf15717b5"

URI_poppler-data = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/poppler-data-0.4.11-9.el10.noarch.rpm;name=poppler-data;unpack=0"
SRC_URI += "${URI_poppler-data}"
SRC_URI[poppler-data.sha256sum] = "a6048df0dca87ed697faf114059df0b717c36d72dadeeab4870e68e1b60229ea"
RDEPENDS:poppler-data = ""

URI_poppler-data-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/poppler-data-devel-0.4.11-9.el10.noarch.rpm;name=poppler-data-devel;unpack=0"
SRC_URI += "${URI_poppler-data-devel}"
SRC_URI[poppler-data-devel.sha256sum] = "5699531b44215d79a03321dd2a0cca924fff32485846e4352fa1bb41f576f4be"
RDEPENDS:poppler-data-devel = " \
 poppler-data \
 pkgconf-pkg-config \
"
