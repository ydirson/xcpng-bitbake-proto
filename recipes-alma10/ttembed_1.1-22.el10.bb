# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ttembed"
PE = "0"
PV = "1.1"
PR = "22.el10"
PACKAGES = "ttembed"
PROVIDES = "rpm/ttembed"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/ttembed-1.1-22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4dc6781df985a91ebfe5bbe8967e1ee8d3c06961421eafbe41017f789dae4f81"

URI_ttembed = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ttembed-1.1-22.el10.x86_64_v2.rpm;name=ttembed;unpack=0"
SRC_URI += "${URI_ttembed}"
SRC_URI[ttembed.sha256sum] = "402e7558bf7b9ba61979f82116d31d3b5ee3b122d2a8206c2a381d4aecf4b2f2"
RDEPENDS:ttembed = " \
 glibc \
"
