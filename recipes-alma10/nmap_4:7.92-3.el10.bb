# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "nmap"
PE = "4"
PV = "7.92"
PR = "3.el10"
PACKAGES = "nmap nmap-ncat"
PROVIDES = "rpm/nmap rpm/nmap-ncat"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/nmap-7.92-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bdb8ca312fc01dc7725052b07ad6a4878f8bfb5eca5f57e074afe8e4675013bd"

URI_nmap = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nmap-7.92-3.el10.x86_64_v2.rpm;name=nmap;unpack=0"
SRC_URI += "${URI_nmap}"
SRC_URI[nmap.sha256sum] = "fd97791c7649fd653dc9efea32d613c8812fca14a83a4e3db61eaffb3088c131"
RDEPENDS:nmap = " \
 libpcap \
 zlib-ng-compat \
 nmap-ncat \
 openssl-libs \
 libgcc \
 libstdc++ \
 pcre2 \
 glibc \
"

URI_nmap-ncat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nmap-ncat-7.92-3.el10.x86_64_v2.rpm;name=nmap-ncat;unpack=0"
SRC_URI += "${URI_nmap-ncat}"
SRC_URI[nmap-ncat.sha256sum] = "ad37c70343c41c630dca441f226e38ac7ea0f7e774f241d85c58811a685da963"
RDEPENDS:nmap-ncat = " \
 libpcap \
 openssl-libs \
 bash \
 glibc \
 alternatives \
"
