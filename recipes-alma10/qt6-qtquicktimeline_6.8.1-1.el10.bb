# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtquicktimeline"
PE = "0"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = "qt6-qtquicktimeline qt6-qtquicktimeline-devel qt6-qtquicktimeline-tests"
PROVIDES = "rpm/qt6-qtquicktimeline rpm/qt6-qtquicktimeline-devel rpm/qt6-qtquicktimeline-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtquicktimeline-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6928c0c4f0504ca03f9898dc0033eea47446307cee4bdc53ac04da402f6fc69"

URI_qt6-qtquicktimeline = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtquicktimeline-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtquicktimeline;unpack=0"
SRC_URI += "${URI_qt6-qtquicktimeline}"
SRC_URI[qt6-qtquicktimeline.sha256sum] = "0a0d8a1f5b1468b0caa67e4246003d5912a6ba537e579dcd7f5001e1f00d0ae2"
RDEPENDS:qt6-qtquicktimeline = " \
 qt6-qtdeclarative \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qtquicktimeline-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtquicktimeline-devel-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtquicktimeline-devel;unpack=0"
SRC_URI += "${URI_qt6-qtquicktimeline-devel}"
SRC_URI[qt6-qtquicktimeline-devel.sha256sum] = "2f3c708ebb7c4da252b9278f99a442a8437cb318747bfde7abc69cd5183063b3"
RDEPENDS:qt6-qtquicktimeline-devel = " \
 qt6-qtdeclarative-devel \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtquicktimeline \
 qt6-qtquicktimeline-devel \
"

URI_qt6-qtquicktimeline-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtquicktimeline-tests-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtquicktimeline-tests;unpack=0"
SRC_URI += "${URI_qt6-qtquicktimeline-tests}"
SRC_URI[qt6-qtquicktimeline-tests.sha256sum] = "35e46a94fe956861895e1bd4f3c96aae5106a0ed3a042606cc8a781d5d48320d"
RDEPENDS:qt6-qtquicktimeline-tests = " \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtbase \
 qt6-qtquicktimeline \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"
