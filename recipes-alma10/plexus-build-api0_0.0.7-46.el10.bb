# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "plexus-build-api0"
PE = "0"
PV = "0.0.7"
PR = "46.el10"
PACKAGES = "plexus-build-api0 plexus-build-api0-javadoc"
PROVIDES = "rpm/plexus-build-api0 rpm/plexus-build-api0-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/plexus-build-api0-0.0.7-46.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2afca703a075a64beaa8e0867ca597315c1104c73f9f5fdc683032edf25bc6a"

URI_plexus-build-api0 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-build-api0-0.0.7-46.el10.noarch.rpm;name=plexus-build-api0;unpack=0"
SRC_URI += "${URI_plexus-build-api0}"
SRC_URI[plexus-build-api0.sha256sum] = "63c07c3a68b8166454fc3334c1c8bd024d3a4b4abf00f061935e24b08565707f"
RDEPENDS:plexus-build-api0 = " \
 plexus-utils \
 javapackages-filesystem \
"

URI_plexus-build-api0-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-build-api0-javadoc-0.0.7-46.el10.noarch.rpm;name=plexus-build-api0-javadoc;unpack=0"
SRC_URI += "${URI_plexus-build-api0-javadoc}"
SRC_URI[plexus-build-api0-javadoc.sha256sum] = "ef0b43e7145e9f37d528af978f214fb6ef19981b1dff14cae79c354c9ae0e92b"
RDEPENDS:plexus-build-api0-javadoc = " \
 javapackages-filesystem \
"
