# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cockpit"
PE = "0"
PV = "334.1"
PR = "1.el10_0"
PACKAGES = "cockpit cockpit-bridge cockpit-doc cockpit-system cockpit-ws cockpit-packagekit cockpit-storaged"
PROVIDES = "rpm/cockpit rpm/cockpit-bridge rpm/cockpit-doc rpm/cockpit-system rpm/cockpit-ws rpm/cockpit-packagekit rpm/cockpit-storaged"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/cockpit-334.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "612f1f1fef5f53fb4a370e7ca89ccd4ed3b4cd0b8734e74ee337e7d6d4dfd700"

URI_cockpit = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cockpit-334.1-1.el10_0.x86_64_v2.rpm;name=cockpit;unpack=0"
SRC_URI += "${URI_cockpit}"
SRC_URI[cockpit.sha256sum] = "839fcd85eef484c4ee8268fc678c0faff065bd74b97693de50e29986cdd03611"
RDEPENDS:cockpit = " \
 cockpit-ws \
 cockpit-bridge \
 cockpit-system \
"

URI_cockpit-bridge = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cockpit-bridge-334.1-1.el10_0.x86_64_v2.rpm;name=cockpit-bridge;unpack=0"
SRC_URI += "${URI_cockpit-bridge}"
SRC_URI[cockpit-bridge.sha256sum] = "bee856d80783a974ba91669885e68ad9aa8aa03fd5b111004c0e7455578cd905"
RDEPENDS:cockpit-bridge = " \
 python3 \
"

URI_cockpit-doc = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cockpit-doc-334.1-1.el10_0.noarch.rpm;name=cockpit-doc;unpack=0"
SRC_URI += "${URI_cockpit-doc}"
SRC_URI[cockpit-doc.sha256sum] = "b2e228883d996b69298df7734fc0a20336b078ef59bb7e2dd7dba488884a702f"
RDEPENDS:cockpit-doc = ""

URI_cockpit-system = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cockpit-system-334.1-1.el10_0.noarch.rpm;name=cockpit-system;unpack=0"
SRC_URI += "${URI_cockpit-system}"
SRC_URI[cockpit-system.sha256sum] = "8e2f14345959e1ecef823f57ac65b971abc56d81eae731454bb816343934b3d1"
RDEPENDS:cockpit-system = " \
 shadow-utils \
 NetworkManager \
 libpwquality \
 sos \
 grep \
 cockpit-bridge \
 coreutils \
 sudo \
"

URI_cockpit-ws = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cockpit-ws-334.1-1.el10_0.x86_64_v2.rpm;name=cockpit-ws;unpack=0"
SRC_URI += "${URI_cockpit-ws}"
SRC_URI[cockpit-ws.sha256sum] = "e6a0123a6036463f4f8c0b4dfeaf47acd4645ed3d97fa84c7dbd76b501a064b2"
RDEPENDS:cockpit-ws = " \
 systemd-libs \
 gnutls \
 libxcrypt \
 openssl \
 libgcc \
 json-glib \
 policycoreutils \
 pam-libs \
 krb5-libs \
 glib-networking \
 bash \
 glib2 \
 glibc \
 selinux-policy \
"

URI_cockpit-packagekit = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cockpit-packagekit-334.1-1.el10_0.noarch.rpm;name=cockpit-packagekit;unpack=0"
SRC_URI += "${URI_cockpit-packagekit}"
SRC_URI[cockpit-packagekit.sha256sum] = "fff5d1d467cd9c14a4bbcba9b65b22eb44e2529125c39145890cc9da80c7f44b"
RDEPENDS:cockpit-packagekit = " \
 polkit \
 cockpit-bridge \
 PackageKit \
"

URI_cockpit-storaged = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cockpit-storaged-334.1-1.el10_0.noarch.rpm;name=cockpit-storaged;unpack=0"
SRC_URI += "${URI_cockpit-storaged}"
SRC_URI[cockpit-storaged.sha256sum] = "cea145daa44422bb14b81a21bf28f4831a7706b3303c8a639e451f92f8813f2e"
RDEPENDS:cockpit-storaged = " \
 python3 \
 python3-dbus \
 bash \
 cockpit-system \
 udisks2 \
"
