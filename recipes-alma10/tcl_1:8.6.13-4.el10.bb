# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tcl"
PE = "1"
PV = "8.6.13"
PR = "4.el10"
PACKAGES = "tcl tcl-devel tcl-doc"
PROVIDES = "rpm/tcl rpm/tcl-devel rpm/tcl-doc"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/tcl-8.6.13-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d98978fed0de47e2058d187e8993f07cf95875f34eb20c9b71a79166c9bb66ee"

URI_tcl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/tcl-8.6.13-4.el10.x86_64_v2.rpm;name=tcl;unpack=0"
SRC_URI += "${URI_tcl}"
SRC_URI[tcl.sha256sum] = "2a0c99d5685d505ea16e47038197f0752c8a7c484f0f05e83f871a096ae6b2c0"
RDEPENDS:tcl = " \
 glibc \
 zlib-ng-compat \
"

URI_tcl-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tcl-devel-8.6.13-4.el10.x86_64_v2.rpm;name=tcl-devel;unpack=0"
SRC_URI += "${URI_tcl-devel}"
SRC_URI[tcl-devel.sha256sum] = "f1340fa2254fad36051504ef08caf04faa7e703a6eb2924d47f369fe851f7eb5"
RDEPENDS:tcl-devel = " \
 zlib-ng-compat-devel \
 pkgconf-pkg-config \
 tcl \
"

URI_tcl-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tcl-doc-8.6.13-4.el10.noarch.rpm;name=tcl-doc;unpack=0"
SRC_URI += "${URI_tcl-doc}"
SRC_URI[tcl-doc.sha256sum] = "6be9be7383bf4c7a2f0907cc59da5c02c2c7e160787653cbe3e9655327148e5b"
RDEPENDS:tcl-doc = " \
 tcl \
"
