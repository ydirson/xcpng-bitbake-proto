# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Date-Manip"
PE = "0"
PV = "6.94"
PR = "5.el10"
PACKAGES = "perl-Date-Manip perl-Date-Manip-tests"
PROVIDES = "rpm/perl-Date-Manip rpm/perl-Date-Manip-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Date-Manip-6.94-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4aa87b0a53ababf0626c0a79e50d5d2cd5a1c401c0b394493396208e65f1bde4"

URI_perl-Date-Manip = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Date-Manip-6.94-5.el10.noarch.rpm;name=perl-Date-Manip;unpack=0"
SRC_URI += "${URI_perl-Date-Manip}"
SRC_URI[perl-Date-Manip.sha256sum] = "90eb168f405bb144bd0b37c099c0d7c29c76b202454fa63440c83d4a32bec942"
RDEPENDS:perl-Date-Manip = " \
 perl-Date-Manip \
 perl-libs \
 perl-Carp \
 perl-interpreter \
 perl-IO \
 perl-Storable \
 perl-Encode \
 perl-PathTools \
 perl-File-Find \
 perl-Exporter \
 perl-Data-Dumper \
"

URI_perl-Date-Manip-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Date-Manip-tests-6.94-5.el10.noarch.rpm;name=perl-Date-Manip-tests;unpack=0"
SRC_URI += "${URI_perl-Date-Manip-tests}"
SRC_URI[perl-Date-Manip-tests.sha256sum] = "791c87c9d4aa979c78efcab42404f4dba732cccb279bcfa283d98c7a34a5750d"
RDEPENDS:perl-Date-Manip-tests = " \
 perl-Date-Manip \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Inter \
 bash \
 perl-interpreter \
"
