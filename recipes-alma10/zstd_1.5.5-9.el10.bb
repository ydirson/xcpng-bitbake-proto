# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "zstd"
PE = "0"
PV = "1.5.5"
PR = "9.el10"
PACKAGES = "libzstd zstd libzstd-devel libzstd-static"
PROVIDES = "rpm/libzstd rpm/zstd rpm/libzstd-devel rpm/libzstd-static"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/zstd-1.5.5-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f012cd03befce17fa354dcb593f92f53fd027c374a8d8b33865b5c6809083e88"

URI_libzstd = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libzstd-1.5.5-9.el10.x86_64_v2.rpm;name=libzstd;unpack=0"
SRC_URI += "${URI_libzstd}"
SRC_URI[libzstd.sha256sum] = "a27ae7025623351b8afaf16c4e3a0e7c31c3777c85960662e1ff7a15da0a3126"
RDEPENDS:libzstd = " \
 glibc \
"

URI_zstd = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/zstd-1.5.5-9.el10.x86_64_v2.rpm;name=zstd;unpack=0"
SRC_URI += "${URI_zstd}"
SRC_URI[zstd.sha256sum] = "0203ada9cd01790816fed26d6597c62936d6f036b0ed9ab1262cbc948d9db1ba"
RDEPENDS:zstd = " \
 zlib-ng-compat \
 lz4-libs \
 libgcc \
 libstdc++ \
 bash \
 glibc \
 xz-libs \
"

URI_libzstd-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libzstd-devel-1.5.5-9.el10.x86_64_v2.rpm;name=libzstd-devel;unpack=0"
SRC_URI += "${URI_libzstd-devel}"
SRC_URI[libzstd-devel.sha256sum] = "2e0d49b33b42a5c6fb4eec21135ffddd7f00d5168bf3e6286b320148e5a143f8"
RDEPENDS:libzstd-devel = " \
 libzstd \
 pkgconf-pkg-config \
"

URI_libzstd-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libzstd-static-1.5.5-9.el10.x86_64_v2.rpm;name=libzstd-static;unpack=0"
SRC_URI += "${URI_libzstd-static}"
SRC_URI[libzstd-static.sha256sum] = "3df4d31d641522744625deaa9561c61c4da43bbc19675439e883cb33291b1c7c"
RDEPENDS:libzstd-static = " \
 libzstd-devel \
"
