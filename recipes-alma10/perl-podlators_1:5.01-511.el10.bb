# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-podlators"
PE = "1"
PV = "5.01"
PR = "511.el10"
PACKAGES = "perl-podlators perl-podlators-tests"
PROVIDES = "rpm/perl-podlators rpm/perl-podlators-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-podlators-5.01-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65f6bb339c84b44dbd492e3d2639c703b71dbb1df23b5f44c6e795f755f47f87"

URI_perl-podlators = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-podlators-5.01-511.el10.noarch.rpm;name=perl-podlators;unpack=0"
SRC_URI += "${URI_perl-podlators}"
SRC_URI[perl-podlators.sha256sum] = "0a91f03c8a56457bb7d9a11eebc0a6cbe714d2ba3db9a5c7b38e8895d59934a0"
RDEPENDS:perl-podlators = " \
 perl-libs \
 perl-Carp \
 perl-interpreter \
 perl-Getopt-Long \
 perl-POSIX \
 perl-File-Basename \
 perl-Encode \
 perl-PathTools \
 perl-Term-ANSIColor \
 perl-Term-Cap \
 perl-podlators \
 perl-Exporter \
 perl-Pod-Simple \
 perl-Pod-Usage \
"

URI_perl-podlators-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-podlators-tests-5.01-511.el10.noarch.rpm;name=perl-podlators-tests;unpack=0"
SRC_URI += "${URI_perl-podlators-tests}"
SRC_URI[perl-podlators-tests.sha256sum] = "b1e533c6002d4d4d87f9a8cd7a246164f9aed93099f04403cd2ff234addbb961"
RDEPENDS:perl-podlators-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-IO \
 perl-Getopt-Long \
 perl-POSIX \
 perl-Encode \
 perl-File-Temp \
 bash \
 perl-PathTools \
 perl-base \
 perl-File-Find \
 perl-podlators \
 perl-interpreter \
 perl-Exporter \
 perl-lib \
"
