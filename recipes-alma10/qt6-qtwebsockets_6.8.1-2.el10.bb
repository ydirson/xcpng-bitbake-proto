# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtwebsockets"
PE = "0"
PV = "6.8.1"
PR = "2.el10"
PACKAGES = "qt6-qtwebsockets qt6-qtwebsockets-devel qt6-qtwebsockets-examples qt6-qtwebsockets-tests"
PROVIDES = "rpm/qt6-qtwebsockets rpm/qt6-qtwebsockets-devel rpm/qt6-qtwebsockets-examples rpm/qt6-qtwebsockets-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtwebsockets-6.8.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ddf3c97399c9f6eba069a3126d829786af5b36350e060a4e5f5bcdb6848f735d"

URI_qt6-qtwebsockets = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtwebsockets-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtwebsockets;unpack=0"
SRC_URI += "${URI_qt6-qtwebsockets}"
SRC_URI[qt6-qtwebsockets.sha256sum] = "c0a5734517bdfed80ee8447e1e442d3fab40136df5756c0e5b45f6135e4887c0"
RDEPENDS:qt6-qtwebsockets = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
"

URI_qt6-qtwebsockets-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtwebsockets-devel-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtwebsockets-devel;unpack=0"
SRC_URI += "${URI_qt6-qtwebsockets-devel}"
SRC_URI[qt6-qtwebsockets-devel.sha256sum] = "f63be04021a65e363949bd5a5231f40d8404e1b19a7c1b180d817313e1513739"
RDEPENDS:qt6-qtwebsockets-devel = " \
 qt6-qtdeclarative \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtbase-devel \
 libstdc++ \
 qt6-qtwebsockets \
 glibc \
"

URI_qt6-qtwebsockets-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtwebsockets-examples-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtwebsockets-examples;unpack=0"
SRC_URI += "${URI_qt6-qtwebsockets-examples}"
SRC_URI[qt6-qtwebsockets-examples.sha256sum] = "a097f5ce7e35e0a735a0484faaf6c92476817a5a208ca003ec2e5e4738dde2e6"
RDEPENDS:qt6-qtwebsockets-examples = " \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 qt6-qtwebsockets \
 glibc \
"

URI_qt6-qtwebsockets-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtwebsockets-tests-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtwebsockets-tests;unpack=0"
SRC_URI += "${URI_qt6-qtwebsockets-tests}"
SRC_URI[qt6-qtwebsockets-tests.sha256sum] = "3cb156e4daaa0a17f0686d903aa923cb68f8e47d5c3c746767077f9d6192fedd"
RDEPENDS:qt6-qtwebsockets-tests = " \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtwebsockets \
 glibc \
"
