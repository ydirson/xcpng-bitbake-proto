# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "fuse3"
PE = "0"
PV = "3.16.2"
PR = "5.el10"
PACKAGES = "fuse-common fuse3 fuse3-libs fuse3-devel"
PROVIDES = "rpm/fuse-common rpm/fuse3 rpm/fuse3-libs rpm/fuse3-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/fuse3-3.16.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dac3d42f3735b0d4d3cdde4afbfcda86cda0d4413c5b2ef8f5ce82537ffdfc96"

URI_fuse-common = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/fuse-common-3.16.2-5.el10.x86_64_v2.rpm;name=fuse-common;unpack=0"
SRC_URI += "${URI_fuse-common}"
SRC_URI[fuse-common.sha256sum] = "d9d36f172173226c7bc0b890bbb4e82985d5d16161d28160fe7bccb116f61399"
RDEPENDS:fuse-common = ""

URI_fuse3 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/fuse3-3.16.2-5.el10.x86_64_v2.rpm;name=fuse3;unpack=0"
SRC_URI += "${URI_fuse3}"
SRC_URI[fuse3.sha256sum] = "5e372d80b6dea8665ba8f1a7f7e7b6495331413d47f16da01a04bf9c775f2fa3"
RDEPENDS:fuse3 = " \
 glibc \
 fuse3-libs \
 fuse-common \
"

URI_fuse3-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/fuse3-libs-3.16.2-5.el10.x86_64_v2.rpm;name=fuse3-libs;unpack=0"
SRC_URI += "${URI_fuse3-libs}"
SRC_URI[fuse3-libs.sha256sum] = "ac715f88060545438e4aa9009404d868e5b045905b171c7c9a269c3e1dfa894c"
RDEPENDS:fuse3-libs = " \
 glibc \
"

URI_fuse3-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fuse3-devel-3.16.2-5.el10.x86_64_v2.rpm;name=fuse3-devel;unpack=0"
SRC_URI += "${URI_fuse3-devel}"
SRC_URI[fuse3-devel.sha256sum] = "84952d98e6049994e000fb717bc580ace1007a642e452390ccdea7e045f965b0"
RDEPENDS:fuse3-devel = " \
 fuse3-libs \
 pkgconf-pkg-config \
"
