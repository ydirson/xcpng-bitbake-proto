# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "greenboot"
PE = "0"
PV = "0.15.9"
PR = "1.el10_0"
PACKAGES = "greenboot greenboot-default-health-checks"
PROVIDES = "rpm/greenboot rpm/greenboot-default-health-checks"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/greenboot-0.15.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f01eefd016fec6fe8f26715a9c794b39f25fb2949d1da251ca734d63c43e1c8"

URI_greenboot = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/greenboot-0.15.9-1.el10_0.x86_64_v2.rpm;name=greenboot;unpack=0"
SRC_URI += "${URI_greenboot}"
SRC_URI[greenboot.sha256sum] = "7992c7c5ee81b9d78ffd6dae2167524a968c17165f1c3a59c2ce60dca7f37b05"
RDEPENDS:greenboot = " \
 systemd \
 grub2-tools-minimal \
 pam \
 bash \
 rpm-ostree \
"

URI_greenboot-default-health-checks = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/greenboot-default-health-checks-0.15.9-1.el10_0.x86_64_v2.rpm;name=greenboot-default-health-checks;unpack=0"
SRC_URI += "${URI_greenboot-default-health-checks}"
SRC_URI[greenboot-default-health-checks.sha256sum] = "ce76380165f5876d8fd4cf539605cd2a62a9f4494c00cc4b9bfa901e8895372a"
RDEPENDS:greenboot-default-health-checks = " \
 util-linux \
 jq \
 bash \
 greenboot \
"
