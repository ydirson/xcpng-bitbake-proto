# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "geocode-glib"
PE = "0"
PV = "3.26.4"
PR = "14.el10"
PACKAGES = "geocode-glib geocode-glib-devel"
PROVIDES = "rpm/geocode-glib rpm/geocode-glib-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/geocode-glib-3.26.4-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fba3dfd31504e40395be1271e465efe0a741588eda99b6ef653e3a8ee680d776"

URI_geocode-glib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/geocode-glib-3.26.4-14.el10.x86_64_v2.rpm;name=geocode-glib;unpack=0"
SRC_URI += "${URI_geocode-glib}"
SRC_URI[geocode-glib.sha256sum] = "def6537ebd3d6cb10b51f6932835274034e9de3f152a0dae3bf92b5d04a37504"
RDEPENDS:geocode-glib = " \
 libsoup3 \
 libgcc \
 json-glib \
 glib2 \
 glibc \
"

URI_geocode-glib-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/geocode-glib-devel-3.26.4-14.el10.x86_64_v2.rpm;name=geocode-glib-devel;unpack=0"
SRC_URI += "${URI_geocode-glib-devel}"
SRC_URI[geocode-glib-devel.sha256sum] = "1fbff9d2186d51ffe8e07c5874843ca154e1629ceb430fe6a8acaed0432a4792"
RDEPENDS:geocode-glib-devel = " \
 geocode-glib \
 glib2-devel \
 pkgconf-pkg-config \
"
