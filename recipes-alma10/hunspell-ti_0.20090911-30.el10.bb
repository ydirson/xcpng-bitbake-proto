# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-ti"
PE = "0"
PV = "0.20090911"
PR = "30.el10"
PACKAGES = "hunspell-ti"
PROVIDES = "rpm/hunspell-ti"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-ti-0.20090911-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe3d5fade20972ac64bd833455fab566ec0509fd6ac35f3c47d34a5dd79d8795"

URI_hunspell-ti = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-ti-0.20090911-30.el10.noarch.rpm;name=hunspell-ti;unpack=0"
SRC_URI += "${URI_hunspell-ti}"
SRC_URI[hunspell-ti.sha256sum] = "98ce4cec63641bedda59a54831ca7eefa814627a2fe22a8bbced2b42e9988446"
RDEPENDS:hunspell-ti = " \
 hunspell-filesystem \
"
