# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mysql8.4"
PE = "0"
PV = "8.4.6"
PR = "2.el10_0"
PACKAGES = "mysql8.4 mysql8.4-common mysql8.4-errmsg mysql8.4-libs mysql8.4-server mysql8.4-devel mysql8.4-test mysql8.4-test-data"
PROVIDES = "rpm/mysql8.4 rpm/mysql8.4-common rpm/mysql8.4-errmsg rpm/mysql8.4-libs rpm/mysql8.4-server rpm/mysql8.4-devel rpm/mysql8.4-test rpm/mysql8.4-test-data"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mysql8.4-8.4.6-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "991631a72f7a5c8389c30a451df8635af8af7aca4ead2b3ba4045cb36dba9c63"

URI_mysql8.4 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mysql8.4-8.4.6-2.el10_0.x86_64_v2.rpm;name=mysql8.4;unpack=0"
SRC_URI += "${URI_mysql8.4}"
SRC_URI[mysql8.4.sha256sum] = "337d8d0d51fa08a6d168d158bc92226e99df294ba626358f8cdf5ffaf3a3a994"
RDEPENDS:mysql8.4 = " \
 zlib-ng-compat \
 openssl-libs \
 libgcc \
 grep \
 libzstd \
 libstdc++ \
 bash \
 mysql8.4-common \
 glibc \
 coreutils \
 libedit \
"

URI_mysql8.4-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mysql8.4-common-8.4.6-2.el10_0.noarch.rpm;name=mysql8.4-common;unpack=0"
SRC_URI += "${URI_mysql8.4-common}"
SRC_URI[mysql8.4-common.sha256sum] = "d28d82cce2fa0c207f0c5e8a92bdda59a52bdae3c24d31c72af961bdf43f604f"
RDEPENDS:mysql8.4-common = " \
 mariadb-connector-c-config \
"

URI_mysql8.4-errmsg = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mysql8.4-errmsg-8.4.6-2.el10_0.noarch.rpm;name=mysql8.4-errmsg;unpack=0"
SRC_URI += "${URI_mysql8.4-errmsg}"
SRC_URI[mysql8.4-errmsg.sha256sum] = "bb9511e88f0708b0c62e3ab0bad8bb2046dd777dd884dc213c6a8fcd2826bb08"
RDEPENDS:mysql8.4-errmsg = " \
 mysql8.4-common \
"

URI_mysql8.4-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mysql8.4-libs-8.4.6-2.el10_0.x86_64_v2.rpm;name=mysql8.4-libs;unpack=0"
SRC_URI += "${URI_mysql8.4-libs}"
SRC_URI[mysql8.4-libs.sha256sum] = "ab93c783c77e346db8c31566ea0cc712cd7fff2ac989b30e0be50abd812c9322"
RDEPENDS:mysql8.4-libs = " \
 zlib-ng-compat \
 openssl-libs \
 libgcc \
 libzstd \
 libstdc++ \
 mysql8.4-common \
 glibc \
"

URI_mysql8.4-server = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mysql8.4-server-8.4.6-2.el10_0.x86_64_v2.rpm;name=mysql8.4-server;unpack=0"
SRC_URI += "${URI_mysql8.4-server}"
SRC_URI[mysql8.4-server.sha256sum] = "292d9eb7b1f1e5e89d9d7e4cd41dbc4a89f3f2dc801e06c9476f47ea7bc18806"
RDEPENDS:mysql8.4-server = " \
 systemd \
 perl-libs \
 policycoreutils-python-utils \
 perl-Getopt-Long \
 mysql-selinux \
 mysql8.4 \
 mysql8.4-common \
 mysql8.4-errmsg \
 libaio \
 numactl-libs \
 libstdc++ \
 libtirpc \
 mecab \
 protobuf-lite \
 shadow-utils \
 zlib-ng-compat \
 libgcc \
 openssl-libs \
 libzstd \
 bash \
 libicu \
 lz4-libs \
 mariadb-connector-c-config \
 glibc \
 coreutils \
 perl-interpreter \
"

URI_mysql8.4-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mysql8.4-devel-8.4.6-2.el10_0.x86_64_v2.rpm;name=mysql8.4-devel;unpack=0"
SRC_URI += "${URI_mysql8.4-devel}"
SRC_URI[mysql8.4-devel.sha256sum] = "b2d8ca88dde364844a23b7fd69ac90ca3d2a0974b62446c1b814026723af79f6"
RDEPENDS:mysql8.4-devel = " \
 zlib-ng-compat-devel \
 libzstd-devel \
 pkgconf-pkg-config \
 openssl-devel \
 bash \
 mysql8.4-libs \
"

URI_mysql8.4-test = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mysql8.4-test-8.4.6-2.el10_0.x86_64_v2.rpm;name=mysql8.4-test;unpack=0"
SRC_URI += "${URI_mysql8.4-test}"
SRC_URI[mysql8.4-test.sha256sum] = "b714bad3b666486049dd5cdbf0952b0c12be71f2a7154d78dcea75597c58ca53"
RDEPENDS:mysql8.4-test = " \
 mysql8.4-test-data \
 perl-libwww-perl \
 perl-FindBin \
 perl-Socket \
 perl-Getopt-Long \
 perl-Sys-Hostname \
 mysql8.4 \
 mysql8.4-common \
 mysql8.4-server \
 perl-Test-Simple \
 perl-IPC-Open3 \
 libstdc++ \
 perl-JSON \
 perl-Data-Dumper \
 perl-Time-HiRes \
 protobuf \
 zlib-ng-compat \
 perl-Digest \
 perl-Memoize \
 openssl \
 perl-Digest-MD5 \
 libgcc \
 openssl-libs \
 libzstd \
 bash \
 perl-Env \
 perl-Exporter \
 lz4 \
 lz4-libs \
 gzip \
 perl-Fcntl \
 perl-File-Compare \
 glibc \
 perl-File-Temp \
"

URI_mysql8.4-test-data = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mysql8.4-test-data-8.4.6-2.el10_0.noarch.rpm;name=mysql8.4-test-data;unpack=0"
SRC_URI += "${URI_mysql8.4-test-data}"
SRC_URI[mysql8.4-test-data.sha256sum] = "634743d5badee59910d831c52ccba8e9bac6ce085620109ebb3bfa7abdc106e6"
RDEPENDS:mysql8.4-test-data = " \
 perl-libs \
 perl-FindBin \
 perl-Getopt-Long \
 perl-overload \
 mysql8.4-test \
 perl-Sys-Hostname \
 perl-threads \
 perl-threads-shared \
 perl-Carp \
 perl-Test-Simple \
 perl-IO \
 perl-JSON \
 perl-lib \
 perl-Data-Dumper \
 perl-Time \
 perl-Time-HiRes \
 perl-Memoize \
 bash \
 perl-English \
 perl-Exporter \
 perl-base \
 perl-constant \
 perl-Fcntl \
 perl-File-Basename \
 perl-POSIX \
 perl-File-Copy \
 perl-PathTools \
 perl-if \
 perl-File-Find \
 perl-interpreter \
 perl-File-Path \
 perl-File-Temp \
"
