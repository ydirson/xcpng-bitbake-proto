# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libkdumpfile"
PE = "0"
PV = "0.5.4"
PR = "8.el10"
PACKAGES = "libkdumpfile libkdumpfile-devel libkdumpfile-doc libkdumpfile-util python3-libkdumpfile"
PROVIDES = "rpm/libkdumpfile rpm/libkdumpfile-devel rpm/libkdumpfile-doc rpm/libkdumpfile-util rpm/python3-libkdumpfile"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libkdumpfile-0.5.4-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e05c96e08192317511c9260f23b6d17ae405e832d6e338c8bb001610573f8b5"

URI_libkdumpfile = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libkdumpfile-0.5.4-8.el10.x86_64_v2.rpm;name=libkdumpfile;unpack=0"
SRC_URI += "${URI_libkdumpfile}"
SRC_URI[libkdumpfile.sha256sum] = "ed5408056fcfc23aafe83067ed86b461479517b6ef567ae30d8d06fbf77b0223"
RDEPENDS:libkdumpfile = " \
 zlib-ng-compat \
 lzo \
 snappy \
 libzstd \
 glibc \
"

URI_libkdumpfile-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libkdumpfile-devel-0.5.4-8.el10.x86_64_v2.rpm;name=libkdumpfile-devel;unpack=0"
SRC_URI += "${URI_libkdumpfile-devel}"
SRC_URI[libkdumpfile-devel.sha256sum] = "c7f06adb3acc941b01fa02f6abb145aee26944d608dcd9524690f08dd99831dc"
RDEPENDS:libkdumpfile-devel = " \
 libkdumpfile-devel \
 zlib-ng-compat-devel \
 libzstd-devel \
 pkgconf-pkg-config \
 snappy-devel \
 lzo-devel \
 libkdumpfile \
"

URI_libkdumpfile-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libkdumpfile-doc-0.5.4-8.el10.noarch.rpm;name=libkdumpfile-doc;unpack=0"
SRC_URI += "${URI_libkdumpfile-doc}"
SRC_URI[libkdumpfile-doc.sha256sum] = "d577f7e54c5ad61c1e7fa9cc60ed29607e5b77c0a0f330710fc7576b90ee179c"
RDEPENDS:libkdumpfile-doc = ""

URI_libkdumpfile-util = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libkdumpfile-util-0.5.4-8.el10.x86_64_v2.rpm;name=libkdumpfile-util;unpack=0"
SRC_URI += "${URI_libkdumpfile-util}"
SRC_URI[libkdumpfile-util.sha256sum] = "70e1d23b93b93d1514b6af2323be4ff39256c4aeda8f6b0490fe877e36d72020"
RDEPENDS:libkdumpfile-util = " \
 glibc \
 libkdumpfile \
"

URI_python3-libkdumpfile = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-libkdumpfile-0.5.4-8.el10.x86_64_v2.rpm;name=python3-libkdumpfile;unpack=0"
SRC_URI += "${URI_python3-libkdumpfile}"
SRC_URI[python3-libkdumpfile.sha256sum] = "6d5fd5a5e6ab28475494501bea8655d072e9ff10b591306227be40b964614975"
RDEPENDS:python3-libkdumpfile = " \
 python3 \
 zlib-ng-compat \
 lzo \
 snappy \
 libzstd \
 glibc \
 libkdumpfile \
"
