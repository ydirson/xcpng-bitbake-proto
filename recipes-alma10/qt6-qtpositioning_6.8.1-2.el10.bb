# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtpositioning"
PE = "0"
PV = "6.8.1"
PR = "2.el10"
PACKAGES = "qt6-qtpositioning qt6-qtpositioning-devel qt6-qtpositioning-examples qt6-qtpositioning-tests"
PROVIDES = "rpm/qt6-qtpositioning rpm/qt6-qtpositioning-devel rpm/qt6-qtpositioning-examples rpm/qt6-qtpositioning-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtpositioning-6.8.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "147f7b25bdc2cfa5888f113f6c3c1e61c7473420f9c99de1458b77cbf8cf5c97"

URI_qt6-qtpositioning = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtpositioning-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtpositioning;unpack=0"
SRC_URI += "${URI_qt6-qtpositioning}"
SRC_URI[qt6-qtpositioning.sha256sum] = "ee8d24ee10816013965bb1e679f0f03e3980f7e2ff6c74c11765ea8a10261435"
RDEPENDS:qt6-qtpositioning = " \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 glibc \
 qt6-qtserialport \
"

URI_qt6-qtpositioning-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtpositioning-devel-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtpositioning-devel;unpack=0"
SRC_URI += "${URI_qt6-qtpositioning-devel}"
SRC_URI[qt6-qtpositioning-devel.sha256sum] = "721df75205f0762b1113815fe6918088552d83f0b2347758a7ce8af76d6ad919"
RDEPENDS:qt6-qtpositioning-devel = " \
 qt6-qtdeclarative-devel \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtpositioning \
 qt6-qtpositioning-devel \
 qt6-qtbase-devel \
"

URI_qt6-qtpositioning-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtpositioning-examples-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtpositioning-examples;unpack=0"
SRC_URI += "${URI_qt6-qtpositioning-examples}"
SRC_URI[qt6-qtpositioning-examples.sha256sum] = "a526201208bb08e6e7d5c018fd18df7e0dc3486b51ed81a28c0b0998463ff829"
RDEPENDS:qt6-qtpositioning-examples = " \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtbase \
 qt6-qtpositioning \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qtpositioning-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtpositioning-tests-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtpositioning-tests;unpack=0"
SRC_URI += "${URI_qt6-qtpositioning-tests}"
SRC_URI[qt6-qtpositioning-tests.sha256sum] = "72fc4eba4c55c313db46e59dd437c0919324b157d4488de8763382c0b3e93507"
RDEPENDS:qt6-qtpositioning-tests = " \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtbase \
 qt6-qtpositioning \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"
