# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "fontforge"
PE = "0"
PV = "20230101"
PR = "13.el10"
PACKAGES = "fontforge fontforge-devel fontforge-doc"
PROVIDES = "rpm/fontforge rpm/fontforge-devel rpm/fontforge-doc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/fontforge-20230101-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ceb168e16d3c57e88fd027e3b2e7e30a48effc6f01bda66fe89ab96851d3c302"

URI_fontforge = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/fontforge-20230101-13.el10.x86_64_v2.rpm;name=fontforge;unpack=0"
SRC_URI += "${URI_fontforge}"
SRC_URI[fontforge.sha256sum] = "61020445dfdccf40a843df78be2cd20a5d7826d5edd2c77582b3a7b264c7ed9a"
RDEPENDS:fontforge = " \
 python3 \
 libpng \
 xdg-utils \
 pango \
 hicolor-icon-theme \
 python3-libs \
 libstdc++ \
 cairo \
 potrace \
 zlib-ng-compat \
 libgcc \
 libxml2 \
 giflib \
 freetype \
 libspiro \
 readline \
 woff2 \
 glib2 \
 gtk3 \
 glibc \
 libjpeg-turbo \
 libtiff \
"

URI_fontforge-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/fontforge-devel-20230101-13.el10.x86_64_v2.rpm;name=fontforge-devel;unpack=0"
SRC_URI += "${URI_fontforge-devel}"
SRC_URI[fontforge-devel.sha256sum] = "94df84781b3c98f41012df2b93b9b13f78d707602e6bfa5db02b2e87a3df4a4c"
RDEPENDS:fontforge-devel = " \
 fontforge-doc \
 fontforge \
"

URI_fontforge-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/fontforge-doc-20230101-13.el10.noarch.rpm;name=fontforge-doc;unpack=0"
SRC_URI += "${URI_fontforge-doc}"
SRC_URI[fontforge-doc.sha256sum] = "9032f58893193e18f59783e8e88479fbe65a6c8862de85cab49456f1e37322f1"
RDEPENDS:fontforge-doc = ""
