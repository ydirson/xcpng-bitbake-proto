# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-BSD-Resource"
PE = "0"
PV = "1.291.100"
PR = "29.el10"
PACKAGES = "perl-BSD-Resource perl-BSD-Resource-tests"
PROVIDES = "rpm/perl-BSD-Resource rpm/perl-BSD-Resource-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-BSD-Resource-1.291.100-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "683073c42419fbeacc962bd1780c3432497cbb205a430110f5f95f47b387a2fb"

URI_perl-BSD-Resource = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-BSD-Resource-1.291.100-29.el10.x86_64_v2.rpm;name=perl-BSD-Resource;unpack=0"
SRC_URI += "${URI_perl-BSD-Resource}"
SRC_URI[perl-BSD-Resource.sha256sum] = "9a4446459869f0421897d581fcdb04d8502948dccc37b616e3de9643e63e724b"
RDEPENDS:perl-BSD-Resource = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-DynaLoader \
 perl-AutoLoader \
 glibc \
 perl-Exporter \
"

URI_perl-BSD-Resource-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-BSD-Resource-tests-1.291.100-29.el10.noarch.rpm;name=perl-BSD-Resource-tests;unpack=0"
SRC_URI += "${URI_perl-BSD-Resource-tests}"
SRC_URI[perl-BSD-Resource-tests.sha256sum] = "f6ec87da9b19b32326a39b612791da3c391cff2101b253c2d2de37d8ef5dbfe9"
RDEPENDS:perl-BSD-Resource-tests = " \
 perl-BSD-Resource \
 perl-interpreter \
 perl-Test-Harness \
 bash \
"
