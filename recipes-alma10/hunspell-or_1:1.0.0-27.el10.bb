# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-or"
PE = "1"
PV = "1.0.0"
PR = "27.el10"
PACKAGES = "hunspell-or"
PROVIDES = "rpm/hunspell-or"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-or-1.0.0-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57460067fc615a4613238d0e3cb1286d136e2e34dc2c0aff10555a02c57148ac"

URI_hunspell-or = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-or-1.0.0-27.el10.noarch.rpm;name=hunspell-or;unpack=0"
SRC_URI += "${URI_hunspell-or}"
SRC_URI[hunspell-or.sha256sum] = "886a5b4a825fa6c6a8ae261a9af64804e6dff5c0524cd7672b4f6210a014a130"
RDEPENDS:hunspell-or = " \
 hunspell \
"
