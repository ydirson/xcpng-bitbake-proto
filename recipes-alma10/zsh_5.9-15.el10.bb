# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "zsh"
PE = "0"
PV = "5.9"
PR = "15.el10"
PACKAGES = "zsh zsh-html"
PROVIDES = "rpm/zsh rpm/zsh-html"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/zsh-5.9-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2a14d2b9fe8be8c4641ef7358855cc5983084393ae5daf34826c4e30f987cc5"

URI_zsh = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/zsh-5.9-15.el10.x86_64_v2.rpm;name=zsh;unpack=0"
SRC_URI += "${URI_zsh}"
SRC_URI[zsh.sha256sum] = "fbde805b8823b9c19b94034cd6be1edcabeb71fc865c8d7993185f33b64fe35d"
RDEPENDS:zsh = " \
 grep \
 ncurses-libs \
 bash \
 pcre2 \
 glibc \
 coreutils \
"

URI_zsh-html = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/zsh-html-5.9-15.el10.noarch.rpm;name=zsh-html;unpack=0"
SRC_URI += "${URI_zsh-html}"
SRC_URI[zsh-html.sha256sum] = "8b5de052d479574b77b7335bfa843825894458eb3168340442d622d621f1dfb6"
RDEPENDS:zsh-html = ""
