# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Math-BigInt-FastCalc"
PE = "0"
PV = "0.501.800"
PR = "511.el10"
PACKAGES = "perl-Math-BigInt-FastCalc perl-Math-BigInt-FastCalc-tests"
PROVIDES = "rpm/perl-Math-BigInt-FastCalc rpm/perl-Math-BigInt-FastCalc-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Math-BigInt-FastCalc-0.501.800-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5816eb567de226e54bba08e0abd3d1d6e1353530cc1182d85b8aa8ac75037b5b"

URI_perl-Math-BigInt-FastCalc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Math-BigInt-FastCalc-0.501.800-511.el10.x86_64_v2.rpm;name=perl-Math-BigInt-FastCalc;unpack=0"
SRC_URI += "${URI_perl-Math-BigInt-FastCalc}"
SRC_URI[perl-Math-BigInt-FastCalc.sha256sum] = "68b9cde3de4e49221e256bd7beb9742ccf26902f01ea59e4d6245d4ab721cfed"
RDEPENDS:perl-Math-BigInt-FastCalc = " \
 glibc \
 perl-Math-BigInt \
 perl-libs \
 perl-Carp \
"

URI_perl-Math-BigInt-FastCalc-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Math-BigInt-FastCalc-tests-0.501.800-511.el10.x86_64_v2.rpm;name=perl-Math-BigInt-FastCalc-tests;unpack=0"
SRC_URI += "${URI_perl-Math-BigInt-FastCalc-tests}"
SRC_URI[perl-Math-BigInt-FastCalc-tests.sha256sum] = "315a8c49b2e935746f8e846fe4f46e22b3322259e622a26239a8fe41bdb2fc7b"
RDEPENDS:perl-Math-BigInt-FastCalc-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Math-BigInt \
 perl-Math-BigInt-FastCalc \
 bash \
 perl-interpreter \
 perl-Exporter \
"
