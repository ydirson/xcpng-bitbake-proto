# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Text-WrapI18N"
PE = "0"
PV = "0.06"
PR = "51.el10"
PACKAGES = "perl-Text-WrapI18N"
PROVIDES = "rpm/perl-Text-WrapI18N"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Text-WrapI18N-0.06-51.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1bf33ccf02a585e5bee039f4691b782aec0d61787f8fbed4b2ec1b8631ed78da"

URI_perl-Text-WrapI18N = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Text-WrapI18N-0.06-51.el10.noarch.rpm;name=perl-Text-WrapI18N;unpack=0"
SRC_URI += "${URI_perl-Text-WrapI18N}"
SRC_URI[perl-Text-WrapI18N.sha256sum] = "0567dba138a66896f11bd724507f05589e8887a48f33f769480383b79dcb40bb"
RDEPENDS:perl-Text-WrapI18N = " \
 perl-Text-CharWidth \
 perl-Exporter \
 perl-libs \
 perl-vars \
"
