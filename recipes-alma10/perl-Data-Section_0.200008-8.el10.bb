# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Data-Section"
PE = "0"
PV = "0.200008"
PR = "8.el10"
PACKAGES = "perl-Data-Section perl-Data-Section-tests"
PROVIDES = "rpm/perl-Data-Section rpm/perl-Data-Section-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Data-Section-0.200008-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31bb21514c0c23c883c2bc42f5e07d205f84f816476ee85a1ba0f0500669f67d"

URI_perl-Data-Section = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Data-Section-0.200008-8.el10.noarch.rpm;name=perl-Data-Section;unpack=0"
SRC_URI += "${URI_perl-Data-Section}"
SRC_URI[perl-Data-Section.sha256sum] = "f03962d409f41c18e84f178b7155440dd5ac6ecab1a6feafa4a2ca6e6732f6e0"
RDEPENDS:perl-Data-Section = " \
 perl-Encode \
 perl-MRO-Compat \
 perl-libs \
 perl-Sub-Exporter \
"

URI_perl-Data-Section-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Data-Section-tests-0.200008-8.el10.noarch.rpm;name=perl-Data-Section-tests;unpack=0"
SRC_URI += "${URI_perl-Data-Section-tests}"
SRC_URI[perl-Data-Section-tests.sha256sum] = "d2d38a448fc4d4b9d6b0e18a0c9ebf5bd74dcd07f4f5b71412ba9be5c7d2074c"
RDEPENDS:perl-Data-Section-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-ExtUtils-MakeMaker \
 perl-Test-FailWarnings \
 perl-Data-Section \
 perl-Encode \
 bash \
 perl-PathTools \
 perl-interpreter \
 perl-base \
 perl-lib \
"
