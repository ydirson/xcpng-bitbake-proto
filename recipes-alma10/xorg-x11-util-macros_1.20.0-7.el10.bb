# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xorg-x11-util-macros"
PE = "0"
PV = "1.20.0"
PR = "7.el10"
PACKAGES = "xorg-x11-util-macros"
PROVIDES = "rpm/xorg-x11-util-macros"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/xorg-x11-util-macros-1.20.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3c7ccff688eb092957827dc162402a1a5af5f5aebfd2f75771321de37d8a3a1"

URI_xorg-x11-util-macros = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xorg-x11-util-macros-1.20.0-7.el10.noarch.rpm;name=xorg-x11-util-macros;unpack=0"
SRC_URI += "${URI_xorg-x11-util-macros}"
SRC_URI[xorg-x11-util-macros.sha256sum] = "3f9a8cc1f1ed9be605cdeca8ad7c88f75a210cfc8e9f74f10b15e35871028716"
RDEPENDS:xorg-x11-util-macros = " \
 automake \
 pkgconf-pkg-config \
 autoconf \
"
