# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-IO-Compress-Lzma"
PE = "0"
PV = "2.206"
PR = "7.el10"
PACKAGES = "perl-IO-Compress-Lzma perl-IO-Compress-Lzma-tests"
PROVIDES = "rpm/perl-IO-Compress-Lzma rpm/perl-IO-Compress-Lzma-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-IO-Compress-Lzma-2.206-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48ab023cc87f98fa1698f5fe4ad97fc08efbc0d9793b5352be7b6b397f07a567"

URI_perl-IO-Compress-Lzma = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-IO-Compress-Lzma-2.206-7.el10.noarch.rpm;name=perl-IO-Compress-Lzma;unpack=0"
SRC_URI += "${URI_perl-IO-Compress-Lzma}"
SRC_URI[perl-IO-Compress-Lzma.sha256sum] = "3725eac2e36c4cae267727ebded71b64ed6b8753796dfea00daa2fae710aaa83"
RDEPENDS:perl-IO-Compress-Lzma = " \
 perl-constant \
 perl-libs \
 perl-IO-Compress \
 perl-IO-Compress-Lzma \
 perl-Compress-Raw-Lzma \
 perl-Compress-Raw-Zlib \
 perl-Exporter \
"

URI_perl-IO-Compress-Lzma-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-IO-Compress-Lzma-tests-2.206-7.el10.noarch.rpm;name=perl-IO-Compress-Lzma-tests;unpack=0"
SRC_URI += "${URI_perl-IO-Compress-Lzma-tests}"
SRC_URI[perl-IO-Compress-Lzma-tests.sha256sum] = "0ea3573732a8e1d454d2fcecd8f4b6393f124d79d932a0c37ecc06ec0592f781"
RDEPENDS:perl-IO-Compress-Lzma-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-IO \
 perl-Scalar-List-Utils \
 perl-IO-Compress \
 perl-IO-Compress-Lzma \
 perl-Compress-Raw-Zlib \
 bash \
 perl-PathTools \
 perl-interpreter \
 perl-File-Path \
 perl-lib \
 perl-IO-String \
"
