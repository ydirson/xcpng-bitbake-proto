# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "upower"
PE = "0"
PV = "1.90.6"
PR = "2.el10"
PACKAGES = "upower upower-libs upower-devel upower-devel-docs"
PROVIDES = "rpm/upower rpm/upower-libs rpm/upower-devel rpm/upower-devel-docs"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/upower-1.90.6-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9cd187151b1ae1614debcd58188cb7354b84713cbaffcc64b863d52655b83553"

URI_upower = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/upower-1.90.6-2.el10.x86_64_v2.rpm;name=upower;unpack=0"
SRC_URI += "${URI_upower}"
SRC_URI[upower.sha256sum] = "b63455b954b158adb7f0bedb49b6935d0bf06568c58be2dce2e806e8fdb8171a"
RDEPENDS:upower = " \
 python3 \
 systemd-udev \
 libgcc \
 libgudev \
 polkit-libs \
 bash \
 glib2 \
 upower-libs \
 glibc \
"

URI_upower-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/upower-libs-1.90.6-2.el10.x86_64_v2.rpm;name=upower-libs;unpack=0"
SRC_URI += "${URI_upower-libs}"
SRC_URI[upower-libs.sha256sum] = "1599a5d384e3e2ea3a632906ea7c70c7c66c392d77ec563a7d2d67e1f62799c3"
RDEPENDS:upower-libs = " \
 glibc \
 libgcc \
 glib2 \
 gobject-introspection \
"

URI_upower-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/upower-devel-1.90.6-2.el10.x86_64_v2.rpm;name=upower-devel;unpack=0"
SRC_URI += "${URI_upower-devel}"
SRC_URI[upower-devel.sha256sum] = "24b9f054e4d517c084bd0c85e0e097cbba43d7c258bee17da09e13bac5d36033"
RDEPENDS:upower-devel = " \
 glib2-devel \
 polkit-devel \
 pkgconf-pkg-config \
 upower-libs \
"

URI_upower-devel-docs = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/upower-devel-docs-1.90.6-2.el10.noarch.rpm;name=upower-devel-docs;unpack=0"
SRC_URI += "${URI_upower-devel-docs}"
SRC_URI[upower-devel-docs.sha256sum] = "6359bff843c2a04435760d1989abebada902735896500d9d671d74e08d558b71"
RDEPENDS:upower-devel-docs = " \
 upower-libs \
"
