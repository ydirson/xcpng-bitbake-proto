# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "patch"
PE = "0"
PV = "2.7.6"
PR = "26.el10"
PACKAGES = "patch"
PROVIDES = "rpm/patch"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/patch-2.7.6-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cebd8ef0f014e785c108483b962ea65be750f91d98d2e2941184a6774d880ec8"

URI_patch = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/patch-2.7.6-26.el10.x86_64_v2.rpm;name=patch;unpack=0"
SRC_URI += "${URI_patch}"
SRC_URI[patch.sha256sum] = "846bc4b572b149918471edfdfe6fbd4cf0d5174f6e262ca24aee9177f62aae9e"
RDEPENDS:patch = " \
 glibc \
 libselinux \
 ed \
 libattr \
"
