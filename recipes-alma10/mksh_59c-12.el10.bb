# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mksh"
PE = "0"
PV = "59c"
PR = "12.el10"
PACKAGES = "mksh"
PROVIDES = "rpm/mksh"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/mksh-59c-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96d8eef96e89c88aba980fd6f529598b5cf3a1fb9216ac6efec01933279795ef"

URI_mksh = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/mksh-59c-12.el10.x86_64_v2.rpm;name=mksh;unpack=0"
SRC_URI += "${URI_mksh}"
SRC_URI[mksh.sha256sum] = "a10a0063b6498dee1fbca3c455c81909c8a6797dbebdcc90699ba2790b603b94"
RDEPENDS:mksh = " \
 grep \
 bash \
 glibc \
 alternatives \
 sed \
"
