# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "popt"
PE = "0"
PV = "1.19"
PR = "8.el10"
PACKAGES = "popt popt-devel popt-static"
PROVIDES = "rpm/popt rpm/popt-devel rpm/popt-static"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/popt-1.19-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "758bf7a5844f0fc68a48a983b38e9710d242edce4ede3e6078018d13f2a1e35c"

URI_popt = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/popt-1.19-8.el10.x86_64_v2.rpm;name=popt;unpack=0"
SRC_URI += "${URI_popt}"
SRC_URI[popt.sha256sum] = "778ac5db7f98f3168d2410e4d4c9cdd0541ec51166dbc66f0147843b9fde6643"
RDEPENDS:popt = " \
 glibc \
"

URI_popt-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/popt-devel-1.19-8.el10.x86_64_v2.rpm;name=popt-devel;unpack=0"
SRC_URI += "${URI_popt-devel}"
SRC_URI[popt-devel.sha256sum] = "812bc231904453c84e4e988ca5b6ad1939f0a643ca9a7b1c3714edfb6bec1868"
RDEPENDS:popt-devel = " \
 popt \
 pkgconf-pkg-config \
"

URI_popt-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/popt-static-1.19-8.el10.x86_64_v2.rpm;name=popt-static;unpack=0"
SRC_URI += "${URI_popt-static}"
SRC_URI[popt-static.sha256sum] = "d647250191548d17cca593c6032bf65be76034047b067f321879104c0138c933"
RDEPENDS:popt-static = " \
 popt-devel \
"
