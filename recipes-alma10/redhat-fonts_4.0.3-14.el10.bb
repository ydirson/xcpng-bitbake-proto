# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "redhat-fonts"
PE = "0"
PV = "4.0.3"
PR = "14.el10"
PACKAGES = "redhat-mono-vf-fonts redhat-text-vf-fonts redhat-display-fonts redhat-display-vf-fonts redhat-mono-fonts redhat-text-fonts"
PROVIDES = "rpm/redhat-mono-vf-fonts rpm/redhat-text-vf-fonts rpm/redhat-display-fonts rpm/redhat-display-vf-fonts rpm/redhat-mono-fonts rpm/redhat-text-fonts"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/redhat-fonts-4.0.3-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56d34ec871f79e074bf1a09910d651eba5b0583c2a809a9232455655685c1575"

URI_redhat-mono-vf-fonts = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/redhat-mono-vf-fonts-4.0.3-14.el10.noarch.rpm;name=redhat-mono-vf-fonts;unpack=0"
SRC_URI += "${URI_redhat-mono-vf-fonts}"
SRC_URI[redhat-mono-vf-fonts.sha256sum] = "5e00a71043dfc40c10f4e7a88ceeb5bff54cfcb3d3bb3a67ffe0284e72f34495"
RDEPENDS:redhat-mono-vf-fonts = " \
 fonts-filesystem \
"

URI_redhat-text-vf-fonts = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/redhat-text-vf-fonts-4.0.3-14.el10.noarch.rpm;name=redhat-text-vf-fonts;unpack=0"
SRC_URI += "${URI_redhat-text-vf-fonts}"
SRC_URI[redhat-text-vf-fonts.sha256sum] = "627e01e8dfcf82e44aee6972ca2b8f2ebcb9efcc8cac60e5d824baa8bd645ce9"
RDEPENDS:redhat-text-vf-fonts = " \
 fonts-filesystem \
"

URI_redhat-display-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/redhat-display-fonts-4.0.3-14.el10.noarch.rpm;name=redhat-display-fonts;unpack=0"
SRC_URI += "${URI_redhat-display-fonts}"
SRC_URI[redhat-display-fonts.sha256sum] = "acf308683f0fe00034491607dae90df36af50402d479dbd0dc5934428d95e524"
RDEPENDS:redhat-display-fonts = " \
 fonts-filesystem \
"

URI_redhat-display-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/redhat-display-vf-fonts-4.0.3-14.el10.noarch.rpm;name=redhat-display-vf-fonts;unpack=0"
SRC_URI += "${URI_redhat-display-vf-fonts}"
SRC_URI[redhat-display-vf-fonts.sha256sum] = "8d7dc0be20684a7a3fb378ba6669b1e30fcf01abeacb86938421ee3404a084a9"
RDEPENDS:redhat-display-vf-fonts = " \
 fonts-filesystem \
"

URI_redhat-mono-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/redhat-mono-fonts-4.0.3-14.el10.noarch.rpm;name=redhat-mono-fonts;unpack=0"
SRC_URI += "${URI_redhat-mono-fonts}"
SRC_URI[redhat-mono-fonts.sha256sum] = "c150d69b3a7761e00521443ca8fc9135c33bfc62971c1cd4559874cbb91f5408"
RDEPENDS:redhat-mono-fonts = " \
 fonts-filesystem \
"

URI_redhat-text-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/redhat-text-fonts-4.0.3-14.el10.noarch.rpm;name=redhat-text-fonts;unpack=0"
SRC_URI += "${URI_redhat-text-fonts}"
SRC_URI[redhat-text-fonts.sha256sum] = "ece22d18996081baa8160cc48a0dedf36332dd8342aa67a968ac3280ee62dc38"
RDEPENDS:redhat-text-fonts = " \
 fonts-filesystem \
"
