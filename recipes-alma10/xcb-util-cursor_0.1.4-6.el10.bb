# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xcb-util-cursor"
PE = "0"
PV = "0.1.4"
PR = "6.el10"
PACKAGES = "xcb-util-cursor xcb-util-cursor-devel"
PROVIDES = "rpm/xcb-util-cursor rpm/xcb-util-cursor-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xcb-util-cursor-0.1.4-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96826177e40f591169aaa9ec88e1bb188f8ffff129dd38ba71f7d0e1be645ad8"

URI_xcb-util-cursor = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xcb-util-cursor-0.1.4-6.el10.x86_64_v2.rpm;name=xcb-util-cursor;unpack=0"
SRC_URI += "${URI_xcb-util-cursor}"
SRC_URI[xcb-util-cursor.sha256sum] = "0fb97341f9401f63e39daa6a0142d50067c890fa8571f3400279bf2eb6282541"
RDEPENDS:xcb-util-cursor = " \
 glibc \
 libxcb \
 xcb-util-image \
 xcb-util-renderutil \
"

URI_xcb-util-cursor-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xcb-util-cursor-devel-0.1.4-6.el10.x86_64_v2.rpm;name=xcb-util-cursor-devel;unpack=0"
SRC_URI += "${URI_xcb-util-cursor-devel}"
SRC_URI[xcb-util-cursor-devel.sha256sum] = "ff402c7837fc34f38dc9d3640d328a5a3dad496275d570d65d6b0eec9124d2d4"
RDEPENDS:xcb-util-cursor-devel = " \
 xcb-util-renderutil-devel \
 pkgconf-pkg-config \
 libxcb-devel \
 xcb-util-cursor \
 xcb-util-image-devel \
"
