# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "crun"
PE = "0"
PV = "1.23.1"
PR = "1.el10_0"
PACKAGES = "crun"
PROVIDES = "rpm/crun"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/crun-1.23.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb432199dd59f97cb8ed2932428684a3ce1f923c34133b99b8f0d6e06136dec4"

URI_crun = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/crun-1.23.1-1.el10_0.x86_64_v2.rpm;name=crun;unpack=0"
SRC_URI += "${URI_crun}"
SRC_URI[crun.sha256sum] = "2554e60c65feaaf94282b4eee86ddedb8a3ddbee0ab676dc84974798fe583da3"
RDEPENDS:crun = " \
 systemd-libs \
 libgcc \
 libcap \
 libseccomp \
 glibc \
"
