# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-XML-LibXML"
PE = "1"
PV = "2.0210"
PR = "4.el10"
PACKAGES = "perl-XML-LibXML perl-XML-LibXML-tests"
PROVIDES = "rpm/perl-XML-LibXML rpm/perl-XML-LibXML-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-XML-LibXML-2.0210-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "abac4609fee4c330cf4415ef9e3bbc47e4c5b27a6eb13e5e6721a427e110556d"

URI_perl-XML-LibXML = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-XML-LibXML-2.0210-4.el10.x86_64_v2.rpm;name=perl-XML-LibXML;unpack=0"
SRC_URI += "${URI_perl-XML-LibXML}"
SRC_URI[perl-XML-LibXML.sha256sum] = "22bafe32557714144e157336ed1263e4065aa1fc50ca3ccf521877ec12fdb8b8"
RDEPENDS:perl-XML-LibXML = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-overload \
 perl-parent \
 perl-Carp \
 perl-vars \
 perl-IO \
 perl-Data-Dumper \
 libxml2 \
 perl-XML-LibXML \
 perl-Encode \
 perl-XML-NamespaceSupport \
 perl-XML-SAX \
 bash \
 perl-XML-SAX-Base \
 perl-Exporter \
 perl-base \
 perl-constant \
 glibc \
 perl-interpreter \
"

URI_perl-XML-LibXML-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-XML-LibXML-tests-2.0210-4.el10.noarch.rpm;name=perl-XML-LibXML-tests;unpack=0"
SRC_URI += "${URI_perl-XML-LibXML-tests}"
SRC_URI[perl-XML-LibXML-tests.sha256sum] = "be351d1eb9d59efa53996da37f42c16d2bcee3b4b79a782620f9b46010f5df8e"
RDEPENDS:perl-XML-LibXML-tests = " \
 perl-Scalar-List-Utils \
 perl-libs \
 glibc-gconv-extra \
 perl-locale \
 perl-overload \
 perl-parent \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Carp \
 perl-vars \
 perl-IO \
 perl-Data-Dumper \
 perl-XML-LibXML \
 perl-XML-SAX \
 bash \
 perl-XML-SAX-Base \
 perl-Errno \
 perl-Exporter \
 perl-constant \
 perl-ExtUtils-MakeMaker \
 perl-POSIX \
 perl-PathTools \
 perl-interpreter \
 perl-lib \
"
