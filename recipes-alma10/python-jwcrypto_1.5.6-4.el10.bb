# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-jwcrypto"
PE = "0"
PV = "1.5.6"
PR = "4.el10"
PACKAGES = "python3-jwcrypto"
PROVIDES = "rpm/python3-jwcrypto"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-jwcrypto-1.5.6-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ca99cb561fea43738297131d08b3e642168e0dcf1fbce30f7f06747e4a86fb8"

URI_python3-jwcrypto = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-jwcrypto-1.5.6-4.el10.noarch.rpm;name=python3-jwcrypto;unpack=0"
SRC_URI += "${URI_python3-jwcrypto}"
SRC_URI[python3-jwcrypto.sha256sum] = "a32cdde04ea9a328cc032cac0d6c77cb168dff2ebfcc0c4e539d9b4da62ed232"
RDEPENDS:python3-jwcrypto = " \
 python3 \
 python3-cryptography \
 python3-typing-extensions \
"
