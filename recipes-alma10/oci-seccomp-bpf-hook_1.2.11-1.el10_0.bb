# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "oci-seccomp-bpf-hook"
PE = "0"
PV = "1.2.11"
PR = "1.el10_0"
PACKAGES = "oci-seccomp-bpf-hook oci-seccomp-bpf-hook-tests"
PROVIDES = "rpm/oci-seccomp-bpf-hook rpm/oci-seccomp-bpf-hook-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/oci-seccomp-bpf-hook-1.2.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ae27bb2e65a159298c04b61e8afb29a1f84635d81eaa8f8aaab2625a4503192"

URI_oci-seccomp-bpf-hook = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/oci-seccomp-bpf-hook-1.2.11-1.el10_0.x86_64_v2.rpm;name=oci-seccomp-bpf-hook;unpack=0"
SRC_URI += "${URI_oci-seccomp-bpf-hook}"
SRC_URI[oci-seccomp-bpf-hook.sha256sum] = "bdc0abc7aba5f051fe0c464a40bc92b8e02be2b61e48f4d6315c6dcf3f2ab18d"
RDEPENDS:oci-seccomp-bpf-hook = " \
 glibc \
 bcc \
 libseccomp \
"

URI_oci-seccomp-bpf-hook-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/oci-seccomp-bpf-hook-tests-1.2.11-1.el10_0.x86_64_v2.rpm;name=oci-seccomp-bpf-hook-tests;unpack=0"
SRC_URI += "${URI_oci-seccomp-bpf-hook-tests}"
SRC_URI[oci-seccomp-bpf-hook-tests.sha256sum] = "012c7eff4764eb21b9f7087e1d0d8c512bd007a7a5c745e161529c896ac6fc92"
RDEPENDS:oci-seccomp-bpf-hook-tests = " \
 oci-seccomp-bpf-hook \
 bash \
 podman \
"
