# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-File-Listing"
PE = "0"
PV = "6.16"
PR = "5.el10"
PACKAGES = "perl-File-Listing perl-File-Listing-tests"
PROVIDES = "rpm/perl-File-Listing rpm/perl-File-Listing-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-File-Listing-6.16-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "767ea4b9ac24619c2c58d741fdf0ff93b16a36f5013532a38ba113f317009ed3"

URI_perl-File-Listing = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-File-Listing-6.16-5.el10.noarch.rpm;name=perl-File-Listing;unpack=0"
SRC_URI += "${URI_perl-File-Listing}"
SRC_URI[perl-File-Listing.sha256sum] = "021dbf088c167ab8055e3932db959b79f306fe7d5d67aa4ec7293a11b8fcc97b"
RDEPENDS:perl-File-Listing = " \
 perl-HTTP-Date \
 perl-Exporter \
 perl-libs \
 perl-Carp \
"

URI_perl-File-Listing-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-File-Listing-tests-6.16-5.el10.noarch.rpm;name=perl-File-Listing-tests;unpack=0"
SRC_URI += "${URI_perl-File-Listing-tests}"
SRC_URI[perl-File-Listing-tests.sha256sum] = "2e3f4e82b6a190c0b906510e40d856edb84d8ac2987db2b4cb91eb9115c9b741"
RDEPENDS:perl-File-Listing-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 bash \
 perl-interpreter \
 perl-File-Listing \
"
