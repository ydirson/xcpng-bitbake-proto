# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "kernel-srpm-macros"
PE = "0"
PV = "1.0"
PR = "25.el10"
PACKAGES = "kernel-rpm-macros kernel-srpm-macros"
PROVIDES = "rpm/kernel-rpm-macros rpm/kernel-srpm-macros"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/kernel-srpm-macros-1.0-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d16d05a53da5bded6c52aa3743253f497463803ab38168621812f728a794bb9d"

URI_kernel-rpm-macros = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/kernel-rpm-macros-205-25.el10.noarch.rpm;name=kernel-rpm-macros;unpack=0"
SRC_URI += "${URI_kernel-rpm-macros}"
SRC_URI[kernel-rpm-macros.sha256sum] = "c1b332b9b8f881b0e05736638fb013f0131b821ce643c75d2090fc46f0b42ddf"
RDEPENDS:kernel-rpm-macros = " \
 redhat-rpm-config \
 kmod \
 gawk \
 grep \
 bash \
 xz \
 binutils \
 sed \
 perl-interpreter \
 findutils \
"

URI_kernel-srpm-macros = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/kernel-srpm-macros-1.0-25.el10.noarch.rpm;name=kernel-srpm-macros;unpack=0"
SRC_URI += "${URI_kernel-srpm-macros}"
SRC_URI[kernel-srpm-macros.sha256sum] = "9eda056264ee33ae8d68c6c3467232637afbfc9901eb96df88ca4f7286877171"
RDEPENDS:kernel-srpm-macros = ""
