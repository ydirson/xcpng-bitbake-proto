# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libarchive"
PE = "0"
PV = "3.7.7"
PR = "4.el10_0"
PACKAGES = "libarchive bsdtar libarchive-devel bsdcat bsdcpio bsdunzip"
PROVIDES = "rpm/libarchive rpm/bsdtar rpm/libarchive-devel rpm/bsdcat rpm/bsdcpio rpm/bsdunzip"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libarchive-3.7.7-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f90555e2eeba4ebe85adbd1292c12351c0e6f089c555ca599db44e765242e1df"

URI_libarchive = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libarchive-3.7.7-4.el10_0.x86_64_v2.rpm;name=libarchive;unpack=0"
SRC_URI += "${URI_libarchive}"
SRC_URI[libarchive.sha256sum] = "07fe1b78a2e4274e9f87d24840713c8faf2f95fe5d29a939ca6959970d707f59"
RDEPENDS:libarchive = " \
 libacl \
 zlib-ng-compat \
 bzip2-libs \
 lz4-libs \
 openssl-libs \
 libxml2 \
 libzstd \
 glibc \
 xz-libs \
"

URI_bsdtar = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/bsdtar-3.7.7-4.el10_0.x86_64_v2.rpm;name=bsdtar;unpack=0"
SRC_URI += "${URI_bsdtar}"
SRC_URI[bsdtar.sha256sum] = "7d908aa6b22af00a3c51bf76617d52c374e2e848df6b11d1b303e56b820f6549"
RDEPENDS:bsdtar = " \
 glibc \
 libarchive \
"

URI_libarchive-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libarchive-devel-3.7.7-4.el10_0.x86_64_v2.rpm;name=libarchive-devel;unpack=0"
SRC_URI += "${URI_libarchive-devel}"
SRC_URI[libarchive-devel.sha256sum] = "11161f02ec862d459a869dcecf5ce6353a6648b9eb4c1db940dc8187eb7520c3"
RDEPENDS:libarchive-devel = " \
 openssl-devel \
 pkgconf-pkg-config \
 libarchive \
"

URI_bsdcat = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/bsdcat-3.7.7-4.el10_0.x86_64_v2.rpm;name=bsdcat;unpack=0"
SRC_URI += "${URI_bsdcat}"
SRC_URI[bsdcat.sha256sum] = "3bd95f9d7ec59000fe17abd70a157b18d3533dc6884b2725cb49611266f5d983"
RDEPENDS:bsdcat = " \
 glibc \
 libarchive \
"

URI_bsdcpio = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/bsdcpio-3.7.7-4.el10_0.x86_64_v2.rpm;name=bsdcpio;unpack=0"
SRC_URI += "${URI_bsdcpio}"
SRC_URI[bsdcpio.sha256sum] = "facbf219fc48255bcd395f64137f37fb1b1dd0a975de73d6d07b8728355632e0"
RDEPENDS:bsdcpio = " \
 glibc \
 libarchive \
"

URI_bsdunzip = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/bsdunzip-3.7.7-4.el10_0.x86_64_v2.rpm;name=bsdunzip;unpack=0"
SRC_URI += "${URI_bsdunzip}"
SRC_URI[bsdunzip.sha256sum] = "4bd6dfa2dc3443f6c9123d5b8311715dd7f202157476671f925f9b24eb01c248"
RDEPENDS:bsdunzip = " \
 glibc \
 libarchive \
"
