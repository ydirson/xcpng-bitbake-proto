# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-Install"
PE = "0"
PV = "2.22"
PR = "511.el10"
PACKAGES = "perl-ExtUtils-Install perl-ExtUtils-Install-tests"
PROVIDES = "rpm/perl-ExtUtils-Install rpm/perl-ExtUtils-Install-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-ExtUtils-Install-2.22-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fdfa4388893ce05a878295721f205588a2f61ffc01c48ef32de1d58abb3c2083"

URI_perl-ExtUtils-Install = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-ExtUtils-Install-2.22-511.el10.noarch.rpm;name=perl-ExtUtils-Install;unpack=0"
SRC_URI += "${URI_perl-ExtUtils-Install}"
SRC_URI[perl-ExtUtils-Install.sha256sum] = "c82c47f529f62334177947d1db392eb4119e8ef1debbdb7de26d6a5f84c702f3"
RDEPENDS:perl-ExtUtils-Install = " \
 perl-ExtUtils-Install \
 perl-libs \
 perl-Carp \
 perl-ExtUtils-MakeMaker \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Copy \
 perl-PathTools \
 perl-AutoSplit \
 perl-File-Find \
 perl-Exporter \
 perl-File-Path \
 perl-Data-Dumper \
"

URI_perl-ExtUtils-Install-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-ExtUtils-Install-tests-2.22-511.el10.noarch.rpm;name=perl-ExtUtils-Install-tests;unpack=0"
SRC_URI += "${URI_perl-ExtUtils-Install-tests}"
SRC_URI[perl-ExtUtils-Install-tests.sha256sum] = "13a3cfea872ca1f808ba37b82687e9872d4df6b9a6cc93b4268e48c159550280"
RDEPENDS:perl-ExtUtils-Install-tests = " \
 perl-ExtUtils-Install \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-ExtUtils-MakeMaker \
 make \
 perl-File-Basename \
 perl-File-Compare \
 bash \
 perl-PathTools \
 perl-File-Find \
 perl-interpreter \
 perl-File-Path \
 perl-Exporter \
 perl-File-Temp \
"
