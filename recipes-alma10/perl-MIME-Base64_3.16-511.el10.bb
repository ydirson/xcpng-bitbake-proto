# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-MIME-Base64"
PE = "0"
PV = "3.16"
PR = "511.el10"
PACKAGES = "perl-MIME-Base64 perl-MIME-Base64-tests"
PROVIDES = "rpm/perl-MIME-Base64 rpm/perl-MIME-Base64-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-MIME-Base64-3.16-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a08f0517960ee3e16370304d4d8ec0123b6c84ab9e7b8736455152abf2e64827"

URI_perl-MIME-Base64 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-MIME-Base64-3.16-511.el10.x86_64_v2.rpm;name=perl-MIME-Base64;unpack=0"
SRC_URI += "${URI_perl-MIME-Base64}"
SRC_URI[perl-MIME-Base64.sha256sum] = "dd00112676f4aa0aa2142d0c99f2a3b892fd9d4fbf6d6d293cc3fb08f32b7fd1"
RDEPENDS:perl-MIME-Base64 = " \
 glibc \
 perl-Exporter \
 perl-libs \
 perl-MIME-Base64 \
"

URI_perl-MIME-Base64-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-MIME-Base64-tests-3.16-511.el10.x86_64_v2.rpm;name=perl-MIME-Base64-tests;unpack=0"
SRC_URI += "${URI_perl-MIME-Base64-tests}"
SRC_URI[perl-MIME-Base64-tests.sha256sum] = "d2579f43d4cc0671254fa3295e2074ee688210fc6ae56a6c186693df3d0554c9"
RDEPENDS:perl-MIME-Base64-tests = " \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-ExtUtils-MakeMaker \
 bash \
 perl-PathTools \
 perl-interpreter \
 perl-MIME-Base64 \
"
