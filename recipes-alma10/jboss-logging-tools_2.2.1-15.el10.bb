# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jboss-logging-tools"
PE = "0"
PV = "2.2.1"
PR = "15.el10"
PACKAGES = "jboss-logging-tools"
PROVIDES = "rpm/jboss-logging-tools"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/jboss-logging-tools-2.2.1-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8564e7b2e3be655524ef1fa556dac602ecc41379ed7514c8b7d84f1a4078b46e"

URI_jboss-logging-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/jboss-logging-tools-2.2.1-15.el10.noarch.rpm;name=jboss-logging-tools;unpack=0"
SRC_URI += "${URI_jboss-logging-tools}"
SRC_URI[jboss-logging-tools.sha256sum] = "c4d4dc6bf66fddda723d2475f102ddae788bf13788dbd51880e0918993eddad8"
RDEPENDS:jboss-logging-tools = " \
 jdeparser \
 javapackages-filesystem \
 java-21-openjdk-headless \
"
