# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "objectweb-asm"
PE = "0"
PV = "9.6"
PR = "6.el10"
PACKAGES = "objectweb-asm objectweb-asm-javadoc"
PROVIDES = "rpm/objectweb-asm rpm/objectweb-asm-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/objectweb-asm-9.6-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b143b76c9e0e7bb5e5cb7ee6e867d0ca549b64a5963710cb4bd4cce11f27f02b"

URI_objectweb-asm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/objectweb-asm-9.6-6.el10.noarch.rpm;name=objectweb-asm;unpack=0"
SRC_URI += "${URI_objectweb-asm}"
SRC_URI[objectweb-asm.sha256sum] = "8b6099b995e5773feb1bc4e8681d6e8c3b9a702f419ec45e933a11b0c7cf20c4"
RDEPENDS:objectweb-asm = " \
 bash \
 javapackages-filesystem \
 javapackages-tools \
"

URI_objectweb-asm-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/objectweb-asm-javadoc-9.6-6.el10.noarch.rpm;name=objectweb-asm-javadoc;unpack=0"
SRC_URI += "${URI_objectweb-asm-javadoc}"
SRC_URI[objectweb-asm-javadoc.sha256sum] = "8ff7166d1fd2efa788e572b0aaf517b13264c706c36c26908beedd0051e1b511"
RDEPENDS:objectweb-asm-javadoc = " \
 javapackages-filesystem \
"
