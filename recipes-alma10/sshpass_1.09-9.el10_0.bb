# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sshpass"
PE = "0"
PV = "1.09"
PR = "9.el10_0"
PACKAGES = "sshpass"
PROVIDES = "rpm/sshpass"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/sshpass-1.09-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd1c6c1f54a3a843b520d8cd4da3c2bb0b0055d24e0f000a6e7def582a88cc78"

URI_sshpass = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sshpass-1.09-9.el10_0.x86_64_v2.rpm;name=sshpass;unpack=0"
SRC_URI += "${URI_sshpass}"
SRC_URI[sshpass.sha256sum] = "16c103fa6649f6b55ed2c57199926b358a053794358868991ab2f05a2c01de79"
RDEPENDS:sshpass = " \
 glibc \
"
