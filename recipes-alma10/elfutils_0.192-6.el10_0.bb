# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "elfutils"
PE = "0"
PV = "0.192"
PR = "6.el10_0"
PACKAGES = "elfutils elfutils-debuginfod-client elfutils-default-yama-scope elfutils-libelf elfutils-libs elfutils-debuginfod elfutils-debuginfod-client-devel elfutils-devel elfutils-libelf-devel"
PROVIDES = "rpm/elfutils rpm/elfutils-debuginfod-client rpm/elfutils-default-yama-scope rpm/elfutils-libelf rpm/elfutils-libs rpm/elfutils-debuginfod rpm/elfutils-debuginfod-client-devel rpm/elfutils-devel rpm/elfutils-libelf-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/elfutils-0.192-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8c4140149c4d4476532734bb9d8316aabe14afde550493ce4370861740c76aa"

URI_elfutils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/elfutils-0.192-6.el10_0.x86_64_v2.rpm;name=elfutils;unpack=0"
SRC_URI += "${URI_elfutils}"
SRC_URI[elfutils.sha256sum] = "679e9accbda4817d58364ac5816140ca6929b8bcb7f8de149cd967efcc740290"
RDEPENDS:elfutils = " \
 libarchive \
 elfutils-debuginfod-client \
 libgcc \
 elfutils-libelf \
 elfutils-libs \
 libstdc++ \
 bash \
 glibc \
"

URI_elfutils-debuginfod-client = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/elfutils-debuginfod-client-0.192-6.el10_0.x86_64_v2.rpm;name=elfutils-debuginfod-client;unpack=0"
SRC_URI += "${URI_elfutils-debuginfod-client}"
SRC_URI[elfutils-debuginfod-client.sha256sum] = "b2c24452d20adc8ae218b3eb25c5e4c46014a2f6536873757e00bd9d7e50a853"
RDEPENDS:elfutils-debuginfod-client = " \
 openssl-libs \
 json-c \
 elfutils-libelf \
 elfutils-libs \
 libcurl \
 glibc \
"

URI_elfutils-default-yama-scope = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/elfutils-default-yama-scope-0.192-6.el10_0.noarch.rpm;name=elfutils-default-yama-scope;unpack=0"
SRC_URI += "${URI_elfutils-default-yama-scope}"
SRC_URI[elfutils-default-yama-scope.sha256sum] = "bf7d2987ef0005650d785c97eb780691cfe106ba20bd4db88e7d607ac2048eca"
RDEPENDS:elfutils-default-yama-scope = " \
 bash \
"

URI_elfutils-libelf = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/elfutils-libelf-0.192-6.el10_0.x86_64_v2.rpm;name=elfutils-libelf;unpack=0"
SRC_URI += "${URI_elfutils-libelf}"
SRC_URI[elfutils-libelf.sha256sum] = "830a3b8b96a866b01c301674251bfc9a28419049fb9e53c633cfe8928b4291d8"
RDEPENDS:elfutils-libelf = " \
 glibc \
 zlib-ng-compat \
 libzstd \
"

URI_elfutils-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/elfutils-libs-0.192-6.el10_0.x86_64_v2.rpm;name=elfutils-libs;unpack=0"
SRC_URI += "${URI_elfutils-libs}"
SRC_URI[elfutils-libs.sha256sum] = "e4f47da39e4a4cf2ee4cb22326751c9f03134f899e5760bae87abc5bf92f42e1"
RDEPENDS:elfutils-libs = " \
 zlib-ng-compat \
 bzip2-libs \
 elfutils-default-yama-scope \
 elfutils-libelf \
 libzstd \
 glibc \
 xz-libs \
"

URI_elfutils-debuginfod = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/elfutils-debuginfod-0.192-6.el10_0.x86_64_v2.rpm;name=elfutils-debuginfod;unpack=0"
SRC_URI += "${URI_elfutils-debuginfod}"
SRC_URI[elfutils-debuginfod.sha256sum] = "ec8fd5c41ae832bac5878c15acbd2b8d3d68c4dea33c9ee06247a9506e92af99"
RDEPENDS:elfutils-debuginfod = " \
 shadow-utils \
 systemd \
 libarchive \
 bsdtar \
 elfutils-debuginfod-client \
 libgcc \
 json-c \
 libmicrohttpd \
 elfutils-libelf \
 elfutils-libs \
 sqlite-libs \
 libstdc++ \
 bash \
 glibc \
 rpm-libs \
 xz-libs \
"

URI_elfutils-debuginfod-client-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/elfutils-debuginfod-client-devel-0.192-6.el10_0.x86_64_v2.rpm;name=elfutils-debuginfod-client-devel;unpack=0"
SRC_URI += "${URI_elfutils-debuginfod-client-devel}"
SRC_URI[elfutils-debuginfod-client-devel.sha256sum] = "296839ce0120e0468ec0d59c271f7426c8e043db077c172fdc2f0d414aa42595"
RDEPENDS:elfutils-debuginfod-client-devel = " \
 elfutils-debuginfod-client \
 pkgconf-pkg-config \
"

URI_elfutils-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/elfutils-devel-0.192-6.el10_0.x86_64_v2.rpm;name=elfutils-devel;unpack=0"
SRC_URI += "${URI_elfutils-devel}"
SRC_URI[elfutils-devel.sha256sum] = "faad0330afbeddf2930192d95d8a69222db9eaf46fd9c10d208559d666d0fe0f"
RDEPENDS:elfutils-devel = " \
 xz-devel \
 zlib-ng-compat-devel \
 libzstd-devel \
 pkgconf-pkg-config \
 elfutils-libs \
 elfutils-libelf-devel \
"

URI_elfutils-libelf-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/elfutils-libelf-devel-0.192-6.el10_0.x86_64_v2.rpm;name=elfutils-libelf-devel;unpack=0"
SRC_URI += "${URI_elfutils-libelf-devel}"
SRC_URI[elfutils-libelf-devel.sha256sum] = "e04c79a2cece40a0b02d56e28ae91068ceb897d356e1b7f38ceeb1bcc47ff5ba"
RDEPENDS:elfutils-libelf-devel = " \
 zlib-ng-compat-devel \
 libzstd-devel \
 pkgconf-pkg-config \
 elfutils-libelf \
"
