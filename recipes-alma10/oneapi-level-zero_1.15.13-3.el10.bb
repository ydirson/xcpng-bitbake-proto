# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "oneapi-level-zero"
PE = "0"
PV = "1.15.13"
PR = "3.el10"
PACKAGES = "oneapi-level-zero oneapi-level-zero-devel"
PROVIDES = "rpm/oneapi-level-zero rpm/oneapi-level-zero-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/oneapi-level-zero-1.15.13-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ff2c1b1589a5cb50b1cc891a63c9d4e9a442772aef08e1beb4f23fc40cb1a52"

URI_oneapi-level-zero = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/oneapi-level-zero-1.15.13-3.el10.x86_64_v2.rpm;name=oneapi-level-zero;unpack=0"
SRC_URI += "${URI_oneapi-level-zero}"
SRC_URI[oneapi-level-zero.sha256sum] = "bf58d13ba434f244991a31a8d7ca4e9731d2ef4cd0b1dfa95938a31f76ce0dd4"
RDEPENDS:oneapi-level-zero = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_oneapi-level-zero-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/oneapi-level-zero-devel-1.15.13-3.el10.x86_64_v2.rpm;name=oneapi-level-zero-devel;unpack=0"
SRC_URI += "${URI_oneapi-level-zero-devel}"
SRC_URI[oneapi-level-zero-devel.sha256sum] = "bb602c9190e45521450207305ffe613bb9575f0de2713d3d66d9a52b1405a563"
RDEPENDS:oneapi-level-zero-devel = " \
 oneapi-level-zero \
 oneapi-level-zero-devel \
 pkgconf-pkg-config \
"
