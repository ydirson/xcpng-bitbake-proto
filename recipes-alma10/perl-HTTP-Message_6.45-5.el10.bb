# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-HTTP-Message"
PE = "0"
PV = "6.45"
PR = "5.el10"
PACKAGES = "perl-HTTP-Message perl-HTTP-Message-tests"
PROVIDES = "rpm/perl-HTTP-Message rpm/perl-HTTP-Message-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-HTTP-Message-6.45-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9374108a6b0fd9959c1a9a087dbd89819698e8e5ff13a930a00e19b21d7200a5"

URI_perl-HTTP-Message = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-HTTP-Message-6.45-5.el10.noarch.rpm;name=perl-HTTP-Message;unpack=0"
SRC_URI += "${URI_perl-HTTP-Message}"
SRC_URI[perl-HTTP-Message.sha256sum] = "98cbcbc4df158ede628f9f78fae8e78dc2bed1757865be03eba33208e52f9173"
RDEPENDS:perl-HTTP-Message = " \
 perl-libs \
 perl-Carp \
 perl-URI \
 perl-IO-Compress \
 perl-Clone \
 perl-IO-HTML \
 perl-Compress-Raw-Zlib \
 perl-Encode \
 perl-Encode-Locale \
 perl-PathTools \
 perl-parent \
 perl-LWP-MediaTypes \
 perl-HTTP-Date \
 perl-HTTP-Message \
 perl-Exporter \
 perl-MIME-Base64 \
"

URI_perl-HTTP-Message-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-HTTP-Message-tests-6.45-5.el10.noarch.rpm;name=perl-HTTP-Message-tests;unpack=0"
SRC_URI += "${URI_perl-HTTP-Message-tests}"
SRC_URI[perl-HTTP-Message-tests.sha256sum] = "0e9553e8745d6816199b5d646e2c43c01cc40dbe08df05052f0c08839f11ceeb"
RDEPENDS:perl-HTTP-Message-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-ExtUtils-MakeMaker \
 perl-Try-Tiny \
 perl-URI \
 perl-Test-Simple \
 perl-Compress-Raw-Zlib \
 perl-Encode \
 perl-File-Temp \
 perl-overload \
 perl-PathTools \
 bash \
 perl-Test-Needs \
 perl-HTTP-Message \
 perl-interpreter \
 perl-lib \
"
