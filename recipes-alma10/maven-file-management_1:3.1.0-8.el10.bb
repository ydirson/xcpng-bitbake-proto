# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "maven-file-management"
PE = "1"
PV = "3.1.0"
PR = "8.el10"
PACKAGES = "maven-file-management maven-file-management-javadoc"
PROVIDES = "rpm/maven-file-management rpm/maven-file-management-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/maven-file-management-3.1.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d06320ccd432b2b133ef3f17855588d129b0f72c62baa06c77980f5d0b6c09b2"

URI_maven-file-management = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-file-management-3.1.0-8.el10.noarch.rpm;name=maven-file-management;unpack=0"
SRC_URI += "${URI_maven-file-management}"
SRC_URI[maven-file-management.sha256sum] = "3fcb813a3bbf51a28f0cc632f34ff6dc8fce8407dc44f0437b18b051f54d3f1a"
RDEPENDS:maven-file-management = " \
 plexus-utils \
 apache-commons-io \
 javapackages-filesystem \
 slf4j \
"

URI_maven-file-management-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-file-management-javadoc-3.1.0-8.el10.noarch.rpm;name=maven-file-management-javadoc;unpack=0"
SRC_URI += "${URI_maven-file-management-javadoc}"
SRC_URI[maven-file-management-javadoc.sha256sum] = "4cad04b0825ef6b71b3c0de9e7f50c8e55499d0150bbac4119ee29fd158e55de"
RDEPENDS:maven-file-management-javadoc = " \
 javapackages-filesystem \
"
