# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "servicelog"
PE = "0"
PV = "1.1.16"
PR = "8.el10"
PACKAGES = ""
PROVIDES = ""


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/servicelog-1.1.16-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d7a05f6092f513ac3a5b2e6aa59bd620322ef34d45b5d29e729b6bd1e8095ac"
