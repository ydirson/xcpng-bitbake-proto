# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "boom-boot"
PE = "0"
PV = "1.6.5"
PR = "3.el10"
PACKAGES = "boom-boot boom-boot-conf python3-boom"
PROVIDES = "rpm/boom-boot rpm/boom-boot-conf rpm/python3-boom"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/boom-boot-1.6.5-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f560f1bdcd50e20ec886dfbe02645d43b9dbb2b6801536b53e2e2eac2c484c9"

URI_boom-boot = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boom-boot-1.6.5-3.el10.noarch.rpm;name=boom-boot;unpack=0"
SRC_URI += "${URI_boom-boot}"
SRC_URI[boom-boot.sha256sum] = "254212b17a73cfc951a0d1159add8bbf74256a938eb9c00e006a358458c3335a"
RDEPENDS:boom-boot = " \
 python3 \
 systemd \
 python3-boom \
 python3-dbus \
 boom-boot-conf \
"

URI_boom-boot-conf = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/boom-boot-conf-1.6.5-3.el10.noarch.rpm;name=boom-boot-conf;unpack=0"
SRC_URI += "${URI_boom-boot-conf}"
SRC_URI[boom-boot-conf.sha256sum] = "da4550a7cfd5ac28ac680c0171c76904d5cb67d0e230cb19eb5be4bd7937b6b5"
RDEPENDS:boom-boot-conf = ""

URI_python3-boom = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-boom-1.6.5-3.el10.noarch.rpm;name=python3-boom;unpack=0"
SRC_URI += "${URI_python3-boom}"
SRC_URI[python3-boom.sha256sum] = "c805b7fd2232b0a464192280276243085c4df05a4592378eaa603aa0c830c6d9"
RDEPENDS:python3-boom = " \
 python3 \
 python3-dbus \
"
