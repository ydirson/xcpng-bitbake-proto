# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "google-noto-fonts"
PE = "0"
PV = "20240401"
PR = "5.el10"
PACKAGES = "google-noto-fonts-common google-noto-sans-mono-vf-fonts google-noto-sans-vf-fonts google-noto-serif-vf-fonts google-noto-fangsong-kss-rotated-fonts google-noto-fangsong-kss-vertical-fonts google-noto-fonts-all google-noto-kufi-arabic-fonts google-noto-kufi-arabic-vf-fonts google-noto-music-fonts google-noto-naskh-arabic-fonts google-noto-naskh-arabic-ui-fonts google-noto-naskh-arabic-ui-vf-fonts google-noto-naskh-arabic-vf-fonts google-noto-nastaliq-urdu-fonts google-noto-nastaliq-urdu-vf-fonts google-noto-rashi-hebrew-fonts google-noto-rashi-hebrew-vf-fonts google-noto-sans-adlam-fonts google-noto-sans-adlam-unjoined-fonts google-noto-sans-adlam-unjoined-vf-fonts google-noto-sans-adlam-vf-fonts google-noto-sans-anatolian-hieroglyphs-fonts google-noto-sans-arabic-fonts google-noto-sans-arabic-vf-fonts google-noto-sans-armenian-fonts google-noto-sans-armenian-vf-fonts google-noto-sans-avestan-fonts google-noto-sans-balinese-fonts google-noto-sans-balinese-vf-fonts google-noto-sans-bamum-fonts google-noto-sans-bamum-vf-fonts google-noto-sans-bassa-vah-fonts google-noto-sans-bassa-vah-vf-fonts google-noto-sans-batak-fonts google-noto-sans-bengali-fonts google-noto-sans-bengali-ui-fonts google-noto-sans-bengali-vf-fonts google-noto-sans-bhaiksuki-fonts google-noto-sans-brahmi-fonts google-noto-sans-buginese-fonts google-noto-sans-buhid-fonts google-noto-sans-canadian-aboriginal-fonts google-noto-sans-canadian-aboriginal-vf-fonts google-noto-sans-carian-fonts google-noto-sans-caucasian-albanian-fonts google-noto-sans-chakma-fonts google-noto-sans-cham-fonts google-noto-sans-cham-vf-fonts google-noto-sans-cherokee-fonts google-noto-sans-cherokee-vf-fonts google-noto-sans-chorasmian-fonts google-noto-sans-coptic-fonts google-noto-sans-cuneiform-fonts google-noto-sans-cypriot-fonts google-noto-sans-cypro-minoan-fonts google-noto-sans-deseret-fonts google-noto-sans-devanagari-fonts google-noto-sans-devanagari-ui-fonts google-noto-sans-devanagari-vf-fonts google-noto-sans-duployan-fonts google-noto-sans-egyptian-hieroglyphs-fonts google-noto-sans-elbasan-fonts google-noto-sans-elymaic-fonts google-noto-sans-ethiopic-fonts google-noto-sans-ethiopic-vf-fonts google-noto-sans-fonts google-noto-sans-georgian-fonts google-noto-sans-georgian-vf-fonts google-noto-sans-glagolitic-fonts google-noto-sans-gothic-fonts google-noto-sans-grantha-fonts google-noto-sans-gujarati-fonts google-noto-sans-gujarati-ui-fonts google-noto-sans-gujarati-vf-fonts google-noto-sans-gunjala-gondi-fonts google-noto-sans-gunjala-gondi-vf-fonts google-noto-sans-gurmukhi-fonts google-noto-sans-gurmukhi-ui-fonts google-noto-sans-gurmukhi-vf-fonts google-noto-sans-hanifi-rohingya-fonts google-noto-sans-hanifi-rohingya-vf-fonts google-noto-sans-hanunoo-fonts google-noto-sans-hatran-fonts google-noto-sans-hebrew-fonts google-noto-sans-hebrew-vf-fonts google-noto-sans-imperial-aramaic-fonts google-noto-sans-indic-siyaq-numbers-fonts google-noto-sans-inscriptional-pahlavi-fonts google-noto-sans-inscriptional-parthian-fonts google-noto-sans-javanese-fonts google-noto-sans-javanese-vf-fonts google-noto-sans-kaithi-fonts google-noto-sans-kannada-fonts google-noto-sans-kannada-ui-fonts google-noto-sans-kannada-ui-vf-fonts google-noto-sans-kannada-vf-fonts google-noto-sans-kawi-fonts google-noto-sans-kawi-vf-fonts google-noto-sans-kayah-li-fonts google-noto-sans-kayah-li-vf-fonts google-noto-sans-kharoshthi-fonts google-noto-sans-khmer-fonts google-noto-sans-khmer-vf-fonts google-noto-sans-khojki-fonts google-noto-sans-khudawadi-fonts google-noto-sans-lao-fonts google-noto-sans-lao-looped-fonts google-noto-sans-lao-looped-vf-fonts google-noto-sans-lao-vf-fonts google-noto-sans-lepcha-fonts google-noto-sans-limbu-fonts google-noto-sans-linear-a-fonts google-noto-sans-linear-b-fonts google-noto-sans-lisu-fonts google-noto-sans-lisu-vf-fonts google-noto-sans-lycian-fonts google-noto-sans-lydian-fonts google-noto-sans-mahajani-fonts google-noto-sans-malayalam-fonts google-noto-sans-malayalam-ui-fonts google-noto-sans-malayalam-ui-vf-fonts google-noto-sans-malayalam-vf-fonts google-noto-sans-mandaic-fonts google-noto-sans-manichaean-fonts google-noto-sans-marchen-fonts google-noto-sans-masaram-gondi-fonts google-noto-sans-math-fonts google-noto-sans-mayan-numerals-fonts google-noto-sans-medefaidrin-fonts google-noto-sans-medefaidrin-vf-fonts google-noto-sans-meetei-mayek-fonts google-noto-sans-meetei-mayek-vf-fonts google-noto-sans-mende-kikakui-fonts google-noto-sans-meroitic-fonts google-noto-sans-miao-fonts google-noto-sans-modi-fonts google-noto-sans-mongolian-fonts google-noto-sans-mono-fonts google-noto-sans-mro-fonts google-noto-sans-multani-fonts google-noto-sans-myanmar-fonts google-noto-sans-myanmar-vf-fonts google-noto-sans-nabataean-fonts google-noto-sans-nag-mundari-fonts google-noto-sans-nag-mundari-vf-fonts google-noto-sans-nandinagari-fonts google-noto-sans-new-tai-lue-fonts google-noto-sans-new-tai-lue-vf-fonts google-noto-sans-newa-fonts google-noto-sans-nko-fonts google-noto-sans-nko-unjoined-fonts google-noto-sans-nko-unjoined-vf-fonts google-noto-sans-nushu-fonts google-noto-sans-ogham-fonts google-noto-sans-ol-chiki-fonts google-noto-sans-ol-chiki-vf-fonts google-noto-sans-old-hungarian-fonts google-noto-sans-old-italic-fonts google-noto-sans-old-north-arabian-fonts google-noto-sans-old-permic-fonts google-noto-sans-old-persian-fonts google-noto-sans-old-sogdian-fonts google-noto-sans-old-south-arabian-fonts google-noto-sans-old-turkic-fonts google-noto-sans-oriya-fonts google-noto-sans-oriya-vf-fonts google-noto-sans-osage-fonts google-noto-sans-osmanya-fonts google-noto-sans-pahawh-hmong-fonts google-noto-sans-palmyrene-fonts google-noto-sans-pau-cin-hau-fonts google-noto-sans-phagspa-fonts google-noto-sans-phoenician-fonts google-noto-sans-psalter-pahlavi-fonts google-noto-sans-rejang-fonts google-noto-sans-runic-fonts google-noto-sans-samaritan-fonts google-noto-sans-saurashtra-fonts google-noto-sans-sharada-fonts google-noto-sans-shavian-fonts google-noto-sans-siddham-fonts google-noto-sans-signwriting-fonts google-noto-sans-sinhala-fonts google-noto-sans-sinhala-ui-fonts google-noto-sans-sinhala-vf-fonts google-noto-sans-sogdian-fonts google-noto-sans-sora-sompeng-fonts google-noto-sans-sora-sompeng-vf-fonts google-noto-sans-soyombo-fonts google-noto-sans-sundanese-fonts google-noto-sans-sundanese-vf-fonts google-noto-sans-syloti-nagri-fonts google-noto-sans-symbols-2-fonts google-noto-sans-symbols-fonts google-noto-sans-symbols-vf-fonts google-noto-sans-syriac-eastern-fonts google-noto-sans-syriac-eastern-vf-fonts google-noto-sans-syriac-fonts google-noto-sans-syriac-vf-fonts google-noto-sans-syriac-western-fonts google-noto-sans-syriac-western-vf-fonts google-noto-sans-tagalog-fonts google-noto-sans-tagbanwa-fonts google-noto-sans-tai-le-fonts google-noto-sans-tai-tham-fonts google-noto-sans-tai-tham-vf-fonts google-noto-sans-tai-viet-fonts google-noto-sans-takri-fonts google-noto-sans-tamil-fonts google-noto-sans-tamil-supplement-fonts google-noto-sans-tamil-ui-fonts google-noto-sans-tamil-ui-vf-fonts google-noto-sans-tamil-vf-fonts google-noto-sans-tangsa-fonts google-noto-sans-tangsa-vf-fonts google-noto-sans-telugu-fonts google-noto-sans-telugu-ui-fonts google-noto-sans-telugu-ui-vf-fonts google-noto-sans-telugu-vf-fonts google-noto-sans-thaana-fonts google-noto-sans-thaana-vf-fonts google-noto-sans-thai-fonts google-noto-sans-thai-looped-fonts google-noto-sans-thai-vf-fonts google-noto-sans-tifinagh-adrar-fonts google-noto-sans-tifinagh-agraw-imazighen-fonts google-noto-sans-tifinagh-ahaggar-fonts google-noto-sans-tifinagh-air-fonts google-noto-sans-tifinagh-apt-fonts google-noto-sans-tifinagh-azawagh-fonts google-noto-sans-tifinagh-fonts google-noto-sans-tifinagh-ghat-fonts google-noto-sans-tifinagh-hawad-fonts google-noto-sans-tifinagh-rhissa-ixa-fonts google-noto-sans-tifinagh-sil-fonts google-noto-sans-tifinagh-tawellemmet-fonts google-noto-sans-tirhuta-fonts google-noto-sans-ugaritic-fonts google-noto-sans-vai-fonts google-noto-sans-vithkuqi-fonts google-noto-sans-vithkuqi-vf-fonts google-noto-sans-wancho-fonts google-noto-sans-warang-citi-fonts google-noto-sans-yi-fonts google-noto-sans-zanabazar-square-fonts google-noto-serif-ahom-fonts google-noto-serif-armenian-fonts google-noto-serif-armenian-vf-fonts google-noto-serif-balinese-fonts google-noto-serif-bengali-fonts google-noto-serif-bengali-vf-fonts google-noto-serif-devanagari-fonts google-noto-serif-devanagari-vf-fonts google-noto-serif-dives-akuru-fonts google-noto-serif-dogra-fonts google-noto-serif-ethiopic-fonts google-noto-serif-ethiopic-vf-fonts google-noto-serif-fonts google-noto-serif-georgian-fonts google-noto-serif-georgian-vf-fonts google-noto-serif-grantha-fonts google-noto-serif-gujarati-fonts google-noto-serif-gujarati-vf-fonts google-noto-serif-gurmukhi-fonts google-noto-serif-gurmukhi-vf-fonts google-noto-serif-hebrew-fonts google-noto-serif-hebrew-vf-fonts google-noto-serif-kannada-fonts google-noto-serif-kannada-vf-fonts google-noto-serif-khitan-small-script-fonts google-noto-serif-khmer-fonts google-noto-serif-khmer-vf-fonts google-noto-serif-khojki-fonts google-noto-serif-khojki-vf-fonts google-noto-serif-lao-fonts google-noto-serif-lao-vf-fonts google-noto-serif-makasar-fonts google-noto-serif-malayalam-fonts google-noto-serif-malayalam-vf-fonts google-noto-serif-myanmar-fonts google-noto-serif-np-hmong-fonts google-noto-serif-np-hmong-vf-fonts google-noto-serif-old-uyghur-fonts google-noto-serif-oriya-fonts google-noto-serif-oriya-vf-fonts google-noto-serif-ottoman-siyaq-fonts google-noto-serif-sinhala-fonts google-noto-serif-sinhala-vf-fonts google-noto-serif-tamil-fonts google-noto-serif-tamil-vf-fonts google-noto-serif-tangut-fonts google-noto-serif-telugu-fonts google-noto-serif-telugu-vf-fonts google-noto-serif-thai-fonts google-noto-serif-thai-vf-fonts google-noto-serif-tibetan-fonts google-noto-serif-tibetan-vf-fonts google-noto-serif-toto-fonts google-noto-serif-toto-vf-fonts google-noto-serif-vithkuqi-fonts google-noto-serif-vithkuqi-vf-fonts google-noto-serif-yezidi-fonts google-noto-serif-yezidi-vf-fonts google-noto-traditional-nushu-fonts google-noto-traditional-nushu-vf-fonts google-noto-fonts-all-static google-noto-fonts-all-vf google-noto-serif-myanmar-vf-fonts"
PROVIDES = "rpm/google-noto-fonts-common rpm/google-noto-sans-mono-vf-fonts rpm/google-noto-sans-vf-fonts rpm/google-noto-serif-vf-fonts rpm/google-noto-fangsong-kss-rotated-fonts rpm/google-noto-fangsong-kss-vertical-fonts rpm/google-noto-fonts-all rpm/google-noto-kufi-arabic-fonts rpm/google-noto-kufi-arabic-vf-fonts rpm/google-noto-music-fonts rpm/google-noto-naskh-arabic-fonts rpm/google-noto-naskh-arabic-ui-fonts rpm/google-noto-naskh-arabic-ui-vf-fonts rpm/google-noto-naskh-arabic-vf-fonts rpm/google-noto-nastaliq-urdu-fonts rpm/google-noto-nastaliq-urdu-vf-fonts rpm/google-noto-rashi-hebrew-fonts rpm/google-noto-rashi-hebrew-vf-fonts rpm/google-noto-sans-adlam-fonts rpm/google-noto-sans-adlam-unjoined-fonts rpm/google-noto-sans-adlam-unjoined-vf-fonts rpm/google-noto-sans-adlam-vf-fonts rpm/google-noto-sans-anatolian-hieroglyphs-fonts rpm/google-noto-sans-arabic-fonts rpm/google-noto-sans-arabic-vf-fonts rpm/google-noto-sans-armenian-fonts rpm/google-noto-sans-armenian-vf-fonts rpm/google-noto-sans-avestan-fonts rpm/google-noto-sans-balinese-fonts rpm/google-noto-sans-balinese-vf-fonts rpm/google-noto-sans-bamum-fonts rpm/google-noto-sans-bamum-vf-fonts rpm/google-noto-sans-bassa-vah-fonts rpm/google-noto-sans-bassa-vah-vf-fonts rpm/google-noto-sans-batak-fonts rpm/google-noto-sans-bengali-fonts rpm/google-noto-sans-bengali-ui-fonts rpm/google-noto-sans-bengali-vf-fonts rpm/google-noto-sans-bhaiksuki-fonts rpm/google-noto-sans-brahmi-fonts rpm/google-noto-sans-buginese-fonts rpm/google-noto-sans-buhid-fonts rpm/google-noto-sans-canadian-aboriginal-fonts rpm/google-noto-sans-canadian-aboriginal-vf-fonts rpm/google-noto-sans-carian-fonts rpm/google-noto-sans-caucasian-albanian-fonts rpm/google-noto-sans-chakma-fonts rpm/google-noto-sans-cham-fonts rpm/google-noto-sans-cham-vf-fonts rpm/google-noto-sans-cherokee-fonts rpm/google-noto-sans-cherokee-vf-fonts rpm/google-noto-sans-chorasmian-fonts rpm/google-noto-sans-coptic-fonts rpm/google-noto-sans-cuneiform-fonts rpm/google-noto-sans-cypriot-fonts rpm/google-noto-sans-cypro-minoan-fonts rpm/google-noto-sans-deseret-fonts rpm/google-noto-sans-devanagari-fonts rpm/google-noto-sans-devanagari-ui-fonts rpm/google-noto-sans-devanagari-vf-fonts rpm/google-noto-sans-duployan-fonts rpm/google-noto-sans-egyptian-hieroglyphs-fonts rpm/google-noto-sans-elbasan-fonts rpm/google-noto-sans-elymaic-fonts rpm/google-noto-sans-ethiopic-fonts rpm/google-noto-sans-ethiopic-vf-fonts rpm/google-noto-sans-fonts rpm/google-noto-sans-georgian-fonts rpm/google-noto-sans-georgian-vf-fonts rpm/google-noto-sans-glagolitic-fonts rpm/google-noto-sans-gothic-fonts rpm/google-noto-sans-grantha-fonts rpm/google-noto-sans-gujarati-fonts rpm/google-noto-sans-gujarati-ui-fonts rpm/google-noto-sans-gujarati-vf-fonts rpm/google-noto-sans-gunjala-gondi-fonts rpm/google-noto-sans-gunjala-gondi-vf-fonts rpm/google-noto-sans-gurmukhi-fonts rpm/google-noto-sans-gurmukhi-ui-fonts rpm/google-noto-sans-gurmukhi-vf-fonts rpm/google-noto-sans-hanifi-rohingya-fonts rpm/google-noto-sans-hanifi-rohingya-vf-fonts rpm/google-noto-sans-hanunoo-fonts rpm/google-noto-sans-hatran-fonts rpm/google-noto-sans-hebrew-fonts rpm/google-noto-sans-hebrew-vf-fonts rpm/google-noto-sans-imperial-aramaic-fonts rpm/google-noto-sans-indic-siyaq-numbers-fonts rpm/google-noto-sans-inscriptional-pahlavi-fonts rpm/google-noto-sans-inscriptional-parthian-fonts rpm/google-noto-sans-javanese-fonts rpm/google-noto-sans-javanese-vf-fonts rpm/google-noto-sans-kaithi-fonts rpm/google-noto-sans-kannada-fonts rpm/google-noto-sans-kannada-ui-fonts rpm/google-noto-sans-kannada-ui-vf-fonts rpm/google-noto-sans-kannada-vf-fonts rpm/google-noto-sans-kawi-fonts rpm/google-noto-sans-kawi-vf-fonts rpm/google-noto-sans-kayah-li-fonts rpm/google-noto-sans-kayah-li-vf-fonts rpm/google-noto-sans-kharoshthi-fonts rpm/google-noto-sans-khmer-fonts rpm/google-noto-sans-khmer-vf-fonts rpm/google-noto-sans-khojki-fonts rpm/google-noto-sans-khudawadi-fonts rpm/google-noto-sans-lao-fonts rpm/google-noto-sans-lao-looped-fonts rpm/google-noto-sans-lao-looped-vf-fonts rpm/google-noto-sans-lao-vf-fonts rpm/google-noto-sans-lepcha-fonts rpm/google-noto-sans-limbu-fonts rpm/google-noto-sans-linear-a-fonts rpm/google-noto-sans-linear-b-fonts rpm/google-noto-sans-lisu-fonts rpm/google-noto-sans-lisu-vf-fonts rpm/google-noto-sans-lycian-fonts rpm/google-noto-sans-lydian-fonts rpm/google-noto-sans-mahajani-fonts rpm/google-noto-sans-malayalam-fonts rpm/google-noto-sans-malayalam-ui-fonts rpm/google-noto-sans-malayalam-ui-vf-fonts rpm/google-noto-sans-malayalam-vf-fonts rpm/google-noto-sans-mandaic-fonts rpm/google-noto-sans-manichaean-fonts rpm/google-noto-sans-marchen-fonts rpm/google-noto-sans-masaram-gondi-fonts rpm/google-noto-sans-math-fonts rpm/google-noto-sans-mayan-numerals-fonts rpm/google-noto-sans-medefaidrin-fonts rpm/google-noto-sans-medefaidrin-vf-fonts rpm/google-noto-sans-meetei-mayek-fonts rpm/google-noto-sans-meetei-mayek-vf-fonts rpm/google-noto-sans-mende-kikakui-fonts rpm/google-noto-sans-meroitic-fonts rpm/google-noto-sans-miao-fonts rpm/google-noto-sans-modi-fonts rpm/google-noto-sans-mongolian-fonts rpm/google-noto-sans-mono-fonts rpm/google-noto-sans-mro-fonts rpm/google-noto-sans-multani-fonts rpm/google-noto-sans-myanmar-fonts rpm/google-noto-sans-myanmar-vf-fonts rpm/google-noto-sans-nabataean-fonts rpm/google-noto-sans-nag-mundari-fonts rpm/google-noto-sans-nag-mundari-vf-fonts rpm/google-noto-sans-nandinagari-fonts rpm/google-noto-sans-new-tai-lue-fonts rpm/google-noto-sans-new-tai-lue-vf-fonts rpm/google-noto-sans-newa-fonts rpm/google-noto-sans-nko-fonts rpm/google-noto-sans-nko-unjoined-fonts rpm/google-noto-sans-nko-unjoined-vf-fonts rpm/google-noto-sans-nushu-fonts rpm/google-noto-sans-ogham-fonts rpm/google-noto-sans-ol-chiki-fonts rpm/google-noto-sans-ol-chiki-vf-fonts rpm/google-noto-sans-old-hungarian-fonts rpm/google-noto-sans-old-italic-fonts rpm/google-noto-sans-old-north-arabian-fonts rpm/google-noto-sans-old-permic-fonts rpm/google-noto-sans-old-persian-fonts rpm/google-noto-sans-old-sogdian-fonts rpm/google-noto-sans-old-south-arabian-fonts rpm/google-noto-sans-old-turkic-fonts rpm/google-noto-sans-oriya-fonts rpm/google-noto-sans-oriya-vf-fonts rpm/google-noto-sans-osage-fonts rpm/google-noto-sans-osmanya-fonts rpm/google-noto-sans-pahawh-hmong-fonts rpm/google-noto-sans-palmyrene-fonts rpm/google-noto-sans-pau-cin-hau-fonts rpm/google-noto-sans-phagspa-fonts rpm/google-noto-sans-phoenician-fonts rpm/google-noto-sans-psalter-pahlavi-fonts rpm/google-noto-sans-rejang-fonts rpm/google-noto-sans-runic-fonts rpm/google-noto-sans-samaritan-fonts rpm/google-noto-sans-saurashtra-fonts rpm/google-noto-sans-sharada-fonts rpm/google-noto-sans-shavian-fonts rpm/google-noto-sans-siddham-fonts rpm/google-noto-sans-signwriting-fonts rpm/google-noto-sans-sinhala-fonts rpm/google-noto-sans-sinhala-ui-fonts rpm/google-noto-sans-sinhala-vf-fonts rpm/google-noto-sans-sogdian-fonts rpm/google-noto-sans-sora-sompeng-fonts rpm/google-noto-sans-sora-sompeng-vf-fonts rpm/google-noto-sans-soyombo-fonts rpm/google-noto-sans-sundanese-fonts rpm/google-noto-sans-sundanese-vf-fonts rpm/google-noto-sans-syloti-nagri-fonts rpm/google-noto-sans-symbols-2-fonts rpm/google-noto-sans-symbols-fonts rpm/google-noto-sans-symbols-vf-fonts rpm/google-noto-sans-syriac-eastern-fonts rpm/google-noto-sans-syriac-eastern-vf-fonts rpm/google-noto-sans-syriac-fonts rpm/google-noto-sans-syriac-vf-fonts rpm/google-noto-sans-syriac-western-fonts rpm/google-noto-sans-syriac-western-vf-fonts rpm/google-noto-sans-tagalog-fonts rpm/google-noto-sans-tagbanwa-fonts rpm/google-noto-sans-tai-le-fonts rpm/google-noto-sans-tai-tham-fonts rpm/google-noto-sans-tai-tham-vf-fonts rpm/google-noto-sans-tai-viet-fonts rpm/google-noto-sans-takri-fonts rpm/google-noto-sans-tamil-fonts rpm/google-noto-sans-tamil-supplement-fonts rpm/google-noto-sans-tamil-ui-fonts rpm/google-noto-sans-tamil-ui-vf-fonts rpm/google-noto-sans-tamil-vf-fonts rpm/google-noto-sans-tangsa-fonts rpm/google-noto-sans-tangsa-vf-fonts rpm/google-noto-sans-telugu-fonts rpm/google-noto-sans-telugu-ui-fonts rpm/google-noto-sans-telugu-ui-vf-fonts rpm/google-noto-sans-telugu-vf-fonts rpm/google-noto-sans-thaana-fonts rpm/google-noto-sans-thaana-vf-fonts rpm/google-noto-sans-thai-fonts rpm/google-noto-sans-thai-looped-fonts rpm/google-noto-sans-thai-vf-fonts rpm/google-noto-sans-tifinagh-adrar-fonts rpm/google-noto-sans-tifinagh-agraw-imazighen-fonts rpm/google-noto-sans-tifinagh-ahaggar-fonts rpm/google-noto-sans-tifinagh-air-fonts rpm/google-noto-sans-tifinagh-apt-fonts rpm/google-noto-sans-tifinagh-azawagh-fonts rpm/google-noto-sans-tifinagh-fonts rpm/google-noto-sans-tifinagh-ghat-fonts rpm/google-noto-sans-tifinagh-hawad-fonts rpm/google-noto-sans-tifinagh-rhissa-ixa-fonts rpm/google-noto-sans-tifinagh-sil-fonts rpm/google-noto-sans-tifinagh-tawellemmet-fonts rpm/google-noto-sans-tirhuta-fonts rpm/google-noto-sans-ugaritic-fonts rpm/google-noto-sans-vai-fonts rpm/google-noto-sans-vithkuqi-fonts rpm/google-noto-sans-vithkuqi-vf-fonts rpm/google-noto-sans-wancho-fonts rpm/google-noto-sans-warang-citi-fonts rpm/google-noto-sans-yi-fonts rpm/google-noto-sans-zanabazar-square-fonts rpm/google-noto-serif-ahom-fonts rpm/google-noto-serif-armenian-fonts rpm/google-noto-serif-armenian-vf-fonts rpm/google-noto-serif-balinese-fonts rpm/google-noto-serif-bengali-fonts rpm/google-noto-serif-bengali-vf-fonts rpm/google-noto-serif-devanagari-fonts rpm/google-noto-serif-devanagari-vf-fonts rpm/google-noto-serif-dives-akuru-fonts rpm/google-noto-serif-dogra-fonts rpm/google-noto-serif-ethiopic-fonts rpm/google-noto-serif-ethiopic-vf-fonts rpm/google-noto-serif-fonts rpm/google-noto-serif-georgian-fonts rpm/google-noto-serif-georgian-vf-fonts rpm/google-noto-serif-grantha-fonts rpm/google-noto-serif-gujarati-fonts rpm/google-noto-serif-gujarati-vf-fonts rpm/google-noto-serif-gurmukhi-fonts rpm/google-noto-serif-gurmukhi-vf-fonts rpm/google-noto-serif-hebrew-fonts rpm/google-noto-serif-hebrew-vf-fonts rpm/google-noto-serif-kannada-fonts rpm/google-noto-serif-kannada-vf-fonts rpm/google-noto-serif-khitan-small-script-fonts rpm/google-noto-serif-khmer-fonts rpm/google-noto-serif-khmer-vf-fonts rpm/google-noto-serif-khojki-fonts rpm/google-noto-serif-khojki-vf-fonts rpm/google-noto-serif-lao-fonts rpm/google-noto-serif-lao-vf-fonts rpm/google-noto-serif-makasar-fonts rpm/google-noto-serif-malayalam-fonts rpm/google-noto-serif-malayalam-vf-fonts rpm/google-noto-serif-myanmar-fonts rpm/google-noto-serif-np-hmong-fonts rpm/google-noto-serif-np-hmong-vf-fonts rpm/google-noto-serif-old-uyghur-fonts rpm/google-noto-serif-oriya-fonts rpm/google-noto-serif-oriya-vf-fonts rpm/google-noto-serif-ottoman-siyaq-fonts rpm/google-noto-serif-sinhala-fonts rpm/google-noto-serif-sinhala-vf-fonts rpm/google-noto-serif-tamil-fonts rpm/google-noto-serif-tamil-vf-fonts rpm/google-noto-serif-tangut-fonts rpm/google-noto-serif-telugu-fonts rpm/google-noto-serif-telugu-vf-fonts rpm/google-noto-serif-thai-fonts rpm/google-noto-serif-thai-vf-fonts rpm/google-noto-serif-tibetan-fonts rpm/google-noto-serif-tibetan-vf-fonts rpm/google-noto-serif-toto-fonts rpm/google-noto-serif-toto-vf-fonts rpm/google-noto-serif-vithkuqi-fonts rpm/google-noto-serif-vithkuqi-vf-fonts rpm/google-noto-serif-yezidi-fonts rpm/google-noto-serif-yezidi-vf-fonts rpm/google-noto-traditional-nushu-fonts rpm/google-noto-traditional-nushu-vf-fonts rpm/google-noto-fonts-all-static rpm/google-noto-fonts-all-vf rpm/google-noto-serif-myanmar-vf-fonts"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/google-noto-fonts-20240401-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "223d9e186b12c8c7d08fa56d4efdcf8429d71154c13f4c2a7a301209eb6684bf"

URI_google-noto-fonts-common = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/google-noto-fonts-common-20240401-5.el10.noarch.rpm;name=google-noto-fonts-common;unpack=0"
SRC_URI += "${URI_google-noto-fonts-common}"
SRC_URI[google-noto-fonts-common.sha256sum] = "63089ee0c30df50b4a98fce875a0671da10e292a1395d5eb38e277947aabdea6"
RDEPENDS:google-noto-fonts-common = ""

URI_google-noto-sans-mono-vf-fonts = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/google-noto-sans-mono-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-mono-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-mono-vf-fonts}"
SRC_URI[google-noto-sans-mono-vf-fonts.sha256sum] = "b67d64fd45ed6ca673486519181e228991bdf29eeb6710478fc0ee219185169a"
RDEPENDS:google-noto-sans-mono-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-vf-fonts = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/google-noto-sans-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-vf-fonts}"
SRC_URI[google-noto-sans-vf-fonts.sha256sum] = "c4f9de30e26e8f8f8db1289600e951306724dbf5e4dc6d6229229fb2c95e3b42"
RDEPENDS:google-noto-sans-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-vf-fonts = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/google-noto-serif-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-vf-fonts}"
SRC_URI[google-noto-serif-vf-fonts.sha256sum] = "d82c52b846ae806b3eb1526470fe4eba07a96a89b3338e460735e70b5776d4d6"
RDEPENDS:google-noto-serif-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-fangsong-kss-rotated-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-fangsong-kss-rotated-fonts-20240401-5.el10.noarch.rpm;name=google-noto-fangsong-kss-rotated-fonts;unpack=0"
SRC_URI += "${URI_google-noto-fangsong-kss-rotated-fonts}"
SRC_URI[google-noto-fangsong-kss-rotated-fonts.sha256sum] = "8a9a8b54f3b120194183a4283c7a8d64b73b5fcd811069ebf5bd0963cbded52a"
RDEPENDS:google-noto-fangsong-kss-rotated-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-fangsong-kss-vertical-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-fangsong-kss-vertical-fonts-20240401-5.el10.noarch.rpm;name=google-noto-fangsong-kss-vertical-fonts;unpack=0"
SRC_URI += "${URI_google-noto-fangsong-kss-vertical-fonts}"
SRC_URI[google-noto-fangsong-kss-vertical-fonts.sha256sum] = "24f16d72069454bc63f7ab5a033d7863c73732089df8aecdb5684f94e02399eb"
RDEPENDS:google-noto-fangsong-kss-vertical-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-fonts-all = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-fonts-all-20240401-5.el10.noarch.rpm;name=google-noto-fonts-all;unpack=0"
SRC_URI += "${URI_google-noto-fonts-all}"
SRC_URI[google-noto-fonts-all.sha256sum] = "7b0feb2e322ffd7f4de794972e2068e7e9c400f7400a72dd591f462667121d8b"
RDEPENDS:google-noto-fonts-all = " \
 google-noto-sans-khudawadi-fonts \
 google-noto-sans-lao-fonts \
 google-noto-sans-lao-looped-fonts \
 google-noto-sans-lao-looped-vf-fonts \
 google-noto-sans-lao-vf-fonts \
 google-noto-sans-lepcha-fonts \
 google-noto-sans-limbu-fonts \
 google-noto-sans-linear-a-fonts \
 google-noto-sans-linear-b-fonts \
 google-noto-sans-lisu-fonts \
 google-noto-sans-lisu-vf-fonts \
 google-noto-sans-lycian-fonts \
 google-noto-sans-lydian-fonts \
 google-noto-sans-mahajani-fonts \
 google-noto-sans-malayalam-fonts \
 google-noto-sans-malayalam-ui-fonts \
 google-noto-sans-malayalam-ui-vf-fonts \
 google-noto-sans-malayalam-vf-fonts \
 google-noto-sans-mandaic-fonts \
 google-noto-sans-manichaean-fonts \
 google-noto-sans-marchen-fonts \
 google-noto-sans-masaram-gondi-fonts \
 google-noto-sans-math-fonts \
 google-noto-sans-mayan-numerals-fonts \
 google-noto-sans-medefaidrin-fonts \
 google-noto-sans-medefaidrin-vf-fonts \
 google-noto-sans-meetei-mayek-fonts \
 google-noto-sans-meetei-mayek-vf-fonts \
 google-noto-sans-mende-kikakui-fonts \
 google-noto-sans-meroitic-fonts \
 google-noto-sans-miao-fonts \
 google-noto-sans-modi-fonts \
 google-noto-sans-mongolian-fonts \
 google-noto-sans-mono-fonts \
 google-noto-sans-mro-fonts \
 google-noto-sans-multani-fonts \
 google-noto-sans-myanmar-fonts \
 google-noto-sans-myanmar-vf-fonts \
 google-noto-sans-nabataean-fonts \
 google-noto-sans-nag-mundari-fonts \
 google-noto-sans-nag-mundari-vf-fonts \
 google-noto-sans-nandinagari-fonts \
 google-noto-sans-new-tai-lue-fonts \
 google-noto-sans-new-tai-lue-vf-fonts \
 google-noto-sans-newa-fonts \
 google-noto-sans-nko-fonts \
 google-noto-sans-nko-unjoined-fonts \
 google-noto-sans-nko-unjoined-vf-fonts \
 google-noto-sans-nushu-fonts \
 google-noto-sans-ogham-fonts \
 google-noto-sans-ol-chiki-fonts \
 google-noto-sans-ol-chiki-vf-fonts \
 google-noto-sans-old-hungarian-fonts \
 google-noto-sans-old-italic-fonts \
 google-noto-sans-old-north-arabian-fonts \
 google-noto-sans-old-permic-fonts \
 google-noto-sans-old-persian-fonts \
 google-noto-sans-old-sogdian-fonts \
 google-noto-sans-old-south-arabian-fonts \
 google-noto-sans-old-turkic-fonts \
 google-noto-sans-oriya-fonts \
 google-noto-sans-oriya-vf-fonts \
 google-noto-sans-osage-fonts \
 google-noto-sans-osmanya-fonts \
 google-noto-sans-pahawh-hmong-fonts \
 google-noto-sans-palmyrene-fonts \
 google-noto-sans-pau-cin-hau-fonts \
 google-noto-sans-phagspa-fonts \
 google-noto-sans-phoenician-fonts \
 google-noto-sans-psalter-pahlavi-fonts \
 google-noto-sans-rejang-fonts \
 google-noto-sans-runic-fonts \
 google-noto-sans-samaritan-fonts \
 google-noto-sans-saurashtra-fonts \
 google-noto-sans-sharada-fonts \
 google-noto-sans-shavian-fonts \
 google-noto-sans-siddham-fonts \
 google-noto-sans-signwriting-fonts \
 google-noto-sans-sinhala-fonts \
 google-noto-sans-sinhala-ui-fonts \
 google-noto-sans-sinhala-vf-fonts \
 google-noto-sans-sogdian-fonts \
 google-noto-sans-sora-sompeng-fonts \
 google-noto-sans-sora-sompeng-vf-fonts \
 google-noto-sans-soyombo-fonts \
 google-noto-sans-sundanese-fonts \
 google-noto-sans-sundanese-vf-fonts \
 google-noto-sans-syloti-nagri-fonts \
 google-noto-sans-symbols-2-fonts \
 google-noto-sans-symbols-fonts \
 google-noto-sans-symbols-vf-fonts \
 google-noto-sans-syriac-eastern-fonts \
 google-noto-sans-syriac-eastern-vf-fonts \
 google-noto-sans-syriac-fonts \
 google-noto-sans-syriac-vf-fonts \
 google-noto-sans-syriac-western-fonts \
 google-noto-sans-syriac-western-vf-fonts \
 google-noto-sans-tagalog-fonts \
 google-noto-sans-tagbanwa-fonts \
 google-noto-sans-tai-le-fonts \
 google-noto-sans-tai-tham-fonts \
 google-noto-sans-tai-tham-vf-fonts \
 google-noto-sans-tai-viet-fonts \
 google-noto-sans-takri-fonts \
 google-noto-sans-tamil-fonts \
 google-noto-sans-tamil-supplement-fonts \
 google-noto-sans-tamil-ui-fonts \
 google-noto-sans-tamil-ui-vf-fonts \
 google-noto-sans-tamil-vf-fonts \
 google-noto-sans-tangsa-fonts \
 google-noto-sans-tangsa-vf-fonts \
 google-noto-sans-telugu-fonts \
 google-noto-sans-telugu-ui-fonts \
 google-noto-sans-telugu-ui-vf-fonts \
 google-noto-sans-telugu-vf-fonts \
 google-noto-sans-thaana-fonts \
 google-noto-sans-thaana-vf-fonts \
 google-noto-sans-thai-fonts \
 google-noto-sans-thai-looped-fonts \
 google-noto-sans-thai-vf-fonts \
 google-noto-sans-tifinagh-adrar-fonts \
 google-noto-sans-tifinagh-agraw-imazighen-fonts \
 google-noto-sans-tifinagh-ahaggar-fonts \
 google-noto-sans-tifinagh-air-fonts \
 google-noto-sans-tifinagh-apt-fonts \
 google-noto-sans-tifinagh-azawagh-fonts \
 google-noto-sans-tifinagh-fonts \
 google-noto-sans-tifinagh-ghat-fonts \
 google-noto-sans-tifinagh-hawad-fonts \
 google-noto-sans-tifinagh-rhissa-ixa-fonts \
 google-noto-sans-tifinagh-sil-fonts \
 google-noto-sans-tifinagh-tawellemmet-fonts \
 google-noto-sans-tirhuta-fonts \
 google-noto-sans-ugaritic-fonts \
 google-noto-sans-vai-fonts \
 google-noto-sans-vithkuqi-fonts \
 google-noto-sans-vithkuqi-vf-fonts \
 google-noto-sans-wancho-fonts \
 google-noto-sans-warang-citi-fonts \
 google-noto-sans-yi-fonts \
 google-noto-sans-zanabazar-square-fonts \
 google-noto-serif-ahom-fonts \
 google-noto-serif-armenian-fonts \
 google-noto-serif-armenian-vf-fonts \
 google-noto-serif-balinese-fonts \
 google-noto-serif-bengali-fonts \
 google-noto-serif-bengali-vf-fonts \
 google-noto-serif-devanagari-fonts \
 google-noto-serif-devanagari-vf-fonts \
 google-noto-serif-dives-akuru-fonts \
 google-noto-serif-dogra-fonts \
 google-noto-serif-ethiopic-fonts \
 google-noto-serif-ethiopic-vf-fonts \
 google-noto-serif-fonts \
 google-noto-serif-georgian-fonts \
 google-noto-serif-georgian-vf-fonts \
 google-noto-serif-grantha-fonts \
 google-noto-serif-gujarati-fonts \
 google-noto-serif-gujarati-vf-fonts \
 google-noto-serif-gurmukhi-fonts \
 google-noto-serif-gurmukhi-vf-fonts \
 google-noto-serif-hebrew-fonts \
 google-noto-serif-hebrew-vf-fonts \
 google-noto-serif-kannada-fonts \
 google-noto-serif-kannada-vf-fonts \
 google-noto-serif-khitan-small-script-fonts \
 google-noto-serif-khmer-fonts \
 google-noto-serif-khmer-vf-fonts \
 google-noto-serif-khojki-fonts \
 google-noto-serif-khojki-vf-fonts \
 google-noto-serif-lao-fonts \
 google-noto-serif-lao-vf-fonts \
 google-noto-serif-makasar-fonts \
 google-noto-serif-malayalam-fonts \
 google-noto-serif-malayalam-vf-fonts \
 google-noto-serif-myanmar-fonts \
 google-noto-serif-np-hmong-fonts \
 google-noto-serif-np-hmong-vf-fonts \
 google-noto-serif-old-uyghur-fonts \
 google-noto-serif-oriya-fonts \
 google-noto-serif-oriya-vf-fonts \
 google-noto-serif-ottoman-siyaq-fonts \
 google-noto-serif-sinhala-fonts \
 google-noto-serif-sinhala-vf-fonts \
 google-noto-serif-tamil-fonts \
 google-noto-serif-tamil-vf-fonts \
 google-noto-serif-tangut-fonts \
 google-noto-serif-telugu-fonts \
 google-noto-serif-telugu-vf-fonts \
 google-noto-serif-thai-fonts \
 google-noto-serif-thai-vf-fonts \
 google-noto-serif-tibetan-fonts \
 google-noto-serif-tibetan-vf-fonts \
 google-noto-serif-toto-fonts \
 google-noto-serif-toto-vf-fonts \
 google-noto-serif-vithkuqi-fonts \
 google-noto-serif-vithkuqi-vf-fonts \
 google-noto-serif-yezidi-fonts \
 google-noto-serif-yezidi-vf-fonts \
 google-noto-traditional-nushu-fonts \
 google-noto-traditional-nushu-vf-fonts \
 google-noto-sans-mono-vf-fonts \
 google-noto-sans-vf-fonts \
 google-noto-serif-vf-fonts \
 google-noto-fangsong-kss-rotated-fonts \
 google-noto-fangsong-kss-vertical-fonts \
 google-noto-kufi-arabic-fonts \
 google-noto-kufi-arabic-vf-fonts \
 google-noto-music-fonts \
 google-noto-naskh-arabic-fonts \
 google-noto-naskh-arabic-ui-fonts \
 google-noto-naskh-arabic-ui-vf-fonts \
 google-noto-naskh-arabic-vf-fonts \
 google-noto-nastaliq-urdu-fonts \
 google-noto-nastaliq-urdu-vf-fonts \
 google-noto-rashi-hebrew-fonts \
 google-noto-rashi-hebrew-vf-fonts \
 google-noto-sans-adlam-fonts \
 google-noto-sans-adlam-unjoined-fonts \
 google-noto-sans-adlam-unjoined-vf-fonts \
 google-noto-sans-adlam-vf-fonts \
 google-noto-sans-anatolian-hieroglyphs-fonts \
 google-noto-sans-arabic-fonts \
 google-noto-sans-arabic-vf-fonts \
 google-noto-sans-armenian-fonts \
 google-noto-sans-armenian-vf-fonts \
 google-noto-sans-avestan-fonts \
 google-noto-sans-balinese-fonts \
 google-noto-sans-balinese-vf-fonts \
 google-noto-sans-bamum-fonts \
 google-noto-sans-bamum-vf-fonts \
 google-noto-sans-bassa-vah-fonts \
 google-noto-sans-bassa-vah-vf-fonts \
 google-noto-sans-batak-fonts \
 google-noto-sans-bengali-fonts \
 google-noto-sans-bengali-ui-fonts \
 google-noto-sans-bengali-vf-fonts \
 google-noto-sans-bhaiksuki-fonts \
 google-noto-sans-brahmi-fonts \
 google-noto-sans-buginese-fonts \
 google-noto-sans-buhid-fonts \
 google-noto-sans-canadian-aboriginal-fonts \
 google-noto-sans-canadian-aboriginal-vf-fonts \
 google-noto-sans-carian-fonts \
 google-noto-sans-caucasian-albanian-fonts \
 google-noto-sans-chakma-fonts \
 google-noto-sans-cham-fonts \
 google-noto-sans-cham-vf-fonts \
 google-noto-sans-cherokee-fonts \
 google-noto-sans-cherokee-vf-fonts \
 google-noto-sans-chorasmian-fonts \
 google-noto-sans-coptic-fonts \
 google-noto-sans-cuneiform-fonts \
 google-noto-sans-cypriot-fonts \
 google-noto-sans-cypro-minoan-fonts \
 google-noto-sans-deseret-fonts \
 google-noto-sans-devanagari-fonts \
 google-noto-sans-devanagari-ui-fonts \
 google-noto-sans-devanagari-vf-fonts \
 google-noto-sans-duployan-fonts \
 google-noto-sans-egyptian-hieroglyphs-fonts \
 google-noto-sans-elbasan-fonts \
 google-noto-sans-elymaic-fonts \
 google-noto-sans-ethiopic-fonts \
 google-noto-sans-ethiopic-vf-fonts \
 google-noto-sans-fonts \
 google-noto-sans-georgian-fonts \
 google-noto-sans-georgian-vf-fonts \
 google-noto-sans-glagolitic-fonts \
 google-noto-sans-gothic-fonts \
 google-noto-sans-grantha-fonts \
 google-noto-sans-gujarati-fonts \
 google-noto-sans-gujarati-ui-fonts \
 google-noto-sans-gujarati-vf-fonts \
 google-noto-sans-gunjala-gondi-fonts \
 google-noto-sans-gunjala-gondi-vf-fonts \
 google-noto-sans-gurmukhi-fonts \
 google-noto-sans-gurmukhi-ui-fonts \
 google-noto-sans-gurmukhi-vf-fonts \
 google-noto-sans-hanifi-rohingya-fonts \
 google-noto-sans-hanifi-rohingya-vf-fonts \
 google-noto-sans-hanunoo-fonts \
 google-noto-sans-hatran-fonts \
 google-noto-sans-hebrew-fonts \
 google-noto-sans-hebrew-vf-fonts \
 google-noto-sans-imperial-aramaic-fonts \
 google-noto-sans-indic-siyaq-numbers-fonts \
 google-noto-sans-inscriptional-pahlavi-fonts \
 google-noto-sans-inscriptional-parthian-fonts \
 google-noto-sans-javanese-fonts \
 google-noto-sans-javanese-vf-fonts \
 google-noto-sans-kaithi-fonts \
 google-noto-sans-kannada-fonts \
 google-noto-sans-kannada-ui-fonts \
 google-noto-sans-kannada-ui-vf-fonts \
 google-noto-sans-kannada-vf-fonts \
 google-noto-sans-kawi-fonts \
 google-noto-sans-kawi-vf-fonts \
 google-noto-sans-kayah-li-fonts \
 google-noto-sans-kayah-li-vf-fonts \
 google-noto-sans-kharoshthi-fonts \
 google-noto-sans-khmer-fonts \
 google-noto-sans-khmer-vf-fonts \
 google-noto-sans-khojki-fonts \
"

URI_google-noto-kufi-arabic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-kufi-arabic-fonts-20240401-5.el10.noarch.rpm;name=google-noto-kufi-arabic-fonts;unpack=0"
SRC_URI += "${URI_google-noto-kufi-arabic-fonts}"
SRC_URI[google-noto-kufi-arabic-fonts.sha256sum] = "29c50e126bfb1ac4838527de8d6959577192c2eacb43fe38c21011a5e4c9d7be"
RDEPENDS:google-noto-kufi-arabic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-kufi-arabic-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-kufi-arabic-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-kufi-arabic-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-kufi-arabic-vf-fonts}"
SRC_URI[google-noto-kufi-arabic-vf-fonts.sha256sum] = "228db38fe7ac98a5b846742cb510ce6bdeaa06106de412f1c678119d280741d1"
RDEPENDS:google-noto-kufi-arabic-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-music-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-music-fonts-20240401-5.el10.noarch.rpm;name=google-noto-music-fonts;unpack=0"
SRC_URI += "${URI_google-noto-music-fonts}"
SRC_URI[google-noto-music-fonts.sha256sum] = "3a45a0114970ecaf5c6445b30e138c82ce201ee99c3b5a6533262b0689a1394c"
RDEPENDS:google-noto-music-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-naskh-arabic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-naskh-arabic-fonts-20240401-5.el10.noarch.rpm;name=google-noto-naskh-arabic-fonts;unpack=0"
SRC_URI += "${URI_google-noto-naskh-arabic-fonts}"
SRC_URI[google-noto-naskh-arabic-fonts.sha256sum] = "19561b99eb8eb2564e309ab1b621e538b2034d457fd343c71ed3c07b7a61fa70"
RDEPENDS:google-noto-naskh-arabic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-naskh-arabic-ui-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-naskh-arabic-ui-fonts-20240401-5.el10.noarch.rpm;name=google-noto-naskh-arabic-ui-fonts;unpack=0"
SRC_URI += "${URI_google-noto-naskh-arabic-ui-fonts}"
SRC_URI[google-noto-naskh-arabic-ui-fonts.sha256sum] = "bf7e533dce40694b904962d41d68ff13958da39a80faa835227df5b315069369"
RDEPENDS:google-noto-naskh-arabic-ui-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-naskh-arabic-ui-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-naskh-arabic-ui-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-naskh-arabic-ui-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-naskh-arabic-ui-vf-fonts}"
SRC_URI[google-noto-naskh-arabic-ui-vf-fonts.sha256sum] = "136c2d5cc6f31a6dfe3897e26b912bc6d065f9d053fe2f78922cc916ba2d22db"
RDEPENDS:google-noto-naskh-arabic-ui-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-naskh-arabic-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-naskh-arabic-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-naskh-arabic-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-naskh-arabic-vf-fonts}"
SRC_URI[google-noto-naskh-arabic-vf-fonts.sha256sum] = "50be46cf41432dc973206495b972ca207f96b26337508bd3d041e7ad6a9df1fc"
RDEPENDS:google-noto-naskh-arabic-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-nastaliq-urdu-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-nastaliq-urdu-fonts-20240401-5.el10.noarch.rpm;name=google-noto-nastaliq-urdu-fonts;unpack=0"
SRC_URI += "${URI_google-noto-nastaliq-urdu-fonts}"
SRC_URI[google-noto-nastaliq-urdu-fonts.sha256sum] = "bb7d9c82ce9ed5c1e314e1ff8c40c174ffa1ddc16c1e24ee0650d6ef91c08b74"
RDEPENDS:google-noto-nastaliq-urdu-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-nastaliq-urdu-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-nastaliq-urdu-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-nastaliq-urdu-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-nastaliq-urdu-vf-fonts}"
SRC_URI[google-noto-nastaliq-urdu-vf-fonts.sha256sum] = "8f4446fab47f3b0785abbce8351361f409d401dde890f04cfd624cfdf5fe8730"
RDEPENDS:google-noto-nastaliq-urdu-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-rashi-hebrew-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-rashi-hebrew-fonts-20240401-5.el10.noarch.rpm;name=google-noto-rashi-hebrew-fonts;unpack=0"
SRC_URI += "${URI_google-noto-rashi-hebrew-fonts}"
SRC_URI[google-noto-rashi-hebrew-fonts.sha256sum] = "d72ef334ae962cc5e996f3e56799e0d10e3775d2816b22209b9b904c7ac1636f"
RDEPENDS:google-noto-rashi-hebrew-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-rashi-hebrew-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-rashi-hebrew-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-rashi-hebrew-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-rashi-hebrew-vf-fonts}"
SRC_URI[google-noto-rashi-hebrew-vf-fonts.sha256sum] = "d3ef8b5a51314934a06d70859193b4d2d6b11b156fdf436b85bf714a9b6f845e"
RDEPENDS:google-noto-rashi-hebrew-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-adlam-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-adlam-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-adlam-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-adlam-fonts}"
SRC_URI[google-noto-sans-adlam-fonts.sha256sum] = "852f13e3a1d2dd270c8e8f0432eabdeae26a7bff27d4f7eccc0fd1eaca028ee4"
RDEPENDS:google-noto-sans-adlam-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-adlam-unjoined-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-adlam-unjoined-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-adlam-unjoined-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-adlam-unjoined-fonts}"
SRC_URI[google-noto-sans-adlam-unjoined-fonts.sha256sum] = "5582f109823bac4ccaa13b17ca59e4ca1af4ae2e7895b2f830665dafa8a61504"
RDEPENDS:google-noto-sans-adlam-unjoined-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-adlam-unjoined-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-adlam-unjoined-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-adlam-unjoined-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-adlam-unjoined-vf-fonts}"
SRC_URI[google-noto-sans-adlam-unjoined-vf-fonts.sha256sum] = "7c80c9d319112420e9edaf2fb54419d656af325b55f9d2a02b13cfeab496c19d"
RDEPENDS:google-noto-sans-adlam-unjoined-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-adlam-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-adlam-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-adlam-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-adlam-vf-fonts}"
SRC_URI[google-noto-sans-adlam-vf-fonts.sha256sum] = "188a55afd74b0a24472907381a7bd51c8c07d72a56ce09756e53486a8903e5a6"
RDEPENDS:google-noto-sans-adlam-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-anatolian-hieroglyphs-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-anatolian-hieroglyphs-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-anatolian-hieroglyphs-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-anatolian-hieroglyphs-fonts}"
SRC_URI[google-noto-sans-anatolian-hieroglyphs-fonts.sha256sum] = "aba8778f54a539945aa58d95b8168aef52bd5e3a620d81070972892e0958185e"
RDEPENDS:google-noto-sans-anatolian-hieroglyphs-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-arabic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-arabic-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-arabic-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-arabic-fonts}"
SRC_URI[google-noto-sans-arabic-fonts.sha256sum] = "476cf8a661192eb173892bf71f540c17226f138bef8b1e605cca106dd738943a"
RDEPENDS:google-noto-sans-arabic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-arabic-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-arabic-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-arabic-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-arabic-vf-fonts}"
SRC_URI[google-noto-sans-arabic-vf-fonts.sha256sum] = "8b835234e0d9484cc18b6026775fdd2a1f0385d6c7ab7ea75b35abf21444cccb"
RDEPENDS:google-noto-sans-arabic-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-armenian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-armenian-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-armenian-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-armenian-fonts}"
SRC_URI[google-noto-sans-armenian-fonts.sha256sum] = "ed21ce338c31576c5022ef37aba9de54d62709b9423eb5b222dd262b28dbede6"
RDEPENDS:google-noto-sans-armenian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-armenian-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-armenian-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-armenian-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-armenian-vf-fonts}"
SRC_URI[google-noto-sans-armenian-vf-fonts.sha256sum] = "b1d388741c933dc4cf10bf6bf942cb3b780aa051dc619a0de99ef86f0ac869c7"
RDEPENDS:google-noto-sans-armenian-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-avestan-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-avestan-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-avestan-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-avestan-fonts}"
SRC_URI[google-noto-sans-avestan-fonts.sha256sum] = "8c1417118df1d43a28bd6cd38263efba4e5f38d6c886baacf452d9fc0da5fd2b"
RDEPENDS:google-noto-sans-avestan-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-balinese-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-balinese-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-balinese-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-balinese-fonts}"
SRC_URI[google-noto-sans-balinese-fonts.sha256sum] = "aa5569f1299e6e533c1fb098b4123ceb5b091ddce2e35f0b63068b979e3ffba9"
RDEPENDS:google-noto-sans-balinese-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-balinese-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-balinese-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-balinese-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-balinese-vf-fonts}"
SRC_URI[google-noto-sans-balinese-vf-fonts.sha256sum] = "c33b9bf06bc1e65b99bff70d20e031e89001d44035549763bebddb22c1c05b7c"
RDEPENDS:google-noto-sans-balinese-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-bamum-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-bamum-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-bamum-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-bamum-fonts}"
SRC_URI[google-noto-sans-bamum-fonts.sha256sum] = "eee33fad25291e2d021a9257c6c05af554521f7d864f3b46e5dd0f691d277e07"
RDEPENDS:google-noto-sans-bamum-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-bamum-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-bamum-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-bamum-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-bamum-vf-fonts}"
SRC_URI[google-noto-sans-bamum-vf-fonts.sha256sum] = "1b44fae8ad06264bddf5ab324ae46d4a3fbc1b3a857e90d2a196a20093135b14"
RDEPENDS:google-noto-sans-bamum-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-bassa-vah-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-bassa-vah-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-bassa-vah-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-bassa-vah-fonts}"
SRC_URI[google-noto-sans-bassa-vah-fonts.sha256sum] = "07ff2cdbe7e11363b06932107f7b3da7400778932a5f2ed52afa9182119cdf3d"
RDEPENDS:google-noto-sans-bassa-vah-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-bassa-vah-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-bassa-vah-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-bassa-vah-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-bassa-vah-vf-fonts}"
SRC_URI[google-noto-sans-bassa-vah-vf-fonts.sha256sum] = "25b36655ce8e07d726fa0c98ff5ccd233b1904a5e9e4eaa956b108de31804d3b"
RDEPENDS:google-noto-sans-bassa-vah-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-batak-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-batak-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-batak-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-batak-fonts}"
SRC_URI[google-noto-sans-batak-fonts.sha256sum] = "f066cce0a4187cc9525eabbd03449831fbbf2b07d5666dca969b7b91d7ef9917"
RDEPENDS:google-noto-sans-batak-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-bengali-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-bengali-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-bengali-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-bengali-fonts}"
SRC_URI[google-noto-sans-bengali-fonts.sha256sum] = "af62ed4099dc11752b9d7046b232d30919967d45c4bd3ec891f37833e87bf673"
RDEPENDS:google-noto-sans-bengali-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-bengali-ui-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-bengali-ui-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-bengali-ui-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-bengali-ui-fonts}"
SRC_URI[google-noto-sans-bengali-ui-fonts.sha256sum] = "0b3b26d1cb6772a6246b646783e811de486e4fc2a3db4de48dbfe129c03bf99f"
RDEPENDS:google-noto-sans-bengali-ui-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-bengali-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-bengali-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-bengali-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-bengali-vf-fonts}"
SRC_URI[google-noto-sans-bengali-vf-fonts.sha256sum] = "35b4492afe01916483533302d0de62ff62ac35d87ca020028ed360bf26a1b103"
RDEPENDS:google-noto-sans-bengali-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-bhaiksuki-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-bhaiksuki-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-bhaiksuki-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-bhaiksuki-fonts}"
SRC_URI[google-noto-sans-bhaiksuki-fonts.sha256sum] = "5c35bc6e85a7abd40d5d710c065b37a17f8f4fb8b5a7636e1880896e3be90bd7"
RDEPENDS:google-noto-sans-bhaiksuki-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-brahmi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-brahmi-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-brahmi-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-brahmi-fonts}"
SRC_URI[google-noto-sans-brahmi-fonts.sha256sum] = "8b48f595067f0e501eab6c0f17f047ebe9a66a2c25bd33b9340d31edcadf29bc"
RDEPENDS:google-noto-sans-brahmi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-buginese-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-buginese-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-buginese-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-buginese-fonts}"
SRC_URI[google-noto-sans-buginese-fonts.sha256sum] = "6e4181b8234c0453b32054abd908d59c6c22c73308021998e3b3724d806ffa5d"
RDEPENDS:google-noto-sans-buginese-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-buhid-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-buhid-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-buhid-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-buhid-fonts}"
SRC_URI[google-noto-sans-buhid-fonts.sha256sum] = "29f5676a1ab47acdcd7947d8fce032a66cc1948a5f4d85c3918e1e197e4bbbea"
RDEPENDS:google-noto-sans-buhid-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-canadian-aboriginal-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-canadian-aboriginal-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-canadian-aboriginal-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-canadian-aboriginal-fonts}"
SRC_URI[google-noto-sans-canadian-aboriginal-fonts.sha256sum] = "c5efdd091363e6bbe7090e5e8a14c0ed403e4de5b43655594680872c3c5bce37"
RDEPENDS:google-noto-sans-canadian-aboriginal-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-canadian-aboriginal-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-canadian-aboriginal-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-canadian-aboriginal-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-canadian-aboriginal-vf-fonts}"
SRC_URI[google-noto-sans-canadian-aboriginal-vf-fonts.sha256sum] = "240725d3bdd9ae41f48a2730bac234173297319c35fd63209340ce3e415ec717"
RDEPENDS:google-noto-sans-canadian-aboriginal-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-carian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-carian-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-carian-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-carian-fonts}"
SRC_URI[google-noto-sans-carian-fonts.sha256sum] = "00870afd8a5ed3d9a2c4b4368108a0d8599fefa2929d8905832c394ff4cb4c1b"
RDEPENDS:google-noto-sans-carian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-caucasian-albanian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-caucasian-albanian-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-caucasian-albanian-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-caucasian-albanian-fonts}"
SRC_URI[google-noto-sans-caucasian-albanian-fonts.sha256sum] = "307c2114c2155385217df54acbfdc5dd1cecbed10ae0f62de120dd9c6b013a65"
RDEPENDS:google-noto-sans-caucasian-albanian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-chakma-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-chakma-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-chakma-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-chakma-fonts}"
SRC_URI[google-noto-sans-chakma-fonts.sha256sum] = "3882e794c5cc90eb1f37b07e79cd61cbe784b8b68e5935befffb8b215b72e540"
RDEPENDS:google-noto-sans-chakma-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-cham-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-cham-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-cham-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-cham-fonts}"
SRC_URI[google-noto-sans-cham-fonts.sha256sum] = "7adc3becac1adc147d1170f23be98dc515ff8e05179f2e5fd397434b2f9dd5ed"
RDEPENDS:google-noto-sans-cham-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-cham-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-cham-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-cham-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-cham-vf-fonts}"
SRC_URI[google-noto-sans-cham-vf-fonts.sha256sum] = "65d33e8d58e1b075b7670361ede8f0872ecc2f59e5d98e1390e78756b4caf401"
RDEPENDS:google-noto-sans-cham-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-cherokee-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-cherokee-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-cherokee-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-cherokee-fonts}"
SRC_URI[google-noto-sans-cherokee-fonts.sha256sum] = "32b8ab0e4d5b64dacff41e27fb4890eafd93594ae909745fbcdb8782e127aa6e"
RDEPENDS:google-noto-sans-cherokee-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-cherokee-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-cherokee-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-cherokee-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-cherokee-vf-fonts}"
SRC_URI[google-noto-sans-cherokee-vf-fonts.sha256sum] = "2615aa1e9f92250603b063bc059f3a6bc9a42f6e1cfec5e22331c3b423539fb7"
RDEPENDS:google-noto-sans-cherokee-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-chorasmian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-chorasmian-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-chorasmian-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-chorasmian-fonts}"
SRC_URI[google-noto-sans-chorasmian-fonts.sha256sum] = "ca16f813ceb18a257c985f62fced4cee9d38d0f999b36f846068a8ab5adede0a"
RDEPENDS:google-noto-sans-chorasmian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-coptic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-coptic-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-coptic-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-coptic-fonts}"
SRC_URI[google-noto-sans-coptic-fonts.sha256sum] = "0054ce44d0999b9f4cca3463c1e84ecd34cb7a267eb20501732770d6feac7eaa"
RDEPENDS:google-noto-sans-coptic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-cuneiform-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-cuneiform-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-cuneiform-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-cuneiform-fonts}"
SRC_URI[google-noto-sans-cuneiform-fonts.sha256sum] = "0c424ba9c3ad2b97e2fd5e7ed74a4ef8c9f4b2855284ca57a72fd49066cd7475"
RDEPENDS:google-noto-sans-cuneiform-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-cypriot-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-cypriot-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-cypriot-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-cypriot-fonts}"
SRC_URI[google-noto-sans-cypriot-fonts.sha256sum] = "fd8a4cc0a81c46bde35ad4d6a6b40b016fb27fe2a9af8b1371c5dc79fe1edb9f"
RDEPENDS:google-noto-sans-cypriot-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-cypro-minoan-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-cypro-minoan-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-cypro-minoan-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-cypro-minoan-fonts}"
SRC_URI[google-noto-sans-cypro-minoan-fonts.sha256sum] = "ee859a3aec26740e898e61a7ddbb28e46828a7356b87b363245281e02a088785"
RDEPENDS:google-noto-sans-cypro-minoan-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-deseret-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-deseret-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-deseret-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-deseret-fonts}"
SRC_URI[google-noto-sans-deseret-fonts.sha256sum] = "3f49ca060a30eb14add8a789e31b6a665a485d31eda3ec5a8292a54d65333729"
RDEPENDS:google-noto-sans-deseret-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-devanagari-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-devanagari-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-devanagari-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-devanagari-fonts}"
SRC_URI[google-noto-sans-devanagari-fonts.sha256sum] = "13ffc821128f3b58ea18859f0c5ed3db496cdece061bc220b542dc561000a535"
RDEPENDS:google-noto-sans-devanagari-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-devanagari-ui-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-devanagari-ui-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-devanagari-ui-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-devanagari-ui-fonts}"
SRC_URI[google-noto-sans-devanagari-ui-fonts.sha256sum] = "bd6b139ece72d4ace4aa37648811c784eee531fa275bbd3cc30b7bafc8cd17c2"
RDEPENDS:google-noto-sans-devanagari-ui-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-devanagari-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-devanagari-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-devanagari-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-devanagari-vf-fonts}"
SRC_URI[google-noto-sans-devanagari-vf-fonts.sha256sum] = "9995fc560ba1862cb7d19daf269c822ed323075f11e4e12f6ab432e39800dd9a"
RDEPENDS:google-noto-sans-devanagari-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-duployan-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-duployan-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-duployan-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-duployan-fonts}"
SRC_URI[google-noto-sans-duployan-fonts.sha256sum] = "f28c6abff187bd4e81a74241a250b46c1c38d35e23009a5cb44826e0598bf6a7"
RDEPENDS:google-noto-sans-duployan-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-egyptian-hieroglyphs-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-egyptian-hieroglyphs-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-egyptian-hieroglyphs-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-egyptian-hieroglyphs-fonts}"
SRC_URI[google-noto-sans-egyptian-hieroglyphs-fonts.sha256sum] = "35c0fd631d19159e90110cf43561401a15df3e577bbc96b0bd02d0b701fa61f4"
RDEPENDS:google-noto-sans-egyptian-hieroglyphs-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-elbasan-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-elbasan-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-elbasan-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-elbasan-fonts}"
SRC_URI[google-noto-sans-elbasan-fonts.sha256sum] = "fe59c21de12e0de39395fcc282a85252721c2d1986c0cf8b2c893ebbc8cafa0c"
RDEPENDS:google-noto-sans-elbasan-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-elymaic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-elymaic-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-elymaic-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-elymaic-fonts}"
SRC_URI[google-noto-sans-elymaic-fonts.sha256sum] = "031290bfa1d46684758226b43cf6693c87410c0eacda604bfc1d22b60a32e86e"
RDEPENDS:google-noto-sans-elymaic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-ethiopic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-ethiopic-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-ethiopic-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-ethiopic-fonts}"
SRC_URI[google-noto-sans-ethiopic-fonts.sha256sum] = "254b769d21f5792abb347ec849e746fcf2ccf0953d9ccf81b02764349078ebe6"
RDEPENDS:google-noto-sans-ethiopic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-ethiopic-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-ethiopic-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-ethiopic-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-ethiopic-vf-fonts}"
SRC_URI[google-noto-sans-ethiopic-vf-fonts.sha256sum] = "3d51d0324db5928d25211ebcf6972d704c21e00236da4cce0f04a232cfb23dc7"
RDEPENDS:google-noto-sans-ethiopic-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-fonts}"
SRC_URI[google-noto-sans-fonts.sha256sum] = "43b4c91189710c4c756f653dd1e02b0b449e361974276c18b7bd2470f3d2f883"
RDEPENDS:google-noto-sans-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-georgian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-georgian-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-georgian-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-georgian-fonts}"
SRC_URI[google-noto-sans-georgian-fonts.sha256sum] = "b8df1578dd30769a3a653c86b9ba4890309cac71410d17e8099c6033c8e18265"
RDEPENDS:google-noto-sans-georgian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-georgian-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-georgian-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-georgian-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-georgian-vf-fonts}"
SRC_URI[google-noto-sans-georgian-vf-fonts.sha256sum] = "de6df081260782274097509060ebeb6994c27abcc8794ed1d8cfeae66c6d68b2"
RDEPENDS:google-noto-sans-georgian-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-glagolitic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-glagolitic-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-glagolitic-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-glagolitic-fonts}"
SRC_URI[google-noto-sans-glagolitic-fonts.sha256sum] = "21a5bc82ab89ddec64c618f4a81a345c5d93ba581803dd49d896f49a20765404"
RDEPENDS:google-noto-sans-glagolitic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-gothic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-gothic-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-gothic-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-gothic-fonts}"
SRC_URI[google-noto-sans-gothic-fonts.sha256sum] = "2beeca188612e4938fbd775e38c3e5f95c8c7152c70630451aa9fb6707529cfe"
RDEPENDS:google-noto-sans-gothic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-grantha-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-grantha-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-grantha-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-grantha-fonts}"
SRC_URI[google-noto-sans-grantha-fonts.sha256sum] = "cb5700ea1caa1abf7ebe603f2cba4e4bf2f3ea0bd9a66093518d0cd133146fee"
RDEPENDS:google-noto-sans-grantha-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-gujarati-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-gujarati-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-gujarati-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-gujarati-fonts}"
SRC_URI[google-noto-sans-gujarati-fonts.sha256sum] = "627c13b88a00c3937b721ad0240b0c389adbb5fd608edf85f8be68da8529d3e9"
RDEPENDS:google-noto-sans-gujarati-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-gujarati-ui-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-gujarati-ui-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-gujarati-ui-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-gujarati-ui-fonts}"
SRC_URI[google-noto-sans-gujarati-ui-fonts.sha256sum] = "3273e5b22723887076ebef424dcf5b1b5d5917246ad866156a0be31dffdf4ed9"
RDEPENDS:google-noto-sans-gujarati-ui-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-gujarati-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-gujarati-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-gujarati-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-gujarati-vf-fonts}"
SRC_URI[google-noto-sans-gujarati-vf-fonts.sha256sum] = "e795472008d9b84b18b508ab9a90f9b9f8c3b0647133824329851ea043c66910"
RDEPENDS:google-noto-sans-gujarati-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-gunjala-gondi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-gunjala-gondi-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-gunjala-gondi-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-gunjala-gondi-fonts}"
SRC_URI[google-noto-sans-gunjala-gondi-fonts.sha256sum] = "baaa70d1ccb1481b1a86343698367639bd7e58f7d82071e1ba1837d1025d2220"
RDEPENDS:google-noto-sans-gunjala-gondi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-gunjala-gondi-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-gunjala-gondi-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-gunjala-gondi-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-gunjala-gondi-vf-fonts}"
SRC_URI[google-noto-sans-gunjala-gondi-vf-fonts.sha256sum] = "f264b1b8aa16575b6913142bccf8921e8824315dd27092c03d28d1a124766092"
RDEPENDS:google-noto-sans-gunjala-gondi-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-gurmukhi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-gurmukhi-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-gurmukhi-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-gurmukhi-fonts}"
SRC_URI[google-noto-sans-gurmukhi-fonts.sha256sum] = "cb44427a90c21521d8bedaf78887a4867b5a88409272ee97296feefa90e17924"
RDEPENDS:google-noto-sans-gurmukhi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-gurmukhi-ui-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-gurmukhi-ui-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-gurmukhi-ui-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-gurmukhi-ui-fonts}"
SRC_URI[google-noto-sans-gurmukhi-ui-fonts.sha256sum] = "4f30f9bbb947029222c07955ee11d25881713d5c8c25a51cb28a16c95aac0485"
RDEPENDS:google-noto-sans-gurmukhi-ui-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-gurmukhi-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-gurmukhi-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-gurmukhi-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-gurmukhi-vf-fonts}"
SRC_URI[google-noto-sans-gurmukhi-vf-fonts.sha256sum] = "ff885d58c8da582ecb35daa47fb6df43a39695904e2a4e72e6938121ea4f4868"
RDEPENDS:google-noto-sans-gurmukhi-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-hanifi-rohingya-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-hanifi-rohingya-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-hanifi-rohingya-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-hanifi-rohingya-fonts}"
SRC_URI[google-noto-sans-hanifi-rohingya-fonts.sha256sum] = "1c58537805cf4530b96af741185727b868af1ba126901ec2e725e8da5f9674a5"
RDEPENDS:google-noto-sans-hanifi-rohingya-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-hanifi-rohingya-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-hanifi-rohingya-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-hanifi-rohingya-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-hanifi-rohingya-vf-fonts}"
SRC_URI[google-noto-sans-hanifi-rohingya-vf-fonts.sha256sum] = "b7dc08ffa9941110de7feb74a1c7fd5ac42dfc342d4e09d1ee0294ddc497b339"
RDEPENDS:google-noto-sans-hanifi-rohingya-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-hanunoo-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-hanunoo-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-hanunoo-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-hanunoo-fonts}"
SRC_URI[google-noto-sans-hanunoo-fonts.sha256sum] = "c5c397becfec78af9b99b00a125d0147b7c09060727cef6a6a0c5d73d328fd5f"
RDEPENDS:google-noto-sans-hanunoo-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-hatran-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-hatran-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-hatran-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-hatran-fonts}"
SRC_URI[google-noto-sans-hatran-fonts.sha256sum] = "52ea9c4cb90e40744be2368a99493a160faa1071fc75b084d6da2d47ce6760f5"
RDEPENDS:google-noto-sans-hatran-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-hebrew-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-hebrew-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-hebrew-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-hebrew-fonts}"
SRC_URI[google-noto-sans-hebrew-fonts.sha256sum] = "fafef7065566ccf684c28feac765540148dcb6c358801b243c3642256bedd047"
RDEPENDS:google-noto-sans-hebrew-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-hebrew-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-hebrew-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-hebrew-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-hebrew-vf-fonts}"
SRC_URI[google-noto-sans-hebrew-vf-fonts.sha256sum] = "a9bee367e92ce2b01a07a34f00d4efaff3596929c893763c44ffc1f9d4181129"
RDEPENDS:google-noto-sans-hebrew-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-imperial-aramaic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-imperial-aramaic-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-imperial-aramaic-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-imperial-aramaic-fonts}"
SRC_URI[google-noto-sans-imperial-aramaic-fonts.sha256sum] = "a4f2c41d4131cb4023dab853282eb3a34fed0015268175ea709016a913982980"
RDEPENDS:google-noto-sans-imperial-aramaic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-indic-siyaq-numbers-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-indic-siyaq-numbers-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-indic-siyaq-numbers-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-indic-siyaq-numbers-fonts}"
SRC_URI[google-noto-sans-indic-siyaq-numbers-fonts.sha256sum] = "000f34cb42408570180aa259d8319a745cb6aeb93a462d636286ba7bac3dc61c"
RDEPENDS:google-noto-sans-indic-siyaq-numbers-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-inscriptional-pahlavi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-inscriptional-pahlavi-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-inscriptional-pahlavi-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-inscriptional-pahlavi-fonts}"
SRC_URI[google-noto-sans-inscriptional-pahlavi-fonts.sha256sum] = "2efa4ca85b86e76942413e207a7f83a10d9414dec89798a16f821f134e566e88"
RDEPENDS:google-noto-sans-inscriptional-pahlavi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-inscriptional-parthian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-inscriptional-parthian-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-inscriptional-parthian-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-inscriptional-parthian-fonts}"
SRC_URI[google-noto-sans-inscriptional-parthian-fonts.sha256sum] = "529094b4aa78de224ecb705fececfef3e63545ef83eeccb0eb56443881b6f1c0"
RDEPENDS:google-noto-sans-inscriptional-parthian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-javanese-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-javanese-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-javanese-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-javanese-fonts}"
SRC_URI[google-noto-sans-javanese-fonts.sha256sum] = "9a708ff51645a657678afd60a33656b228aa95a7662e6aadd8d2136e52c9483d"
RDEPENDS:google-noto-sans-javanese-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-javanese-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-javanese-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-javanese-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-javanese-vf-fonts}"
SRC_URI[google-noto-sans-javanese-vf-fonts.sha256sum] = "eeea648a51a7dfa716e1bd7fda05d7d77a35d6a0a0b9617e610a4bb1b4c640de"
RDEPENDS:google-noto-sans-javanese-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-kaithi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-kaithi-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-kaithi-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-kaithi-fonts}"
SRC_URI[google-noto-sans-kaithi-fonts.sha256sum] = "dbd1a1317392c6d8202d7b83f45b6a14a707a955a0cd19cdbdcb0ed637530c70"
RDEPENDS:google-noto-sans-kaithi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-kannada-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-kannada-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-kannada-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-kannada-fonts}"
SRC_URI[google-noto-sans-kannada-fonts.sha256sum] = "5edfb535e3919062066cdad5fe76870bfcf0d3800d3d5e6494f5c4fc4a570a47"
RDEPENDS:google-noto-sans-kannada-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-kannada-ui-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-kannada-ui-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-kannada-ui-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-kannada-ui-fonts}"
SRC_URI[google-noto-sans-kannada-ui-fonts.sha256sum] = "3ac2fea0dcf88bf8c7d6a68b3fb189e94542c76d474ae2fbb63a7ddecee3844a"
RDEPENDS:google-noto-sans-kannada-ui-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-kannada-ui-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-kannada-ui-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-kannada-ui-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-kannada-ui-vf-fonts}"
SRC_URI[google-noto-sans-kannada-ui-vf-fonts.sha256sum] = "7741559eb40d8480c3cc05d7d5b48ea376112d74504d2f4ffb24294ea2a854a4"
RDEPENDS:google-noto-sans-kannada-ui-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-kannada-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-kannada-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-kannada-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-kannada-vf-fonts}"
SRC_URI[google-noto-sans-kannada-vf-fonts.sha256sum] = "b15bf78789b6081bff0f55085442129af3bf3b450dc42e328b04238cf045b92b"
RDEPENDS:google-noto-sans-kannada-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-kawi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-kawi-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-kawi-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-kawi-fonts}"
SRC_URI[google-noto-sans-kawi-fonts.sha256sum] = "fd041855e462c8c7e4e82a8184819a2c2b2a4da2cc9a0ecf228f00c6c2fbe5c5"
RDEPENDS:google-noto-sans-kawi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-kawi-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-kawi-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-kawi-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-kawi-vf-fonts}"
SRC_URI[google-noto-sans-kawi-vf-fonts.sha256sum] = "63e0500da9e715d9986eb4af17e26620811f7c5080e6220d58a47a6cced74e23"
RDEPENDS:google-noto-sans-kawi-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-kayah-li-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-kayah-li-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-kayah-li-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-kayah-li-fonts}"
SRC_URI[google-noto-sans-kayah-li-fonts.sha256sum] = "7df28737da76748dad3491545aeef1e23ffb6bbcc3cff679e87fb67235ff1bb4"
RDEPENDS:google-noto-sans-kayah-li-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-kayah-li-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-kayah-li-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-kayah-li-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-kayah-li-vf-fonts}"
SRC_URI[google-noto-sans-kayah-li-vf-fonts.sha256sum] = "c7e605fec2053c1a6762a95e96552b68fd55b1222fa536b45ca94e9b52de0f65"
RDEPENDS:google-noto-sans-kayah-li-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-kharoshthi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-kharoshthi-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-kharoshthi-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-kharoshthi-fonts}"
SRC_URI[google-noto-sans-kharoshthi-fonts.sha256sum] = "13aa82d48c990fd071c11410aa9f9b35eaf22ca4256e1ef0f67e6eb645a71d0f"
RDEPENDS:google-noto-sans-kharoshthi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-khmer-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-khmer-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-khmer-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-khmer-fonts}"
SRC_URI[google-noto-sans-khmer-fonts.sha256sum] = "ce05fdbb1362d3b662851cdd9207faa9069ff5e3e0e1179cc01be84b3fe9ec75"
RDEPENDS:google-noto-sans-khmer-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-khmer-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-khmer-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-khmer-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-khmer-vf-fonts}"
SRC_URI[google-noto-sans-khmer-vf-fonts.sha256sum] = "f8da307083fda5444c7c3b1264b8891c52c743d79f11efdf5db2a45adb23926f"
RDEPENDS:google-noto-sans-khmer-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-khojki-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-khojki-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-khojki-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-khojki-fonts}"
SRC_URI[google-noto-sans-khojki-fonts.sha256sum] = "a6c5817282470ac492719732a56ef99d938a42adcba97ea382c38d4a73e4cd8a"
RDEPENDS:google-noto-sans-khojki-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-khudawadi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-khudawadi-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-khudawadi-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-khudawadi-fonts}"
SRC_URI[google-noto-sans-khudawadi-fonts.sha256sum] = "21d0c4d265cdc05bdb3f1e68f1a14f3cedbc3c3824efad30031f6ea49b6464e5"
RDEPENDS:google-noto-sans-khudawadi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-lao-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-lao-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-lao-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-lao-fonts}"
SRC_URI[google-noto-sans-lao-fonts.sha256sum] = "6d518f330c128eab49a95a30ca150a09f6843e372b18b26695d299c45ebe0e00"
RDEPENDS:google-noto-sans-lao-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-lao-looped-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-lao-looped-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-lao-looped-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-lao-looped-fonts}"
SRC_URI[google-noto-sans-lao-looped-fonts.sha256sum] = "cc6a37ce2351fa82d6db9ca13cacca0e2cc7a37ed2961b28a2018854f02c34c4"
RDEPENDS:google-noto-sans-lao-looped-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-lao-looped-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-lao-looped-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-lao-looped-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-lao-looped-vf-fonts}"
SRC_URI[google-noto-sans-lao-looped-vf-fonts.sha256sum] = "44dab6577429e6e5e9c7d6fcd02c3b65b23142ec1b51e7229ac1deaa07a6c2df"
RDEPENDS:google-noto-sans-lao-looped-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-lao-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-lao-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-lao-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-lao-vf-fonts}"
SRC_URI[google-noto-sans-lao-vf-fonts.sha256sum] = "61f959f4be438214b4f2c7e1bac2b9971c4de45932f8559c50620fd0fa0ee47c"
RDEPENDS:google-noto-sans-lao-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-lepcha-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-lepcha-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-lepcha-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-lepcha-fonts}"
SRC_URI[google-noto-sans-lepcha-fonts.sha256sum] = "d2e6a3f602e4df45716470b776ab0d3036e6131d2b019720be0c2d58b61bf317"
RDEPENDS:google-noto-sans-lepcha-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-limbu-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-limbu-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-limbu-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-limbu-fonts}"
SRC_URI[google-noto-sans-limbu-fonts.sha256sum] = "78bc48c3bcd3952e2ebf66968de64f693b497ccd38b18e2c1b4895dc5899d706"
RDEPENDS:google-noto-sans-limbu-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-linear-a-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-linear-a-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-linear-a-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-linear-a-fonts}"
SRC_URI[google-noto-sans-linear-a-fonts.sha256sum] = "c1903a3812aab379aff0935f04c4d9b6ef163ed7013d2a7df80ab3ab4cabe647"
RDEPENDS:google-noto-sans-linear-a-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-linear-b-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-linear-b-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-linear-b-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-linear-b-fonts}"
SRC_URI[google-noto-sans-linear-b-fonts.sha256sum] = "82b7393b2ea6f9356e71b2e44cd394f1b310fc5c47d7498a6c0822bf3622b15c"
RDEPENDS:google-noto-sans-linear-b-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-lisu-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-lisu-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-lisu-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-lisu-fonts}"
SRC_URI[google-noto-sans-lisu-fonts.sha256sum] = "29b5ed258d44f3c3c1949a65e7a173bdc5eed6badbe683207edd8091a092cb83"
RDEPENDS:google-noto-sans-lisu-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-lisu-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-lisu-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-lisu-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-lisu-vf-fonts}"
SRC_URI[google-noto-sans-lisu-vf-fonts.sha256sum] = "699b17bb22ab89b40b70d3c4f3688821047faa78a0e4b997632667665851b809"
RDEPENDS:google-noto-sans-lisu-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-lycian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-lycian-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-lycian-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-lycian-fonts}"
SRC_URI[google-noto-sans-lycian-fonts.sha256sum] = "0f348c8ff69b32a6c6a2ce09df0dcf54e9f8a4f6c8eb1307bb02937db55ea541"
RDEPENDS:google-noto-sans-lycian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-lydian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-lydian-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-lydian-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-lydian-fonts}"
SRC_URI[google-noto-sans-lydian-fonts.sha256sum] = "7eae9e7ae16daaf9f77139d8eb0bed392d787216fccf03d5339b5a8b0a9141ef"
RDEPENDS:google-noto-sans-lydian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-mahajani-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-mahajani-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-mahajani-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-mahajani-fonts}"
SRC_URI[google-noto-sans-mahajani-fonts.sha256sum] = "d860d9bd2c5c7d3c8112b093b7d4ed40d62b4fd0e3a7804119656b218675a8ab"
RDEPENDS:google-noto-sans-mahajani-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-malayalam-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-malayalam-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-malayalam-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-malayalam-fonts}"
SRC_URI[google-noto-sans-malayalam-fonts.sha256sum] = "23f1c953b3be455d423923a2b73771d27e50fb8331dc06f43f7745a67bb86ee6"
RDEPENDS:google-noto-sans-malayalam-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-malayalam-ui-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-malayalam-ui-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-malayalam-ui-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-malayalam-ui-fonts}"
SRC_URI[google-noto-sans-malayalam-ui-fonts.sha256sum] = "d1d68d1b3951deed77e85129e998f0f7dee7964c46a76f509ad668da2ca2934d"
RDEPENDS:google-noto-sans-malayalam-ui-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-malayalam-ui-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-malayalam-ui-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-malayalam-ui-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-malayalam-ui-vf-fonts}"
SRC_URI[google-noto-sans-malayalam-ui-vf-fonts.sha256sum] = "f49a865e349101a950818c75e00aaf43e9e29fff9f3b4d530998d05858d1728c"
RDEPENDS:google-noto-sans-malayalam-ui-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-malayalam-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-malayalam-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-malayalam-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-malayalam-vf-fonts}"
SRC_URI[google-noto-sans-malayalam-vf-fonts.sha256sum] = "84d1f2925a0b33bfa1842ef7275c9cf887b1064ebd300666257b344ffd48b818"
RDEPENDS:google-noto-sans-malayalam-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-mandaic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-mandaic-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-mandaic-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-mandaic-fonts}"
SRC_URI[google-noto-sans-mandaic-fonts.sha256sum] = "220249bced64cfd005602c956bc4ff5359895cbd1bd8103b5262907feb4f8d7f"
RDEPENDS:google-noto-sans-mandaic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-manichaean-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-manichaean-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-manichaean-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-manichaean-fonts}"
SRC_URI[google-noto-sans-manichaean-fonts.sha256sum] = "3ecb496ce8ba083e2fda28247ca604a03b836083de512a596e5f1ee080e4fbea"
RDEPENDS:google-noto-sans-manichaean-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-marchen-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-marchen-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-marchen-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-marchen-fonts}"
SRC_URI[google-noto-sans-marchen-fonts.sha256sum] = "c501084016688020969c15db73e6900a35c95bce88dbc7b1e52b37baef6f8892"
RDEPENDS:google-noto-sans-marchen-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-masaram-gondi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-masaram-gondi-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-masaram-gondi-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-masaram-gondi-fonts}"
SRC_URI[google-noto-sans-masaram-gondi-fonts.sha256sum] = "f39539f9334b38d352b3a19eaeba2ccccc05e0527a6a43d7687a60b311db9243"
RDEPENDS:google-noto-sans-masaram-gondi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-math-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-math-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-math-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-math-fonts}"
SRC_URI[google-noto-sans-math-fonts.sha256sum] = "2e6646cb947138018d4fd99fc255c8827cbe8bc5aa05d3cb2a5b7ee02e2e4b21"
RDEPENDS:google-noto-sans-math-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-mayan-numerals-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-mayan-numerals-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-mayan-numerals-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-mayan-numerals-fonts}"
SRC_URI[google-noto-sans-mayan-numerals-fonts.sha256sum] = "4f3bedf6ae16c40beb9d9f8e5ebbdc2807721b0d481957239c8762a9c9447e5c"
RDEPENDS:google-noto-sans-mayan-numerals-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-medefaidrin-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-medefaidrin-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-medefaidrin-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-medefaidrin-fonts}"
SRC_URI[google-noto-sans-medefaidrin-fonts.sha256sum] = "fc399a66f1af703155c4a68bdad93e183fc93c76e444dbe3371e0e0279694317"
RDEPENDS:google-noto-sans-medefaidrin-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-medefaidrin-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-medefaidrin-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-medefaidrin-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-medefaidrin-vf-fonts}"
SRC_URI[google-noto-sans-medefaidrin-vf-fonts.sha256sum] = "df6bce39035a5230a483ef62a861bf32ef2bc70b506cdc495a4997389a8a347b"
RDEPENDS:google-noto-sans-medefaidrin-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-meetei-mayek-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-meetei-mayek-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-meetei-mayek-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-meetei-mayek-fonts}"
SRC_URI[google-noto-sans-meetei-mayek-fonts.sha256sum] = "a1ae20650cce0526c80f824d58187d5a8581bf876d92eebe45e2de71819d5a6c"
RDEPENDS:google-noto-sans-meetei-mayek-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-meetei-mayek-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-meetei-mayek-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-meetei-mayek-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-meetei-mayek-vf-fonts}"
SRC_URI[google-noto-sans-meetei-mayek-vf-fonts.sha256sum] = "849dba78c97eeb5c54e9a8d1425011b4488b48ae1a8b602ffcbd4e0e75b4c0f9"
RDEPENDS:google-noto-sans-meetei-mayek-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-mende-kikakui-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-mende-kikakui-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-mende-kikakui-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-mende-kikakui-fonts}"
SRC_URI[google-noto-sans-mende-kikakui-fonts.sha256sum] = "f960a0b948e17d56656d04b15d913cd9cb1e464d216c0958a95374e8e798600e"
RDEPENDS:google-noto-sans-mende-kikakui-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-meroitic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-meroitic-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-meroitic-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-meroitic-fonts}"
SRC_URI[google-noto-sans-meroitic-fonts.sha256sum] = "9052315a85ef13754de939c4406b031677ff2717b9c885ca20e2c8cf7b13103c"
RDEPENDS:google-noto-sans-meroitic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-miao-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-miao-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-miao-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-miao-fonts}"
SRC_URI[google-noto-sans-miao-fonts.sha256sum] = "5cba4a712b16342607e91d7bc53c96276591414b72b0aaa5165fe8ed70c6809d"
RDEPENDS:google-noto-sans-miao-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-modi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-modi-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-modi-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-modi-fonts}"
SRC_URI[google-noto-sans-modi-fonts.sha256sum] = "383aed2a5fbc13aa0980f4372cb29c1a6f1b1aac026e3b62b4718881f2b2e422"
RDEPENDS:google-noto-sans-modi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-mongolian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-mongolian-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-mongolian-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-mongolian-fonts}"
SRC_URI[google-noto-sans-mongolian-fonts.sha256sum] = "27ff072df43048e156e1260cf81a719ed1c2b899b0bb4344742ecbe91c99a61b"
RDEPENDS:google-noto-sans-mongolian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-mono-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-mono-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-mono-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-mono-fonts}"
SRC_URI[google-noto-sans-mono-fonts.sha256sum] = "325fb25eaf118b9d765bacd80768e299496817daa4aa56b74d292962e2d21c02"
RDEPENDS:google-noto-sans-mono-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-mro-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-mro-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-mro-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-mro-fonts}"
SRC_URI[google-noto-sans-mro-fonts.sha256sum] = "54aef8a3d84f868c787fd4f04f82d4d889f548508b4890ff11b9c851080b5d1f"
RDEPENDS:google-noto-sans-mro-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-multani-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-multani-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-multani-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-multani-fonts}"
SRC_URI[google-noto-sans-multani-fonts.sha256sum] = "894fae4f8871411c9f3f66f6e7d2b687a01f784bff73fcb997a02521f403b032"
RDEPENDS:google-noto-sans-multani-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-myanmar-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-myanmar-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-myanmar-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-myanmar-fonts}"
SRC_URI[google-noto-sans-myanmar-fonts.sha256sum] = "abf96dc32a0c112225651ba2212899b4f8a37b9106cd8d1e34fab1c61b688a6a"
RDEPENDS:google-noto-sans-myanmar-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-myanmar-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-myanmar-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-myanmar-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-myanmar-vf-fonts}"
SRC_URI[google-noto-sans-myanmar-vf-fonts.sha256sum] = "4a1adc715013f2711b4a6f04b8ecdd69fd9924a50304e6f1e86b1963a53d0e3c"
RDEPENDS:google-noto-sans-myanmar-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-nabataean-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-nabataean-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-nabataean-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-nabataean-fonts}"
SRC_URI[google-noto-sans-nabataean-fonts.sha256sum] = "b3a2256f3cba08db2f2856537b4209d9556bedc792f12664fa24798a0e350d30"
RDEPENDS:google-noto-sans-nabataean-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-nag-mundari-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-nag-mundari-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-nag-mundari-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-nag-mundari-fonts}"
SRC_URI[google-noto-sans-nag-mundari-fonts.sha256sum] = "996d20c3554471d1dbe5ce32c71da055d8586ea7ee59d1a684e0ae9108428f3b"
RDEPENDS:google-noto-sans-nag-mundari-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-nag-mundari-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-nag-mundari-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-nag-mundari-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-nag-mundari-vf-fonts}"
SRC_URI[google-noto-sans-nag-mundari-vf-fonts.sha256sum] = "3ae5c9beeabc8e64431819531aa45af1d2000f6952b693e7026e1f9973364863"
RDEPENDS:google-noto-sans-nag-mundari-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-nandinagari-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-nandinagari-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-nandinagari-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-nandinagari-fonts}"
SRC_URI[google-noto-sans-nandinagari-fonts.sha256sum] = "cb2c70fc3638011287d3a5e450f460ab9cf84f83e133b22f56e0ba63b9c0b4de"
RDEPENDS:google-noto-sans-nandinagari-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-new-tai-lue-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-new-tai-lue-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-new-tai-lue-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-new-tai-lue-fonts}"
SRC_URI[google-noto-sans-new-tai-lue-fonts.sha256sum] = "313b2ac9e0ea572089d9864d67239b4dd69064908847caf91a5cd634a0d61cf7"
RDEPENDS:google-noto-sans-new-tai-lue-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-new-tai-lue-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-new-tai-lue-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-new-tai-lue-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-new-tai-lue-vf-fonts}"
SRC_URI[google-noto-sans-new-tai-lue-vf-fonts.sha256sum] = "1c1d873be2cfdb18429e0557771da52114dd655620ba7383b900a642592fae3e"
RDEPENDS:google-noto-sans-new-tai-lue-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-newa-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-newa-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-newa-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-newa-fonts}"
SRC_URI[google-noto-sans-newa-fonts.sha256sum] = "6da01a5ad8c0f7352263a4b609cf994c84155769aa25bfab86b22fbce6d69d93"
RDEPENDS:google-noto-sans-newa-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-nko-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-nko-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-nko-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-nko-fonts}"
SRC_URI[google-noto-sans-nko-fonts.sha256sum] = "d0a095b637d69f317ee604dae78a2daf5eeecf525d23f6a96b2f5ee62932c372"
RDEPENDS:google-noto-sans-nko-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-nko-unjoined-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-nko-unjoined-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-nko-unjoined-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-nko-unjoined-fonts}"
SRC_URI[google-noto-sans-nko-unjoined-fonts.sha256sum] = "78783b87722ff3b1f594e9fe63c3d12297d8538ecfc6cb9ab0393ec437e51501"
RDEPENDS:google-noto-sans-nko-unjoined-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-nko-unjoined-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-nko-unjoined-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-nko-unjoined-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-nko-unjoined-vf-fonts}"
SRC_URI[google-noto-sans-nko-unjoined-vf-fonts.sha256sum] = "c64524fd28ee9cc775ab165af38a916ba77e329c3ed7d87617364905652f4f86"
RDEPENDS:google-noto-sans-nko-unjoined-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-nushu-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-nushu-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-nushu-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-nushu-fonts}"
SRC_URI[google-noto-sans-nushu-fonts.sha256sum] = "5e6e8971370711c3639c009922b9515e895c1a8527fcafc0a100ab14c078ff9e"
RDEPENDS:google-noto-sans-nushu-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-ogham-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-ogham-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-ogham-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-ogham-fonts}"
SRC_URI[google-noto-sans-ogham-fonts.sha256sum] = "8d664da609d2a8ea4b84595e74fa7621b118b6305e4550a0eb20dbe8cb38e133"
RDEPENDS:google-noto-sans-ogham-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-ol-chiki-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-ol-chiki-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-ol-chiki-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-ol-chiki-fonts}"
SRC_URI[google-noto-sans-ol-chiki-fonts.sha256sum] = "9e5182eaba3709a8c8603e81d13d277faeecb1f54ebe4b0caefd9358b63c7c23"
RDEPENDS:google-noto-sans-ol-chiki-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-ol-chiki-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-ol-chiki-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-ol-chiki-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-ol-chiki-vf-fonts}"
SRC_URI[google-noto-sans-ol-chiki-vf-fonts.sha256sum] = "d0956b16cd5877fa205c37cd9830a2f98bc4c070b706bcd8b2b356255f3e3d6a"
RDEPENDS:google-noto-sans-ol-chiki-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-old-hungarian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-old-hungarian-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-old-hungarian-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-old-hungarian-fonts}"
SRC_URI[google-noto-sans-old-hungarian-fonts.sha256sum] = "afc21546fc2b49d84668ae1b198efab5bad29d5ae60d2cdec61db82458ccd0f6"
RDEPENDS:google-noto-sans-old-hungarian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-old-italic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-old-italic-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-old-italic-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-old-italic-fonts}"
SRC_URI[google-noto-sans-old-italic-fonts.sha256sum] = "e033d9c5777a10382e20fbcfe1c1cc019eda7d3b33fea32c1d8c5bd3bca2dbb9"
RDEPENDS:google-noto-sans-old-italic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-old-north-arabian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-old-north-arabian-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-old-north-arabian-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-old-north-arabian-fonts}"
SRC_URI[google-noto-sans-old-north-arabian-fonts.sha256sum] = "cdab28a1ed334e64547fa6954acb64f5f960018d062a55dd51eefc5d68eb0617"
RDEPENDS:google-noto-sans-old-north-arabian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-old-permic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-old-permic-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-old-permic-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-old-permic-fonts}"
SRC_URI[google-noto-sans-old-permic-fonts.sha256sum] = "65acb98fa78b3654d25c91a8ff2197ac1b0cc3d87a0f5d9cf42ef066c9359961"
RDEPENDS:google-noto-sans-old-permic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-old-persian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-old-persian-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-old-persian-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-old-persian-fonts}"
SRC_URI[google-noto-sans-old-persian-fonts.sha256sum] = "461d232cbc7d16a614255639306ad0b025ef7d3bc5f6ef03118f1f0d91cf04e7"
RDEPENDS:google-noto-sans-old-persian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-old-sogdian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-old-sogdian-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-old-sogdian-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-old-sogdian-fonts}"
SRC_URI[google-noto-sans-old-sogdian-fonts.sha256sum] = "37bfee3d27a87ae6899d6266016a5ee6e7e09978421af97ded2e57ece1e81564"
RDEPENDS:google-noto-sans-old-sogdian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-old-south-arabian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-old-south-arabian-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-old-south-arabian-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-old-south-arabian-fonts}"
SRC_URI[google-noto-sans-old-south-arabian-fonts.sha256sum] = "a261008e7308b68803af02f1a28fbd2d0667241f6d439d7923206218b26d7f4f"
RDEPENDS:google-noto-sans-old-south-arabian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-old-turkic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-old-turkic-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-old-turkic-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-old-turkic-fonts}"
SRC_URI[google-noto-sans-old-turkic-fonts.sha256sum] = "fc2f21205357589a8023c13fd25304187a53711aed30eae71732f0ca406b0dcb"
RDEPENDS:google-noto-sans-old-turkic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-oriya-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-oriya-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-oriya-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-oriya-fonts}"
SRC_URI[google-noto-sans-oriya-fonts.sha256sum] = "277594a593b286a699dff1e2457b1e92f629f48d78c2a125119caf4e365e13b4"
RDEPENDS:google-noto-sans-oriya-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-oriya-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-oriya-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-oriya-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-oriya-vf-fonts}"
SRC_URI[google-noto-sans-oriya-vf-fonts.sha256sum] = "b996719fc0f845a8706bee5b62faaf1de5aa973b354cbd90d23f94c6f2833034"
RDEPENDS:google-noto-sans-oriya-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-osage-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-osage-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-osage-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-osage-fonts}"
SRC_URI[google-noto-sans-osage-fonts.sha256sum] = "0230d40b0af1697e6f79e0a3563736a333befc77b3a3ac9ed851572b614698fb"
RDEPENDS:google-noto-sans-osage-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-osmanya-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-osmanya-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-osmanya-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-osmanya-fonts}"
SRC_URI[google-noto-sans-osmanya-fonts.sha256sum] = "5a6d3aacf2e2fbbbe63e1dc236711e677e460d41aa61761e930d3638bbcab7e4"
RDEPENDS:google-noto-sans-osmanya-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-pahawh-hmong-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-pahawh-hmong-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-pahawh-hmong-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-pahawh-hmong-fonts}"
SRC_URI[google-noto-sans-pahawh-hmong-fonts.sha256sum] = "60b8cfa8e7dbdf95f4c9fc1f2c3034d523670c308c108cb3b239ffdde76ac04c"
RDEPENDS:google-noto-sans-pahawh-hmong-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-palmyrene-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-palmyrene-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-palmyrene-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-palmyrene-fonts}"
SRC_URI[google-noto-sans-palmyrene-fonts.sha256sum] = "19408bf3ba53f5393b0a874ab4628426b956ba61b8b8463c8ca401a3f9aec8ad"
RDEPENDS:google-noto-sans-palmyrene-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-pau-cin-hau-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-pau-cin-hau-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-pau-cin-hau-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-pau-cin-hau-fonts}"
SRC_URI[google-noto-sans-pau-cin-hau-fonts.sha256sum] = "613771423952e15b677bd58d69fc1ca5b04bbc9bddea04c92cc157d33ea2bad9"
RDEPENDS:google-noto-sans-pau-cin-hau-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-phagspa-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-phagspa-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-phagspa-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-phagspa-fonts}"
SRC_URI[google-noto-sans-phagspa-fonts.sha256sum] = "39f5ff08f3f06e47d4dd8def1a1b7d22636ced492fcb39e33cce6a9940b3c4ba"
RDEPENDS:google-noto-sans-phagspa-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-phoenician-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-phoenician-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-phoenician-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-phoenician-fonts}"
SRC_URI[google-noto-sans-phoenician-fonts.sha256sum] = "af83fcc3d63d8dc437f64da361a7c22ee90339b2d9e3c811d8afb9592e996b44"
RDEPENDS:google-noto-sans-phoenician-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-psalter-pahlavi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-psalter-pahlavi-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-psalter-pahlavi-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-psalter-pahlavi-fonts}"
SRC_URI[google-noto-sans-psalter-pahlavi-fonts.sha256sum] = "973e7ec7068ae592e55df0e8d490a1959b6609169c79a4f1c1d17ab9b8228e2b"
RDEPENDS:google-noto-sans-psalter-pahlavi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-rejang-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-rejang-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-rejang-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-rejang-fonts}"
SRC_URI[google-noto-sans-rejang-fonts.sha256sum] = "27e6e45952370f3d2736fd8ea221ff68daed68195610be3790e5b1c898d5169f"
RDEPENDS:google-noto-sans-rejang-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-runic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-runic-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-runic-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-runic-fonts}"
SRC_URI[google-noto-sans-runic-fonts.sha256sum] = "2e12b3ef4059b67ffcca9de1924cdc4c97a4adb4dbeeef42af30424febbf752d"
RDEPENDS:google-noto-sans-runic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-samaritan-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-samaritan-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-samaritan-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-samaritan-fonts}"
SRC_URI[google-noto-sans-samaritan-fonts.sha256sum] = "357fd5f6e58102bc34af90a9bbe23f0cc0b3c73d7efb9116852477c651272d78"
RDEPENDS:google-noto-sans-samaritan-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-saurashtra-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-saurashtra-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-saurashtra-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-saurashtra-fonts}"
SRC_URI[google-noto-sans-saurashtra-fonts.sha256sum] = "f45252997dc240528064e3e3ebfd904fe170e9d923d77246bd3d56a655163074"
RDEPENDS:google-noto-sans-saurashtra-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-sharada-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-sharada-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-sharada-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-sharada-fonts}"
SRC_URI[google-noto-sans-sharada-fonts.sha256sum] = "3d14f0e82d2da33a96d71e2accca6b93c97c794cb0a3ff335d7ce83ad3649e88"
RDEPENDS:google-noto-sans-sharada-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-shavian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-shavian-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-shavian-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-shavian-fonts}"
SRC_URI[google-noto-sans-shavian-fonts.sha256sum] = "3e47886b835186cf6d4ce8da43dea34c13d7bf7ae2b4d8f07373ea4dec2471f3"
RDEPENDS:google-noto-sans-shavian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-siddham-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-siddham-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-siddham-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-siddham-fonts}"
SRC_URI[google-noto-sans-siddham-fonts.sha256sum] = "5f06b9087b616754b4f29102504b19b17d8a903c7517ea775b29b7820e2864ab"
RDEPENDS:google-noto-sans-siddham-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-signwriting-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-signwriting-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-signwriting-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-signwriting-fonts}"
SRC_URI[google-noto-sans-signwriting-fonts.sha256sum] = "164a4d62a2e77a614fb9bc6d1b5ec8346c1de4401dc0cb9576b31119479936b2"
RDEPENDS:google-noto-sans-signwriting-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-sinhala-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-sinhala-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-sinhala-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-sinhala-fonts}"
SRC_URI[google-noto-sans-sinhala-fonts.sha256sum] = "6bff898745870801c7bbc8bdf65a6164a2d3ad16895bacd045756b3dfe450f48"
RDEPENDS:google-noto-sans-sinhala-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-sinhala-ui-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-sinhala-ui-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-sinhala-ui-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-sinhala-ui-fonts}"
SRC_URI[google-noto-sans-sinhala-ui-fonts.sha256sum] = "08421a0d19570b1737425004caf626c5dfa4b9ef3b03fd20f72fb7c8081fce19"
RDEPENDS:google-noto-sans-sinhala-ui-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-sinhala-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-sinhala-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-sinhala-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-sinhala-vf-fonts}"
SRC_URI[google-noto-sans-sinhala-vf-fonts.sha256sum] = "70ad4691f25fb7d06b9c6e042331da35f9fd04dd6f95a3040ab76a162197abed"
RDEPENDS:google-noto-sans-sinhala-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-sogdian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-sogdian-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-sogdian-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-sogdian-fonts}"
SRC_URI[google-noto-sans-sogdian-fonts.sha256sum] = "52c2718659157fe66a30e80c75375c47614b678d7079d229182a52d8ed3d8728"
RDEPENDS:google-noto-sans-sogdian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-sora-sompeng-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-sora-sompeng-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-sora-sompeng-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-sora-sompeng-fonts}"
SRC_URI[google-noto-sans-sora-sompeng-fonts.sha256sum] = "2e776afaf43fbd5726b04dea7b4187de9507e9d763175a25694666dd8f78d597"
RDEPENDS:google-noto-sans-sora-sompeng-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-sora-sompeng-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-sora-sompeng-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-sora-sompeng-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-sora-sompeng-vf-fonts}"
SRC_URI[google-noto-sans-sora-sompeng-vf-fonts.sha256sum] = "67b33e86ec6750f9adf844682d9d79d2bafe307fb10f2f5c97e399d37db39989"
RDEPENDS:google-noto-sans-sora-sompeng-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-soyombo-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-soyombo-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-soyombo-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-soyombo-fonts}"
SRC_URI[google-noto-sans-soyombo-fonts.sha256sum] = "c1d92eeb474d35cb709874ab23634dadf101bedb988ff74174cc1cbe67b1c7f2"
RDEPENDS:google-noto-sans-soyombo-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-sundanese-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-sundanese-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-sundanese-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-sundanese-fonts}"
SRC_URI[google-noto-sans-sundanese-fonts.sha256sum] = "88dffe0f94ff2b0134064e4f33cca57a9d5966e9d5ee6441469b655106e9fd9c"
RDEPENDS:google-noto-sans-sundanese-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-sundanese-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-sundanese-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-sundanese-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-sundanese-vf-fonts}"
SRC_URI[google-noto-sans-sundanese-vf-fonts.sha256sum] = "a7c6a1efb623c1c86ead1181964679e9329ab26e38a530bafe393793e41958e7"
RDEPENDS:google-noto-sans-sundanese-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-syloti-nagri-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-syloti-nagri-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-syloti-nagri-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-syloti-nagri-fonts}"
SRC_URI[google-noto-sans-syloti-nagri-fonts.sha256sum] = "8730b4fe81ba5bc949cf189ab7584a05417f86b6e782c465bbeb85d1c4a577da"
RDEPENDS:google-noto-sans-syloti-nagri-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-symbols-2-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-symbols-2-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-symbols-2-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-symbols-2-fonts}"
SRC_URI[google-noto-sans-symbols-2-fonts.sha256sum] = "1f347e39576b054db73aeb31fefa10df1a57d47e24d48c30a12078518f082696"
RDEPENDS:google-noto-sans-symbols-2-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-symbols-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-symbols-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-symbols-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-symbols-fonts}"
SRC_URI[google-noto-sans-symbols-fonts.sha256sum] = "4f6170258037ef05e922ce0c3292442180afd320d10305c42f0322bff334681e"
RDEPENDS:google-noto-sans-symbols-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-symbols-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-symbols-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-symbols-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-symbols-vf-fonts}"
SRC_URI[google-noto-sans-symbols-vf-fonts.sha256sum] = "3f502520ba01f2ed3c93311d91a9c858592edce8c40218bd00622302f8d0e4b4"
RDEPENDS:google-noto-sans-symbols-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-syriac-eastern-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-syriac-eastern-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-syriac-eastern-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-syriac-eastern-fonts}"
SRC_URI[google-noto-sans-syriac-eastern-fonts.sha256sum] = "2dee23fcbc40e3cc1397fb943327e1e1db4e0ac1fd153b2d2077cfe84e1d5e11"
RDEPENDS:google-noto-sans-syriac-eastern-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-syriac-eastern-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-syriac-eastern-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-syriac-eastern-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-syriac-eastern-vf-fonts}"
SRC_URI[google-noto-sans-syriac-eastern-vf-fonts.sha256sum] = "cfaf799ee5268e57fac00caa146fb8d808ffb76c55a2817752b8c57ad2573e7a"
RDEPENDS:google-noto-sans-syriac-eastern-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-syriac-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-syriac-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-syriac-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-syriac-fonts}"
SRC_URI[google-noto-sans-syriac-fonts.sha256sum] = "644920432af03b85292922567434449d567d336866a82ecba55fd6485dca8ad4"
RDEPENDS:google-noto-sans-syriac-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-syriac-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-syriac-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-syriac-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-syriac-vf-fonts}"
SRC_URI[google-noto-sans-syriac-vf-fonts.sha256sum] = "767a86d1eba033b27aa59cfd57da938ee8e6b4e27144a10c7ad96cc9efc0aa83"
RDEPENDS:google-noto-sans-syriac-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-syriac-western-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-syriac-western-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-syriac-western-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-syriac-western-fonts}"
SRC_URI[google-noto-sans-syriac-western-fonts.sha256sum] = "818ec182b20ae8f5aaec5a6207e8cbada272ae5000d7afd2107b06ed9ef70b86"
RDEPENDS:google-noto-sans-syriac-western-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-syriac-western-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-syriac-western-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-syriac-western-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-syriac-western-vf-fonts}"
SRC_URI[google-noto-sans-syriac-western-vf-fonts.sha256sum] = "44b37137492fdd6f58dd5137cd9602c117e7a6bc5b512b10d1e131237d55af83"
RDEPENDS:google-noto-sans-syriac-western-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tagalog-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tagalog-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tagalog-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tagalog-fonts}"
SRC_URI[google-noto-sans-tagalog-fonts.sha256sum] = "4c6271d8348fe64d330c396006c7b428256cd2e134599163a6d4056cf27bdf8d"
RDEPENDS:google-noto-sans-tagalog-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tagbanwa-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tagbanwa-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tagbanwa-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tagbanwa-fonts}"
SRC_URI[google-noto-sans-tagbanwa-fonts.sha256sum] = "860659e35500dd6fb7c869fdccaa357097e0b8f027a7d781a6ce1f1d0257f987"
RDEPENDS:google-noto-sans-tagbanwa-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tai-le-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tai-le-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tai-le-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tai-le-fonts}"
SRC_URI[google-noto-sans-tai-le-fonts.sha256sum] = "b04d8379d3c7d9c84b91347993875885c63ed202b151950e30e2103f5f5e4a02"
RDEPENDS:google-noto-sans-tai-le-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tai-tham-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tai-tham-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tai-tham-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tai-tham-fonts}"
SRC_URI[google-noto-sans-tai-tham-fonts.sha256sum] = "d2d946fddea411050badd312cbb06f230030fb87cc15d5331afa9b000b63b3f3"
RDEPENDS:google-noto-sans-tai-tham-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tai-tham-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tai-tham-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tai-tham-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tai-tham-vf-fonts}"
SRC_URI[google-noto-sans-tai-tham-vf-fonts.sha256sum] = "0d3cac1ee9709f0aa5c271b9a45b2ce02cea57c55e510aa250a8612252ab8858"
RDEPENDS:google-noto-sans-tai-tham-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tai-viet-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tai-viet-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tai-viet-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tai-viet-fonts}"
SRC_URI[google-noto-sans-tai-viet-fonts.sha256sum] = "dbca73e8ec1cff94f2383eb06d71a204ff85cb68c4ae56977c6e21d29308ea29"
RDEPENDS:google-noto-sans-tai-viet-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-takri-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-takri-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-takri-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-takri-fonts}"
SRC_URI[google-noto-sans-takri-fonts.sha256sum] = "ae2c9fe58375d1011146f3b07e8ea59a03da3298f817a3267cef6b9a52820571"
RDEPENDS:google-noto-sans-takri-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tamil-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tamil-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tamil-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tamil-fonts}"
SRC_URI[google-noto-sans-tamil-fonts.sha256sum] = "d99aa69893d38d1deb45a622d270a827adf0bd856319a9c210c25d2047084de5"
RDEPENDS:google-noto-sans-tamil-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tamil-supplement-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tamil-supplement-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tamil-supplement-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tamil-supplement-fonts}"
SRC_URI[google-noto-sans-tamil-supplement-fonts.sha256sum] = "53c199ef3bece8e06250fccb28ef4593690479b80bb5e259ca08ba61ab5ab309"
RDEPENDS:google-noto-sans-tamil-supplement-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tamil-ui-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tamil-ui-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tamil-ui-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tamil-ui-fonts}"
SRC_URI[google-noto-sans-tamil-ui-fonts.sha256sum] = "1199baf9abc15dcd75b8d80b1dd9d29e29746e9a3243fbf6ae3292a33332e5c1"
RDEPENDS:google-noto-sans-tamil-ui-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tamil-ui-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tamil-ui-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tamil-ui-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tamil-ui-vf-fonts}"
SRC_URI[google-noto-sans-tamil-ui-vf-fonts.sha256sum] = "6295b1788a7f0af631c0644674ebe21a4694daa05be5a0c40ee9b2ff44631c6c"
RDEPENDS:google-noto-sans-tamil-ui-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tamil-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tamil-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tamil-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tamil-vf-fonts}"
SRC_URI[google-noto-sans-tamil-vf-fonts.sha256sum] = "4e617217dee256398dcf5288e08107f766c60634be2962f69623d27ff872263b"
RDEPENDS:google-noto-sans-tamil-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tangsa-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tangsa-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tangsa-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tangsa-fonts}"
SRC_URI[google-noto-sans-tangsa-fonts.sha256sum] = "a41aa6d29f66f4d1535f96749c7763db88293be41d8e5ae951f155a11d1927f6"
RDEPENDS:google-noto-sans-tangsa-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tangsa-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tangsa-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tangsa-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tangsa-vf-fonts}"
SRC_URI[google-noto-sans-tangsa-vf-fonts.sha256sum] = "aa8c81919ebce4d3d57e8d059ef875416169090b408991081ec9041013f0867c"
RDEPENDS:google-noto-sans-tangsa-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-telugu-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-telugu-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-telugu-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-telugu-fonts}"
SRC_URI[google-noto-sans-telugu-fonts.sha256sum] = "7e799b174a71c4333d3d7ad86602fd31dd02204ecfc5c9dd2e643aedbd6724b7"
RDEPENDS:google-noto-sans-telugu-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-telugu-ui-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-telugu-ui-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-telugu-ui-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-telugu-ui-fonts}"
SRC_URI[google-noto-sans-telugu-ui-fonts.sha256sum] = "e682d231a664874e401c74fbe85834b07abf50bb55d6c0cb04072686bebe1de3"
RDEPENDS:google-noto-sans-telugu-ui-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-telugu-ui-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-telugu-ui-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-telugu-ui-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-telugu-ui-vf-fonts}"
SRC_URI[google-noto-sans-telugu-ui-vf-fonts.sha256sum] = "43485a78c368a708d7f63d4329cbba4695fa769761e32eb3f130b3f013964545"
RDEPENDS:google-noto-sans-telugu-ui-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-telugu-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-telugu-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-telugu-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-telugu-vf-fonts}"
SRC_URI[google-noto-sans-telugu-vf-fonts.sha256sum] = "65c143d7723da118475d4bc8f59156ddc2dde17a5fddf1eb4b50833114aaae4b"
RDEPENDS:google-noto-sans-telugu-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-thaana-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-thaana-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-thaana-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-thaana-fonts}"
SRC_URI[google-noto-sans-thaana-fonts.sha256sum] = "f0d0c7ddc4b432972760be1918920827f7da5ab6e37e41676e4f97856730a90e"
RDEPENDS:google-noto-sans-thaana-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-thaana-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-thaana-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-thaana-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-thaana-vf-fonts}"
SRC_URI[google-noto-sans-thaana-vf-fonts.sha256sum] = "bb8415c04571aa32e58473ffddc2272e1940d3bdc7e24550ba7232291d59e591"
RDEPENDS:google-noto-sans-thaana-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-thai-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-thai-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-thai-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-thai-fonts}"
SRC_URI[google-noto-sans-thai-fonts.sha256sum] = "e0920b198d37d183be2a91bb61c03a783027acbb5009707f81e5d82f35422f26"
RDEPENDS:google-noto-sans-thai-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-thai-looped-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-thai-looped-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-thai-looped-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-thai-looped-fonts}"
SRC_URI[google-noto-sans-thai-looped-fonts.sha256sum] = "69f6665838fca81c028ec9d2d59cca0a5babc2aeed8c98c6443e3ebd21784338"
RDEPENDS:google-noto-sans-thai-looped-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-thai-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-thai-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-thai-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-thai-vf-fonts}"
SRC_URI[google-noto-sans-thai-vf-fonts.sha256sum] = "ccce7f0ea4bcba6e3fa8640181da717921829271e0ee94529e92a381b47edb34"
RDEPENDS:google-noto-sans-thai-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-adrar-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-adrar-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tifinagh-adrar-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tifinagh-adrar-fonts}"
SRC_URI[google-noto-sans-tifinagh-adrar-fonts.sha256sum] = "547c8eca0888fc50d17574338bcb28e98bcdad6bd85ed09da8990bf249e8069b"
RDEPENDS:google-noto-sans-tifinagh-adrar-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-agraw-imazighen-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-agraw-imazighen-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tifinagh-agraw-imazighen-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tifinagh-agraw-imazighen-fonts}"
SRC_URI[google-noto-sans-tifinagh-agraw-imazighen-fonts.sha256sum] = "71dd9bfe12584cda2cc0f5dde8d7ebc7f3f2828da3d1a73c53e855e822959c0e"
RDEPENDS:google-noto-sans-tifinagh-agraw-imazighen-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-ahaggar-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-ahaggar-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tifinagh-ahaggar-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tifinagh-ahaggar-fonts}"
SRC_URI[google-noto-sans-tifinagh-ahaggar-fonts.sha256sum] = "2e45a864619cfb022ebcdfae34713369b6f1e0503e272e04f1736f5c91c008a9"
RDEPENDS:google-noto-sans-tifinagh-ahaggar-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-air-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-air-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tifinagh-air-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tifinagh-air-fonts}"
SRC_URI[google-noto-sans-tifinagh-air-fonts.sha256sum] = "baf8ada74db05ef726dde8f29708536f4b7710ebefe2095cd8ce07a05a1a5926"
RDEPENDS:google-noto-sans-tifinagh-air-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-apt-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-apt-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tifinagh-apt-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tifinagh-apt-fonts}"
SRC_URI[google-noto-sans-tifinagh-apt-fonts.sha256sum] = "aa8861f8c2e38bb380e86596a478f4c9f24b47ecefa5abfd0df351bc4342e123"
RDEPENDS:google-noto-sans-tifinagh-apt-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-azawagh-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-azawagh-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tifinagh-azawagh-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tifinagh-azawagh-fonts}"
SRC_URI[google-noto-sans-tifinagh-azawagh-fonts.sha256sum] = "8997d8329bb1a030ce2702443dfd2bc63804cc0e4d458d18564bce85ee219a01"
RDEPENDS:google-noto-sans-tifinagh-azawagh-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tifinagh-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tifinagh-fonts}"
SRC_URI[google-noto-sans-tifinagh-fonts.sha256sum] = "2c5fbf7b17a3d25b5521661a16d11a9db7b7b7ece06d6901fa4470a16a0cb191"
RDEPENDS:google-noto-sans-tifinagh-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-ghat-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-ghat-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tifinagh-ghat-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tifinagh-ghat-fonts}"
SRC_URI[google-noto-sans-tifinagh-ghat-fonts.sha256sum] = "e09059cde452d1198b1cc0a085535f146deb122b6ced09b3a36d51fe10693342"
RDEPENDS:google-noto-sans-tifinagh-ghat-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-hawad-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-hawad-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tifinagh-hawad-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tifinagh-hawad-fonts}"
SRC_URI[google-noto-sans-tifinagh-hawad-fonts.sha256sum] = "2fe5462a880cfc45297eedf44722315f41ce1783837cf9e43fe3e96efa23b128"
RDEPENDS:google-noto-sans-tifinagh-hawad-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-rhissa-ixa-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-rhissa-ixa-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tifinagh-rhissa-ixa-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tifinagh-rhissa-ixa-fonts}"
SRC_URI[google-noto-sans-tifinagh-rhissa-ixa-fonts.sha256sum] = "9e72dd9a2c323050d9460e48150150d91b9721b566bb3b38b32b368f299407fe"
RDEPENDS:google-noto-sans-tifinagh-rhissa-ixa-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-sil-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-sil-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tifinagh-sil-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tifinagh-sil-fonts}"
SRC_URI[google-noto-sans-tifinagh-sil-fonts.sha256sum] = "2254a071df74b0205d22550752577e36b2bcd2ae599f653156ef3f3292223c4c"
RDEPENDS:google-noto-sans-tifinagh-sil-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tifinagh-tawellemmet-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tifinagh-tawellemmet-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tifinagh-tawellemmet-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tifinagh-tawellemmet-fonts}"
SRC_URI[google-noto-sans-tifinagh-tawellemmet-fonts.sha256sum] = "98e1b94b4f4a0fa9a80f0da671ceb6a668fc96f6dfc697db4b9884c5faeebd07"
RDEPENDS:google-noto-sans-tifinagh-tawellemmet-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-tirhuta-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-tirhuta-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-tirhuta-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-tirhuta-fonts}"
SRC_URI[google-noto-sans-tirhuta-fonts.sha256sum] = "4fd59e3549c27649dae1b722b95f292f77810b5954949b1cb99ace1be8d07b45"
RDEPENDS:google-noto-sans-tirhuta-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-ugaritic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-ugaritic-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-ugaritic-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-ugaritic-fonts}"
SRC_URI[google-noto-sans-ugaritic-fonts.sha256sum] = "4d366a2dd74db171bdbe77c936c580d4b01b94e94f272d2c145ce77217b1885a"
RDEPENDS:google-noto-sans-ugaritic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-vai-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-vai-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-vai-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-vai-fonts}"
SRC_URI[google-noto-sans-vai-fonts.sha256sum] = "2b9a4cce1a151651a73bc5a489080adfd2981b14ade8939c655ee38a4c096c38"
RDEPENDS:google-noto-sans-vai-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-vithkuqi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-vithkuqi-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-vithkuqi-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-vithkuqi-fonts}"
SRC_URI[google-noto-sans-vithkuqi-fonts.sha256sum] = "df874d6246b06db80c0d37e3d0d148c36d7338bcad3175f187422d029be40687"
RDEPENDS:google-noto-sans-vithkuqi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-vithkuqi-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-vithkuqi-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-vithkuqi-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-vithkuqi-vf-fonts}"
SRC_URI[google-noto-sans-vithkuqi-vf-fonts.sha256sum] = "e2a36b178eccaad63b8cbfdbf4c8df9b2bd6d9d24140ae6b55fd6f1df9129781"
RDEPENDS:google-noto-sans-vithkuqi-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-wancho-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-wancho-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-wancho-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-wancho-fonts}"
SRC_URI[google-noto-sans-wancho-fonts.sha256sum] = "9277b8221e16e51326f562fceb41c44b174c7b6409028bf247d526c7ebea049d"
RDEPENDS:google-noto-sans-wancho-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-warang-citi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-warang-citi-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-warang-citi-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-warang-citi-fonts}"
SRC_URI[google-noto-sans-warang-citi-fonts.sha256sum] = "1f1ace30dfb3f9dec416fe364577375a4fb5a214ba5c3b5528e4f60dec40d505"
RDEPENDS:google-noto-sans-warang-citi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-yi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-yi-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-yi-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-yi-fonts}"
SRC_URI[google-noto-sans-yi-fonts.sha256sum] = "8067fa3ae72d6527211285c5e30a137d9ea22140d143797c764a7acbe9604e23"
RDEPENDS:google-noto-sans-yi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-sans-zanabazar-square-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-zanabazar-square-fonts-20240401-5.el10.noarch.rpm;name=google-noto-sans-zanabazar-square-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-zanabazar-square-fonts}"
SRC_URI[google-noto-sans-zanabazar-square-fonts.sha256sum] = "20238bdbec6689cc32008eb122c4184383209400720d2eb4c4841a74cfac201b"
RDEPENDS:google-noto-sans-zanabazar-square-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-ahom-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-ahom-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-ahom-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-ahom-fonts}"
SRC_URI[google-noto-serif-ahom-fonts.sha256sum] = "7929065643855f1f7e2dec2451a14a75e6903a9d30979b06f217b4395be4c4e6"
RDEPENDS:google-noto-serif-ahom-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-armenian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-armenian-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-armenian-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-armenian-fonts}"
SRC_URI[google-noto-serif-armenian-fonts.sha256sum] = "fa4e7756f5c92ef01ddc65f7a372715883d911be7ebbcc2da5fba03cd22e34df"
RDEPENDS:google-noto-serif-armenian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-armenian-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-armenian-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-armenian-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-armenian-vf-fonts}"
SRC_URI[google-noto-serif-armenian-vf-fonts.sha256sum] = "78bdf3ccf288e1eacd2375733ecc16ba9472114cb041b5776ea32923167c966d"
RDEPENDS:google-noto-serif-armenian-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-balinese-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-balinese-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-balinese-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-balinese-fonts}"
SRC_URI[google-noto-serif-balinese-fonts.sha256sum] = "db1427a7ea1f0607c9704619070daf0e37adadf6cac4bca1a74bd410c0345260"
RDEPENDS:google-noto-serif-balinese-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-bengali-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-bengali-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-bengali-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-bengali-fonts}"
SRC_URI[google-noto-serif-bengali-fonts.sha256sum] = "291ffc1c22835e5d6487939744fe117d9463755a8596ba9b3c496268727fbd8b"
RDEPENDS:google-noto-serif-bengali-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-bengali-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-bengali-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-bengali-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-bengali-vf-fonts}"
SRC_URI[google-noto-serif-bengali-vf-fonts.sha256sum] = "92ec5f01c73864e285af4ba6818dcd97453f96b39b24f27671171f4525dbea72"
RDEPENDS:google-noto-serif-bengali-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-devanagari-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-devanagari-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-devanagari-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-devanagari-fonts}"
SRC_URI[google-noto-serif-devanagari-fonts.sha256sum] = "71a77a6b6bc9a5464a232bb7065daf3c7760b56be8063cbdd6e52d1989e27a64"
RDEPENDS:google-noto-serif-devanagari-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-devanagari-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-devanagari-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-devanagari-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-devanagari-vf-fonts}"
SRC_URI[google-noto-serif-devanagari-vf-fonts.sha256sum] = "6550cf128096475f79907266802940d11ad3a235f4a66dea8a317b8504c2f5ec"
RDEPENDS:google-noto-serif-devanagari-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-dives-akuru-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-dives-akuru-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-dives-akuru-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-dives-akuru-fonts}"
SRC_URI[google-noto-serif-dives-akuru-fonts.sha256sum] = "b0d885ac849af73d1d4403bff9f085c8378bed586edd5840e7b1d4b3bb65b4ee"
RDEPENDS:google-noto-serif-dives-akuru-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-dogra-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-dogra-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-dogra-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-dogra-fonts}"
SRC_URI[google-noto-serif-dogra-fonts.sha256sum] = "de0b87458218b00a27c8d5d931a9194edec162f9b78b2f1f97cea179132edb16"
RDEPENDS:google-noto-serif-dogra-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-ethiopic-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-ethiopic-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-ethiopic-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-ethiopic-fonts}"
SRC_URI[google-noto-serif-ethiopic-fonts.sha256sum] = "40bfb7a2bbb0593b5a9ac9132c7c53a2cafc70455240bd376acf75d3c0e0c10f"
RDEPENDS:google-noto-serif-ethiopic-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-ethiopic-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-ethiopic-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-ethiopic-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-ethiopic-vf-fonts}"
SRC_URI[google-noto-serif-ethiopic-vf-fonts.sha256sum] = "5d74f0bed3f325e1cb4efbfee20ae01bf4e064babc3ee0cab1b1dd6fc28560bb"
RDEPENDS:google-noto-serif-ethiopic-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-fonts}"
SRC_URI[google-noto-serif-fonts.sha256sum] = "f1c83e83e1595301f3f1d19881f19e572eecf995733425445b15393288b99897"
RDEPENDS:google-noto-serif-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-georgian-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-georgian-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-georgian-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-georgian-fonts}"
SRC_URI[google-noto-serif-georgian-fonts.sha256sum] = "3ee9a67898ed9a8cea9cc11253f2f27d8c855c4d28c717f480064b0ba5441c07"
RDEPENDS:google-noto-serif-georgian-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-georgian-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-georgian-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-georgian-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-georgian-vf-fonts}"
SRC_URI[google-noto-serif-georgian-vf-fonts.sha256sum] = "adfb876afbd4f75b27c74ea814188e071bd34bcc2c305e15defd437d3b9826cc"
RDEPENDS:google-noto-serif-georgian-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-grantha-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-grantha-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-grantha-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-grantha-fonts}"
SRC_URI[google-noto-serif-grantha-fonts.sha256sum] = "676544d4f7e40fa89053bd896917c5190311b7345ae85f0e44b529b903c1bd5a"
RDEPENDS:google-noto-serif-grantha-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-gujarati-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-gujarati-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-gujarati-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-gujarati-fonts}"
SRC_URI[google-noto-serif-gujarati-fonts.sha256sum] = "3ecf06834b88ee658807442e8cf78fee679b2e44122dc15e345c3d050484f7c1"
RDEPENDS:google-noto-serif-gujarati-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-gujarati-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-gujarati-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-gujarati-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-gujarati-vf-fonts}"
SRC_URI[google-noto-serif-gujarati-vf-fonts.sha256sum] = "fcd292ce54a9e81394229fc328d7183422da469d8d2a759652db7d93afa0cc71"
RDEPENDS:google-noto-serif-gujarati-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-gurmukhi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-gurmukhi-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-gurmukhi-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-gurmukhi-fonts}"
SRC_URI[google-noto-serif-gurmukhi-fonts.sha256sum] = "a87c94e6ecebc84f12309225f2c2480749706c98382fa8125d04dfdcff75cc4c"
RDEPENDS:google-noto-serif-gurmukhi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-gurmukhi-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-gurmukhi-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-gurmukhi-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-gurmukhi-vf-fonts}"
SRC_URI[google-noto-serif-gurmukhi-vf-fonts.sha256sum] = "cb1370ffc67fda285b832bb0b5ef8f5fa3faf5f7a53c4cc783217f4698fb4975"
RDEPENDS:google-noto-serif-gurmukhi-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-hebrew-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-hebrew-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-hebrew-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-hebrew-fonts}"
SRC_URI[google-noto-serif-hebrew-fonts.sha256sum] = "627eac7e1bbb570b7a7ddd270326e8c6ab84b0cc18c055003bc3bc33be816270"
RDEPENDS:google-noto-serif-hebrew-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-hebrew-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-hebrew-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-hebrew-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-hebrew-vf-fonts}"
SRC_URI[google-noto-serif-hebrew-vf-fonts.sha256sum] = "787f9827ae66e95adbd1d8a1cac84a83d0c59cf31b9987e31e439bb6ab7a7f4f"
RDEPENDS:google-noto-serif-hebrew-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-kannada-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-kannada-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-kannada-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-kannada-fonts}"
SRC_URI[google-noto-serif-kannada-fonts.sha256sum] = "c3ebe192270206de39af0ad9ef69f5e90d39bba6f86c520d333e02afe9a49673"
RDEPENDS:google-noto-serif-kannada-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-kannada-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-kannada-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-kannada-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-kannada-vf-fonts}"
SRC_URI[google-noto-serif-kannada-vf-fonts.sha256sum] = "4f9b3ef8e7a20222c1dc92075df2ece978b5e4defde5fa29e602bed3dabaea2f"
RDEPENDS:google-noto-serif-kannada-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-khitan-small-script-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-khitan-small-script-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-khitan-small-script-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-khitan-small-script-fonts}"
SRC_URI[google-noto-serif-khitan-small-script-fonts.sha256sum] = "b1abfc1ce76002189b54168f240590bf37d76ae64b08b406b6f1ef0ce037176b"
RDEPENDS:google-noto-serif-khitan-small-script-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-khmer-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-khmer-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-khmer-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-khmer-fonts}"
SRC_URI[google-noto-serif-khmer-fonts.sha256sum] = "e3340192687244e45a9827fee2f0c6caac351f9250d01226e873bd839cb6f890"
RDEPENDS:google-noto-serif-khmer-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-khmer-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-khmer-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-khmer-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-khmer-vf-fonts}"
SRC_URI[google-noto-serif-khmer-vf-fonts.sha256sum] = "06d10bbef3b1ebd25355ef663d02dcc760405e2aa2214eecd5edd1a2f0d38813"
RDEPENDS:google-noto-serif-khmer-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-khojki-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-khojki-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-khojki-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-khojki-fonts}"
SRC_URI[google-noto-serif-khojki-fonts.sha256sum] = "7300798a21830075f04740188ce7c711948f840341f9abc1764cb4751464a15b"
RDEPENDS:google-noto-serif-khojki-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-khojki-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-khojki-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-khojki-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-khojki-vf-fonts}"
SRC_URI[google-noto-serif-khojki-vf-fonts.sha256sum] = "73cba9bc3e7b5856edc5509e1ac723bf9793eb88ce3ec3be963e44b7c8311d94"
RDEPENDS:google-noto-serif-khojki-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-lao-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-lao-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-lao-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-lao-fonts}"
SRC_URI[google-noto-serif-lao-fonts.sha256sum] = "b672811d1adc2e57190462c35deb73edc9c20580eda5bff09f328ffdfa01b004"
RDEPENDS:google-noto-serif-lao-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-lao-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-lao-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-lao-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-lao-vf-fonts}"
SRC_URI[google-noto-serif-lao-vf-fonts.sha256sum] = "e316fedd5d4f9bca1ee21f79459a645f79bd2dd112c2cdc32802e9316cdc58b5"
RDEPENDS:google-noto-serif-lao-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-makasar-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-makasar-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-makasar-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-makasar-fonts}"
SRC_URI[google-noto-serif-makasar-fonts.sha256sum] = "d5e3e01deb96c3ba1acf5196a0af2a52b7b90099ceaee80d241d2b30fda9088b"
RDEPENDS:google-noto-serif-makasar-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-malayalam-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-malayalam-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-malayalam-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-malayalam-fonts}"
SRC_URI[google-noto-serif-malayalam-fonts.sha256sum] = "bc6113c2674c14299f8aefe854d882914aa607cf39bc8192f513daa1ac49bcc5"
RDEPENDS:google-noto-serif-malayalam-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-malayalam-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-malayalam-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-malayalam-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-malayalam-vf-fonts}"
SRC_URI[google-noto-serif-malayalam-vf-fonts.sha256sum] = "bc6e5a9f16ae422f0a4da28ab15134fa59455f2aba7b2dfeebe35e9f6c0a8b00"
RDEPENDS:google-noto-serif-malayalam-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-myanmar-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-myanmar-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-myanmar-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-myanmar-fonts}"
SRC_URI[google-noto-serif-myanmar-fonts.sha256sum] = "e49ebe319c52ccc5a53c195aa8f4e9ee6e0ef9d204b1c33c1d55a6778794cf83"
RDEPENDS:google-noto-serif-myanmar-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-np-hmong-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-np-hmong-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-np-hmong-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-np-hmong-fonts}"
SRC_URI[google-noto-serif-np-hmong-fonts.sha256sum] = "3ef104134b40efbabbaf5a785d5cfdd0c5694a23df23c0a58731fbb6e411269f"
RDEPENDS:google-noto-serif-np-hmong-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-np-hmong-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-np-hmong-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-np-hmong-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-np-hmong-vf-fonts}"
SRC_URI[google-noto-serif-np-hmong-vf-fonts.sha256sum] = "2ecf8b8e0bbf86604e2a0f2f268a5695e10100db0cef5663301c38ead619ad06"
RDEPENDS:google-noto-serif-np-hmong-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-old-uyghur-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-old-uyghur-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-old-uyghur-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-old-uyghur-fonts}"
SRC_URI[google-noto-serif-old-uyghur-fonts.sha256sum] = "00ab55757a8b4f88080f517b2e51e5c32284f33150d1f806ce580818a90e3a1c"
RDEPENDS:google-noto-serif-old-uyghur-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-oriya-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-oriya-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-oriya-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-oriya-fonts}"
SRC_URI[google-noto-serif-oriya-fonts.sha256sum] = "6720d8cd59aed36a7b0ed8ae878b60319dd7a6a1c28fb0a18f77867e88b488e1"
RDEPENDS:google-noto-serif-oriya-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-oriya-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-oriya-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-oriya-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-oriya-vf-fonts}"
SRC_URI[google-noto-serif-oriya-vf-fonts.sha256sum] = "72ba8c85548096391c2c14d2d9d51f174f8f8d8061dd7e53f58ebe91b013b1af"
RDEPENDS:google-noto-serif-oriya-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-ottoman-siyaq-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-ottoman-siyaq-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-ottoman-siyaq-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-ottoman-siyaq-fonts}"
SRC_URI[google-noto-serif-ottoman-siyaq-fonts.sha256sum] = "59e0c16ec6cfbe3a22a70209ee581201557a5dd46e3b669903031f3be0b8c7d1"
RDEPENDS:google-noto-serif-ottoman-siyaq-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-sinhala-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-sinhala-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-sinhala-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-sinhala-fonts}"
SRC_URI[google-noto-serif-sinhala-fonts.sha256sum] = "b0781d5fe3671ba59a0065d75c216383b76a8b370d0819bec7ec26b3cff0ec24"
RDEPENDS:google-noto-serif-sinhala-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-sinhala-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-sinhala-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-sinhala-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-sinhala-vf-fonts}"
SRC_URI[google-noto-serif-sinhala-vf-fonts.sha256sum] = "ecda37a27400402e1b9fd699fbcb0e2d40da73ad13481126786e6000036315de"
RDEPENDS:google-noto-serif-sinhala-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-tamil-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-tamil-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-tamil-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-tamil-fonts}"
SRC_URI[google-noto-serif-tamil-fonts.sha256sum] = "b5cc3188f1e9e8d5e3bc6bc9afaee4ab8f08f08e4d4bac0c46714bc826c7cda4"
RDEPENDS:google-noto-serif-tamil-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-tamil-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-tamil-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-tamil-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-tamil-vf-fonts}"
SRC_URI[google-noto-serif-tamil-vf-fonts.sha256sum] = "908c2e98a6f930893d0896817c8ef75beb893db8a119ad140a7fb540e7e5f1c0"
RDEPENDS:google-noto-serif-tamil-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-tangut-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-tangut-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-tangut-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-tangut-fonts}"
SRC_URI[google-noto-serif-tangut-fonts.sha256sum] = "ff49d0e535b92058f7aa57c876a343b5488519c53b608c9f5c1d99df8a126b0c"
RDEPENDS:google-noto-serif-tangut-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-telugu-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-telugu-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-telugu-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-telugu-fonts}"
SRC_URI[google-noto-serif-telugu-fonts.sha256sum] = "bce6735eb462a84995ed6fc3d2f50ae03ceb8c983b80673eeb1804e8e1941de8"
RDEPENDS:google-noto-serif-telugu-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-telugu-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-telugu-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-telugu-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-telugu-vf-fonts}"
SRC_URI[google-noto-serif-telugu-vf-fonts.sha256sum] = "55305632ef49f1725cf49e51271549b1301404fc0aefb8366d88cd9d26a54abe"
RDEPENDS:google-noto-serif-telugu-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-thai-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-thai-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-thai-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-thai-fonts}"
SRC_URI[google-noto-serif-thai-fonts.sha256sum] = "9852c4ec482bc6dd901fff063730c215de2bac99531e8bf02da216110690ee49"
RDEPENDS:google-noto-serif-thai-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-thai-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-thai-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-thai-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-thai-vf-fonts}"
SRC_URI[google-noto-serif-thai-vf-fonts.sha256sum] = "bfa4eb33d11a50c8ac70c5d6797a9889c1974e994be30fe017654442be87ac6e"
RDEPENDS:google-noto-serif-thai-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-tibetan-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-tibetan-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-tibetan-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-tibetan-fonts}"
SRC_URI[google-noto-serif-tibetan-fonts.sha256sum] = "e86d47bf49b70f41e5495400f9dffb241eae598e52fc950452954dea73f6c6c9"
RDEPENDS:google-noto-serif-tibetan-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-tibetan-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-tibetan-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-tibetan-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-tibetan-vf-fonts}"
SRC_URI[google-noto-serif-tibetan-vf-fonts.sha256sum] = "aae57aa98b1a6cbf52d4a2d5e9de17799fa496af71fd60743b26df309c8e3411"
RDEPENDS:google-noto-serif-tibetan-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-toto-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-toto-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-toto-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-toto-fonts}"
SRC_URI[google-noto-serif-toto-fonts.sha256sum] = "2e1661fec3b52a9bb065ba2dbba7dfb51e9663b7231eebf4fe806bf9629133e6"
RDEPENDS:google-noto-serif-toto-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-toto-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-toto-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-toto-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-toto-vf-fonts}"
SRC_URI[google-noto-serif-toto-vf-fonts.sha256sum] = "7ead7830075fbc07c19f672077f08fdaaf0ea4fac9b0cca2eb26659f7c728bdb"
RDEPENDS:google-noto-serif-toto-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-vithkuqi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-vithkuqi-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-vithkuqi-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-vithkuqi-fonts}"
SRC_URI[google-noto-serif-vithkuqi-fonts.sha256sum] = "6ed9c82b19f77d56bdca78d2251baf498adeab4b3df68f186d8f3a65aa8cd404"
RDEPENDS:google-noto-serif-vithkuqi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-vithkuqi-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-vithkuqi-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-vithkuqi-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-vithkuqi-vf-fonts}"
SRC_URI[google-noto-serif-vithkuqi-vf-fonts.sha256sum] = "b2de98925248d9dec89b794647568c3a1c8764a962cace0637bac887b4cb6106"
RDEPENDS:google-noto-serif-vithkuqi-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-yezidi-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-yezidi-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-yezidi-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-yezidi-fonts}"
SRC_URI[google-noto-serif-yezidi-fonts.sha256sum] = "487ab35c8b32658c133cf181ea2bf3dc9cfbb5a1ef429ce7eb467dfb7eed1c38"
RDEPENDS:google-noto-serif-yezidi-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-serif-yezidi-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-serif-yezidi-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-yezidi-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-yezidi-vf-fonts}"
SRC_URI[google-noto-serif-yezidi-vf-fonts.sha256sum] = "536b5cdc6278e928beb171ce0fa6c24edb17a521a1eb20501b96f74cd309bbeb"
RDEPENDS:google-noto-serif-yezidi-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-traditional-nushu-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-traditional-nushu-fonts-20240401-5.el10.noarch.rpm;name=google-noto-traditional-nushu-fonts;unpack=0"
SRC_URI += "${URI_google-noto-traditional-nushu-fonts}"
SRC_URI[google-noto-traditional-nushu-fonts.sha256sum] = "2984c0628931b87bb4f6c776724a3977d57662d6b1a643acb8c5709ed3b41884"
RDEPENDS:google-noto-traditional-nushu-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-traditional-nushu-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-traditional-nushu-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-traditional-nushu-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-traditional-nushu-vf-fonts}"
SRC_URI[google-noto-traditional-nushu-vf-fonts.sha256sum] = "d3619560e5e7e0882d5dd36d1cbe0a38bcc394deee7eb973107cc60f890a3c3d"
RDEPENDS:google-noto-traditional-nushu-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"

URI_google-noto-fonts-all-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/google-noto-fonts-all-static-20240401-5.el10.noarch.rpm;name=google-noto-fonts-all-static;unpack=0"
SRC_URI += "${URI_google-noto-fonts-all-static}"
SRC_URI[google-noto-fonts-all-static.sha256sum] = "820ca273a854a53e1f0f69c16cd9a8d153d4a700fcf7803d63bfce25293f82bb"
RDEPENDS:google-noto-fonts-all-static = " \
 google-noto-sans-khudawadi-fonts \
 google-noto-sans-lao-fonts \
 google-noto-sans-lao-looped-fonts \
 google-noto-sans-lepcha-fonts \
 google-noto-sans-limbu-fonts \
 google-noto-sans-linear-a-fonts \
 google-noto-sans-linear-b-fonts \
 google-noto-sans-lisu-fonts \
 google-noto-sans-lycian-fonts \
 google-noto-sans-lydian-fonts \
 google-noto-sans-mahajani-fonts \
 google-noto-sans-malayalam-fonts \
 google-noto-sans-malayalam-ui-fonts \
 google-noto-sans-mandaic-fonts \
 google-noto-sans-manichaean-fonts \
 google-noto-sans-marchen-fonts \
 google-noto-sans-masaram-gondi-fonts \
 google-noto-sans-math-fonts \
 google-noto-sans-mayan-numerals-fonts \
 google-noto-sans-medefaidrin-fonts \
 google-noto-sans-meetei-mayek-fonts \
 google-noto-sans-mende-kikakui-fonts \
 google-noto-sans-meroitic-fonts \
 google-noto-sans-miao-fonts \
 google-noto-sans-modi-fonts \
 google-noto-sans-mongolian-fonts \
 google-noto-sans-mono-fonts \
 google-noto-sans-mro-fonts \
 google-noto-sans-multani-fonts \
 google-noto-sans-myanmar-fonts \
 google-noto-sans-nabataean-fonts \
 google-noto-sans-nag-mundari-fonts \
 google-noto-sans-nandinagari-fonts \
 google-noto-sans-new-tai-lue-fonts \
 google-noto-sans-newa-fonts \
 google-noto-sans-nko-fonts \
 google-noto-sans-nko-unjoined-fonts \
 google-noto-sans-nushu-fonts \
 google-noto-sans-ogham-fonts \
 google-noto-sans-ol-chiki-fonts \
 google-noto-sans-old-hungarian-fonts \
 google-noto-sans-old-italic-fonts \
 google-noto-sans-old-north-arabian-fonts \
 google-noto-sans-old-permic-fonts \
 google-noto-sans-old-persian-fonts \
 google-noto-sans-old-sogdian-fonts \
 google-noto-sans-old-south-arabian-fonts \
 google-noto-sans-old-turkic-fonts \
 google-noto-sans-oriya-fonts \
 google-noto-sans-osage-fonts \
 google-noto-sans-osmanya-fonts \
 google-noto-sans-pahawh-hmong-fonts \
 google-noto-sans-palmyrene-fonts \
 google-noto-sans-pau-cin-hau-fonts \
 google-noto-sans-phagspa-fonts \
 google-noto-sans-phoenician-fonts \
 google-noto-sans-psalter-pahlavi-fonts \
 google-noto-sans-rejang-fonts \
 google-noto-sans-runic-fonts \
 google-noto-sans-samaritan-fonts \
 google-noto-sans-saurashtra-fonts \
 google-noto-sans-sharada-fonts \
 google-noto-sans-shavian-fonts \
 google-noto-sans-siddham-fonts \
 google-noto-sans-signwriting-fonts \
 google-noto-sans-sinhala-fonts \
 google-noto-sans-sinhala-ui-fonts \
 google-noto-sans-sogdian-fonts \
 google-noto-sans-sora-sompeng-fonts \
 google-noto-sans-soyombo-fonts \
 google-noto-sans-sundanese-fonts \
 google-noto-sans-syloti-nagri-fonts \
 google-noto-sans-symbols-2-fonts \
 google-noto-sans-symbols-fonts \
 google-noto-sans-syriac-eastern-fonts \
 google-noto-sans-syriac-fonts \
 google-noto-sans-syriac-western-fonts \
 google-noto-sans-tagalog-fonts \
 google-noto-sans-tagbanwa-fonts \
 google-noto-sans-tai-le-fonts \
 google-noto-sans-tai-tham-fonts \
 google-noto-sans-tai-viet-fonts \
 google-noto-sans-takri-fonts \
 google-noto-sans-tamil-fonts \
 google-noto-sans-tamil-supplement-fonts \
 google-noto-sans-tamil-ui-fonts \
 google-noto-sans-tangsa-fonts \
 google-noto-sans-telugu-fonts \
 google-noto-sans-telugu-ui-fonts \
 google-noto-sans-thaana-fonts \
 google-noto-sans-thai-fonts \
 google-noto-sans-thai-looped-fonts \
 google-noto-sans-tifinagh-adrar-fonts \
 google-noto-sans-tifinagh-agraw-imazighen-fonts \
 google-noto-sans-tifinagh-ahaggar-fonts \
 google-noto-sans-tifinagh-air-fonts \
 google-noto-sans-tifinagh-apt-fonts \
 google-noto-sans-tifinagh-azawagh-fonts \
 google-noto-sans-tifinagh-fonts \
 google-noto-sans-tifinagh-ghat-fonts \
 google-noto-sans-tifinagh-hawad-fonts \
 google-noto-sans-tifinagh-rhissa-ixa-fonts \
 google-noto-sans-tifinagh-sil-fonts \
 google-noto-sans-tifinagh-tawellemmet-fonts \
 google-noto-sans-tirhuta-fonts \
 google-noto-sans-ugaritic-fonts \
 google-noto-sans-vai-fonts \
 google-noto-sans-vithkuqi-fonts \
 google-noto-sans-wancho-fonts \
 google-noto-sans-warang-citi-fonts \
 google-noto-sans-yi-fonts \
 google-noto-sans-zanabazar-square-fonts \
 google-noto-serif-ahom-fonts \
 google-noto-serif-armenian-fonts \
 google-noto-serif-balinese-fonts \
 google-noto-serif-bengali-fonts \
 google-noto-serif-devanagari-fonts \
 google-noto-serif-dives-akuru-fonts \
 google-noto-serif-dogra-fonts \
 google-noto-serif-ethiopic-fonts \
 google-noto-serif-fonts \
 google-noto-serif-georgian-fonts \
 google-noto-serif-grantha-fonts \
 google-noto-serif-gujarati-fonts \
 google-noto-serif-gurmukhi-fonts \
 google-noto-serif-hebrew-fonts \
 google-noto-serif-kannada-fonts \
 google-noto-serif-khitan-small-script-fonts \
 google-noto-serif-khmer-fonts \
 google-noto-serif-khojki-fonts \
 google-noto-serif-lao-fonts \
 google-noto-serif-makasar-fonts \
 google-noto-serif-malayalam-fonts \
 google-noto-serif-myanmar-fonts \
 google-noto-serif-np-hmong-fonts \
 google-noto-serif-old-uyghur-fonts \
 google-noto-serif-oriya-fonts \
 google-noto-serif-ottoman-siyaq-fonts \
 google-noto-serif-sinhala-fonts \
 google-noto-serif-tamil-fonts \
 google-noto-serif-tangut-fonts \
 google-noto-serif-telugu-fonts \
 google-noto-serif-thai-fonts \
 google-noto-serif-tibetan-fonts \
 google-noto-serif-toto-fonts \
 google-noto-serif-vithkuqi-fonts \
 google-noto-serif-yezidi-fonts \
 google-noto-traditional-nushu-fonts \
 google-noto-fangsong-kss-rotated-fonts \
 google-noto-fangsong-kss-vertical-fonts \
 google-noto-kufi-arabic-fonts \
 google-noto-music-fonts \
 google-noto-naskh-arabic-fonts \
 google-noto-naskh-arabic-ui-fonts \
 google-noto-nastaliq-urdu-fonts \
 google-noto-rashi-hebrew-fonts \
 google-noto-sans-adlam-fonts \
 google-noto-sans-adlam-unjoined-fonts \
 google-noto-sans-anatolian-hieroglyphs-fonts \
 google-noto-sans-arabic-fonts \
 google-noto-sans-armenian-fonts \
 google-noto-sans-avestan-fonts \
 google-noto-sans-balinese-fonts \
 google-noto-sans-bamum-fonts \
 google-noto-sans-bassa-vah-fonts \
 google-noto-sans-batak-fonts \
 google-noto-sans-bengali-fonts \
 google-noto-sans-bengali-ui-fonts \
 google-noto-sans-bhaiksuki-fonts \
 google-noto-sans-brahmi-fonts \
 google-noto-sans-buginese-fonts \
 google-noto-sans-buhid-fonts \
 google-noto-sans-canadian-aboriginal-fonts \
 google-noto-sans-carian-fonts \
 google-noto-sans-caucasian-albanian-fonts \
 google-noto-sans-chakma-fonts \
 google-noto-sans-cham-fonts \
 google-noto-sans-cherokee-fonts \
 google-noto-sans-chorasmian-fonts \
 google-noto-sans-coptic-fonts \
 google-noto-sans-cuneiform-fonts \
 google-noto-sans-cypriot-fonts \
 google-noto-sans-cypro-minoan-fonts \
 google-noto-sans-deseret-fonts \
 google-noto-sans-devanagari-fonts \
 google-noto-sans-devanagari-ui-fonts \
 google-noto-sans-duployan-fonts \
 google-noto-sans-egyptian-hieroglyphs-fonts \
 google-noto-sans-elbasan-fonts \
 google-noto-sans-elymaic-fonts \
 google-noto-sans-ethiopic-fonts \
 google-noto-sans-fonts \
 google-noto-sans-georgian-fonts \
 google-noto-sans-glagolitic-fonts \
 google-noto-sans-gothic-fonts \
 google-noto-sans-grantha-fonts \
 google-noto-sans-gujarati-fonts \
 google-noto-sans-gujarati-ui-fonts \
 google-noto-sans-gunjala-gondi-fonts \
 google-noto-sans-gurmukhi-fonts \
 google-noto-sans-gurmukhi-ui-fonts \
 google-noto-sans-hanifi-rohingya-fonts \
 google-noto-sans-hanunoo-fonts \
 google-noto-sans-hatran-fonts \
 google-noto-sans-hebrew-fonts \
 google-noto-sans-imperial-aramaic-fonts \
 google-noto-sans-indic-siyaq-numbers-fonts \
 google-noto-sans-inscriptional-pahlavi-fonts \
 google-noto-sans-inscriptional-parthian-fonts \
 google-noto-sans-javanese-fonts \
 google-noto-sans-kaithi-fonts \
 google-noto-sans-kannada-fonts \
 google-noto-sans-kannada-ui-fonts \
 google-noto-sans-kawi-fonts \
 google-noto-sans-kayah-li-fonts \
 google-noto-sans-kharoshthi-fonts \
 google-noto-sans-khmer-fonts \
 google-noto-sans-khojki-fonts \
"

URI_google-noto-fonts-all-vf = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/google-noto-fonts-all-vf-20240401-5.el10.noarch.rpm;name=google-noto-fonts-all-vf;unpack=0"
SRC_URI += "${URI_google-noto-fonts-all-vf}"
SRC_URI[google-noto-fonts-all-vf.sha256sum] = "bbc9522a4dbcb5f82cae702f31300bbbda498bb8fb7c0cdbad9312e271bc571a"
RDEPENDS:google-noto-fonts-all-vf = " \
 google-noto-sans-lao-looped-vf-fonts \
 google-noto-sans-lao-vf-fonts \
 google-noto-sans-lisu-vf-fonts \
 google-noto-sans-malayalam-ui-vf-fonts \
 google-noto-sans-malayalam-vf-fonts \
 google-noto-sans-medefaidrin-vf-fonts \
 google-noto-sans-meetei-mayek-vf-fonts \
 google-noto-sans-myanmar-vf-fonts \
 google-noto-sans-nag-mundari-vf-fonts \
 google-noto-sans-new-tai-lue-vf-fonts \
 google-noto-sans-nko-unjoined-vf-fonts \
 google-noto-sans-ol-chiki-vf-fonts \
 google-noto-sans-oriya-vf-fonts \
 google-noto-sans-mono-vf-fonts \
 google-noto-sans-vf-fonts \
 google-noto-serif-vf-fonts \
 google-noto-sans-sinhala-vf-fonts \
 google-noto-sans-sora-sompeng-vf-fonts \
 google-noto-sans-sundanese-vf-fonts \
 google-noto-sans-symbols-vf-fonts \
 google-noto-sans-syriac-eastern-vf-fonts \
 google-noto-sans-syriac-vf-fonts \
 google-noto-sans-syriac-western-vf-fonts \
 google-noto-sans-tai-tham-vf-fonts \
 google-noto-sans-tamil-ui-vf-fonts \
 google-noto-sans-tamil-vf-fonts \
 google-noto-sans-tangsa-vf-fonts \
 google-noto-sans-telugu-ui-vf-fonts \
 google-noto-sans-telugu-vf-fonts \
 google-noto-sans-thaana-vf-fonts \
 google-noto-sans-thai-vf-fonts \
 google-noto-sans-vithkuqi-vf-fonts \
 google-noto-serif-armenian-vf-fonts \
 google-noto-serif-bengali-vf-fonts \
 google-noto-serif-devanagari-vf-fonts \
 google-noto-serif-ethiopic-vf-fonts \
 google-noto-serif-georgian-vf-fonts \
 google-noto-serif-gujarati-vf-fonts \
 google-noto-serif-gurmukhi-vf-fonts \
 google-noto-serif-hebrew-vf-fonts \
 google-noto-serif-kannada-vf-fonts \
 google-noto-serif-khmer-vf-fonts \
 google-noto-serif-khojki-vf-fonts \
 google-noto-serif-lao-vf-fonts \
 google-noto-serif-malayalam-vf-fonts \
 google-noto-serif-np-hmong-vf-fonts \
 google-noto-serif-oriya-vf-fonts \
 google-noto-serif-sinhala-vf-fonts \
 google-noto-serif-tamil-vf-fonts \
 google-noto-serif-telugu-vf-fonts \
 google-noto-serif-thai-vf-fonts \
 google-noto-serif-tibetan-vf-fonts \
 google-noto-serif-toto-vf-fonts \
 google-noto-serif-vithkuqi-vf-fonts \
 google-noto-serif-yezidi-vf-fonts \
 google-noto-traditional-nushu-vf-fonts \
 google-noto-kufi-arabic-vf-fonts \
 google-noto-naskh-arabic-ui-vf-fonts \
 google-noto-naskh-arabic-vf-fonts \
 google-noto-nastaliq-urdu-vf-fonts \
 google-noto-rashi-hebrew-vf-fonts \
 google-noto-sans-adlam-unjoined-vf-fonts \
 google-noto-sans-adlam-vf-fonts \
 google-noto-sans-arabic-vf-fonts \
 google-noto-sans-armenian-vf-fonts \
 google-noto-sans-balinese-vf-fonts \
 google-noto-sans-bamum-vf-fonts \
 google-noto-sans-bassa-vah-vf-fonts \
 google-noto-sans-bengali-vf-fonts \
 google-noto-sans-canadian-aboriginal-vf-fonts \
 google-noto-sans-cham-vf-fonts \
 google-noto-sans-cherokee-vf-fonts \
 google-noto-sans-devanagari-vf-fonts \
 google-noto-sans-ethiopic-vf-fonts \
 google-noto-sans-georgian-vf-fonts \
 google-noto-sans-gujarati-vf-fonts \
 google-noto-sans-gunjala-gondi-vf-fonts \
 google-noto-sans-gurmukhi-vf-fonts \
 google-noto-sans-hanifi-rohingya-vf-fonts \
 google-noto-sans-hebrew-vf-fonts \
 google-noto-sans-javanese-vf-fonts \
 google-noto-sans-kannada-ui-vf-fonts \
 google-noto-sans-kannada-vf-fonts \
 google-noto-sans-kawi-vf-fonts \
 google-noto-sans-kayah-li-vf-fonts \
 google-noto-sans-khmer-vf-fonts \
"

URI_google-noto-serif-myanmar-vf-fonts = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/google-noto-serif-myanmar-vf-fonts-20240401-5.el10.noarch.rpm;name=google-noto-serif-myanmar-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-serif-myanmar-vf-fonts}"
SRC_URI[google-noto-serif-myanmar-vf-fonts.sha256sum] = "d9ac97bf59400717e8fb024825dccfd5aac5bc694173ecf7b9ad7b1e4d6c75ec"
RDEPENDS:google-noto-serif-myanmar-vf-fonts = " \
 fonts-filesystem \
 google-noto-fonts-common \
"
