# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libfido2"
PE = "0"
PV = "1.14.0"
PR = "7.el10"
PACKAGES = "libfido2 fido2-tools libfido2-devel"
PROVIDES = "rpm/libfido2 rpm/fido2-tools rpm/libfido2-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libfido2-1.14.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "34836fe9e15a44f01eb71f086491cd52569c86288fcfc46b2d9e8f34cd61b9f8"

URI_libfido2 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libfido2-1.14.0-7.el10.x86_64_v2.rpm;name=libfido2;unpack=0"
SRC_URI += "${URI_libfido2}"
SRC_URI[libfido2.sha256sum] = "c20d37af21563d2495f276d74b5283019a94c4e88a58ab2e029552972d04d6a7"
RDEPENDS:libfido2 = " \
 zlib-ng-compat \
 systemd-libs \
 openssl-libs \
 libcbor \
 glibc \
"

URI_fido2-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fido2-tools-1.14.0-7.el10.x86_64_v2.rpm;name=fido2-tools;unpack=0"
SRC_URI += "${URI_fido2-tools}"
SRC_URI[fido2-tools.sha256sum] = "129e7a5321475d4f29d67dc93c99a7868ac8bbd3789deaac2005c6b58230622c"
RDEPENDS:fido2-tools = " \
 zlib-ng-compat \
 libfido2 \
 openssl-libs \
 libcbor \
 glibc \
"

URI_libfido2-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libfido2-devel-1.14.0-7.el10.x86_64_v2.rpm;name=libfido2-devel;unpack=0"
SRC_URI += "${URI_libfido2-devel}"
SRC_URI[libfido2-devel.sha256sum] = "39e83d83429d8297066d89c656de3a91a7a61a3e76edc74910cf687cb7edb6a3"
RDEPENDS:libfido2-devel = " \
 libfido2 \
 openssl-devel \
 pkgconf-pkg-config \
"
