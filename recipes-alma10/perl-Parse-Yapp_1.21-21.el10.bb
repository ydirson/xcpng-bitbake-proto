# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Parse-Yapp"
PE = "0"
PV = "1.21"
PR = "21.el10"
PACKAGES = "perl-Parse-Yapp perl-Parse-Yapp-tests"
PROVIDES = "rpm/perl-Parse-Yapp rpm/perl-Parse-Yapp-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Parse-Yapp-1.21-21.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b67efeeed5c34469d363c7746b3ad8774584d4628a588459650f7c489bb086f"

URI_perl-Parse-Yapp = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Parse-Yapp-1.21-21.el10.noarch.rpm;name=perl-Parse-Yapp;unpack=0"
SRC_URI += "${URI_perl-Parse-Yapp}"
SRC_URI[perl-Parse-Yapp.sha256sum] = "ed5a151a239e3c65e8c511a6a38885f459a9c997a77ecf885bc00e689c6be518"
RDEPENDS:perl-Parse-Yapp = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-Parse-Yapp \
 perl-File-Basename \
 perl-Getopt-Std \
 perl-interpreter \
"

URI_perl-Parse-Yapp-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Parse-Yapp-tests-1.21-21.el10.noarch.rpm;name=perl-Parse-Yapp-tests;unpack=0"
SRC_URI += "${URI_perl-Parse-Yapp-tests}"
SRC_URI[perl-Parse-Yapp-tests.sha256sum] = "782629b0dbadce829843ae01fc982612255d39fab668f691a8bc2669dcec85a7"
RDEPENDS:perl-Parse-Yapp-tests = " \
 perl-interpreter \
 perl-Test-Harness \
 bash \
 perl-Parse-Yapp \
"
