# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "emacs"
PE = "1"
PV = "29.4"
PR = "10.el10_0"
PACKAGES = "emacs emacs-common emacs-filesystem emacs-lucid emacs-nw emacs-devel emacs-gtk+x11 emacs-terminal"
PROVIDES = "rpm/emacs rpm/emacs-common rpm/emacs-filesystem rpm/emacs-lucid rpm/emacs-nw rpm/emacs-devel rpm/emacs-gtk+x11 rpm/emacs-terminal"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/emacs-29.4-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "773be5a663cf5bdc39156777558e56cc044e05778730fa8c434d5b44419415a1"

URI_emacs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/emacs-29.4-10.el10_0.x86_64_v2.rpm;name=emacs;unpack=0"
SRC_URI += "${URI_emacs}"
SRC_URI[emacs.sha256sum] = "28855ba00f8110334987694ea46e1b00450eef143914dc0973afddfe7dbc9956"
RDEPENDS:emacs = " \
 systemd-libs \
 libpng \
 libtree-sitter \
 pango \
 fontconfig \
 ncurses-libs \
 dbus-libs \
 libselinux \
 libacl \
 emacs-common \
 jansson \
 libotf \
 cairo \
 alternatives \
 alsa-lib \
 zlib-ng-compat \
 gnutls \
 google-noto-sans-mono-vf-fonts \
 librsvg2 \
 libgcc \
 libwebp \
 libxml2 \
 gdk-pixbuf2 \
 sqlite-libs \
 bash \
 giflib \
 freetype \
 harfbuzz \
 glib2 \
 gtk3 \
 glibc \
 libjpeg-turbo \
 libtiff \
"

URI_emacs-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/emacs-common-29.4-10.el10_0.x86_64_v2.rpm;name=emacs-common;unpack=0"
SRC_URI += "${URI_emacs-common}"
SRC_URI[emacs-common.sha256sum] = "1a99e61f4aa57ccc7ab9d0083f51bf8e7226ade9c5970069cd7393b92c4d36cd"
RDEPENDS:emacs-common = " \
 emacs-filesystem \
 libtree-sitter \
 pkgconf-pkg-config \
 bash \
 glibc \
 alternatives \
 libgccjit \
"

URI_emacs-filesystem = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/emacs-filesystem-29.4-10.el10_0.noarch.rpm;name=emacs-filesystem;unpack=0"
SRC_URI += "${URI_emacs-filesystem}"
SRC_URI[emacs-filesystem.sha256sum] = "ad151663eebd56c4f7d0f72ffe359e74c5b8129ec50afe582506c3557ce07711"
RDEPENDS:emacs-filesystem = ""

URI_emacs-lucid = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/emacs-lucid-29.4-10.el10_0.x86_64_v2.rpm;name=emacs-lucid;unpack=0"
SRC_URI += "${URI_emacs-lucid}"
SRC_URI[emacs-lucid.sha256sum] = "7f19dc365129b8551cb8c0537b8183d9757a66bf63c6768534b40ee3408d0481"
RDEPENDS:emacs-lucid = " \
 systemd-libs \
 libpng \
 libtree-sitter \
 libICE \
 fontconfig \
 libSM \
 libX11 \
 ncurses-libs \
 dbus-libs \
 libselinux \
 libXcomposite \
 libXext \
 m17n-lib \
 libXfixes \
 libacl \
 Xaw3d \
 emacs-common \
 libXi \
 jansson \
 libXinerama \
 libXmu \
 libotf \
 libXpm \
 libXrandr \
 libXrender \
 libXt \
 cairo \
 alternatives \
 alsa-lib \
 zlib-ng-compat \
 gnutls \
 google-noto-sans-mono-vf-fonts \
 librsvg2 \
 libgcc \
 libwebp \
 libxml2 \
 gdk-pixbuf2 \
 sqlite-libs \
 bash \
 giflib \
 freetype \
 harfbuzz \
 glib2 \
 glibc \
 libjpeg-turbo \
 libtiff \
"

URI_emacs-nw = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/emacs-nw-29.4-10.el10_0.x86_64_v2.rpm;name=emacs-nw;unpack=0"
SRC_URI += "${URI_emacs-nw}"
SRC_URI[emacs-nw.sha256sum] = "e62c4da3f0c52b6e892fb813a56a039c96dbc23d6fe88fd60791721a1c498b92"
RDEPENDS:emacs-nw = " \
 alsa-lib \
 libacl \
 zlib-ng-compat \
 emacs-common \
 systemd-libs \
 gnutls \
 jansson \
 libgcc \
 libtree-sitter \
 libxml2 \
 sqlite-libs \
 bash \
 ncurses-libs \
 glibc \
 libselinux \
 dbus-libs \
 alternatives \
"

URI_emacs-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/emacs-devel-29.4-10.el10_0.x86_64_v2.rpm;name=emacs-devel;unpack=0"
SRC_URI += "${URI_emacs-devel}"
SRC_URI[emacs-devel.sha256sum] = "252c1e43cd7ad67100ea6ecb8776637fa04574ba671a5629c68fe41221a0cd61"
RDEPENDS:emacs-devel = ""

URI_emacs-gtk+x11 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/emacs-gtk+x11-29.4-10.el10_0.x86_64_v2.rpm;name=emacs-gtk+x11;unpack=0"
SRC_URI += "${URI_emacs-gtk+x11}"
SRC_URI[emacs-gtk+x11.sha256sum] = "29cb319f7ba53be117274e3dbdacbf1a4fc8daeef722c26769d118877eb3cfc0"
RDEPENDS:emacs-gtk+x11 = " \
 systemd-libs \
 libpng \
 libtree-sitter \
 libICE \
 pango \
 fontconfig \
 libX11 \
 libSM \
 ncurses-libs \
 dbus-libs \
 libselinux \
 libXcomposite \
 libXext \
 m17n-lib \
 libXfixes \
 libacl \
 emacs-common \
 libXi \
 jansson \
 libXinerama \
 libotf \
 libXrandr \
 libXrender \
 cairo \
 alternatives \
 libgccjit \
 alsa-lib \
 zlib-ng-compat \
 gnutls \
 librsvg2 \
 libgcc \
 libwebp \
 libxml2 \
 gdk-pixbuf2 \
 sqlite-libs \
 bash \
 giflib \
 freetype \
 harfbuzz \
 glib2 \
 gtk3 \
 glibc \
 libjpeg-turbo \
 libtiff \
"

URI_emacs-terminal = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/emacs-terminal-29.4-10.el10_0.noarch.rpm;name=emacs-terminal;unpack=0"
SRC_URI += "${URI_emacs-terminal}"
SRC_URI[emacs-terminal.sha256sum] = "acc99fdd900235d74ea86da09f65d44c5227dcc15656f7362a9d43916a26fe02"
RDEPENDS:emacs-terminal = " \
 emacs \
 bash \
"
