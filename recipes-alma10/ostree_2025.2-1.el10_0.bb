# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ostree"
PE = "0"
PV = "2025.2"
PR = "1.el10_0"
PACKAGES = "ostree ostree-grub2 ostree-libs ostree-devel"
PROVIDES = "rpm/ostree rpm/ostree-grub2 rpm/ostree-libs rpm/ostree-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ostree-2025.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "445884b8821a86836b05fe9fc66c3ef6d09cb8bbe062bcd7b38da6674bab03d7"

URI_ostree = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ostree-2025.2-1.el10_0.x86_64_v2.rpm;name=ostree;unpack=0"
SRC_URI += "${URI_ostree}"
SRC_URI[ostree.sha256sum] = "7ab96baf280e8e56a84b552e43a198903efb84b849a40924f2ad30061cbc4611"
RDEPENDS:ostree = " \
 ostree-libs \
 systemd \
 gnupg2 \
 systemd-libs \
 libarchive \
 fuse-libs \
 openssl-libs \
 libgcc \
 composefs \
 composefs-libs \
 bash \
 glib2 \
 dracut \
 glibc \
 libselinux \
"

URI_ostree-grub2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ostree-grub2-2025.2-1.el10_0.x86_64_v2.rpm;name=ostree-grub2;unpack=0"
SRC_URI += "${URI_ostree-grub2}"
SRC_URI[ostree-grub2.sha256sum] = "d2eef79726018a1ea88b6c95eade52f94499b1fee30c1240fed55205c8da2473"
RDEPENDS:ostree-grub2 = " \
 ostree \
 bash \
 grub2-pc \
"

URI_ostree-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ostree-libs-2025.2-1.el10_0.x86_64_v2.rpm;name=ostree-libs;unpack=0"
SRC_URI += "${URI_ostree-libs}"
SRC_URI[ostree-libs.sha256sum] = "70e50b742f5e35c4657605b00421fc90b9e64a7ff40c9046267b0611efbd1c92"
RDEPENDS:ostree-libs = " \
 zlib-ng-compat \
 systemd-libs \
 libarchive \
 openssl-libs \
 libgcc \
 gpgme \
 libmount \
 libgpg-error \
 composefs-libs \
 glib2 \
 libcurl \
 glibc \
 libselinux \
 xz-libs \
"

URI_ostree-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ostree-devel-2025.2-1.el10_0.x86_64_v2.rpm;name=ostree-devel;unpack=0"
SRC_URI += "${URI_ostree-devel}"
SRC_URI[ostree-devel.sha256sum] = "6693a911b7e08b69eb451b3a9e6f6d41a4df2f321b3b923caa18b408da402572"
RDEPENDS:ostree-devel = " \
 ostree-libs \
 gpgme-devel \
 libarchive-devel \
 glib2-devel \
 xz-devel \
 systemd-devel \
 zlib-ng-compat-devel \
 composefs-devel \
 libgpg-error-devel \
 pkgconf-pkg-config \
 openssl-devel \
 libselinux-devel \
 libcurl-devel \
"
