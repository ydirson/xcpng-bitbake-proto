# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "crypto-policies"
PE = "0"
PV = "20250214"
PR = "1.gitfd9b9b9.el10_0.1"
PACKAGES = "crypto-policies crypto-policies-scripts crypto-policies-pq-preview"
PROVIDES = "rpm/crypto-policies rpm/crypto-policies-scripts rpm/crypto-policies-pq-preview"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/crypto-policies-20250214-1.gitfd9b9b9.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "abe2493fc44988741c068f0e45d693f53277e350bff1203b07d0ce451d4f7494"

URI_crypto-policies = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/crypto-policies-20250214-1.gitfd9b9b9.el10_0.1.noarch.rpm;name=crypto-policies;unpack=0"
SRC_URI += "${URI_crypto-policies}"
SRC_URI[crypto-policies.sha256sum] = "401300e086e07e8209d25fbc25aaea8ce749a4f9595b623c7509239eebe3f693"
RDEPENDS:crypto-policies = " \
 bash \
"

URI_crypto-policies-scripts = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/crypto-policies-scripts-20250214-1.gitfd9b9b9.el10_0.1.noarch.rpm;name=crypto-policies-scripts;unpack=0"
SRC_URI += "${URI_crypto-policies-scripts}"
SRC_URI[crypto-policies-scripts.sha256sum] = "8893abd142afaa061530e1d029164b4a8b3eb05758d8fc4958340174aad88e4c"
RDEPENDS:crypto-policies-scripts = " \
 python3 \
 crypto-policies \
 bash \
"

URI_crypto-policies-pq-preview = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/crypto-policies-pq-preview-20250214-1.gitfd9b9b9.el10_0.1.noarch.rpm;name=crypto-policies-pq-preview;unpack=0"
SRC_URI += "${URI_crypto-policies-pq-preview}"
SRC_URI[crypto-policies-pq-preview.sha256sum] = "5d23a1aaf06a4a8835357fa74889fb3fae1427fa87d9680cc09ed61fb316c689"
RDEPENDS:crypto-policies-pq-preview = " \
 crypto-policies \
 oqsprovider \
 liboqs \
"
