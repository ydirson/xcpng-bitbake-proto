# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qatlib"
PE = "0"
PV = "24.09.0"
PR = "2.el10"
PACKAGES = "qatlib qatlib-service qatlib-devel qatlib-tests"
PROVIDES = "rpm/qatlib rpm/qatlib-service rpm/qatlib-devel rpm/qatlib-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qatlib-24.09.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cbf0a4a237d4791dfd43a69ba29e59d9bc188a4b29ef8ed47bc9ce1108459f98"

URI_qatlib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qatlib-24.09.0-2.el10.x86_64_v2.rpm;name=qatlib;unpack=0"
SRC_URI += "${URI_qatlib}"
SRC_URI[qatlib.sha256sum] = "2140789384d762eddbdf25f18d5440fda732048d29022137ec98a2b534a8f2bf"
RDEPENDS:qatlib = " \
 shadow-utils \
 numactl-libs \
 openssl-libs \
 bash \
 glibc \
"

URI_qatlib-service = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qatlib-service-24.09.0-2.el10.x86_64_v2.rpm;name=qatlib-service;unpack=0"
SRC_URI += "${URI_qatlib-service}"
SRC_URI[qatlib-service.sha256sum] = "8e319d7b6888d437c87efc09bd1ddf1c7554d55385cca017764e7061bde32675"
RDEPENDS:qatlib-service = " \
 qatlib \
 systemd \
 numactl-libs \
 pciutils \
 bash \
 glibc \
"

URI_qatlib-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qatlib-devel-24.09.0-2.el10.x86_64_v2.rpm;name=qatlib-devel;unpack=0"
SRC_URI += "${URI_qatlib-devel}"
SRC_URI[qatlib-devel.sha256sum] = "64834307ffd57f37e0c4ef5ffe046e66b04e4b12d8f7ba671bb9ac1a26ee4865"
RDEPENDS:qatlib-devel = " \
 qatlib-devel \
 openssl-devel \
 qatlib \
 pkgconf-pkg-config \
"

URI_qatlib-tests = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qatlib-tests-24.09.0-2.el10.x86_64_v2.rpm;name=qatlib-tests;unpack=0"
SRC_URI += "${URI_qatlib-tests}"
SRC_URI[qatlib-tests.sha256sum] = "b5e1cfa2e1d1ae0769373c31b6f214bb93cb7ce5b9572ab6d9e207e11cc81c80"
RDEPENDS:qatlib-tests = " \
 glibc \
 openssl-libs \
 zlib-ng-compat \
 qatlib \
"
