# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-pluggy"
PE = "0"
PV = "1.3.0"
PR = "5.el10"
PACKAGES = "python3-pluggy"
PROVIDES = "rpm/python3-pluggy"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/python-pluggy-1.3.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2a2d579428e71fb5b0421eed8bb4b27c126f0a3bb03ecafb5008c0590c6f299"

URI_python3-pluggy = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-pluggy-1.3.0-5.el10.noarch.rpm;name=python3-pluggy;unpack=0"
SRC_URI += "${URI_python3-pluggy}"
SRC_URI[python3-pluggy.sha256sum] = "6c715f64aecb9b35c0f04d33633d2e0bd9be534b9e0b5951d6b462d409a58455"
RDEPENDS:python3-pluggy = " \
 python3 \
"
