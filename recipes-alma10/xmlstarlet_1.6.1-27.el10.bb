# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xmlstarlet"
PE = "0"
PV = "1.6.1"
PR = "27.el10"
PACKAGES = "xmlstarlet"
PROVIDES = "rpm/xmlstarlet"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xmlstarlet-1.6.1-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1deca509e1f94c23acbad31112a13d3f384616f09e49ca98b143183f375c92b4"

URI_xmlstarlet = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xmlstarlet-1.6.1-27.el10.x86_64_v2.rpm;name=xmlstarlet;unpack=0"
SRC_URI += "${URI_xmlstarlet}"
SRC_URI[xmlstarlet.sha256sum] = "365d2b8340a2a9bb0324a1f2f1306eac35fbf45a9fe863c3ad41ee3d5031b192"
RDEPENDS:xmlstarlet = " \
 glibc \
 libxslt \
 libxml2 \
"
