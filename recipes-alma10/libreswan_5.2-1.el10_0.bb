# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libreswan"
PE = "0"
PV = "5.2"
PR = "1.el10_0"
PACKAGES = "libreswan"
PROVIDES = "rpm/libreswan"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libreswan-5.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "defa519dc81d9de9bb55bd6a699ffb7863a7051ab45c55455ceddf959835c00e"

URI_libreswan = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libreswan-5.2-1.el10_0.x86_64_v2.rpm;name=libreswan;unpack=0"
SRC_URI += "${URI_libreswan}"
SRC_URI[libreswan.sha256sum] = "27bc52ab502708ef096b32cb56775fe4e85724983dff1aad65c868ba25244e12"
RDEPENDS:libreswan = " \
 systemd \
 nss \
 ldns \
 nss-softokn \
 iproute \
 unbound-libs \
 nss-tools \
 nss-util \
 procps-ng \
 libseccomp \
 libselinux \
 libcap-ng \
 libcurl \
 openldap \
 libevent \
 libxcrypt \
 audit-libs \
 libgcc \
 pam-libs \
 bash \
 logrotate \
 glibc \
 coreutils \
 nspr \
"
