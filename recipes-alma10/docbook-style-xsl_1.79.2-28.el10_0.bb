# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "docbook-style-xsl"
PE = "0"
PV = "1.79.2"
PR = "28.el10_0"
PACKAGES = "docbook-style-xsl"
PROVIDES = "rpm/docbook-style-xsl"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/docbook-style-xsl-1.79.2-28.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59865e5744bd444fe2656b9dc684038419a2e713abb81687226d943ceaeb95dd"

URI_docbook-style-xsl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/docbook-style-xsl-1.79.2-28.el10_0.noarch.rpm;name=docbook-style-xsl;unpack=0"
SRC_URI += "${URI_docbook-style-xsl}"
SRC_URI[docbook-style-xsl.sha256sum] = "0b3abfed4089a673894ec586c20b2ef5de05c038f56190f7a124aaa9751c6513"
RDEPENDS:docbook-style-xsl = " \
 xml-common \
 bash \
 libxml2 \
 docbook-dtds \
"
