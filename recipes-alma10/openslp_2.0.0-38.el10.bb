# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "openslp"
PE = "0"
PV = "2.0.0"
PR = "38.el10"
PACKAGES = "openslp openslp-devel openslp-server"
PROVIDES = "rpm/openslp rpm/openslp-devel rpm/openslp-server"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/openslp-2.0.0-38.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07368c609e29b862a96bc66251bf602671b8b35e3fa223144c17ceb6d1613a7d"

URI_openslp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/openslp-2.0.0-38.el10.x86_64_v2.rpm;name=openslp;unpack=0"
SRC_URI += "${URI_openslp}"
SRC_URI[openslp.sha256sum] = "618f4666f7a9622bf1414e707de965dff7a2d3a3a9be305c59137aae2acb45ba"
RDEPENDS:openslp = " \
 glibc \
"

URI_openslp-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/openslp-devel-2.0.0-38.el10.x86_64_v2.rpm;name=openslp-devel;unpack=0"
SRC_URI += "${URI_openslp-devel}"
SRC_URI[openslp-devel.sha256sum] = "c8af425911501fa7f2f178ff8d15866ed780827284757e2335d6f530ac0522b6"
RDEPENDS:openslp-devel = " \
 openslp \
"

URI_openslp-server = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/openslp-server-2.0.0-38.el10.x86_64_v2.rpm;name=openslp-server;unpack=0"
SRC_URI += "${URI_openslp-server}"
SRC_URI[openslp-server.sha256sum] = "d9508c68cada13df11515343e209b618aee0b464f64bcf5f3a6e6802b7860856"
RDEPENDS:openslp-server = " \
 systemd-libs \
 iproute \
 openslp \
 bash \
 glibc \
"
