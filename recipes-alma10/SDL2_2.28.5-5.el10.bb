# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "SDL2"
PE = "0"
PV = "2.28.5"
PR = "5.el10"
PACKAGES = "SDL2 SDL2-devel SDL2-static"
PROVIDES = "rpm/SDL2 rpm/SDL2-devel rpm/SDL2-static"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/SDL2-2.28.5-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62fad36f40b223b40314f4be328f14ddf9880496136772b1ea08780b4f146712"

URI_SDL2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/SDL2-2.28.5-5.el10.x86_64_v2.rpm;name=SDL2;unpack=0"
SRC_URI += "${URI_SDL2}"
SRC_URI[SDL2.sha256sum] = "24672c9933d69443d72ad9a9e41b3a7847850d1e96dc57729485413eba7efb99"
RDEPENDS:SDL2 = " \
 glibc \
 libdecor \
"

URI_SDL2-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/SDL2-devel-2.28.5-5.el10.x86_64_v2.rpm;name=SDL2-devel;unpack=0"
SRC_URI += "${URI_SDL2-devel}"
SRC_URI[SDL2-devel.sha256sum] = "7bc0ad7871bdb387284875f118260fde7fcf9bf90bab6f7b29c2e82ad12e250c"
RDEPENDS:SDL2-devel = " \
 cmake-filesystem \
 libglvnd-devel \
 pkgconf-pkg-config \
 mesa-libEGL-devel \
 libX11-devel \
 bash \
 SDL2 \
"

URI_SDL2-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/SDL2-static-2.28.5-5.el10.x86_64_v2.rpm;name=SDL2-static;unpack=0"
SRC_URI += "${URI_SDL2-static}"
SRC_URI[SDL2-static.sha256sum] = "320edf2d19642255f593353ed034a397b57d879634360e16a5b2aaa81251b057"
RDEPENDS:SDL2-static = " \
 SDL2-devel \
"
