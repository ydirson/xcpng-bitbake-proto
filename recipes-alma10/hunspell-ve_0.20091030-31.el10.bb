# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-ve"
PE = "0"
PV = "0.20091030"
PR = "31.el10"
PACKAGES = "hunspell-ve"
PROVIDES = "rpm/hunspell-ve"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-ve-0.20091030-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "08fdab09b3ad3263042e426f4a9d3158551c2c173020f801e4f4b9e8c7f788c0"

URI_hunspell-ve = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-ve-0.20091030-31.el10.noarch.rpm;name=hunspell-ve;unpack=0"
SRC_URI += "${URI_hunspell-ve}"
SRC_URI[hunspell-ve.sha256sum] = "d74009bd9542b025a37828249026887fe2fd7691fe237c430bd7770e4d3c85ea"
RDEPENDS:hunspell-ve = " \
 hunspell-filesystem \
"
