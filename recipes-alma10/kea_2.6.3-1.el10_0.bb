# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "kea"
PE = "0"
PV = "2.6.3"
PR = "1.el10_0"
PACKAGES = "kea kea-libs kea-doc kea-hooks kea-keama kea-devel"
PROVIDES = "rpm/kea rpm/kea-libs rpm/kea-doc rpm/kea-hooks rpm/kea-keama rpm/kea-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/kea-2.6.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97d13231468132bc81b4197f0601953e4a1a86a58208ffd18c54adda124d9547"

URI_kea = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kea-2.6.3-1.el10_0.x86_64_v2.rpm;name=kea;unpack=0"
SRC_URI += "${URI_kea}"
SRC_URI[kea.sha256sum] = "ebc0cab64755d5cc3ecff197789165e4825b50242609e4be87f6a4e655c46b39"
RDEPENDS:kea = " \
 python3 \
 shadow-utils \
 systemd \
 util-linux \
 libgcc \
 openssl-libs \
 libstdc++ \
 bash \
 kea-libs \
 glibc \
 coreutils \
"

URI_kea-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kea-libs-2.6.3-1.el10_0.x86_64_v2.rpm;name=kea-libs;unpack=0"
SRC_URI += "${URI_kea-libs}"
SRC_URI[kea-libs.sha256sum] = "ea5486fff0f9949ebcb54f480b9c0d84cc2c6474e78aabe86748f600f87ebd60"
RDEPENDS:kea-libs = " \
 libpq \
 openssl-libs \
 libgcc \
 libstdc++ \
 mariadb-connector-c \
 glibc \
 boost-system \
 log4cplus \
"

URI_kea-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/kea-doc-2.6.3-1.el10_0.noarch.rpm;name=kea-doc;unpack=0"
SRC_URI += "${URI_kea-doc}"
SRC_URI[kea-doc.sha256sum] = "ab452a69b5f245b954d573ecd533f02e48f97330ace10abf6066632e389e1bb3"
RDEPENDS:kea-doc = ""

URI_kea-hooks = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/kea-hooks-2.6.3-1.el10_0.x86_64_v2.rpm;name=kea-hooks;unpack=0"
SRC_URI += "${URI_kea-hooks}"
SRC_URI[kea-hooks.sha256sum] = "88e75cedec3e34b3aaf7b6d24f16fc7fbde1f010429f0cbade628ac10bd1e817"
RDEPENDS:kea-hooks = " \
 libpq \
 openssl-libs \
 libgcc \
 mariadb-connector-c \
 kea-libs \
 glibc \
 boost-system \
 log4cplus \
"

URI_kea-keama = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/kea-keama-2.6.3-1.el10_0.x86_64_v2.rpm;name=kea-keama;unpack=0"
SRC_URI += "${URI_kea-keama}"
SRC_URI[kea-keama.sha256sum] = "e5356d0455482c61a3f83b529a9df63b46b86eebf1db32a8e34f37d9eaef347c"
RDEPENDS:kea-keama = " \
 glibc \
"

URI_kea-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/kea-devel-2.6.3-1.el10_0.x86_64_v2.rpm;name=kea-devel;unpack=0"
SRC_URI += "${URI_kea-devel}"
SRC_URI[kea-devel.sha256sum] = "204a473a990f67fe84087cde3ebecd82e181a31f488aa9cf616959306ae2873e"
RDEPENDS:kea-devel = " \
 openssl-devel \
 pkgconf-pkg-config \
 kea-libs \
 boost-devel \
"
