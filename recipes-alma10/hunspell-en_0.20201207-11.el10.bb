# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-en"
PE = "0"
PV = "0.20201207"
PR = "11.el10"
PACKAGES = "hunspell-en hunspell-en-GB hunspell-en-US"
PROVIDES = "rpm/hunspell-en rpm/hunspell-en-GB rpm/hunspell-en-US"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-en-0.20201207-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d441698d6dad3bc200b813361ffc19da3da9a68ae0b05da491ed185875f781d1"

URI_hunspell-en = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-en-0.20201207-11.el10.noarch.rpm;name=hunspell-en;unpack=0"
SRC_URI += "${URI_hunspell-en}"
SRC_URI[hunspell-en.sha256sum] = "cb44aaa16dbc1d37f5a919d49b767750f5a5303ca62d8c978621c66f2bff0cbe"
RDEPENDS:hunspell-en = " \
 hunspell-en-GB \
 hunspell-en-US \
 hunspell \
"

URI_hunspell-en-GB = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-en-GB-0.20201207-11.el10.noarch.rpm;name=hunspell-en-GB;unpack=0"
SRC_URI += "${URI_hunspell-en-GB}"
SRC_URI[hunspell-en-GB.sha256sum] = "c0c373bf981cb5f1798a71c74d6f0435f6e35b23ab8f13133f8e00b650b6ab51"
RDEPENDS:hunspell-en-GB = " \
 hunspell-filesystem \
 hunspell \
"

URI_hunspell-en-US = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-en-US-0.20201207-11.el10.noarch.rpm;name=hunspell-en-US;unpack=0"
SRC_URI += "${URI_hunspell-en-US}"
SRC_URI[hunspell-en-US.sha256sum] = "70180e88547e3baef51fcb9d9708c4a10a84a2f602721f8a28b19cb409ef6a77"
RDEPENDS:hunspell-en-US = " \
 hunspell-filesystem \
 hunspell \
"
