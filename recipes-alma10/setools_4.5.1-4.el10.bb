# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "setools"
PE = "0"
PV = "4.5.1"
PR = "4.el10"
PACKAGES = "python3-setools setools-console setools setools-console-analyses setools-gui"
PROVIDES = "rpm/python3-setools rpm/setools-console rpm/setools rpm/setools-console-analyses rpm/setools-gui"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/setools-4.5.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f6beb66c0c6e5fb91f4589c21bcd2b14367df6ce4b05e7b60e76c04360e4f8e"

URI_python3-setools = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-setools-4.5.1-4.el10.x86_64_v2.rpm;name=python3-setools;unpack=0"
SRC_URI += "${URI_python3-setools}"
SRC_URI[python3-setools.sha256sum] = "5a64fc5b6983abf2cb32ec3d5e75590cd8dd1f854bfc492a7c254a95baa8fda1"
RDEPENDS:python3-setools = " \
 python3 \
 python3-setuptools \
 glibc \
 libselinux \
 libsepol \
"

URI_setools-console = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/setools-console-4.5.1-4.el10.x86_64_v2.rpm;name=setools-console;unpack=0"
SRC_URI += "${URI_setools-console}"
SRC_URI[setools-console.sha256sum] = "e4ac9d7c936ad54524139e1550dbeef1325dd6e90a01d4bc273670b6b8289b7f"
RDEPENDS:setools-console = " \
 python3 \
 libselinux \
 python3-setools \
"

URI_setools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/setools-4.5.1-4.el10.x86_64_v2.rpm;name=setools;unpack=0"
SRC_URI += "${URI_setools}"
SRC_URI[setools.sha256sum] = "eccc36e4677cf1da9cf6825bc4580a8c0dd6a3a76b8ffcfcff5b9a3faa497476"
RDEPENDS:setools = " \
 setools-console-analyses \
 setools-gui \
 setools-console \
"

URI_setools-console-analyses = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/setools-console-analyses-4.5.1-4.el10.x86_64_v2.rpm;name=setools-console-analyses;unpack=0"
SRC_URI += "${URI_setools-console-analyses}"
SRC_URI[setools-console-analyses.sha256sum] = "5792fabc2405f70b43fd54a84bae342cd0e24838c2ddf1f4e7a5564660c94331"
RDEPENDS:setools-console-analyses = " \
 python3 \
 libselinux \
 python3-networkx \
 python3-setools \
"

URI_setools-gui = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/setools-gui-4.5.1-4.el10.x86_64_v2.rpm;name=setools-gui;unpack=0"
SRC_URI += "${URI_setools-gui}"
SRC_URI[setools-gui.sha256sum] = "eedf7c6696c2f34dd49c1f6b3a2a73375b00307b33b782b7f986518a40229529"
RDEPENDS:setools-gui = " \
 python3 \
 python3-pyqt6 \
 python3-setools \
 python3-pyqt6-sip \
 python3-networkx \
"
