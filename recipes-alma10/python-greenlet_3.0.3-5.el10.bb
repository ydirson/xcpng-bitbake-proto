# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-greenlet"
PE = "0"
PV = "3.0.3"
PR = "5.el10"
PACKAGES = "python3-greenlet python3-greenlet-devel"
PROVIDES = "rpm/python3-greenlet rpm/python3-greenlet-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-greenlet-3.0.3-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50fb28e565f9b43ee411681cf28b62f5be1a0b9e0c080829a6852022922bcc2e"

URI_python3-greenlet = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-greenlet-3.0.3-5.el10.x86_64_v2.rpm;name=python3-greenlet;unpack=0"
SRC_URI += "${URI_python3-greenlet}"
SRC_URI[python3-greenlet.sha256sum] = "0d0300ea363b6226c48918c63c837d40c65bdace2929545d68f391209984721f"
RDEPENDS:python3-greenlet = " \
 glibc \
 python3 \
 libgcc \
 libstdc++ \
"

URI_python3-greenlet-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-greenlet-devel-3.0.3-5.el10.x86_64_v2.rpm;name=python3-greenlet-devel;unpack=0"
SRC_URI += "${URI_python3-greenlet-devel}"
SRC_URI[python3-greenlet-devel.sha256sum] = "a25f42e17050b0e5751089e0de567a92ddfc6e43c9a10da0633cf0bc1d605315"
RDEPENDS:python3-greenlet-devel = " \
 python3-greenlet \
"
