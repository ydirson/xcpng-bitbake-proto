# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "apache-commons-net"
PE = "0"
PV = "3.10.0"
PR = "6.el10"
PACKAGES = "apache-commons-net apache-commons-net-javadoc"
PROVIDES = "rpm/apache-commons-net rpm/apache-commons-net-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/apache-commons-net-3.10.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "112cfb77da5ba6211253ae634de4260cffc749094d6f2c61d83bfbf4c072756f"

URI_apache-commons-net = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/apache-commons-net-3.10.0-6.el10.noarch.rpm;name=apache-commons-net;unpack=0"
SRC_URI += "${URI_apache-commons-net}"
SRC_URI[apache-commons-net.sha256sum] = "c0969edda9a00ea4295604555bbb84f3c1638403c72f9e9a856f0c19b4fd7640"
RDEPENDS:apache-commons-net = " \
 javapackages-filesystem \
"

URI_apache-commons-net-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/apache-commons-net-javadoc-3.10.0-6.el10.noarch.rpm;name=apache-commons-net-javadoc;unpack=0"
SRC_URI += "${URI_apache-commons-net-javadoc}"
SRC_URI[apache-commons-net-javadoc.sha256sum] = "dd569c470bd314cda672bf9a03ce7037880daf2c0c6620ca1b7db39b6bf61ab5"
RDEPENDS:apache-commons-net-javadoc = " \
 javapackages-filesystem \
"
