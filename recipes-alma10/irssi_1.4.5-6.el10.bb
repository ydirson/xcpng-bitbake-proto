# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "irssi"
PE = "0"
PV = "1.4.5"
PR = "6.el10"
PACKAGES = "irssi irssi-devel"
PROVIDES = "rpm/irssi rpm/irssi-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/irssi-1.4.5-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d47c1e013b9aea85642755d97207bc33e0a47c5c657d9eaf7a73b5e36b4bb02a"

URI_irssi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/irssi-1.4.5-6.el10.x86_64_v2.rpm;name=irssi;unpack=0"
SRC_URI += "${URI_irssi}"
SRC_URI[irssi.sha256sum] = "7b9b88d4f0674c6eee12979e2b329a36a774122d9f1382a763c20efd7d837c1e"
RDEPENDS:irssi = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 libxcrypt \
 openssl-libs \
 utf8proc \
 perl-DynaLoader \
 perl-Symbol \
 ncurses-libs \
 glib2 \
 glibc \
 perl-Exporter \
 perl-lib \
"

URI_irssi-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/irssi-devel-1.4.5-6.el10.x86_64_v2.rpm;name=irssi-devel;unpack=0"
SRC_URI += "${URI_irssi-devel}"
SRC_URI[irssi-devel.sha256sum] = "c5a35f30ab739be90bb9eb6631e0e8e88d4cee4303ef96daf6d0f500d0faf39a"
RDEPENDS:irssi-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 irssi \
"
