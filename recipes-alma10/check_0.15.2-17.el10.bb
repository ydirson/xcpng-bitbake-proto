# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "check"
PE = "0"
PV = "0.15.2"
PR = "17.el10"
PACKAGES = "check check-devel check-static check-checkmk"
PROVIDES = "rpm/check rpm/check-devel rpm/check-static rpm/check-checkmk"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/check-0.15.2-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b92715dcfa1435765e72f6f131fb09c187fa25fa91d00adaf39aecf4a8b4a107"

URI_check = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/check-0.15.2-17.el10.x86_64_v2.rpm;name=check;unpack=0"
SRC_URI += "${URI_check}"
SRC_URI[check.sha256sum] = "09fb2a4ca896d80a4d3771d121193e0d124a81f136b9be6acbb6a4f3f23003e2"
RDEPENDS:check = " \
 glibc \
 libgcc \
"

URI_check-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/check-devel-0.15.2-17.el10.x86_64_v2.rpm;name=check-devel;unpack=0"
SRC_URI += "${URI_check-devel}"
SRC_URI[check-devel.sha256sum] = "d62b89314548503ebb36f10566c715949b126c905c0f3e1879d7e32d6272df3b"
RDEPENDS:check-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 check-static \
 check \
"

URI_check-static = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/check-static-0.15.2-17.el10.x86_64_v2.rpm;name=check-static;unpack=0"
SRC_URI += "${URI_check-static}"
SRC_URI[check-static.sha256sum] = "7c771dba2078f4e2bce91c35914f88131ac56e1fb29cc892ec71b3f2022b37ae"
RDEPENDS:check-static = ""

URI_check-checkmk = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/check-checkmk-0.15.2-17.el10.noarch.rpm;name=check-checkmk;unpack=0"
SRC_URI += "${URI_check-checkmk}"
SRC_URI[check-checkmk.sha256sum] = "3513810989fdbbb3982b3d3286ac6930949cffa218f40e8e56c31830016cf6af"
RDEPENDS:check-checkmk = " \
 gawk \
 check \
"
