# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "debugedit"
PE = "0"
PV = "5.1"
PR = "5.el10_0"
PACKAGES = "debugedit"
PROVIDES = "rpm/debugedit"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/debugedit-5.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e0e2ca44e3226105b75f7fe39acc536e5017bdf247d174ec07365548a3469ab"

URI_debugedit = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/debugedit-5.1-5.el10_0.x86_64_v2.rpm;name=debugedit;unpack=0"
SRC_URI += "${URI_debugedit}"
SRC_URI[debugedit.sha256sum] = "259db6e58ab8587863b8308391f61453ec3e706ebfa6c9c7f878e46592db02e8"
RDEPENDS:debugedit = " \
 elfutils \
 gdb-headless \
 gawk \
 grep \
 elfutils-libelf \
 dwz \
 elfutils-libs \
 bash \
 binutils \
 xz \
 glibc \
 coreutils \
 sed \
 findutils \
"
