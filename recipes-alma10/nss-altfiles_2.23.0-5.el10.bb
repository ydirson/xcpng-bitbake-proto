# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "nss-altfiles"
PE = "0"
PV = "2.23.0"
PR = "5.el10"
PACKAGES = "nss-altfiles"
PROVIDES = "rpm/nss-altfiles"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/nss-altfiles-2.23.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d8310bacd8077022e5dd9c19c73e15953faca4383e1374dfa0593b62ac236ad"

URI_nss-altfiles = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nss-altfiles-2.23.0-5.el10.x86_64_v2.rpm;name=nss-altfiles;unpack=0"
SRC_URI += "${URI_nss-altfiles}"
SRC_URI[nss-altfiles.sha256sum] = "10b10bd24eec783b73722ce4ef5920fa4918dcaf7ab675a7d5e83c666b333340"
RDEPENDS:nss-altfiles = " \
 glibc \
"
