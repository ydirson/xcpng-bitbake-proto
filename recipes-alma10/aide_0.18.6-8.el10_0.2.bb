# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "aide"
PE = "0"
PV = "0.18.6"
PR = "8.el10_0.2"
PACKAGES = "aide"
PROVIDES = "rpm/aide"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/aide-0.18.6-8.el10_0.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5f1ccfb4ec5564f2c48dc89e8cbf2cfc8b5e694d401c67888700e8a7658303e"

URI_aide = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/aide-0.18.6-8.el10_0.2.x86_64_v2.rpm;name=aide;unpack=0"
SRC_URI += "${URI_aide}"
SRC_URI[aide.sha256sum] = "103b624f7a98ad193fc21dc82e6bab602844c5c198eb6f32f9d02ea5dc326471"
RDEPENDS:aide = " \
 libacl \
 zlib-ng-compat \
 e2fsprogs-libs \
 gnutls \
 audit-libs \
 pcre2 \
 libcurl \
 glibc \
 libselinux \
"
