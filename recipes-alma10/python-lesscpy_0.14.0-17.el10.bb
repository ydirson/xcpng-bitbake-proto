# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-lesscpy"
PE = "0"
PV = "0.14.0"
PR = "17.el10"
PACKAGES = "python3-lesscpy"
PROVIDES = "rpm/python3-lesscpy"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/python-lesscpy-0.14.0-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f943749b460728e840f0df3899f1d7ef5eafef5a016f4d4d1be67bd03b6af950"

URI_python3-lesscpy = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-lesscpy-0.14.0-17.el10.noarch.rpm;name=python3-lesscpy;unpack=0"
SRC_URI += "${URI_python3-lesscpy}"
SRC_URI[python3-lesscpy.sha256sum] = "c9bb11e36b6e39cab2845c4529d0227522bbc4aef4a3bb78658a01c051c84254"
RDEPENDS:python3-lesscpy = " \
 python3 \
 python3-six \
 python3-ply \
"
