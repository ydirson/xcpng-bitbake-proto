# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libpfm"
PE = "0"
PV = "4.13.0"
PR = "10.el10"
PACKAGES = "libpfm libpfm-devel python3-libpfm libpfm-static"
PROVIDES = "rpm/libpfm rpm/libpfm-devel rpm/python3-libpfm rpm/libpfm-static"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libpfm-4.13.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2eb240321a167fcc3435d09d9a99326e03406df36ccca19e4e9d1550dcca1fcb"

URI_libpfm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libpfm-4.13.0-10.el10.x86_64_v2.rpm;name=libpfm;unpack=0"
SRC_URI += "${URI_libpfm}"
SRC_URI[libpfm.sha256sum] = "adbc4e1d3d76aca2b8017e6b11e5912ba4de5ba0f45964f50c672e88aa5a1470"
RDEPENDS:libpfm = " \
 glibc \
"

URI_libpfm-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libpfm-devel-4.13.0-10.el10.x86_64_v2.rpm;name=libpfm-devel;unpack=0"
SRC_URI += "${URI_libpfm-devel}"
SRC_URI[libpfm-devel.sha256sum] = "b6963990c165dce3ff98598c460aac184d115cbe5a775d742a0409bb73daff9c"
RDEPENDS:libpfm-devel = " \
 libpfm \
"

URI_python3-libpfm = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-libpfm-4.13.0-10.el10.x86_64_v2.rpm;name=python3-libpfm;unpack=0"
SRC_URI += "${URI_python3-libpfm}"
SRC_URI[python3-libpfm.sha256sum] = "9cee6a1fdf3aaf68f0993f21de7e67e536ac287d066d731dc674bf7531635c79"
RDEPENDS:python3-libpfm = " \
 glibc \
 python3 \
 libpfm \
"

URI_libpfm-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libpfm-static-4.13.0-10.el10.x86_64_v2.rpm;name=libpfm-static;unpack=0"
SRC_URI += "${URI_libpfm-static}"
SRC_URI[libpfm-static.sha256sum] = "ed76ac58176136398650e52d473d40efba599a0ec953de8d21e8ee4950e66113"
RDEPENDS:libpfm-static = " \
 libpfm \
"
