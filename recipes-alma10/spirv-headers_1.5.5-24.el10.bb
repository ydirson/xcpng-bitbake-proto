# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "spirv-headers"
PE = "0"
PV = "1.5.5"
PR = "24.el10"
PACKAGES = "spirv-headers-devel"
PROVIDES = "rpm/spirv-headers-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/spirv-headers-1.5.5-24.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45db000de25dc937a5083e40f4d75361f652d06d2ffb1d143c36a5cd9684950e"

URI_spirv-headers-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/spirv-headers-devel-1.5.5-24.el10.noarch.rpm;name=spirv-headers-devel;unpack=0"
SRC_URI += "${URI_spirv-headers-devel}"
SRC_URI[spirv-headers-devel.sha256sum] = "643130840a8db7afa28efe1b34687666da6962b75665834adce2822f12ee9e8d"
RDEPENDS:spirv-headers-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
"
