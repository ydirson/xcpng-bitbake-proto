# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-IO-All"
PE = "0"
PV = "0.87"
PR = "26.el10"
PACKAGES = "perl-IO-All perl-IO-All-tests"
PROVIDES = "rpm/perl-IO-All rpm/perl-IO-All-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-IO-All-0.87-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6db17b8667e9868b4b9e76bf5953ddc2701fef5952538637a61944fc6f58b43c"

URI_perl-IO-All = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-IO-All-0.87-26.el10.noarch.rpm;name=perl-IO-All;unpack=0"
SRC_URI += "${URI_perl-IO-All}"
SRC_URI[perl-IO-All.sha256sum] = "d2069fc8ecb6cefcc7d473c8adaad1f5954913ca7093c06f4e2188f98bdc6168"
RDEPENDS:perl-IO-All = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-IO \
 perl-File-ReadBackwards \
 perl-Fcntl \
 perl-POSIX \
 perl-overload \
 perl-File-Copy \
 perl-PathTools \
 perl-Symbol \
 perl-Tie-File \
 perl-File-MimeInfo \
 perl-File-Path \
 perl-IO-All \
"

URI_perl-IO-All-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-IO-All-tests-0.87-26.el10.noarch.rpm;name=perl-IO-All-tests;unpack=0"
SRC_URI += "${URI_perl-IO-All-tests}"
SRC_URI[perl-IO-All-tests.sha256sum] = "f937395e920000422666596af28facd0458bdb26effae206c8a37b1538075d81"
RDEPENDS:perl-IO-All-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-vars \
 perl-IO \
 perl-diagnostics \
 perl-FindBin \
 perl-File-Temp \
 bash \
 perl-PathTools \
 perl-base \
 perl-IO-All \
 perl-interpreter \
 perl-File-Path \
 perl-Data-Dumper \
 perl-Exporter \
 perl-lib \
 perl-Test-Pod \
"
