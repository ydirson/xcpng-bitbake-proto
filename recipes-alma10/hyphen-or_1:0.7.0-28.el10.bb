# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-or"
PE = "1"
PV = "0.7.0"
PR = "28.el10"
PACKAGES = "hyphen-or"
PROVIDES = "rpm/hyphen-or"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-or-0.7.0-28.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7821e31ca0cf72b23a483fd60fffc9524e2a79bbf8240ceb5d58c1e4d5502705"

URI_hyphen-or = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-or-0.7.0-28.el10.noarch.rpm;name=hyphen-or;unpack=0"
SRC_URI += "${URI_hyphen-or}"
SRC_URI[hyphen-or.sha256sum] = "ad35f67267b2712117ad38384cc71b441d211848dda39aa0b9508faf412e782e"
RDEPENDS:hyphen-or = " \
 hyphen \
"
