# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jaxb-istack-commons"
PE = "0"
PV = "4.2.0"
PR = "9.el10"
PACKAGES = "jaxb-istack-commons-runtime jaxb-istack-commons-tools jaxb-istack-commons-maven-plugin jaxb-istack-commons-test"
PROVIDES = "rpm/jaxb-istack-commons-runtime rpm/jaxb-istack-commons-tools rpm/jaxb-istack-commons-maven-plugin rpm/jaxb-istack-commons-test"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/jaxb-istack-commons-4.2.0-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0dd76af80e1c8e9c46fb550846eff43cfcaec5145c0117fd711cc6d9f988d639"

URI_jaxb-istack-commons-runtime = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jaxb-istack-commons-runtime-4.2.0-9.el10.noarch.rpm;name=jaxb-istack-commons-runtime;unpack=0"
SRC_URI += "${URI_jaxb-istack-commons-runtime}"
SRC_URI[jaxb-istack-commons-runtime.sha256sum] = "ac4e972f856f2dee129f4f4c1a6d737e326c85a25567a1013f9dc5f1abce9af3"
RDEPENDS:jaxb-istack-commons-runtime = " \
 javapackages-filesystem \
"

URI_jaxb-istack-commons-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jaxb-istack-commons-tools-4.2.0-9.el10.noarch.rpm;name=jaxb-istack-commons-tools;unpack=0"
SRC_URI += "${URI_jaxb-istack-commons-tools}"
SRC_URI[jaxb-istack-commons-tools.sha256sum] = "33bd8dc78e552dee1034e91e016b85b7f7f66c14dcafbce44b6c4f1bde1c7651"
RDEPENDS:jaxb-istack-commons-tools = " \
 javapackages-filesystem \
"

URI_jaxb-istack-commons-maven-plugin = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jaxb-istack-commons-maven-plugin-4.2.0-9.el10.noarch.rpm;name=jaxb-istack-commons-maven-plugin;unpack=0"
SRC_URI += "${URI_jaxb-istack-commons-maven-plugin}"
SRC_URI[jaxb-istack-commons-maven-plugin.sha256sum] = "a6953da342df12b384c4c64ac3bdbc7605c7913ccf5e7c13987d9d0926297d6b"
RDEPENDS:jaxb-istack-commons-maven-plugin = " \
 jaxb-codemodel \
 maven-resolver \
 junit \
 javapackages-filesystem \
"

URI_jaxb-istack-commons-test = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jaxb-istack-commons-test-4.2.0-9.el10.noarch.rpm;name=jaxb-istack-commons-test;unpack=0"
SRC_URI += "${URI_jaxb-istack-commons-test}"
SRC_URI[jaxb-istack-commons-test.sha256sum] = "ea4d869c8ec475e043e535ac13b22459ec205f91a13ce19572fa8707ee69cbd9"
RDEPENDS:jaxb-istack-commons-test = " \
 junit \
 javapackages-filesystem \
"
