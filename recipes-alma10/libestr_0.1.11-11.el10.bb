# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libestr"
PE = "0"
PV = "0.1.11"
PR = "11.el10"
PACKAGES = "libestr libestr-devel"
PROVIDES = "rpm/libestr rpm/libestr-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libestr-0.1.11-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6716fcb13cd5631c7a6a4f268929ce4871566351d86ce3ace830881af818bb0"

URI_libestr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libestr-0.1.11-11.el10.x86_64_v2.rpm;name=libestr;unpack=0"
SRC_URI += "${URI_libestr}"
SRC_URI[libestr.sha256sum] = "08e0f314018ba9614bc281bdc41a00f455681b56e7d746d0cdc374baaed49308"
RDEPENDS:libestr = " \
 glibc \
"

URI_libestr-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libestr-devel-0.1.11-11.el10.x86_64_v2.rpm;name=libestr-devel;unpack=0"
SRC_URI += "${URI_libestr-devel}"
SRC_URI[libestr-devel.sha256sum] = "14953a245b64ebfd0f0a9cea1046b3054621d8e417bd6670c3dc2eebfb231fca"
RDEPENDS:libestr-devel = " \
 libestr \
 pkgconf-pkg-config \
"
