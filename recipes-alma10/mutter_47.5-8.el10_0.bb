# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mutter"
PE = "0"
PV = "47.5"
PR = "8.el10_0"
PACKAGES = "mutter mutter-common mutter-devel mutter-tests"
PROVIDES = "rpm/mutter rpm/mutter-common rpm/mutter-devel rpm/mutter-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mutter-47.5-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4bdb7f18b44a58493f76578a52239df3d3ed3ec2994a1fd4905dc1ed51eda0d3"

URI_mutter = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mutter-47.5-8.el10_0.x86_64_v2.rpm;name=mutter;unpack=0"
SRC_URI += "${URI_mutter}"
SRC_URI[mutter.sha256sum] = "69e719c95888fcecd75de448f1a2d4913f33d9791014e5ba36fcb93cedc991fa"
RDEPENDS:mutter = " \
 lcms2 \
 systemd-libs \
 libICE \
 pango \
 libSM \
 libX11 \
 libcanberra \
 mutter-common \
 libX11-xcb \
 libXau \
 dbus \
 libXcomposite \
 libXcursor \
 libXdamage \
 libdisplay-info \
 libdrm \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 gnome-control-center-filesystem \
 libeis \
 fribidi \
 gnome-desktop4 \
 libXrandr \
 cairo \
 libXtst \
 gnome-settings-daemon \
 atk \
 libwacom \
 libglvnd-egl \
 libglvnd-gles \
 libglvnd-glx \
 libwayland-server \
 libgcc \
 gdk-pixbuf2 \
 libgudev \
 libxcb \
 pipewire \
 mesa-libgbm \
 graphene \
 libxkbcommon \
 pipewire-libs \
 libxkbcommon-x11 \
 libxkbfile \
 pixman \
 startup-notification \
 gsettings-desktop-schemas \
 harfbuzz \
 libinput \
 glib2 \
 colord-libs \
 glibc \
 gtk4 \
"

URI_mutter-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mutter-common-47.5-8.el10_0.noarch.rpm;name=mutter-common;unpack=0"
SRC_URI += "${URI_mutter-common}"
SRC_URI[mutter-common.sha256sum] = "88df4e69939724d65fcd64caf9451c2e83ee9af23a504587657768cf1de832e1"
RDEPENDS:mutter-common = ""

URI_mutter-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mutter-devel-47.5-8.el10_0.x86_64_v2.rpm;name=mutter-devel;unpack=0"
SRC_URI += "${URI_mutter-devel}"
SRC_URI[mutter-devel.sha256sum] = "5b9a2b51e2d268e2a3353340c1bfda8fe3cd21c8ead260835d5c6c9af8648189"
RDEPENDS:mutter-devel = " \
 glib2-devel \
 mutter \
 pango-devel \
 libX11-devel \
 harfbuzz-devel \
 libXext \
 libXfixes-devel \
 libXi-devel \
 cairo \
 cairo-devel \
 atk-devel \
 libglvnd-devel \
 libwayland-client \
 libglvnd-gles \
 libgcc \
 mesa-libEGL-devel \
 libxcb \
 graphene-devel \
 pixman-devel \
 wayland-devel \
 gsettings-desktop-schemas-devel \
 pkgconf-pkg-config \
 glib2 \
 glibc \
 mutter-devel \
"

URI_mutter-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mutter-tests-47.5-8.el10_0.x86_64_v2.rpm;name=mutter-tests;unpack=0"
SRC_URI += "${URI_mutter-tests}"
SRC_URI[mutter-tests.sha256sum] = "c195c038c50d9179e0052c53ad1be4d4e8b300000c3a3eae084cb19e7d369954"
RDEPENDS:mutter-tests = " \
 python3 \
 mutter \
 libX11 \
 libXext \
 libei \
 libXrandr \
 cairo \
 atk \
 libwayland-client \
 libglvnd-gles \
 libwayland-cursor \
 libwayland-server \
 libgcc \
 bash \
 mesa-libgbm \
 pipewire-libs \
 glib2 \
 gtk3 \
 colord-libs \
 glibc \
 mutter-devel \
"
