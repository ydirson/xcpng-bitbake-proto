# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mysql8.0"
PE = "0"
PV = "8.0.36"
PR = "4.el10"
PACKAGES = ""
PROVIDES = ""


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/mysql8.0-8.0.36-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f823bfff48eb5146bc9e0aa8b6b9518e22a4db2637ae1b4c2337c7b2fe99f7ca"
