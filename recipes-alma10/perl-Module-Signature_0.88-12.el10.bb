# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Module-Signature"
PE = "0"
PV = "0.88"
PR = "12.el10"
PACKAGES = "perl-Module-Signature perl-Module-Signature-tests"
PROVIDES = "rpm/perl-Module-Signature rpm/perl-Module-Signature-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Module-Signature-0.88-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2917d9569533cba46692a0dcc4022b09177f8791ef793b83045c585e3dcc13fc"

URI_perl-Module-Signature = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Module-Signature-0.88-12.el10.noarch.rpm;name=perl-Module-Signature;unpack=0"
SRC_URI += "${URI_perl-Module-Signature}"
SRC_URI[perl-Module-Signature.sha256sum] = "4735784aedbbf84b047d4a7e41773d9333dbeeae535386b7daf4cbd4f754b2d7"
RDEPENDS:perl-Module-Signature = " \
 perl-constant \
 gnupg2 \
 perl-libs \
 perl-ExtUtils-Manifest \
 perl-vars \
 perl-interpreter \
 perl-version \
 perl-IO \
 perl-Digest-SHA \
 perl-Text-Diff \
 perl-Module-Signature \
 perl-PathTools \
 perl-Exporter \
 perl-File-Temp \
"

URI_perl-Module-Signature-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Module-Signature-tests-0.88-12.el10.noarch.rpm;name=perl-Module-Signature-tests;unpack=0"
SRC_URI += "${URI_perl-Module-Signature-tests}"
SRC_URI[perl-Module-Signature-tests.sha256sum] = "f862f91f7a6eae0459e029c6d3a4be87d0fe82d85d94cc721e0afa6a6a43c867"
RDEPENDS:perl-Module-Signature-tests = " \
 perl-IPC-Run \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-FindBin \
 perl-Getopt-Long \
 perl-File-Basename \
 perl-Module-Signature \
 bash \
 perl-PathTools \
 perl-interpreter \
 perl-File-Path \
 perl-Data-Dumper \
 perl-lib \
 perl-Pod-Usage \
"
