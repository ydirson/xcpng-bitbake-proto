# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libXcomposite"
PE = "0"
PV = "0.4.6"
PR = "5.el10"
PACKAGES = "libXcomposite libXcomposite-devel"
PROVIDES = "rpm/libXcomposite rpm/libXcomposite-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libXcomposite-0.4.6-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7de3299bb4ae58dd70aba5c0caf10d8911f94ecd1453e5733fa3ae03a6a5d88d"

URI_libXcomposite = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXcomposite-0.4.6-5.el10.x86_64_v2.rpm;name=libXcomposite;unpack=0"
SRC_URI += "${URI_libXcomposite}"
SRC_URI[libXcomposite.sha256sum] = "5c1ca4308cadf9fc06cf92d82f47b5be8dce3fe64671830818c3df7767521d9a"
RDEPENDS:libXcomposite = " \
 glibc \
 libX11 \
"

URI_libXcomposite-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXcomposite-devel-0.4.6-5.el10.x86_64_v2.rpm;name=libXcomposite-devel;unpack=0"
SRC_URI += "${URI_libXcomposite-devel}"
SRC_URI[libXcomposite-devel.sha256sum] = "052a5ee0bf5d451ae656dc5d6a6ab0f43e013032a350de857d66fed58d19b52a"
RDEPENDS:libXcomposite-devel = " \
 libXfixes-devel \
 pkgconf-pkg-config \
 libX11-devel \
 xorg-x11-proto-devel \
 libXcomposite \
"
