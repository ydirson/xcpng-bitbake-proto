# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "microcode_ctl"
PE = "4"
PV = "20250211"
PR = "1.20250812.1.el10_0"
PACKAGES = "microcode_ctl microcode_ctl"
PROVIDES = "rpm/microcode_ctl rpm/microcode_ctl"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/microcode_ctl-20250211-1.20250812.1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4cf2f3863fb6b898902495d0bbb5b54a14c4b64b33885c6703bf88932720742"

URI_microcode_ctl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/microcode_ctl-20250211-1.20250812.1.el10_0.noarch.rpm;name=microcode_ctl;unpack=0"
SRC_URI += "${URI_microcode_ctl}"
SRC_URI[microcode_ctl.sha256sum] = "c26a6f7e5bf1df997e134a44798df17152a3f0350e028555a5c674e9a00800d9"
RDEPENDS:microcode_ctl = " \
 coreutils \
 systemd \
 bash \
 dracut \
"

URI_microcode_ctl = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/microcode_ctl-20250211-1.20250812.1.el10_0.noarch.rpm;name=microcode_ctl;unpack=0"
SRC_URI += "${URI_microcode_ctl}"
SRC_URI[microcode_ctl.sha256sum] = "c26a6f7e5bf1df997e134a44798df17152a3f0350e028555a5c674e9a00800d9"
RDEPENDS:microcode_ctl = " \
 coreutils \
 systemd \
 bash \
 dracut \
"
