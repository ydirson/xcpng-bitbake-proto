# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libXpm"
PE = "0"
PV = "3.5.17"
PR = "5.el10"
PACKAGES = "libXpm libXpm-devel"
PROVIDES = "rpm/libXpm rpm/libXpm-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libXpm-3.5.17-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64773942d37dbdaada91492825d4833b31a3141772cffe6be524576ba286dcea"

URI_libXpm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXpm-3.5.17-5.el10.x86_64_v2.rpm;name=libXpm;unpack=0"
SRC_URI += "${URI_libXpm}"
SRC_URI[libXpm.sha256sum] = "7bc380eac7c0ec5040eaa27855e585c3ae868fa7b4b542c315ef7226f6c229f9"
RDEPENDS:libXpm = " \
 glibc \
 libX11 \
"

URI_libXpm-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXpm-devel-3.5.17-5.el10.x86_64_v2.rpm;name=libXpm-devel;unpack=0"
SRC_URI += "${URI_libXpm-devel}"
SRC_URI[libXpm-devel.sha256sum] = "19fffea0778306be624cc643ef21a16b595f18b3a5f548e4c0e1956ba7c13fec"
RDEPENDS:libXpm-devel = " \
 libXpm \
 pkgconf-pkg-config \
 libX11 \
 libX11-devel \
 libXt \
 glibc \
 libXext \
"
