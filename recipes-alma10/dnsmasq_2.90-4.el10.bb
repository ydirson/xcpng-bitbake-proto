# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dnsmasq"
PE = "0"
PV = "2.90"
PR = "4.el10"
PACKAGES = "dnsmasq dnsmasq-utils dnsmasq-langpack"
PROVIDES = "rpm/dnsmasq rpm/dnsmasq-utils rpm/dnsmasq-langpack"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/dnsmasq-2.90-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c005c1c905b67754e0cb768ea925164593bae9c929bfe0493938cae6161244b"

URI_dnsmasq = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dnsmasq-2.90-4.el10.x86_64_v2.rpm;name=dnsmasq;unpack=0"
SRC_URI += "${URI_dnsmasq}"
SRC_URI[dnsmasq.sha256sum] = "304c9b10e89b5f543b51ae6f025a1335e7aebdc8bde4d0f44195217c20319ef6"
RDEPENDS:dnsmasq = " \
 gmp \
 libnetfilter_conntrack \
 bash \
 glibc \
 libidn2 \
 dbus-libs \
 nettle \
"

URI_dnsmasq-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dnsmasq-utils-2.90-4.el10.x86_64_v2.rpm;name=dnsmasq-utils;unpack=0"
SRC_URI += "${URI_dnsmasq-utils}"
SRC_URI[dnsmasq-utils.sha256sum] = "c612ef10136d5add599029fb148728dbb7492d087e11e8ece31d25d5c1990d57"
RDEPENDS:dnsmasq-utils = " \
 glibc \
"

URI_dnsmasq-langpack = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/dnsmasq-langpack-2.90-4.el10.noarch.rpm;name=dnsmasq-langpack;unpack=0"
SRC_URI += "${URI_dnsmasq-langpack}"
SRC_URI[dnsmasq-langpack.sha256sum] = "4b73a5797c9e303d08e91a3670cd3290855b6af938acc2ee1c6e5dbcef75f74e"
RDEPENDS:dnsmasq-langpack = " \
 dnsmasq \
"
