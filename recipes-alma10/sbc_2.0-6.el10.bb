# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sbc"
PE = "0"
PV = "2.0"
PR = "6.el10"
PACKAGES = "libsbc sbc sbc-devel"
PROVIDES = "rpm/libsbc rpm/sbc rpm/sbc-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/sbc-2.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7b6e41ef0027de93248c1f9b6f3a34013b69f8c523d8c21873a304340f44913"

URI_libsbc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libsbc-2.0-6.el10.x86_64_v2.rpm;name=libsbc;unpack=0"
SRC_URI += "${URI_libsbc}"
SRC_URI[libsbc.sha256sum] = "47255d3dd61b58b952c021416814025bb36cbde5f0dfbf2ddde78699e7cf4beb"
RDEPENDS:libsbc = " \
 glibc \
"

URI_sbc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sbc-2.0-6.el10.x86_64_v2.rpm;name=sbc;unpack=0"
SRC_URI += "${URI_sbc}"
SRC_URI[sbc.sha256sum] = "bf4e8cad7bddd40e1753d75bf64fd865908b196ea84d9d646c594d0cf37bb8cc"
RDEPENDS:sbc = " \
 glibc \
 libsbc \
"

URI_sbc-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sbc-devel-2.0-6.el10.x86_64_v2.rpm;name=sbc-devel;unpack=0"
SRC_URI += "${URI_sbc-devel}"
SRC_URI[sbc-devel.sha256sum] = "bfe4f0540f1fef231f6027b9f86ba168e6f4cd56ad12ed800671ba5a23246d8e"
RDEPENDS:sbc-devel = " \
 sbc \
 pkgconf-pkg-config \
 libsbc \
"
