# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xxhash"
PE = "0"
PV = "0.8.2"
PR = "4.el10"
PACKAGES = "xxhash xxhash-devel xxhash-doc xxhash-libs"
PROVIDES = "rpm/xxhash rpm/xxhash-devel rpm/xxhash-doc rpm/xxhash-libs"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/xxhash-0.8.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f0523eee0e9fd7c3092ee37316490d143d41e3ca8ea6a8d59cad545c160e90d"

URI_xxhash = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/xxhash-0.8.2-4.el10.x86_64_v2.rpm;name=xxhash;unpack=0"
SRC_URI += "${URI_xxhash}"
SRC_URI[xxhash.sha256sum] = "2eee3927ad752da0df85aa7b4c3a0f77b528813a91662e2f9ef0edab636889ec"
RDEPENDS:xxhash = " \
 glibc \
"

URI_xxhash-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/xxhash-devel-0.8.2-4.el10.x86_64_v2.rpm;name=xxhash-devel;unpack=0"
SRC_URI += "${URI_xxhash-devel}"
SRC_URI[xxhash-devel.sha256sum] = "4f3e41d6b70ae3b8fce650a7fa1856900ea169d40e8a15b33339b14459a8e486"
RDEPENDS:xxhash-devel = " \
 xxhash-libs \
 pkgconf-pkg-config \
"

URI_xxhash-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/xxhash-doc-0.8.2-4.el10.noarch.rpm;name=xxhash-doc;unpack=0"
SRC_URI += "${URI_xxhash-doc}"
SRC_URI[xxhash-doc.sha256sum] = "9524aaa6c0c0883ef582030e48fdd7566cbdecec8a7f9d2f971f7bedb6eeb632"
RDEPENDS:xxhash-doc = ""

URI_xxhash-libs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/xxhash-libs-0.8.2-4.el10.x86_64_v2.rpm;name=xxhash-libs;unpack=0"
SRC_URI += "${URI_xxhash-libs}"
SRC_URI[xxhash-libs.sha256sum] = "e8d49d799402fc40db3e0f727385fbbe12d7f83e3a2dfbfbb1ef370d5878111b"
RDEPENDS:xxhash-libs = " \
 glibc \
"
