# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "desktop-file-utils"
PE = "0"
PV = "0.26"
PR = "14.el10"
PACKAGES = "desktop-file-utils"
PROVIDES = "rpm/desktop-file-utils"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/desktop-file-utils-0.26-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "776309fa5d871a706ea6784d593607b73f832549a8e211a120f778154570200c"

URI_desktop-file-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/desktop-file-utils-0.26-14.el10.x86_64_v2.rpm;name=desktop-file-utils;unpack=0"
SRC_URI += "${URI_desktop-file-utils}"
SRC_URI[desktop-file-utils.sha256sum] = "d773682c41e812d363789a14e6194fa9718a39d2fc31c268bcaac8470e8b09d1"
RDEPENDS:desktop-file-utils = " \
 glibc \
 emacs-filesystem \
 bash \
 glib2 \
"
