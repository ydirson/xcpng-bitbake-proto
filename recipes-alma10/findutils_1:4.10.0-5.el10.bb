# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "findutils"
PE = "1"
PV = "4.10.0"
PR = "5.el10"
PACKAGES = "findutils"
PROVIDES = "rpm/findutils"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/findutils-4.10.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ba2dbc22d3335840d831e7feec863d6aee3a244d4133341f0e8f21dc2875dd0"

URI_findutils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/findutils-4.10.0-5.el10.x86_64_v2.rpm;name=findutils;unpack=0"
SRC_URI += "${URI_findutils}"
SRC_URI[findutils.sha256sum] = "0d86cc13b34e26c0f7a3a77488ec38b216fe9b26e7cd89d0cf704ceeda72c733"
RDEPENDS:findutils = " \
 glibc \
 libselinux \
"
