# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "attr"
PE = "0"
PV = "2.5.2"
PR = "5.el10"
PACKAGES = "attr libattr libattr-devel"
PROVIDES = "rpm/attr rpm/libattr rpm/libattr-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/attr-2.5.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ac48b43e6ab3eba36ca831de9ed6247d773fdb821970bade2ddb7a28a18ac2e"

URI_attr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/attr-2.5.2-5.el10.x86_64_v2.rpm;name=attr;unpack=0"
SRC_URI += "${URI_attr}"
SRC_URI[attr.sha256sum] = "7b1c7a413f954e5e12ce8baa35a6953b7c166fbf356d7bd5527b0e1b80541132"
RDEPENDS:attr = " \
 glibc \
 libattr \
"

URI_libattr = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libattr-2.5.2-5.el10.x86_64_v2.rpm;name=libattr;unpack=0"
SRC_URI += "${URI_libattr}"
SRC_URI[libattr.sha256sum] = "aa11985585fdb587c541f93bf509de8329839aa5b20da1cb59faba00442ff1fe"
RDEPENDS:libattr = " \
 glibc \
"

URI_libattr-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libattr-devel-2.5.2-5.el10.x86_64_v2.rpm;name=libattr-devel;unpack=0"
SRC_URI += "${URI_libattr-devel}"
SRC_URI[libattr-devel.sha256sum] = "6795e0e9fd34f3f5736d8d063e83bd9e90ead2602d15cb50fe6708c5f161bb98"
RDEPENDS:libattr-devel = " \
 glibc-devel \
 pkgconf-pkg-config \
 libattr \
"
