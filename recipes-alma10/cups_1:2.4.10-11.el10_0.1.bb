# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cups"
PE = "1"
PV = "2.4.10"
PR = "11.el10_0.1"
PACKAGES = "cups-filesystem cups-libs cups cups-client cups-devel cups-ipptool cups-lpd cups-printerapp"
PROVIDES = "rpm/cups-filesystem rpm/cups-libs rpm/cups rpm/cups-client rpm/cups-devel rpm/cups-ipptool rpm/cups-lpd rpm/cups-printerapp"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/cups-2.4.10-11.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9945396233fcb8854eac8741950345aad68cb963fe14886c0ef36f19b08e646"

URI_cups-filesystem = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cups-filesystem-2.4.10-11.el10_0.1.noarch.rpm;name=cups-filesystem;unpack=0"
SRC_URI += "${URI_cups-filesystem}"
SRC_URI[cups-filesystem.sha256sum] = "0a57c29c2d81aeb9fcc53bc8dd11b2a0086b7ef4582b0bfb3ce29e9af931975f"
RDEPENDS:cups-filesystem = ""

URI_cups-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cups-libs-2.4.10-11.el10_0.1.x86_64_v2.rpm;name=cups-libs;unpack=0"
SRC_URI += "${URI_cups-libs}"
SRC_URI[cups-libs.sha256sum] = "58c7c8706d7739d814e4d9465419a35a32fb60ff430b203032aba10140dbb720"
RDEPENDS:cups-libs = " \
 zlib-ng-compat \
 gnutls \
 cups-filesystem \
 krb5-libs \
 avahi-libs \
 glibc \
"

URI_cups = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cups-2.4.10-11.el10_0.1.x86_64_v2.rpm;name=cups;unpack=0"
SRC_URI += "${URI_cups}"
SRC_URI[cups.sha256sum] = "ef2e47ce333559a50f04d60bd9b8cde627bba1073bd3848be1cf9c9e868f56fd"
RDEPENDS:cups = " \
 python3 \
 systemd \
 systemd-libs \
 cups-filesystem \
 cups-libs \
 krb5-libs \
 dbus \
 dbus-libs \
 libselinux \
 cups-client \
 cups-filters \
 libacl \
 acl \
 libstdc++ \
 sed \
 libusb1 \
 audit-libs \
 libgcc \
 grep \
 pam-libs \
 avahi-libs \
 bash \
 glibc \
"

URI_cups-client = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cups-client-2.4.10-11.el10_0.1.x86_64_v2.rpm;name=cups-client;unpack=0"
SRC_URI += "${URI_cups-client}"
SRC_URI[cups-client.sha256sum] = "ef33e6fc265ba5370bba096d95656ada5313d8a295d810da9b1004cf045f2d6e"
RDEPENDS:cups-client = " \
 glibc \
 cups-libs \
 bash \
 alternatives \
"

URI_cups-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cups-devel-2.4.10-11.el10_0.1.x86_64_v2.rpm;name=cups-devel;unpack=0"
SRC_URI += "${URI_cups-devel}"
SRC_URI[cups-devel.sha256sum] = "49e0c0cdf995ce0720597bfe70f819d0ffda8ef6eda3726a39f6487a6a9e1ac6"
RDEPENDS:cups-devel = " \
 gnutls-devel \
 zlib-ng-compat-devel \
 avahi-devel \
 cups-libs \
 pkgconf-pkg-config \
 bash \
 krb5-devel \
"

URI_cups-ipptool = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cups-ipptool-2.4.10-11.el10_0.1.x86_64_v2.rpm;name=cups-ipptool;unpack=0"
SRC_URI += "${URI_cups-ipptool}"
SRC_URI[cups-ipptool.sha256sum] = "65e3b016b7350ba0b41a262acbe01eebb11ef6ca6576745623ecf863e0114870"
RDEPENDS:cups-ipptool = " \
 glibc \
 avahi-libs \
 avahi \
 cups-libs \
"

URI_cups-lpd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cups-lpd-2.4.10-11.el10_0.1.x86_64_v2.rpm;name=cups-lpd;unpack=0"
SRC_URI += "${URI_cups-lpd}"
SRC_URI[cups-lpd.sha256sum] = "d168134a859fdc62f42f9ca0dccb498b1782f67186d062e4b0249150d2e15e43"
RDEPENDS:cups-lpd = " \
 glibc \
 cups-libs \
 bash \
 cups \
"

URI_cups-printerapp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cups-printerapp-2.4.10-11.el10_0.1.x86_64_v2.rpm;name=cups-printerapp;unpack=0"
SRC_URI += "${URI_cups-printerapp}"
SRC_URI[cups-printerapp.sha256sum] = "6f5d2ad8f6855b052c6561e200f59e908c8e2454c567bed5d3c20340e84bc251"
RDEPENDS:cups-printerapp = " \
 cups-libs \
 avahi \
 pam-libs \
 avahi-libs \
 glibc \
"
