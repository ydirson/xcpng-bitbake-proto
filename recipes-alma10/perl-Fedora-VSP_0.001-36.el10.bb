# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Fedora-VSP"
PE = "0"
PV = "0.001"
PR = "36.el10"
PACKAGES = "perl-Fedora-VSP perl-Fedora-VSP-tests"
PROVIDES = "rpm/perl-Fedora-VSP rpm/perl-Fedora-VSP-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Fedora-VSP-0.001-36.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c89fe4afb2cad369923ff806aa676148c230ccd8567c0a7e157916ba6652c61"

URI_perl-Fedora-VSP = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Fedora-VSP-0.001-36.el10.noarch.rpm;name=perl-Fedora-VSP;unpack=0"
SRC_URI += "${URI_perl-Fedora-VSP}"
SRC_URI[perl-Fedora-VSP.sha256sum] = "5b00390f79ec6fefd63cf8e2c2ebed5df7d34f23291d86e8276725831f10e892"
RDEPENDS:perl-Fedora-VSP = " \
 perl-libs \
"

URI_perl-Fedora-VSP-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Fedora-VSP-tests-0.001-36.el10.noarch.rpm;name=perl-Fedora-VSP-tests;unpack=0"
SRC_URI += "${URI_perl-Fedora-VSP-tests}"
SRC_URI[perl-Fedora-VSP-tests.sha256sum] = "90cf0b5c04934be030bfd13ee71bbd8cff2830e6cee0e2272898832a70bb370e"
RDEPENDS:perl-Fedora-VSP-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-version \
 perl-Fedora-VSP \
 bash \
 perl-interpreter \
"
