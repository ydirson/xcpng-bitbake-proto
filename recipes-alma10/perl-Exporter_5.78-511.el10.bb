# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Exporter"
PE = "0"
PV = "5.78"
PR = "511.el10"
PACKAGES = "perl-Exporter perl-Exporter-tests"
PROVIDES = "rpm/perl-Exporter rpm/perl-Exporter-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Exporter-5.78-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ad1b80844b4f41496987e879594a1049c0dacf94bfba69dfee5ae7f356ea5b3"

URI_perl-Exporter = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Exporter-5.78-511.el10.noarch.rpm;name=perl-Exporter;unpack=0"
SRC_URI += "${URI_perl-Exporter}"
SRC_URI[perl-Exporter.sha256sum] = "3c23ebc3c23a498244aabebf0f6ca0257daf33423885f615b3602700823e6c7b"
RDEPENDS:perl-Exporter = " \
 perl-libs \
 perl-Carp \
"

URI_perl-Exporter-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Exporter-tests-5.78-511.el10.noarch.rpm;name=perl-Exporter-tests;unpack=0"
SRC_URI += "${URI_perl-Exporter-tests}"
SRC_URI[perl-Exporter-tests.sha256sum] = "b2b83269bfe1f2ec885168615a832ac9971f917c658e3e71f429975e89abed39"
RDEPENDS:perl-Exporter-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Carp \
 perl-vars \
 bash \
 perl-interpreter \
 perl-Exporter \
"
