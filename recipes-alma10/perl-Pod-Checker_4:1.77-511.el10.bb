# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Pod-Checker"
PE = "4"
PV = "1.77"
PR = "511.el10"
PACKAGES = "perl-Pod-Checker perl-Pod-Checker-tests"
PROVIDES = "rpm/perl-Pod-Checker rpm/perl-Pod-Checker-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Pod-Checker-1.77-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a7a1df18043c3b245591930f359a0994ca4d92dcc08a6dbc60c1310e2a5daa9"

URI_perl-Pod-Checker = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Pod-Checker-1.77-511.el10.noarch.rpm;name=perl-Pod-Checker;unpack=0"
SRC_URI += "${URI_perl-Pod-Checker}"
SRC_URI[perl-Pod-Checker.sha256sum] = "a822d46b937093eba8b8f9b03d5ded24c66cee0d32b0534c0d6341d158618c23"
RDEPENDS:perl-Pod-Checker = " \
 perl-libs \
 perl-Carp \
 perl-interpreter \
 perl-Getopt-Long \
 perl-Pod-Checker \
 perl-Exporter \
 perl-base \
 perl-Pod-Simple \
 perl-Pod-Usage \
"

URI_perl-Pod-Checker-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Pod-Checker-tests-1.77-511.el10.noarch.rpm;name=perl-Pod-Checker-tests;unpack=0"
SRC_URI += "${URI_perl-Pod-Checker-tests}"
SRC_URI[perl-Pod-Checker-tests.sha256sum] = "36c26da4dde37ca04304df0bc41ae9e669eb2199486796c127b173ddf8599887"
RDEPENDS:perl-Pod-Checker-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-vars \
 perl-FileHandle \
 perl-File-Basename \
 bash \
 perl-PathTools \
 perl-Pod-Checker \
 perl-interpreter \
 perl-Exporter \
"
