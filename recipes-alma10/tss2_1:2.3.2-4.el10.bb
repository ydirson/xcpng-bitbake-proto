# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tss2"
PE = "1"
PV = "2.3.2"
PR = "4.el10"
PACKAGES = "tss2 tss2-devel"
PROVIDES = "rpm/tss2 rpm/tss2-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/tss2-2.3.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "204d598f9035536ae4309b6147bb8641277574a8d4b111772afac7c617733fb3"

URI_tss2 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/tss2-2.3.2-4.el10.x86_64_v2.rpm;name=tss2;unpack=0"
SRC_URI += "${URI_tss2}"
SRC_URI[tss2.sha256sum] = "3b7c08898424125e35f12b0ec21315ae15c427e7ff44b3b352a5875a082d1405"
RDEPENDS:tss2 = " \
 glibc \
 openssl \
 openssl-libs \
"

URI_tss2-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/tss2-devel-2.3.2-4.el10.x86_64_v2.rpm;name=tss2-devel;unpack=0"
SRC_URI += "${URI_tss2-devel}"
SRC_URI[tss2-devel.sha256sum] = "040e6532de4503f9d5038ebe9dad84117b4cae009b29d66c7c91295ed9425c37"
RDEPENDS:tss2-devel = " \
 tss2 \
"
