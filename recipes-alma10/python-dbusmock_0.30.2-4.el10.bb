# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-dbusmock"
PE = "0"
PV = "0.30.2"
PR = "4.el10"
PACKAGES = "python3-dbusmock"
PROVIDES = "rpm/python3-dbusmock"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/python-dbusmock-0.30.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f528fe7fcd2be552f4a1835758b8476bdbc6f493acdb34a9e740b130b324954d"

URI_python3-dbusmock = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-dbusmock-0.30.2-4.el10.noarch.rpm;name=python3-dbusmock;unpack=0"
SRC_URI += "${URI_python3-dbusmock}"
SRC_URI[python3-dbusmock.sha256sum] = "48e1eee747b3c3ab26d37301b6e313ac5993f34ff0f1f0ef2175ebf00a195da8"
RDEPENDS:python3-dbusmock = " \
 python3 \
 python3-gobject \
 python3-dbus \
 dbus-x11 \
"
