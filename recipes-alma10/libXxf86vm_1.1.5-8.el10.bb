# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libXxf86vm"
PE = "0"
PV = "1.1.5"
PR = "8.el10"
PACKAGES = "libXxf86vm libXxf86vm-devel"
PROVIDES = "rpm/libXxf86vm rpm/libXxf86vm-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libXxf86vm-1.1.5-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73505b2a7660d5be0720fe7fc9a3bbff5683bab37ee2e6475e49f758c5a2093a"

URI_libXxf86vm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXxf86vm-1.1.5-8.el10.x86_64_v2.rpm;name=libXxf86vm;unpack=0"
SRC_URI += "${URI_libXxf86vm}"
SRC_URI[libXxf86vm.sha256sum] = "f1ae6b67e68c2f760c3612bbb98ea722fd8a2b5a9ac6b350523209cbc19ee3d4"
RDEPENDS:libXxf86vm = " \
 glibc \
 libX11 \
 libXext \
"

URI_libXxf86vm-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libXxf86vm-devel-1.1.5-8.el10.x86_64_v2.rpm;name=libXxf86vm-devel;unpack=0"
SRC_URI += "${URI_libXxf86vm-devel}"
SRC_URI[libXxf86vm-devel.sha256sum] = "1601b761ddceac29c37015c55b6f19df823276097ae1ee24f48ba4c1299a9c82"
RDEPENDS:libXxf86vm-devel = " \
 libXext-devel \
 pkgconf-pkg-config \
 libX11-devel \
 xorg-x11-proto-devel \
 libXxf86vm \
"
