# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libevent"
PE = "0"
PV = "2.1.12"
PR = "16.el10"
PACKAGES = "libevent libevent-devel libevent-doc"
PROVIDES = "rpm/libevent rpm/libevent-devel rpm/libevent-doc"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libevent-2.1.12-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a89b7ecaea233546fe83247ced35d8946a5a4eadb9c9261e46cecb4b7cbdf828"

URI_libevent = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libevent-2.1.12-16.el10.x86_64_v2.rpm;name=libevent;unpack=0"
SRC_URI += "${URI_libevent}"
SRC_URI[libevent.sha256sum] = "d52f9b12a6e5a62c71465090bf59f87241616ee47cf217645bd74903273834ec"
RDEPENDS:libevent = " \
 glibc \
 openssl-libs \
"

URI_libevent-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libevent-devel-2.1.12-16.el10.x86_64_v2.rpm;name=libevent-devel;unpack=0"
SRC_URI += "${URI_libevent-devel}"
SRC_URI[libevent-devel.sha256sum] = "730e672988db573f3ad50323edf22868a7c7d8658c250332a0c0a5344fd2eee3"
RDEPENDS:libevent-devel = " \
 python3 \
 libevent-devel \
 pkgconf-pkg-config \
 libevent \
"

URI_libevent-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libevent-doc-2.1.12-16.el10.noarch.rpm;name=libevent-doc;unpack=0"
SRC_URI += "${URI_libevent-doc}"
SRC_URI[libevent-doc.sha256sum] = "d1086f3495b2c44797e045301bd299ed44f6f33d9b90a4dc9ed99a20166caf34"
RDEPENDS:libevent-doc = ""
