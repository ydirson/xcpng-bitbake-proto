# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "eglexternalplatform"
PE = "0"
PV = "1.1"
PR = "10.el10"
PACKAGES = "eglexternalplatform-devel"
PROVIDES = "rpm/eglexternalplatform-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/eglexternalplatform-1.1-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c868464f3dfed0f9bbbaaee236069326cf5ccdc727ad38f3df2e6a4775fe8b9f"

URI_eglexternalplatform-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/eglexternalplatform-devel-1.1-10.el10.noarch.rpm;name=eglexternalplatform-devel;unpack=0"
SRC_URI += "${URI_eglexternalplatform-devel}"
SRC_URI[eglexternalplatform-devel.sha256sum] = "f6b1449398c68a35b00c00f299953a1fccb7071ada33db052eb500f5a23965e6"
RDEPENDS:eglexternalplatform-devel = " \
 pkgconf-pkg-config \
"
