# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtcharts"
PE = "0"
PV = "6.8.1"
PR = "2.el10"
PACKAGES = "qt6-qtcharts qt6-qtcharts-devel qt6-qtcharts-examples qt6-qtcharts-tests"
PROVIDES = "rpm/qt6-qtcharts rpm/qt6-qtcharts-devel rpm/qt6-qtcharts-examples rpm/qt6-qtcharts-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtcharts-6.8.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45b310170c356e7197337de76662cfdee7e3ef404ae9a4261827da4cbf9bf6a5"

URI_qt6-qtcharts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtcharts-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtcharts;unpack=0"
SRC_URI += "${URI_qt6-qtcharts}"
SRC_URI[qt6-qtcharts.sha256sum] = "0cc469a117f8767c72c6a096264e6382d665d9da26baa91b42f32b4057900603"
RDEPENDS:qt6-qtcharts = " \
 qt6-qtdeclarative \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qtcharts-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtcharts-devel-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtcharts-devel;unpack=0"
SRC_URI += "${URI_qt6-qtcharts-devel}"
SRC_URI[qt6-qtcharts-devel.sha256sum] = "a041689947e45b9f08ea2c42c8cd1b4c36f42808c2068e1b113cac5c0157e7e5"
RDEPENDS:qt6-qtcharts-devel = " \
 qt6-qtdeclarative-devel \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtcharts \
 qt6-qtcharts-devel \
"

URI_qt6-qtcharts-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtcharts-examples-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtcharts-examples;unpack=0"
SRC_URI += "${URI_qt6-qtcharts-examples}"
SRC_URI[qt6-qtcharts-examples.sha256sum] = "5fd2760b226bec2286aae42ddeb7022b6cac3e73b9efb3cfe6ec5100810703b0"
RDEPENDS:qt6-qtcharts-examples = " \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
 qt6-qtcharts \
"

URI_qt6-qtcharts-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtcharts-tests-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtcharts-tests;unpack=0"
SRC_URI += "${URI_qt6-qtcharts-tests}"
SRC_URI[qt6-qtcharts-tests.sha256sum] = "f8b74d2ba408d9b72e59e970746afcb46b137a57a1f238aae272daf109414d8b"
RDEPENDS:qt6-qtcharts-tests = " \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
 qt6-qtcharts \
"
