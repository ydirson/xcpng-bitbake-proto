# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-version"
PE = "8"
PV = "0.99.32"
PR = "4.el10"
PACKAGES = "perl-version perl-version-tests"
PROVIDES = "rpm/perl-version rpm/perl-version-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-version-0.99.32-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69296532df793ff85c443f06cfe9dba66f08b55a195cd1656b0b2a8fc51c68c9"

URI_perl-version = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-version-0.99.32-4.el10.x86_64_v2.rpm;name=perl-version;unpack=0"
SRC_URI += "${URI_perl-version}"
SRC_URI[perl-version.sha256sum] = "997f8e8f5f7ed372da5849d1a66f3341fc66dc3c6a72affb086b2235820a0928"
RDEPENDS:perl-version = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-version \
 perl-locale \
 perl-POSIX \
 perl-B \
 perl-overload \
 perl-if \
 glibc \
"

URI_perl-version-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-version-tests-0.99.32-4.el10.x86_64_v2.rpm;name=perl-version-tests;unpack=0"
SRC_URI += "${URI_perl-version-tests}"
SRC_URI[perl-version-tests.sha256sum] = "e926d73869e97644677b4e24e636d4f68848eac8b9b98359298728ee17e4412f"
RDEPENDS:perl-version-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Scalar-List-Utils \
 perl-I18N-Langinfo \
 perl-version \
 perl-File-Basename \
 perl-POSIX \
 perl-File-Temp \
 bash \
 perl-PathTools \
 perl-if \
 perl-interpreter \
 perl-Data-Dumper \
 perl-base \
 perl-lib \
"
