# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtserialbus"
PE = "0"
PV = "6.8.1"
PR = "2.el10"
PACKAGES = "qt6-qtserialbus qt6-qtserialbus-devel qt6-qtserialbus-examples qt6-qtserialbus-tests"
PROVIDES = "rpm/qt6-qtserialbus rpm/qt6-qtserialbus-devel rpm/qt6-qtserialbus-examples rpm/qt6-qtserialbus-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtserialbus-6.8.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3262bc07b025432d55f9f5ef1f4d8f4d497332016e603bb6817a70bb83d13076"

URI_qt6-qtserialbus = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtserialbus-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtserialbus;unpack=0"
SRC_URI += "${URI_qt6-qtserialbus}"
SRC_URI[qt6-qtserialbus.sha256sum] = "3cedbc69aab7b5e7c2d154d56b415d41ce7d6eb313e918fbe6cd20e224b54a4b"
RDEPENDS:qt6-qtserialbus = " \
 glibc \
 libstdc++ \
 qt6-qtserialport \
 qt6-qtbase \
"

URI_qt6-qtserialbus-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtserialbus-devel-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtserialbus-devel;unpack=0"
SRC_URI += "${URI_qt6-qtserialbus-devel}"
SRC_URI[qt6-qtserialbus-devel.sha256sum] = "f5d9dde974085747af0a42e2a079f4f94c7e4ad48b42fb59721074c6fd94465f"
RDEPENDS:qt6-qtserialbus-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtserialbus \
 qt6-qtserialport-devel \
"

URI_qt6-qtserialbus-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtserialbus-examples-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtserialbus-examples;unpack=0"
SRC_URI += "${URI_qt6-qtserialbus-examples}"
SRC_URI[qt6-qtserialbus-examples.sha256sum] = "e3a45435108e827e7a45df1392349b003d77e332686ad2ca17f1d175f9e3e699"
RDEPENDS:qt6-qtserialbus-examples = " \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
 qt6-qtserialbus \
 qt6-qtserialport \
"

URI_qt6-qtserialbus-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtserialbus-tests-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtserialbus-tests;unpack=0"
SRC_URI += "${URI_qt6-qtserialbus-tests}"
SRC_URI[qt6-qtserialbus-tests.sha256sum] = "f6f8dd9c06ab7bf8bc9fdc6e5217867e0b7e9fd335da89c4a240d86948861451"
RDEPENDS:qt6-qtserialbus-tests = " \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 glibc \
 qt6-qtserialbus \
"
