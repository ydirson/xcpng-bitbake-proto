# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cloud-init"
PE = "0"
PV = "24.4"
PR = "3.el10_0.2"
PACKAGES = "cloud-init"
PROVIDES = "rpm/cloud-init"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/cloud-init-24.4-3.el10_0.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19bb270987c5242272d371049f29a698493914cf7741e7310136338159e7acc6"

URI_cloud-init = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cloud-init-24.4-3.el10_0.2.noarch.rpm;name=cloud-init;unpack=0"
SRC_URI += "${URI_cloud-init}"
SRC_URI[cloud-init.sha256sum] = "c8703d31e5f37391a9b6dadd4843f0bbc6ef9b36508e47af0b8d9228e66d4893"
RDEPENDS:cloud-init = " \
 python3 \
 systemd \
 iproute \
 python3-jinja2 \
 python3-jsonpatch \
 util-linux \
 dhcpcd \
 python3-libselinux \
 xfsprogs \
 e2fsprogs \
 python3-oauthlib \
 shadow-utils \
 python3-requests \
 python3-pyyaml \
 openssl \
 bash \
 python3-policycoreutils \
 hostname \
 python3-configobj \
 python3-pyserial \
 procps-ng \
"
