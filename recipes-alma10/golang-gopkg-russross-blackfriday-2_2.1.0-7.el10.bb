# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "golang-gopkg-russross-blackfriday-2"
PE = "0"
PV = "2.1.0"
PR = "7.el10"
PACKAGES = "compat-golang-github-russross-blackfriday-2-devel golang-gopkg-russross-blackfriday-2-devel"
PROVIDES = "rpm/compat-golang-github-russross-blackfriday-2-devel rpm/golang-gopkg-russross-blackfriday-2-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/golang-gopkg-russross-blackfriday-2-2.1.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd086743a4bccbc849c89e74d14cc74af07706937867c53dc0781abef26d325a"

URI_compat-golang-github-russross-blackfriday-2-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/compat-golang-github-russross-blackfriday-2-devel-2.1.0-7.el10.noarch.rpm;name=compat-golang-github-russross-blackfriday-2-devel;unpack=0"
SRC_URI += "${URI_compat-golang-github-russross-blackfriday-2-devel}"
SRC_URI[compat-golang-github-russross-blackfriday-2-devel.sha256sum] = "f225318a5c1919179abee9e8c7dc9eb6ce6116d2cc6742cd2f2a5e87d7ffc7ed"
RDEPENDS:compat-golang-github-russross-blackfriday-2-devel = " \
 golang-gopkg-russross-blackfriday-2-devel \
 go-filesystem \
"

URI_golang-gopkg-russross-blackfriday-2-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/golang-gopkg-russross-blackfriday-2-devel-2.1.0-7.el10.noarch.rpm;name=golang-gopkg-russross-blackfriday-2-devel;unpack=0"
SRC_URI += "${URI_golang-gopkg-russross-blackfriday-2-devel}"
SRC_URI[golang-gopkg-russross-blackfriday-2-devel.sha256sum] = "ff4764a8083453b68b19c09a9cbaf4fb9b3bc6377373bd39010bdb1421edb860"
RDEPENDS:golang-gopkg-russross-blackfriday-2-devel = " \
 go-filesystem \
"
