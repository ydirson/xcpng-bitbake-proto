# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-CPAN-Meta-YAML"
PE = "0"
PV = "0.018"
PR = "512.el10"
PACKAGES = "perl-CPAN-Meta-YAML perl-CPAN-Meta-YAML-tests"
PROVIDES = "rpm/perl-CPAN-Meta-YAML rpm/perl-CPAN-Meta-YAML-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-CPAN-Meta-YAML-0.018-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a08934228f9840f752a0198076a45aca78a30aacd7246d8c711412a8a593a52"

URI_perl-CPAN-Meta-YAML = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-CPAN-Meta-YAML-0.018-512.el10.noarch.rpm;name=perl-CPAN-Meta-YAML;unpack=0"
SRC_URI += "${URI_perl-CPAN-Meta-YAML}"
SRC_URI[perl-CPAN-Meta-YAML.sha256sum] = "8af7c7f0d072f10486e525ab5c90eb091e7b963a48767afe58f6e043ce9c44b4"
RDEPENDS:perl-CPAN-Meta-YAML = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-Fcntl \
 perl-B \
 perl-Exporter \
"

URI_perl-CPAN-Meta-YAML-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-CPAN-Meta-YAML-tests-0.018-512.el10.noarch.rpm;name=perl-CPAN-Meta-YAML-tests;unpack=0"
SRC_URI += "${URI_perl-CPAN-Meta-YAML-tests}"
SRC_URI[perl-CPAN-Meta-YAML-tests.sha256sum] = "39549d2cbf3453cf96a7f37eaab950704c17f024ce4550acf890b266af828539"
RDEPENDS:perl-CPAN-Meta-YAML-tests = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Getopt-Long \
 perl-Test-Harness \
 perl-Carp \
 perl-CPAN-Meta-YAML \
 perl-vars \
 perl-IO \
 perl-Test-Simple \
 perl-lib \
 bash \
 perl-Exporter \
 perl-base \
 perl-ExtUtils-MakeMaker \
 perl-File-Basename \
 perl-PathTools \
 perl-File-Find \
 perl-interpreter \
 perl-File-Temp \
"
