# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dwz"
PE = "0"
PV = "0.15"
PR = "7.el10"
PACKAGES = "dwz"
PROVIDES = "rpm/dwz"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/dwz-0.15-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5124c66fd927d79302678948480508f79c94e1cd5fa6bdfd85fa8b30df38cc97"

URI_dwz = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dwz-0.15-7.el10.x86_64_v2.rpm;name=dwz;unpack=0"
SRC_URI += "${URI_dwz}"
SRC_URI[dwz.sha256sum] = "3093deaf594a3d7ffa39c637483a230793d504601f3b24d52b9218d57f6fb494"
RDEPENDS:dwz = " \
 glibc \
 elfutils-libelf \
"
