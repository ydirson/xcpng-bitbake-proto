# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "golang"
PE = "0"
PV = "1.24.6"
PR = "1.el10_0.alma.1"
PACKAGES = "go-toolset golang golang-bin golang-docs golang-misc golang-race golang-src golang-tests"
PROVIDES = "rpm/go-toolset rpm/golang rpm/golang-bin rpm/golang-docs rpm/golang-misc rpm/golang-race rpm/golang-src rpm/golang-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/golang-1.24.6-1.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad95f4001b7b5d6b907c0eda45b90b9bb482294df1003fc2decb2086f14beb74"

URI_go-toolset = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/go-toolset-1.24.6-1.el10_0.alma.1.x86_64_v2.rpm;name=go-toolset;unpack=0"
SRC_URI += "${URI_go-toolset}"
SRC_URI[go-toolset.sha256sum] = "15a4e159c3d5d7335273f124c9de106aa5c3adbb19e5f26417c455a77ff01f76"
RDEPENDS:go-toolset = " \
 delve \
 golang \
"

URI_golang = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/golang-1.24.6-1.el10_0.alma.1.x86_64_v2.rpm;name=golang;unpack=0"
SRC_URI += "${URI_golang}"
SRC_URI[golang.sha256sum] = "f40370ad23068ebbcb629c1496095902c4de715ec70c4d222c4ed566897fdb65"
RDEPENDS:golang = " \
 golang-race \
 openssl-devel \
 golang-src \
 golang-bin \
"

URI_golang-bin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/golang-bin-1.24.6-1.el10_0.alma.1.x86_64_v2.rpm;name=golang-bin;unpack=0"
SRC_URI += "${URI_golang-bin}"
SRC_URI[golang-bin.sha256sum] = "209930824be5b6b9a2d3218797eb28a4d11e056057dca0d8a33a8d34c33009f8"
RDEPENDS:golang-bin = " \
 bash \
 gcc \
 glibc \
 alternatives \
 golang \
"

URI_golang-docs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/golang-docs-1.24.6-1.el10_0.alma.1.noarch.rpm;name=golang-docs;unpack=0"
SRC_URI += "${URI_golang-docs}"
SRC_URI[golang-docs.sha256sum] = "b540c93d9030e14609394ea67606f28cd6f298bcddaaae80a6be8d7183f50ecf"
RDEPENDS:golang-docs = " \
 golang \
"

URI_golang-misc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/golang-misc-1.24.6-1.el10_0.alma.1.noarch.rpm;name=golang-misc;unpack=0"
SRC_URI += "${URI_golang-misc}"
SRC_URI[golang-misc.sha256sum] = "83670aa8ef8253d2cb3f7b30cf7fded4995488eec26e485effc10065b9c86975"
RDEPENDS:golang-misc = " \
 golang \
"

URI_golang-race = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/golang-race-1.24.6-1.el10_0.alma.1.x86_64_v2.rpm;name=golang-race;unpack=0"
SRC_URI += "${URI_golang-race}"
SRC_URI[golang-race.sha256sum] = "b3c08b7954aa095119848440303f5d34a67817bb6940b6607243cc3944ad94d7"
RDEPENDS:golang-race = " \
 golang \
"

URI_golang-src = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/golang-src-1.24.6-1.el10_0.alma.1.noarch.rpm;name=golang-src;unpack=0"
SRC_URI += "${URI_golang-src}"
SRC_URI[golang-src.sha256sum] = "48ca27c5b38c1f2fa1ac58ece2e1458a2dc7567cbcd79dcb6776e513680a5167"
RDEPENDS:golang-src = ""

URI_golang-tests = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/golang-tests-1.24.6-1.el10_0.alma.1.noarch.rpm;name=golang-tests;unpack=0"
SRC_URI += "${URI_golang-tests}"
SRC_URI[golang-tests.sha256sum] = "d2f30e00924a779cf17c9bde4531ce463af71fc9b65a7cfa2fb330d6b1275c01"
RDEPENDS:golang-tests = " \
 golang \
"
