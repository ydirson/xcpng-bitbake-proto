# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pptp"
PE = "0"
PV = "1.10.0"
PR = "22.el10"
PACKAGES = "pptp pptp-setup"
PROVIDES = "rpm/pptp rpm/pptp-setup"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/pptp-1.10.0-22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb5d22179000e2821185445f4efd896d5d9b5a98432b44b4db3d40d9c821e44f"

URI_pptp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pptp-1.10.0-22.el10.x86_64_v2.rpm;name=pptp;unpack=0"
SRC_URI += "${URI_pptp}"
SRC_URI[pptp.sha256sum] = "9c39bc1a02cae4ec2701c44e2e522f518c5010f575f4c59724b777ae04e44608"
RDEPENDS:pptp = " \
 glibc \
 systemd \
 iproute \
 ppp \
"

URI_pptp-setup = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/pptp-setup-1.10.0-22.el10.x86_64_v2.rpm;name=pptp-setup;unpack=0"
SRC_URI += "${URI_pptp-setup}"
SRC_URI[pptp-setup.sha256sum] = "940990dc75590e22f7d0fd54d52896df0730a58bcffa57e5ab9774eb7ba683ed"
RDEPENDS:pptp-setup = " \
 perl-libs \
 perl-vars \
 perl-Getopt-Long \
 perl-interpreter \
 pptp \
"
