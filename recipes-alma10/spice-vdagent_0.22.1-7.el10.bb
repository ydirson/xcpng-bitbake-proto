# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "spice-vdagent"
PE = "0"
PV = "0.22.1"
PR = "7.el10"
PACKAGES = "spice-vdagent"
PROVIDES = "rpm/spice-vdagent"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/spice-vdagent-0.22.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42f99bda893e76483d74d4d3797d6f05ebc37bdf5c912ac778abd86f0d66393c"

URI_spice-vdagent = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/spice-vdagent-0.22.1-7.el10.x86_64_v2.rpm;name=spice-vdagent;unpack=0"
SRC_URI += "${URI_spice-vdagent}"
SRC_URI[spice-vdagent.sha256sum] = "246c0b59af76d22b6aec0235204c9a2d2f436eb282de558222835aff5558f443"
RDEPENDS:spice-vdagent = " \
 alsa-lib \
 libXfixes \
 libpciaccess \
 systemd \
 systemd-libs \
 libXinerama \
 libXrandr \
 libX11 \
 bash \
 glib2 \
 glibc \
 dbus-libs \
 libdrm \
"
