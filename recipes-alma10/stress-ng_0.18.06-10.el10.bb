# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "stress-ng"
PE = "0"
PV = "0.18.06"
PR = "10.el10"
PACKAGES = "stress-ng"
PROVIDES = "rpm/stress-ng"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/stress-ng-0.18.06-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "275b39b7c96ddc6c0b6d5bad6b31a7e1eda0d4c3671583ae3fd3d70d867fa477"

URI_stress-ng = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/stress-ng-0.18.06-10.el10.x86_64_v2.rpm;name=stress-ng;unpack=0"
SRC_URI += "${URI_stress-ng}"
SRC_URI[stress-ng.sha256sum] = "1ddbc2fbd80c6cdc5389cbaa163036a4d52074d758fdff1ca9d7d38ff459b371"
RDEPENDS:stress-ng = " \
 zlib-ng-compat \
 libxcrypt \
 Judy \
 glibc \
 lksctp-tools \
"
