# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lapack"
PE = "0"
PV = "3.12.0"
PR = "7.el10"
PACKAGES = "blas lapack blas-devel blas64 blas64_ lapack-devel lapack-static lapack64 lapack64_ blas-static"
PROVIDES = "rpm/blas rpm/lapack rpm/blas-devel rpm/blas64 rpm/blas64_ rpm/lapack-devel rpm/lapack-static rpm/lapack64 rpm/lapack64_ rpm/blas-static"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/lapack-3.12.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1640b966916737dc1937f021aa23acc808168488e77ec7a3a8a0e066ec9bb85"

URI_blas = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/blas-3.12.0-7.el10.x86_64_v2.rpm;name=blas;unpack=0"
SRC_URI += "${URI_blas}"
SRC_URI[blas.sha256sum] = "e76dd7b0d4f0348b65c3dc35caab40e69de147e65b6d9958329216dabbd0a0af"
RDEPENDS:blas = " \
 glibc \
 libgcc \
 libgfortran \
"

URI_lapack = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lapack-3.12.0-7.el10.x86_64_v2.rpm;name=lapack;unpack=0"
SRC_URI += "${URI_lapack}"
SRC_URI[lapack.sha256sum] = "88eeef7f0e39e8188520f325ae46f07c1d0f8767f983bef1132687f1c84979fe"
RDEPENDS:lapack = " \
 glibc \
 libgcc \
 libgfortran \
 blas \
"

URI_blas-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/blas-devel-3.12.0-7.el10.x86_64_v2.rpm;name=blas-devel;unpack=0"
SRC_URI += "${URI_blas-devel}"
SRC_URI[blas-devel.sha256sum] = "f2e147491ebfdae3a6b1254b9fb355373c805225a5d907fcc436f1491fdaff85"
RDEPENDS:blas-devel = " \
 blas-devel \
 blas64 \
 blas64_ \
 cmake-filesystem \
 pkgconf-pkg-config \
 blas \
 gcc-gfortran \
"

URI_blas64 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/blas64-3.12.0-7.el10.x86_64_v2.rpm;name=blas64;unpack=0"
SRC_URI += "${URI_blas64}"
SRC_URI[blas64.sha256sum] = "a25bb523a0c6c1131b31bfa488126996f679cce2eb050c11ea9ac589c172c9a3"
RDEPENDS:blas64 = " \
 glibc \
 libgcc \
 libgfortran \
"

URI_blas64_ = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/blas64_-3.12.0-7.el10.x86_64_v2.rpm;name=blas64_;unpack=0"
SRC_URI += "${URI_blas64_}"
SRC_URI[blas64_.sha256sum] = "ddebbab61f5dabd0336bcdc693fe744d23ba2e9dcad14fb6be0006d7bf8a01e0"
RDEPENDS:blas64_ = " \
 glibc \
 libgcc \
 libgfortran \
"

URI_lapack-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/lapack-devel-3.12.0-7.el10.x86_64_v2.rpm;name=lapack-devel;unpack=0"
SRC_URI += "${URI_lapack-devel}"
SRC_URI[lapack-devel.sha256sum] = "145080ce1f4dfc8c2b555ac1eff0a5fdb63e063d75d6abb2c26ac2a281604232"
RDEPENDS:lapack-devel = " \
 blas-devel \
 lapack \
 lapack-devel \
 cmake-filesystem \
 lapack64 \
 lapack64_ \
 pkgconf-pkg-config \
"

URI_lapack-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/lapack-static-3.12.0-7.el10.x86_64_v2.rpm;name=lapack-static;unpack=0"
SRC_URI += "${URI_lapack-static}"
SRC_URI[lapack-static.sha256sum] = "ff0760ed2a76b2b68da8b2b4294590a9882196fcfc6aee4b8f8908ccd0b6eeb0"
RDEPENDS:lapack-static = " \
 lapack-devel \
"

URI_lapack64 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/lapack64-3.12.0-7.el10.x86_64_v2.rpm;name=lapack64;unpack=0"
SRC_URI += "${URI_lapack64}"
SRC_URI[lapack64.sha256sum] = "010859967229f3d8f9afabe29192e7c404511f962bcd80f89f64354e032e4c2f"
RDEPENDS:lapack64 = " \
 glibc \
 blas64 \
 libgcc \
 libgfortran \
"

URI_lapack64_ = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/lapack64_-3.12.0-7.el10.x86_64_v2.rpm;name=lapack64_;unpack=0"
SRC_URI += "${URI_lapack64_}"
SRC_URI[lapack64_.sha256sum] = "8fa35a09be989879e478fa80a6b8669a60a89ab14fce0b03a324d4915060c99d"
RDEPENDS:lapack64_ = " \
 glibc \
 blas64_ \
 libgcc \
 libgfortran \
"

URI_blas-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/blas-static-3.12.0-7.el10.x86_64_v2.rpm;name=blas-static;unpack=0"
SRC_URI += "${URI_blas-static}"
SRC_URI[blas-static.sha256sum] = "98bdcdb55c8aa5e6332da1b0ad86f54010fe565e3042e122b345a6258d7399d2"
RDEPENDS:blas-static = " \
 blas-devel \
"
