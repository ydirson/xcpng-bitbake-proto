# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pyserial"
PE = "0"
PV = "3.5"
PR = "11.el10"
PACKAGES = "python3-pyserial"
PROVIDES = "rpm/python3-pyserial"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/pyserial-3.5-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6367b23904863b63e651a16c24a4e8d2a75ca762e272fe1b4489e707a6337f34"

URI_python3-pyserial = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-pyserial-3.5-11.el10.noarch.rpm;name=python3-pyserial;unpack=0"
SRC_URI += "${URI_python3-pyserial}"
SRC_URI[python3-pyserial.sha256sum] = "32089bda68ed855102e4b243d70c152e379097f264c4c9715ebd275830af3e3b"
RDEPENDS:python3-pyserial = " \
 python3 \
"
