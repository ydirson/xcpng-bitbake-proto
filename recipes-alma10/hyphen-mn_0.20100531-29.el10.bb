# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-mn"
PE = "0"
PV = "0.20100531"
PR = "29.el10"
PACKAGES = "hyphen-mn"
PROVIDES = "rpm/hyphen-mn"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-mn-0.20100531-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "624e4fd43da1f348904dc90d07593aad58445c778397084facf75148ff95397c"

URI_hyphen-mn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-mn-0.20100531-29.el10.noarch.rpm;name=hyphen-mn;unpack=0"
SRC_URI += "${URI_hyphen-mn}"
SRC_URI[hyphen-mn.sha256sum] = "90f8e582d1d7b25347b1cbce3f0d703bdf040c60535dac18337c416fd580b75f"
RDEPENDS:hyphen-mn = " \
 hyphen \
"
