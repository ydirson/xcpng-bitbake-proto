# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-configobj"
PE = "0"
PV = "5.0.8"
PR = "10.el10"
PACKAGES = "python3-configobj"
PROVIDES = "rpm/python3-configobj"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-configobj-5.0.8-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f74584331e080055e08fd3542ece54bcbeefe1ae6689d78fa7b6b74b58e1147d"

URI_python3-configobj = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-configobj-5.0.8-10.el10.noarch.rpm;name=python3-configobj;unpack=0"
SRC_URI += "${URI_python3-configobj}"
SRC_URI[python3-configobj.sha256sum] = "7070f34110f4dba45faa4315d60ed767e7931c901e6fe02f3d0ca7f686eb81c7"
RDEPENDS:python3-configobj = " \
 python3 \
 python3-six \
"
