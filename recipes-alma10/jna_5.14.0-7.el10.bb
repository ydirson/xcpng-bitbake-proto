# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jna"
PE = "0"
PV = "5.14.0"
PR = "7.el10"
PACKAGES = "jna jna-contrib jna-javadoc"
PROVIDES = "rpm/jna rpm/jna-contrib rpm/jna-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/jna-5.14.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b35212a01be0438b2e126c09ae3b7bb7111aaa3da44c80065277f58697057cd"

URI_jna = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jna-5.14.0-7.el10.x86_64_v2.rpm;name=jna;unpack=0"
SRC_URI += "${URI_jna}"
SRC_URI[jna.sha256sum] = "eb0f5566e3160aab10b282ab84e38abfeb21e50872a5a3a6507e3ccd2b9028ce"
RDEPENDS:jna = " \
 glibc \
 libffi \
 javapackages-filesystem \
"

URI_jna-contrib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jna-contrib-5.14.0-7.el10.noarch.rpm;name=jna-contrib;unpack=0"
SRC_URI += "${URI_jna-contrib}"
SRC_URI[jna-contrib.sha256sum] = "07baec2c051cea09bbb6d9e49e84062c0a2e1bfc34a91f6e8fc4ab7e68316cef"
RDEPENDS:jna-contrib = " \
 jna \
 javapackages-filesystem \
"

URI_jna-javadoc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/jna-javadoc-5.14.0-7.el10.noarch.rpm;name=jna-javadoc;unpack=0"
SRC_URI += "${URI_jna-javadoc}"
SRC_URI[jna-javadoc.sha256sum] = "835bcce821797cd385e513777cb7128a696dbe879bc3f8ad50d63fcc792dc934"
RDEPENDS:jna-javadoc = " \
 javapackages-filesystem \
"
