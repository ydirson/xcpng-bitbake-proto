# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "kernelshark"
PE = "1"
PV = "2.3.1"
PR = "4.el10"
PACKAGES = "kernelshark"
PROVIDES = "rpm/kernelshark"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/kernelshark-2.3.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb7b2a782349da2511e75c8767f730ffe540c9cb29fe39cfff4178bb62edf35d"

URI_kernelshark = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/kernelshark-2.3.1-4.el10.x86_64_v2.rpm;name=kernelshark;unpack=0"
SRC_URI += "${URI_kernelshark}"
SRC_URI[kernelshark.sha256sum] = "c9fff3e93a589487d4321ef61a79b63352a10bc71c17582e1e8e43b235cb364a"
RDEPENDS:kernelshark = " \
 libtracecmd-devel \
 qt6-qtscxml \
 freeglut \
 json-c \
 libstdc++ \
 libtracecmd \
 libtraceevent \
 libtracefs \
 json-c-devel \
 libglvnd-glx \
 libgcc \
 mesa-libGLU \
 bash \
 google-noto-sans-fonts \
 pkgconf-pkg-config \
 qt6-qtbase \
 polkit \
 qt6-qtbase-gui \
 glibc \
"
