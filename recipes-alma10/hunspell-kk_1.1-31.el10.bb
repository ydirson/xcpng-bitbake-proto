# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-kk"
PE = "0"
PV = "1.1"
PR = "31.el10"
PACKAGES = "hunspell-kk"
PROVIDES = "rpm/hunspell-kk"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-kk-1.1-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbcc149a649e4cc67ed005d6b3332a21f9eb9b9ce8f29cf0b37bd3a8b7a3eb5f"

URI_hunspell-kk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-kk-1.1-31.el10.noarch.rpm;name=hunspell-kk;unpack=0"
SRC_URI += "${URI_hunspell-kk}"
SRC_URI[hunspell-kk.sha256sum] = "2ddfee64137373799798f2b3747e13eea8403c64dce915830d756e390f7ee34b"
RDEPENDS:hunspell-kk = " \
 hunspell-filesystem \
"
