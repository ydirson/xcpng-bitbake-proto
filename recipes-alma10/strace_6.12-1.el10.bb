# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "strace"
PE = "0"
PV = "6.12"
PR = "1.el10"
PACKAGES = "strace"
PROVIDES = "rpm/strace"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/strace-6.12-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcc271716f9bcfc8f3a4b0793de3c47ac1961a032ef9025ad0284d314bc1851d"

URI_strace = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/strace-6.12-1.el10.x86_64_v2.rpm;name=strace;unpack=0"
SRC_URI += "${URI_strace}"
SRC_URI[strace.sha256sum] = "7f3a71aad68f05411d4f36c52fa54624ea508c136ced6bf055cb9f89aa0b69e6"
RDEPENDS:strace = " \
 glibc \
 libselinux \
 bash \
 elfutils-libs \
"
