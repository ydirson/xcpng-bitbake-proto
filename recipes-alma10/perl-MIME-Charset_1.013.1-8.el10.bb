# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-MIME-Charset"
PE = "0"
PV = "1.013.1"
PR = "8.el10"
PACKAGES = "perl-MIME-Charset perl-MIME-Charset-tests"
PROVIDES = "rpm/perl-MIME-Charset rpm/perl-MIME-Charset-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-MIME-Charset-1.013.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b87985000e06e0507f4beffc55acae7d3e29c689f98fe01099b52d93a0a05b9"

URI_perl-MIME-Charset = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-MIME-Charset-1.013.1-8.el10.noarch.rpm;name=perl-MIME-Charset;unpack=0"
SRC_URI += "${URI_perl-MIME-Charset}"
SRC_URI[perl-MIME-Charset.sha256sum] = "a455fc8190c4fb739a0c71f291057acb8799bd5238fe84b8170609a29b7821de"
RDEPENDS:perl-MIME-Charset = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-Encode \
 perl-Exporter \
"

URI_perl-MIME-Charset-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-MIME-Charset-tests-1.013.1-8.el10.noarch.rpm;name=perl-MIME-Charset-tests;unpack=0"
SRC_URI += "${URI_perl-MIME-Charset-tests}"
SRC_URI[perl-MIME-Charset-tests.sha256sum] = "75efcce97f488f52cdd8bbfaae3e3de955259ac6b3936bb8d0e4eeb26bf91850"
RDEPENDS:perl-MIME-Charset-tests = " \
 perl-MIME-Charset \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 bash \
 perl-interpreter \
"
