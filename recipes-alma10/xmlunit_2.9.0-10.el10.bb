# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xmlunit"
PE = "0"
PV = "2.9.0"
PR = "10.el10"
PACKAGES = "xmlunit xmlunit-assertj xmlunit-core xmlunit-javadoc xmlunit-legacy xmlunit-matchers xmlunit-placeholders"
PROVIDES = "rpm/xmlunit rpm/xmlunit-assertj rpm/xmlunit-core rpm/xmlunit-javadoc rpm/xmlunit-legacy rpm/xmlunit-matchers rpm/xmlunit-placeholders"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/xmlunit-2.9.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "498894b294288840ca3f5de8aaf6adf79d3cf31b426de86bbeade2a2aa747ab0"

URI_xmlunit = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xmlunit-2.9.0-10.el10.noarch.rpm;name=xmlunit;unpack=0"
SRC_URI += "${URI_xmlunit}"
SRC_URI[xmlunit.sha256sum] = "1b2373a36dcc77a3454ba8de6d4c11eb7968bfdec4c1dca1cfa75e760567aa3a"
RDEPENDS:xmlunit = " \
 maven-bundle-plugin \
 javapackages-filesystem \
"

URI_xmlunit-assertj = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xmlunit-assertj-2.9.0-10.el10.noarch.rpm;name=xmlunit-assertj;unpack=0"
SRC_URI += "${URI_xmlunit-assertj}"
SRC_URI[xmlunit-assertj.sha256sum] = "e0d4270c06c102c7ebc8a95ab2fca59d1990b061be0ea5f7b1ab772d41482c3f"
RDEPENDS:xmlunit-assertj = " \
 xmlunit-core \
 assertj-core \
 javapackages-filesystem \
"

URI_xmlunit-core = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xmlunit-core-2.9.0-10.el10.noarch.rpm;name=xmlunit-core;unpack=0"
SRC_URI += "${URI_xmlunit-core}"
SRC_URI[xmlunit-core.sha256sum] = "94decf6fe492560b76fc7422e5e323acc2e7e2d03cc9f265e5996dbfade553bd"
RDEPENDS:xmlunit-core = " \
 javapackages-filesystem \
"

URI_xmlunit-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xmlunit-javadoc-2.9.0-10.el10.noarch.rpm;name=xmlunit-javadoc;unpack=0"
SRC_URI += "${URI_xmlunit-javadoc}"
SRC_URI[xmlunit-javadoc.sha256sum] = "e73d304aadec79b10a50824262da7067d14aa31123c2885cc6a86bf6516ede44"
RDEPENDS:xmlunit-javadoc = " \
 javapackages-filesystem \
"

URI_xmlunit-legacy = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xmlunit-legacy-2.9.0-10.el10.noarch.rpm;name=xmlunit-legacy;unpack=0"
SRC_URI += "${URI_xmlunit-legacy}"
SRC_URI[xmlunit-legacy.sha256sum] = "bfa333c18b9b945ac0e78350f1d31c5f68e0b002cf1fd532f2f823a358f4b51f"
RDEPENDS:xmlunit-legacy = " \
 xmlunit-core \
 junit \
 javapackages-filesystem \
"

URI_xmlunit-matchers = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xmlunit-matchers-2.9.0-10.el10.noarch.rpm;name=xmlunit-matchers;unpack=0"
SRC_URI += "${URI_xmlunit-matchers}"
SRC_URI[xmlunit-matchers.sha256sum] = "ec03e0f14376ff838336c0589d39ceea2fe8336a540696d393152896f4015fa3"
RDEPENDS:xmlunit-matchers = " \
 xmlunit-core \
 hamcrest \
 javapackages-filesystem \
"

URI_xmlunit-placeholders = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xmlunit-placeholders-2.9.0-10.el10.noarch.rpm;name=xmlunit-placeholders;unpack=0"
SRC_URI += "${URI_xmlunit-placeholders}"
SRC_URI[xmlunit-placeholders.sha256sum] = "44cf76c6ca04ff079b98bfaab20e54cb9872e41e9cbf9247c84c504643a0bea1"
RDEPENDS:xmlunit-placeholders = " \
 xmlunit-core \
 javapackages-filesystem \
"
