# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-eu"
PE = "0"
PV = "0.20190406"
PR = "11.el10"
PACKAGES = "hyphen-eu"
PROVIDES = "rpm/hyphen-eu"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-eu-0.20190406-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c07ae127b0a9ddd1f08fe0d67223bc72baae4ea50889a5bb466de47f6ad6b06"

URI_hyphen-eu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-eu-0.20190406-11.el10.noarch.rpm;name=hyphen-eu;unpack=0"
SRC_URI += "${URI_hyphen-eu}"
SRC_URI[hyphen-eu.sha256sum] = "668c1e061121cfd49b5ae6cf769b87ff812ebda7c59bb55613699b13ad37a380"
RDEPENDS:hyphen-eu = " \
 hyphen \
"
