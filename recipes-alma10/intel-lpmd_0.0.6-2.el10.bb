# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "intel-lpmd"
PE = "0"
PV = "0.0.6"
PR = "2.el10"
PACKAGES = "intel-lpmd"
PROVIDES = "rpm/intel-lpmd"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/intel-lpmd-0.0.6-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f307e3418b45dfcf52c1d8eb11242eaae055ceb83e06eaa7debc7d9e1a4b03d"

URI_intel-lpmd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/intel-lpmd-0.0.6-2.el10.x86_64_v2.rpm;name=intel-lpmd;unpack=0"
SRC_URI += "${URI_intel-lpmd}"
SRC_URI[intel-lpmd.sha256sum] = "619372913a64e42bafdc53d2e531491856a63226648af9e7a2b4dd048aaec923"
RDEPENDS:intel-lpmd = " \
 systemd-libs \
 libgcc \
 libnl3 \
 libxml2 \
 bash \
 glib2 \
 glibc \
"
