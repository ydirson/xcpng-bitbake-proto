# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "speech-dispatcher"
PE = "0"
PV = "0.11.5"
PR = "8.el10"
PACKAGES = "python3-speechd speech-dispatcher speech-dispatcher-doc speech-dispatcher-espeak-ng speech-dispatcher-libs speech-dispatcher-utils speech-dispatcher-devel"
PROVIDES = "rpm/python3-speechd rpm/speech-dispatcher rpm/speech-dispatcher-doc rpm/speech-dispatcher-espeak-ng rpm/speech-dispatcher-libs rpm/speech-dispatcher-utils rpm/speech-dispatcher-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/speech-dispatcher-0.11.5-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f40d8ae697f33f8e0dc70c4c8d1e96c8877e5831fda3d7ae850d5b988b26a7d"

URI_python3-speechd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-speechd-0.11.5-8.el10.x86_64_v2.rpm;name=python3-speechd;unpack=0"
SRC_URI += "${URI_python3-speechd}"
SRC_URI[python3-speechd.sha256sum] = "815ae2f4be1906a13210ad42a8f377fe7b7d434e270fac7dba818d0ef358730d"
RDEPENDS:python3-speechd = " \
 python3 \
"

URI_speech-dispatcher = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/speech-dispatcher-0.11.5-8.el10.x86_64_v2.rpm;name=speech-dispatcher;unpack=0"
SRC_URI += "${URI_speech-dispatcher}"
SRC_URI[speech-dispatcher.sha256sum] = "fd67de939425a662b281ca6f7adf6df3da45e5c7102fdd53013784986c21bcf5"
RDEPENDS:speech-dispatcher = " \
 alsa-lib \
 systemd \
 libtool-ltdl \
 speech-dispatcher-espeak-ng \
 pulseaudio-libs \
 dotconf \
 bash \
 glib2 \
 glibc \
 libao \
 libsndfile \
"

URI_speech-dispatcher-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/speech-dispatcher-doc-0.11.5-8.el10.noarch.rpm;name=speech-dispatcher-doc;unpack=0"
SRC_URI += "${URI_speech-dispatcher-doc}"
SRC_URI[speech-dispatcher-doc.sha256sum] = "5a9fc92d9d28eb666a66cfb6c385d3a5c9ed44e32e8e0bac4e525c978b7d002c"
RDEPENDS:speech-dispatcher-doc = " \
 speech-dispatcher \
"

URI_speech-dispatcher-espeak-ng = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/speech-dispatcher-espeak-ng-0.11.5-8.el10.x86_64_v2.rpm;name=speech-dispatcher-espeak-ng;unpack=0"
SRC_URI += "${URI_speech-dispatcher-espeak-ng}"
SRC_URI[speech-dispatcher-espeak-ng.sha256sum] = "5e819f00bedd3e25402a55a51b022b325ce3ce19b9fe52f07f57d619458afaa2"
RDEPENDS:speech-dispatcher-espeak-ng = " \
 libtool-ltdl \
 speech-dispatcher \
 espeak-ng \
 dotconf \
 glib2 \
 glibc \
"

URI_speech-dispatcher-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/speech-dispatcher-libs-0.11.5-8.el10.x86_64_v2.rpm;name=speech-dispatcher-libs;unpack=0"
SRC_URI += "${URI_speech-dispatcher-libs}"
SRC_URI[speech-dispatcher-libs.sha256sum] = "6869e345daeff6257f1fea350605b31a9ab7fdb830f716d58972bddf2142512e"
RDEPENDS:speech-dispatcher-libs = " \
 glibc \
 libgcc \
 libtool-ltdl \
 glib2 \
"

URI_speech-dispatcher-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/speech-dispatcher-utils-0.11.5-8.el10.x86_64_v2.rpm;name=speech-dispatcher-utils;unpack=0"
SRC_URI += "${URI_speech-dispatcher-utils}"
SRC_URI[speech-dispatcher-utils.sha256sum] = "210c134927af73d21f43dcc5d3de403a56435c198087c435a42cce49792e911c"
RDEPENDS:speech-dispatcher-utils = " \
 python3 \
 python3-speechd \
 speech-dispatcher-libs \
 pulseaudio-utils \
 glibc \
"

URI_speech-dispatcher-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/speech-dispatcher-devel-0.11.5-8.el10.x86_64_v2.rpm;name=speech-dispatcher-devel;unpack=0"
SRC_URI += "${URI_speech-dispatcher-devel}"
SRC_URI[speech-dispatcher-devel.sha256sum] = "4fc4ba028095bc3737e6bcce5cd951428ab50c41b1f9a026561eb0c8544a18e9"
RDEPENDS:speech-dispatcher-devel = " \
 speech-dispatcher-libs \
 glib2-devel \
 pkgconf-pkg-config \
"
