# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Unicode-Collate"
PE = "0"
PV = "1.31"
PR = "511.el10"
PACKAGES = "perl-Unicode-Collate perl-Unicode-Collate-tests"
PROVIDES = "rpm/perl-Unicode-Collate rpm/perl-Unicode-Collate-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Unicode-Collate-1.31-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ccce005a95e6aeaf4c293983a2af673d26d6a5e940ca10f700d5d094f8e61e5"

URI_perl-Unicode-Collate = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Unicode-Collate-1.31-511.el10.x86_64_v2.rpm;name=perl-Unicode-Collate;unpack=0"
SRC_URI += "${URI_perl-Unicode-Collate}"
SRC_URI[perl-Unicode-Collate.sha256sum] = "dec3b114e45353c211ded92e58352820055a6f9d0a537e40303e1a9f84ca5bca"
RDEPENDS:perl-Unicode-Collate = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-Unicode-Collate \
 perl-Unicode-Normalize \
 perl-PathTools \
 glibc \
 perl-base \
"

URI_perl-Unicode-Collate-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Unicode-Collate-tests-1.31-511.el10.x86_64_v2.rpm;name=perl-Unicode-Collate-tests;unpack=0"
SRC_URI += "${URI_perl-Unicode-Collate-tests}"
SRC_URI[perl-Unicode-Collate-tests.sha256sum] = "39676901a49070bba571f2c7cb8615ec9c6ded46e7d5149c254f1e4d0b1bf84f"
RDEPENDS:perl-Unicode-Collate-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Unicode-Collate \
 bash \
 perl-interpreter \
"
