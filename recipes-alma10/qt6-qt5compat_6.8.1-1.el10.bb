# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qt5compat"
PE = "0"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = "qt6-qt5compat qt6-qt5compat-devel qt6-qt5compat-examples qt6-qt5compat-tests"
PROVIDES = "rpm/qt6-qt5compat rpm/qt6-qt5compat-devel rpm/qt6-qt5compat-examples rpm/qt6-qt5compat-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qt5compat-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65610df0505f77cca384d16e871a1bf65b4a4ca3af7d36c168f6159257a41458"

URI_qt6-qt5compat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qt5compat-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qt5compat;unpack=0"
SRC_URI += "${URI_qt6-qt5compat}"
SRC_URI[qt6-qt5compat.sha256sum] = "d29792d7c2d442107fc294a3786eb3a0962983ebafc4520b2c6791d343cc3ea0"
RDEPENDS:qt6-qt5compat = " \
 qt6-qtdeclarative \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
 libicu \
 qt6-qtshadertools \
"

URI_qt6-qt5compat-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qt5compat-devel-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qt5compat-devel;unpack=0"
SRC_URI += "${URI_qt6-qt5compat-devel}"
SRC_URI[qt6-qt5compat-devel.sha256sum] = "877bae5724e5f6abca6e815d2b400fbc2478bc7a51314bb392f4dc7b4e430ef7"
RDEPENDS:qt6-qt5compat-devel = " \
 qt6-qtbase-devel \
 qt6-qt5compat \
 cmake-filesystem \
 pkgconf-pkg-config \
"

URI_qt6-qt5compat-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qt5compat-examples-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qt5compat-examples;unpack=0"
SRC_URI += "${URI_qt6-qt5compat-examples}"
SRC_URI[qt6-qt5compat-examples.sha256sum] = "c124fcf8461fa440fc23bc98b65a332cdc6b348de5ceb8301dace7ec2e33ce9a"
RDEPENDS:qt6-qt5compat-examples = " \
 libgcc \
 qt6-qt5compat \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qt5compat-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qt5compat-tests-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qt5compat-tests;unpack=0"
SRC_URI += "${URI_qt6-qt5compat-tests}"
SRC_URI[qt6-qt5compat-tests.sha256sum] = "82a3a4dfc5d1ad5ddd2d4682055a42edaf4d73eb07a25d936b92f828914a8ef6"
RDEPENDS:qt6-qt5compat-tests = " \
 libgcc \
 qt6-qt5compat \
 qt6-qtbase \
 libstdc++ \
 bash \
 glibc \
"
