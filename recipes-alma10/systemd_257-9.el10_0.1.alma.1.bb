# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "systemd"
PE = "0"
PV = "257"
PR = "9.el10_0.1.alma.1"
PACKAGES = "systemd systemd-container systemd-libs systemd-oomd systemd-pam systemd-resolved systemd-rpm-macros systemd-udev systemd-boot-unsigned systemd-devel systemd-journal-remote systemd-ukify"
PROVIDES = "rpm/systemd rpm/systemd-container rpm/systemd-libs rpm/systemd-oomd rpm/systemd-pam rpm/systemd-resolved rpm/systemd-rpm-macros rpm/systemd-udev rpm/systemd-boot-unsigned rpm/systemd-devel rpm/systemd-journal-remote rpm/systemd-ukify"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/systemd-257-9.el10_0.1.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8576788b4bbf6c13fd97cebd15b0d11f61e1b598931f50a01c1d3d81878b9bc6"

URI_systemd = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/systemd-257-9.el10_0.1.alma.1.x86_64_v2.rpm;name=systemd;unpack=0"
SRC_URI += "${URI_systemd}"
SRC_URI[systemd.sha256sum] = "390c2d11e3f9b1f46a13c8c8d249561d3cd8a5d12b23f57bf35291018913d94f"
RDEPENDS:systemd = " \
 systemd-libs \
 systemd-pam \
 systemd-rpm-macros \
 dbus \
 libseccomp \
 libselinux \
 libacl \
 util-linux \
 libblkid \
 libcap \
 xz-libs \
 zlib-ng-compat \
 libfdisk \
 libxcrypt \
 audit-libs \
 openssl-libs \
 libgcc \
 grep \
 pam-libs \
 bash \
 bzip2-libs \
 libmount \
 glibc \
 coreutils \
"

URI_systemd-container = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/systemd-container-257-9.el10_0.1.alma.1.x86_64_v2.rpm;name=systemd-container;unpack=0"
SRC_URI += "${URI_systemd-container}"
SRC_URI[systemd-container.sha256sum] = "fd94cc7b800b343e398f031f85e491f887089eafc17c924832aaa91b230923b4"
RDEPENDS:systemd-container = " \
 libacl \
 systemd \
 zlib-ng-compat \
 bzip2-libs \
 libseccomp \
 libgcc \
 openssl-libs \
 libcap \
 libcurl \
 glibc \
 libselinux \
 xz-libs \
"

URI_systemd-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/systemd-libs-257-9.el10_0.1.alma.1.x86_64_v2.rpm;name=systemd-libs;unpack=0"
SRC_URI += "${URI_systemd-libs}"
SRC_URI[systemd-libs.sha256sum] = "760070d2df56d62efcbb77449286e4de7edb6c596252808a9acddeb254bfc10c"
RDEPENDS:systemd-libs = " \
 glibc \
 libgcc \
 libcap \
"

URI_systemd-oomd = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/systemd-oomd-257-9.el10_0.1.alma.1.x86_64_v2.rpm;name=systemd-oomd;unpack=0"
SRC_URI += "${URI_systemd-oomd}"
SRC_URI[systemd-oomd.sha256sum] = "f3540d4cb8c5eb81a3f6a02f28f19202424a0508344a6f9723b6e55fdeeae8ec"
RDEPENDS:systemd-oomd = " \
 systemd \
 systemd-udev \
 libgcc \
 bash \
 glibc \
"

URI_systemd-pam = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/systemd-pam-257-9.el10_0.1.alma.1.x86_64_v2.rpm;name=systemd-pam;unpack=0"
SRC_URI += "${URI_systemd-pam}"
SRC_URI[systemd-pam.sha256sum] = "28f63f2e99b13347773edfa10f6f03e0e45937b2095ae88135a15bef3b631dde"
RDEPENDS:systemd-pam = " \
 systemd \
 libgcc \
 libcap \
 pam-libs \
 glibc \
"

URI_systemd-resolved = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/systemd-resolved-257-9.el10_0.1.alma.1.x86_64_v2.rpm;name=systemd-resolved;unpack=0"
SRC_URI += "${URI_systemd-resolved}"
SRC_URI[systemd-resolved.sha256sum] = "cf42bc8304f7c2fd690a06aead9cb2988e6b570eb64a15e5b9ed35f421f8ead0"
RDEPENDS:systemd-resolved = " \
 shadow-utils \
 systemd \
 libgcc \
 openssl-libs \
 grep \
 bash \
 glibc \
 libidn2 \
"

URI_systemd-rpm-macros = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/systemd-rpm-macros-257-9.el10_0.1.alma.1.noarch.rpm;name=systemd-rpm-macros;unpack=0"
SRC_URI += "${URI_systemd-rpm-macros}"
SRC_URI[systemd-rpm-macros.sha256sum] = "ee4cc3d347dbab2f4fe1cb9c55c64f951c793999206234c427cd8cfeb3b56b46"
RDEPENDS:systemd-rpm-macros = " \
 bash \
"

URI_systemd-udev = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/systemd-udev-257-9.el10_0.1.alma.1.x86_64_v2.rpm;name=systemd-udev;unpack=0"
SRC_URI += "${URI_systemd-udev}"
SRC_URI[systemd-udev.sha256sum] = "28e1b1aeed26d79ddccbda37a2517cf3ff430100d37caa1d8cd58885ef38b93c"
RDEPENDS:systemd-udev = " \
 systemd \
 grubby \
 libfdisk \
 cryptsetup-libs \
 kmod \
 libgcc \
 openssl-libs \
 grep \
 libblkid \
 kmod-libs \
 kbd \
 bash \
 glibc \
"

URI_systemd-boot-unsigned = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/systemd-boot-unsigned-257-9.el10_0.1.alma.1.x86_64_v2.rpm;name=systemd-boot-unsigned;unpack=0"
SRC_URI += "${URI_systemd-boot-unsigned}"
SRC_URI[systemd-boot-unsigned.sha256sum] = "ae5f55021037567e423ea1ea2648dc1003eea1d288472377bf9bda158763ffe2"
RDEPENDS:systemd-boot-unsigned = ""

URI_systemd-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/systemd-devel-257-9.el10_0.1.alma.1.x86_64_v2.rpm;name=systemd-devel;unpack=0"
SRC_URI += "${URI_systemd-devel}"
SRC_URI[systemd-devel.sha256sum] = "8b6ef28756f0f3df1858c8d4a0d21fa4debea37b5c2cfc7c7acad1744b057aaf"
RDEPENDS:systemd-devel = " \
 systemd-rpm-macros \
 systemd-libs \
"

URI_systemd-journal-remote = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/systemd-journal-remote-257-9.el10_0.1.alma.1.x86_64_v2.rpm;name=systemd-journal-remote;unpack=0"
SRC_URI += "${URI_systemd-journal-remote}"
SRC_URI[systemd-journal-remote.sha256sum] = "f325b78854748499d4dcd97815143226125c32d5324a4c707b1c2a3739a2e188"
RDEPENDS:systemd-journal-remote = " \
 firewalld-filesystem \
 systemd \
 libgcc \
 libmicrohttpd \
 bash \
 libcurl \
 glibc \
"

URI_systemd-ukify = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/systemd-ukify-257-9.el10_0.1.alma.1.noarch.rpm;name=systemd-ukify;unpack=0"
SRC_URI += "${URI_systemd-ukify}"
SRC_URI[systemd-ukify.sha256sum] = "b0e7fdfc580a9962ea94f400bdca3c0e5571e31e3edd5930dca08713b09eebb6"
RDEPENDS:systemd-ukify = " \
 python3 \
 systemd \
 python3-pefile \
 python3-cryptography \
 systemd-boot-unsigned \
 python3-zstd \
"
