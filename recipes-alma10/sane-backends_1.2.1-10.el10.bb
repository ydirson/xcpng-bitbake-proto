# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sane-backends"
PE = "0"
PV = "1.2.1"
PR = "10.el10"
PACKAGES = "sane-backends sane-backends-daemon sane-backends-devel sane-backends-doc sane-backends-drivers-cameras sane-backends-drivers-scanners sane-backends-libs"
PROVIDES = "rpm/sane-backends rpm/sane-backends-daemon rpm/sane-backends-devel rpm/sane-backends-doc rpm/sane-backends-drivers-cameras rpm/sane-backends-drivers-scanners rpm/sane-backends-libs"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/sane-backends-1.2.1-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e102c2b4de8127cf732e52f0dfa7d03c76640a18c033f5d90072c257f2f43c3c"

URI_sane-backends = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sane-backends-1.2.1-10.el10.x86_64_v2.rpm;name=sane-backends;unpack=0"
SRC_URI += "${URI_sane-backends}"
SRC_URI[sane-backends.sha256sum] = "be4744762306c1d2b55df7b0fa287aff29122f03d0d6c4061ada1da1a498426d"
RDEPENDS:sane-backends = " \
 systemd \
 sane-backends-libs \
 libpng \
 systemd-udev \
 libieee1284 \
 libxml2 \
 bash \
 glibc \
 libjpeg-turbo \
 sane-airscan \
 libusb1 \
"

URI_sane-backends-daemon = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sane-backends-daemon-1.2.1-10.el10.x86_64_v2.rpm;name=sane-backends-daemon;unpack=0"
SRC_URI += "${URI_sane-backends-daemon}"
SRC_URI[sane-backends-daemon.sha256sum] = "a572786de8f52dfc7c543669568e8ab5fe05261f6afe42eb6c0eeafaefa61661"
RDEPENDS:sane-backends-daemon = " \
 sane-backends-libs \
 systemd-libs \
 bash \
 glibc \
 sane-backends \
"

URI_sane-backends-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sane-backends-devel-1.2.1-10.el10.x86_64_v2.rpm;name=sane-backends-devel;unpack=0"
SRC_URI += "${URI_sane-backends-devel}"
SRC_URI[sane-backends-devel.sha256sum] = "bc5742c6850cf28e82c69cd7bc35507e7df78af2fc4da9443561a3d9ff02ddbd"
RDEPENDS:sane-backends-devel = " \
 libtiff-devel \
 sane-backends-drivers-cameras \
 sane-backends-drivers-scanners \
 sane-backends-libs \
 pkgconf-pkg-config \
 libieee1284-devel \
 libusb1-devel \
 bash \
 libjpeg-turbo-devel \
 sane-backends \
"

URI_sane-backends-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sane-backends-doc-1.2.1-10.el10.noarch.rpm;name=sane-backends-doc;unpack=0"
SRC_URI += "${URI_sane-backends-doc}"
SRC_URI[sane-backends-doc.sha256sum] = "a8f719251fa758af5777e58436a7a2e161b6cbf9f8ab2f088e7b1b1876fe1a34"
RDEPENDS:sane-backends-doc = ""

URI_sane-backends-drivers-cameras = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sane-backends-drivers-cameras-1.2.1-10.el10.x86_64_v2.rpm;name=sane-backends-drivers-cameras;unpack=0"
SRC_URI += "${URI_sane-backends-drivers-cameras}"
SRC_URI[sane-backends-drivers-cameras.sha256sum] = "469010851f25b9eac3769854d4ae102e42e496ba77c9df4425fe4e09078f97af"
RDEPENDS:sane-backends-drivers-cameras = " \
 sane-backends-libs \
 libgcc \
 libieee1284 \
 libxml2 \
 libgphoto2 \
 libstdc++ \
 glibc \
 libv4l \
 libtiff \
 libjpeg-turbo \
 sane-backends \
 libusb1 \
"

URI_sane-backends-drivers-scanners = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sane-backends-drivers-scanners-1.2.1-10.el10.x86_64_v2.rpm;name=sane-backends-drivers-scanners;unpack=0"
SRC_URI += "${URI_sane-backends-drivers-scanners}"
SRC_URI[sane-backends-drivers-scanners.sha256sum] = "7612346e886a579e6bf4d655b5bce5a533bdd71538246d32dcf037ba38eb3446"
RDEPENDS:sane-backends-drivers-scanners = " \
 sane-backends-libs \
 libgcc \
 libieee1284 \
 libxml2 \
 libstdc++ \
 glibc \
 libtiff \
 libjpeg-turbo \
 sane-backends \
 libusb1 \
"

URI_sane-backends-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sane-backends-libs-1.2.1-10.el10.x86_64_v2.rpm;name=sane-backends-libs;unpack=0"
SRC_URI += "${URI_sane-backends-libs}"
SRC_URI[sane-backends-libs.sha256sum] = "1ee300bfe6b94728487e925674f6deb825a03219f2f6df416cf980511e4c199f"
RDEPENDS:sane-backends-libs = " \
 glibc \
 libxml2 \
 libusb1 \
"
