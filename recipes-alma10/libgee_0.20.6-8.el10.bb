# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libgee"
PE = "0"
PV = "0.20.6"
PR = "8.el10"
PACKAGES = "libgee libgee-devel"
PROVIDES = "rpm/libgee rpm/libgee-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libgee-0.20.6-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0799ef9e721be633854d8ecb6783c350f414748cf782a6cf08b898820279b739"

URI_libgee = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libgee-0.20.6-8.el10.x86_64_v2.rpm;name=libgee;unpack=0"
SRC_URI += "${URI_libgee}"
SRC_URI[libgee.sha256sum] = "686f2f9c809434cf34a6109858542cac284f79df576b9625f852d7753a34f37c"
RDEPENDS:libgee = " \
 glibc \
 glib2 \
"

URI_libgee-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libgee-devel-0.20.6-8.el10.x86_64_v2.rpm;name=libgee-devel;unpack=0"
SRC_URI += "${URI_libgee-devel}"
SRC_URI[libgee-devel.sha256sum] = "c3dac7e3c466f0cc8caa7db0351bd004c5281645800192efebb3a1ef48171b46"
RDEPENDS:libgee-devel = " \
 libgee \
 glib2-devel \
 pkgconf-pkg-config \
"
