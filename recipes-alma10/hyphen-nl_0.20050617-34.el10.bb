# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-nl"
PE = "0"
PV = "0.20050617"
PR = "34.el10"
PACKAGES = "hyphen-nl"
PROVIDES = "rpm/hyphen-nl"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-nl-0.20050617-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25d02571fa80444f4be76ee095f9015dac75f59dabd8129cce62adabb443277e"

URI_hyphen-nl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-nl-0.20050617-34.el10.noarch.rpm;name=hyphen-nl;unpack=0"
SRC_URI += "${URI_hyphen-nl}"
SRC_URI[hyphen-nl.sha256sum] = "03413b6091524ac5693918c88bdbf9ff0f3848bd63d588f8567d73c2a50f99ea"
RDEPENDS:hyphen-nl = " \
 hyphen \
"
