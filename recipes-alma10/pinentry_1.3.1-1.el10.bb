# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pinentry"
PE = "0"
PV = "1.3.1"
PR = "1.el10"
PACKAGES = "pinentry pinentry-gnome3 pinentry-tty pinentry-emacs pinentry-qt"
PROVIDES = "rpm/pinentry rpm/pinentry-gnome3 rpm/pinentry-tty rpm/pinentry-emacs rpm/pinentry-qt"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/pinentry-1.3.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d774330730a8fc034729917ce9ebbcce335807b259982272ee2cdc316d0ae3d6"

URI_pinentry = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pinentry-1.3.1-1.el10.x86_64_v2.rpm;name=pinentry;unpack=0"
SRC_URI += "${URI_pinentry}"
SRC_URI[pinentry.sha256sum] = "a645264ddd36d3ea37965fa0e5edde473d945116a44ea1cf810b14b9b3e57e8e"
RDEPENDS:pinentry = " \
 libassuan \
 libgpg-error \
 libsecret \
 ncurses-libs \
 bash \
 glib2 \
 glibc \
"

URI_pinentry-gnome3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pinentry-gnome3-1.3.1-1.el10.x86_64_v2.rpm;name=pinentry-gnome3;unpack=0"
SRC_URI += "${URI_pinentry-gnome3}"
SRC_URI[pinentry-gnome3.sha256sum] = "8547e109464ad46b3b4b172d98abab0598433b002832a1804fdc9a276f9771cb"
RDEPENDS:pinentry-gnome3 = " \
 libassuan \
 libgpg-error \
 pinentry \
 libsecret \
 ncurses-libs \
 glib2 \
 glibc \
 gcr-libs \
"

URI_pinentry-tty = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pinentry-tty-1.3.1-1.el10.x86_64_v2.rpm;name=pinentry-tty;unpack=0"
SRC_URI += "${URI_pinentry-tty}"
SRC_URI[pinentry-tty.sha256sum] = "e53d9968c63783361a5ef87466c109dfdaaf083e5b7e3869d1094df68fb2eea2"
RDEPENDS:pinentry-tty = " \
 libassuan \
 libgpg-error \
 pinentry \
 libsecret \
 glib2 \
 glibc \
"

URI_pinentry-emacs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/pinentry-emacs-1.3.1-1.el10.x86_64_v2.rpm;name=pinentry-emacs;unpack=0"
SRC_URI += "${URI_pinentry-emacs}"
SRC_URI[pinentry-emacs.sha256sum] = "be50df06cf2055f0c1b97b6e7d2bca8f772845591b75b4fb2cf6741447026e7a"
RDEPENDS:pinentry-emacs = " \
 libassuan \
 libgpg-error \
 pinentry \
 libsecret \
 glib2 \
 glibc \
"

URI_pinentry-qt = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/pinentry-qt-1.3.1-1.el10.x86_64_v2.rpm;name=pinentry-qt;unpack=0"
SRC_URI += "${URI_pinentry-qt}"
SRC_URI[pinentry-qt.sha256sum] = "f4f46fa219b121754a90be5d182429fe5e2e15a1a191ce6b9d18d1b9f8586d13"
RDEPENDS:pinentry-qt = " \
 libassuan \
 libgcc \
 qt6-qtbase \
 libgpg-error \
 pinentry \
 libsecret \
 libstdc++ \
 qt6-qtbase-gui \
 glib2 \
 ncurses-libs \
 glibc \
"
