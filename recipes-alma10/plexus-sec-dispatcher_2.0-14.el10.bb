# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "plexus-sec-dispatcher"
PE = "0"
PV = "2.0"
PR = "14.el10"
PACKAGES = "plexus-sec-dispatcher plexus-sec-dispatcher-javadoc"
PROVIDES = "rpm/plexus-sec-dispatcher rpm/plexus-sec-dispatcher-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/plexus-sec-dispatcher-2.0-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0bf7b0ce4f5b47942e22856c9e0a561abd53a4f18a9a20699b6f89a6bbec73b"

URI_plexus-sec-dispatcher = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/plexus-sec-dispatcher-2.0-14.el10.noarch.rpm;name=plexus-sec-dispatcher;unpack=0"
SRC_URI += "${URI_plexus-sec-dispatcher}"
SRC_URI[plexus-sec-dispatcher.sha256sum] = "5a55b653a5a10bb3af9d92cea849b9d2aef4233928e3a1059a2968a9000f3824"
RDEPENDS:plexus-sec-dispatcher = " \
 plexus-cipher \
 atinject \
 plexus-utils \
 javapackages-filesystem \
"

URI_plexus-sec-dispatcher-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-sec-dispatcher-javadoc-2.0-14.el10.noarch.rpm;name=plexus-sec-dispatcher-javadoc;unpack=0"
SRC_URI += "${URI_plexus-sec-dispatcher-javadoc}"
SRC_URI[plexus-sec-dispatcher-javadoc.sha256sum] = "976427431a461edbff0e6a5ff1370b3eec6bcc86f878c27b1f4faef86b708d8b"
RDEPENDS:plexus-sec-dispatcher-javadoc = " \
 javapackages-filesystem \
"
