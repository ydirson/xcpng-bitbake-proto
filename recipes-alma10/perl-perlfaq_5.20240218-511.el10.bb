# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-perlfaq"
PE = "0"
PV = "5.20240218"
PR = "511.el10"
PACKAGES = "perl-perlfaq perl-perlfaq-tests"
PROVIDES = "rpm/perl-perlfaq rpm/perl-perlfaq-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-perlfaq-5.20240218-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a33dee75e1c54b8da86b88b0fed3aac4b28d97cd681442ff1e94042a852d59c4"

URI_perl-perlfaq = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-perlfaq-5.20240218-511.el10.noarch.rpm;name=perl-perlfaq;unpack=0"
SRC_URI += "${URI_perl-perlfaq}"
SRC_URI[perl-perlfaq.sha256sum] = "6faef71d77d814ed09b4ff2478987a6c79d2da894214e7ddb190f82917844482"
RDEPENDS:perl-perlfaq = " \
 perl-libs \
"

URI_perl-perlfaq-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-perlfaq-tests-5.20240218-511.el10.noarch.rpm;name=perl-perlfaq-tests;unpack=0"
SRC_URI += "${URI_perl-perlfaq-tests}"
SRC_URI[perl-perlfaq-tests.sha256sum] = "01d4b4c2a87a5619dbf402e7801be07a82bd0f84d485dffc1ccfa2a9bb6ccb1c"
RDEPENDS:perl-perlfaq-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-IO \
 perl-IPC-Open3 \
 bash \
 perl-PathTools \
 perl-perlfaq \
 perl-interpreter \
"
