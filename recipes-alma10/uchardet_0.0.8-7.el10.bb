# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "uchardet"
PE = "0"
PV = "0.0.8"
PR = "7.el10"
PACKAGES = "uchardet uchardet-devel"
PROVIDES = "rpm/uchardet rpm/uchardet-devel"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/uchardet-0.0.8-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0d17b111a08714e557bf857021af1ac9cbcb25ff5980c31918c0f5e5adf68da"

URI_uchardet = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/uchardet-0.0.8-7.el10.x86_64_v2.rpm;name=uchardet;unpack=0"
SRC_URI += "${URI_uchardet}"
SRC_URI[uchardet.sha256sum] = "877ff6ef7ee620a238717775823d18ffc9599df551d6ac3baf2a179f94067480"
RDEPENDS:uchardet = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_uchardet-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/uchardet-devel-0.0.8-7.el10.x86_64_v2.rpm;name=uchardet-devel;unpack=0"
SRC_URI += "${URI_uchardet-devel}"
SRC_URI[uchardet-devel.sha256sum] = "794c744210779d7cb642482427afbb7b2ce5c4d31187d6ff83a00724d5fbfbfc"
RDEPENDS:uchardet-devel = " \
 uchardet \
 cmake-filesystem \
 pkgconf-pkg-config \
"
