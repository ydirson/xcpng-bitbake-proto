# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Test-Warn"
PE = "0"
PV = "0.37"
PR = "7.el10"
PACKAGES = "perl-Test-Warn"
PROVIDES = "rpm/perl-Test-Warn"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Test-Warn-0.37-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "977ffe891edd38afbd80552b6b4d42ed9e67a13efaa2d6a2ae23968a2ead51c0"

URI_perl-Test-Warn = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Test-Warn-0.37-7.el10.noarch.rpm;name=perl-Test-Warn;unpack=0"
SRC_URI += "${URI_perl-Test-Warn}"
SRC_URI[perl-Test-Warn.sha256sum] = "b0a080c76cbaac456946d2f177d12d95a7e3db6d66633e4409b88c9303281da0"
RDEPENDS:perl-Test-Warn = " \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-Sub-Uplevel \
 perl-Exporter \
"
