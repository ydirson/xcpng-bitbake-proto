# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ansible-collection-microsoft-sql"
PE = "0"
PV = "2.5.2"
PR = "1.el10"
PACKAGES = "ansible-collection-microsoft-sql"
PROVIDES = "rpm/ansible-collection-microsoft-sql"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ansible-collection-microsoft-sql-2.5.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf98dca9fcf9ee2095d7a761aefba8aa7022199408a42e840ddfa87dfdc75085"

URI_ansible-collection-microsoft-sql = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ansible-collection-microsoft-sql-2.5.2-1.el10.noarch.rpm;name=ansible-collection-microsoft-sql;unpack=0"
SRC_URI += "${URI_ansible-collection-microsoft-sql}"
SRC_URI[ansible-collection-microsoft-sql.sha256sum] = "d3c74ce58b65861983ae98c71f193c4b5efaf7f4c5c291f39fedd627ef806e30"
RDEPENDS:ansible-collection-microsoft-sql = " \
 ansible-core \
 rhel-system-roles \
 bash \
"
