# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Unicode-UTF8"
PE = "0"
PV = "0.62"
PR = "28.el10"
PACKAGES = "perl-Unicode-UTF8 perl-Unicode-UTF8-tests"
PROVIDES = "rpm/perl-Unicode-UTF8 rpm/perl-Unicode-UTF8-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Unicode-UTF8-0.62-28.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d630625279792a647c3a1bb0a9a0298b69e7e2280fc76c98efad6aaab1546133"

URI_perl-Unicode-UTF8 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Unicode-UTF8-0.62-28.el10.x86_64_v2.rpm;name=perl-Unicode-UTF8;unpack=0"
SRC_URI += "${URI_perl-Unicode-UTF8}"
SRC_URI[perl-Unicode-UTF8.sha256sum] = "98449c5ab55f98bd9c803875203608faa463482c7c54d5bbeec9f8c3be50c268"
RDEPENDS:perl-Unicode-UTF8 = " \
 glibc \
 perl-Exporter \
 perl-libs \
"

URI_perl-Unicode-UTF8-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Unicode-UTF8-tests-0.62-28.el10.x86_64_v2.rpm;name=perl-Unicode-UTF8-tests;unpack=0"
SRC_URI += "${URI_perl-Unicode-UTF8-tests}"
SRC_URI[perl-Unicode-UTF8-tests.sha256sum] = "ec7c5ffbd0691122cf65bc3a6f2837dbd7a294561d5568da5a491f07402bb34c"
RDEPENDS:perl-Unicode-UTF8-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-Scalar-List-Utils \
 perl-IO \
 perl-Unicode-UTF8 \
 perl-Encode \
 bash \
 perl-interpreter \
 perl-Test-Fatal \
 perl-lib \
"
