# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "apiguardian"
PE = "0"
PV = "1.1.2"
PR = "13.el10"
PACKAGES = "apiguardian apiguardian-javadoc"
PROVIDES = "rpm/apiguardian rpm/apiguardian-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/apiguardian-1.1.2-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b78762b4f99d234626ec8c50343ea5f21ddb9318df14dcac0967934021648068"

URI_apiguardian = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/apiguardian-1.1.2-13.el10.noarch.rpm;name=apiguardian;unpack=0"
SRC_URI += "${URI_apiguardian}"
SRC_URI[apiguardian.sha256sum] = "556ba9ad2f7ec41a4d4b68452bc4c9c320d9f37ef7286bdb44bd1b1602c96277"
RDEPENDS:apiguardian = " \
 javapackages-filesystem \
"

URI_apiguardian-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/apiguardian-javadoc-1.1.2-13.el10.noarch.rpm;name=apiguardian-javadoc;unpack=0"
SRC_URI += "${URI_apiguardian-javadoc}"
SRC_URI[apiguardian-javadoc.sha256sum] = "6177b13c498b7894e131f88364cc05fa302640e2a157995a8a68f608d2ed022f"
RDEPENDS:apiguardian-javadoc = " \
 javapackages-filesystem \
"
