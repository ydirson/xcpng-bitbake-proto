# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "s-nail"
PE = "0"
PV = "14.9.24"
PR = "12.el10"
PACKAGES = "s-nail"
PROVIDES = "rpm/s-nail"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/s-nail-14.9.24-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63a66a5bc227868ad50505bfbbd194626be3603fcb4618f06e6d54af1ec5579e"

URI_s-nail = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/s-nail-14.9.24-12.el10.x86_64_v2.rpm;name=s-nail;unpack=0"
SRC_URI += "${URI_s-nail}"
SRC_URI[s-nail.sha256sum] = "13985f0993b1e3f4f096ab2f576dd59a44884ad41fe81ca4d6a3e17b54e8329a"
RDEPENDS:s-nail = " \
 openssl-libs \
 krb5-libs \
 bash \
 ncurses-libs \
 glibc \
 alternatives \
 libidn2 \
"
