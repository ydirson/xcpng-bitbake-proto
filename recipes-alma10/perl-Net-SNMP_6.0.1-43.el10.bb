# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Net-SNMP"
PE = "0"
PV = "6.0.1"
PR = "43.el10"
PACKAGES = "perl-Net-SNMP perl-Net-SNMP-tests"
PROVIDES = "rpm/perl-Net-SNMP rpm/perl-Net-SNMP-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Net-SNMP-6.0.1-43.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac59413df4398317b63cd04a7e05871592b739d06c0845046afbc38f08a59f39"

URI_perl-Net-SNMP = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Net-SNMP-6.0.1-43.el10.noarch.rpm;name=perl-Net-SNMP;unpack=0"
SRC_URI += "${URI_perl-Net-SNMP}"
SRC_URI[perl-Net-SNMP.sha256sum] = "b39207bf9fed2bf7b00e1aeb084b6860bca73aaa9ee397c38d2cfd810391fa92"
RDEPENDS:perl-Net-SNMP = " \
 perl-Math-BigInt \
 perl-libs \
 perl-Carp \
 perl-interpreter \
 perl-IO \
 perl-Digest-HMAC \
 perl-Digest-MD5 \
 perl-Socket \
 perl-Digest-SHA \
 perl-Crypt-DES \
 perl-Errno \
 perl-Exporter \
 perl-base \
 perl-Net-SNMP \
"

URI_perl-Net-SNMP-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Net-SNMP-tests-6.0.1-43.el10.noarch.rpm;name=perl-Net-SNMP-tests;unpack=0"
SRC_URI += "${URI_perl-Net-SNMP-tests}"
SRC_URI[perl-Net-SNMP-tests.sha256sum] = "78bc1f420e0a62434d2c9a2a57322976b06038c257bc8ed70c953b18e2003cc7"
RDEPENDS:perl-Net-SNMP-tests = " \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 bash \
 perl-interpreter \
 perl-Net-SNMP \
"
