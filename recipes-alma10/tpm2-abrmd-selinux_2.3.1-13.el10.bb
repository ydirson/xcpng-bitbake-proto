# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tpm2-abrmd-selinux"
PE = "0"
PV = "2.3.1"
PR = "13.el10"
PACKAGES = "tpm2-abrmd-selinux"
PROVIDES = "rpm/tpm2-abrmd-selinux"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tpm2-abrmd-selinux-2.3.1-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e01fa753d93b80be0ec6bfe526cbb5635a89d0e8d1af4ac6b3610c768bb5eee3"

URI_tpm2-abrmd-selinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tpm2-abrmd-selinux-2.3.1-13.el10.noarch.rpm;name=tpm2-abrmd-selinux;unpack=0"
SRC_URI += "${URI_tpm2-abrmd-selinux}"
SRC_URI[tpm2-abrmd-selinux.sha256sum] = "61dee5fced2fee09bd43cf5409c508f37a1e4c7d7a4a7b6cfeae0527b189a01f"
RDEPENDS:tpm2-abrmd-selinux = " \
 policycoreutils-python-utils \
 policycoreutils \
 bash \
 selinux-policy \
 libselinux-utils \
"
