# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libatasmart"
PE = "0"
PV = "0.19"
PR = "30.el10"
PACKAGES = "libatasmart libatasmart-devel"
PROVIDES = "rpm/libatasmart rpm/libatasmart-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libatasmart-0.19-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84d8bf63bd19602736c9f0413b12dcf819b02fdf99d575e76cb5a802c737dc78"

URI_libatasmart = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libatasmart-0.19-30.el10.x86_64_v2.rpm;name=libatasmart;unpack=0"
SRC_URI += "${URI_libatasmart}"
SRC_URI[libatasmart.sha256sum] = "ee928598c341207ffe579e799d2d2cd18b34efc067126a848aeb57569444ed5f"
RDEPENDS:libatasmart = " \
 glibc \
 systemd-libs \
"

URI_libatasmart-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libatasmart-devel-0.19-30.el10.x86_64_v2.rpm;name=libatasmart-devel;unpack=0"
SRC_URI += "${URI_libatasmart-devel}"
SRC_URI[libatasmart-devel.sha256sum] = "b44221b093c9bcd28aa77e5c123ac6cd5cc829695da08f3b69f524dad09e3657"
RDEPENDS:libatasmart-devel = " \
 libatasmart \
 vala \
 pkgconf-pkg-config \
"
