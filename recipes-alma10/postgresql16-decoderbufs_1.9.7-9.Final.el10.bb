# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "postgresql16-decoderbufs"
PE = "0"
PV = "1.9.7"
PR = "9.Final.el10"
PACKAGES = "postgres-decoderbufs"
PROVIDES = "rpm/postgres-decoderbufs"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/postgresql16-decoderbufs-1.9.7-9.Final.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc9e83844e4a3a4ede88d19624951d39a18f039413608aa393fb96e3c92377d0"

URI_postgres-decoderbufs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postgres-decoderbufs-1.9.7-9.Final.el10.x86_64_v2.rpm;name=postgres-decoderbufs;unpack=0"
SRC_URI += "${URI_postgres-decoderbufs}"
SRC_URI[postgres-decoderbufs.sha256sum] = "0369f55cf64d1f129dd6f044678ca4a343b3df9056171e3018acb5b981b71b9d"
RDEPENDS:postgres-decoderbufs = " \
 glibc \
 postgresql-server \
 protobuf-c \
"
