# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "micropipenv"
PE = "0"
PV = "1.6.0"
PR = "9.el10"
PACKAGES = "micropipenv micropipenv+toml"
PROVIDES = "rpm/micropipenv rpm/micropipenv+toml"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/micropipenv-1.6.0-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d4a3da237f5e2e4d4f05bfd62dcbb863c625f4b546707030f2a716719c46f93"

URI_micropipenv = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/micropipenv-1.6.0-9.el10.noarch.rpm;name=micropipenv;unpack=0"
SRC_URI += "${URI_micropipenv}"
SRC_URI[micropipenv.sha256sum] = "f758953feff048ca692622b91008076e10b28ef0dd4da165d898a6bd9d6bc55e"
RDEPENDS:micropipenv = " \
 python3 \
 python3-pip \
"

URI_micropipenv+toml = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/micropipenv+toml-1.6.0-9.el10.noarch.rpm;name=micropipenv+toml;unpack=0"
SRC_URI += "${URI_micropipenv+toml}"
SRC_URI[micropipenv+toml.sha256sum] = "9bbdf3889d93e6609dc7b2af32fb0885a99d0eda5e387e014b05724feab6a18e"
RDEPENDS:micropipenv+toml = " \
 python3 \
 micropipenv \
"
