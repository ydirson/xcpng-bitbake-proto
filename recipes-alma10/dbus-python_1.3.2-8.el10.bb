# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dbus-python"
PE = "0"
PV = "1.3.2"
PR = "8.el10"
PACKAGES = "python3-dbus dbus-python-devel"
PROVIDES = "rpm/python3-dbus rpm/dbus-python-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/dbus-python-1.3.2-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7fc39e071e552931ba2383a78e0caf7fd487e075f5b253bfdf9985aaa12ac19d"

URI_python3-dbus = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-dbus-1.3.2-8.el10.x86_64_v2.rpm;name=python3-dbus;unpack=0"
SRC_URI += "${URI_python3-dbus}"
SRC_URI[python3-dbus.sha256sum] = "08b7bedeb61cbd8fadc25ecadaa14a4010daf84e20ad1a8216ca60d1490656bb"
RDEPENDS:python3-dbus = " \
 glibc \
 dbus-libs \
 python3 \
 glib2 \
"

URI_dbus-python-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/dbus-python-devel-1.3.2-8.el10.x86_64_v2.rpm;name=dbus-python-devel;unpack=0"
SRC_URI += "${URI_dbus-python-devel}"
SRC_URI[dbus-python-devel.sha256sum] = "1f0886b8e941cb994174f2cd47ae13261aa55c6376c9c62dbd7e72b699a9ac27"
RDEPENDS:dbus-python-devel = " \
 dbus-devel \
 pkgconf-pkg-config \
"
