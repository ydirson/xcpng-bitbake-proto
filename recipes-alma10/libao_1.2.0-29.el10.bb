# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libao"
PE = "0"
PV = "1.2.0"
PR = "29.el10"
PACKAGES = "libao libao-devel"
PROVIDES = "rpm/libao rpm/libao-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libao-1.2.0-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb02d438f60fac31a98f18c95ca91dde6a03ace03b8bdb88f3c7f787e66e0a72"

URI_libao = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libao-1.2.0-29.el10.x86_64_v2.rpm;name=libao;unpack=0"
SRC_URI += "${URI_libao}"
SRC_URI[libao.sha256sum] = "fcd995ca4b7faad2ca8361e5a5d74b0cc64da4e8bda6fbbbb68d6c81eddc8df4"
RDEPENDS:libao = " \
 glibc \
 pulseaudio-libs \
 alsa-lib \
"

URI_libao-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libao-devel-1.2.0-29.el10.x86_64_v2.rpm;name=libao-devel;unpack=0"
SRC_URI += "${URI_libao-devel}"
SRC_URI[libao-devel.sha256sum] = "f7fcfbf698cf3be86b664139eed26db44bda460d1439f907bd36b23ab92166ac"
RDEPENDS:libao-devel = " \
 pkgconf-pkg-config \
 libao \
"
