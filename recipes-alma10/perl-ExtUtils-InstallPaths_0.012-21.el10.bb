# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-InstallPaths"
PE = "0"
PV = "0.012"
PR = "21.el10"
PACKAGES = "perl-ExtUtils-InstallPaths"
PROVIDES = "rpm/perl-ExtUtils-InstallPaths"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-ExtUtils-InstallPaths-0.012-21.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4ada82863ea6c3d6f8fa018fdfcd025b2d1d384b71f5c98c8f7531680c6bf4f"

URI_perl-ExtUtils-InstallPaths = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-ExtUtils-InstallPaths-0.012-21.el10.noarch.rpm;name=perl-ExtUtils-InstallPaths;unpack=0"
SRC_URI += "${URI_perl-ExtUtils-InstallPaths}"
SRC_URI[perl-ExtUtils-InstallPaths.sha256sum] = "d597285ade6c7e4be2e6eec8d9184c74f9860237520930109eebc444d259e2a5"
RDEPENDS:perl-ExtUtils-InstallPaths = " \
 perl-PathTools \
 perl-libs \
 perl-ExtUtils-Config \
 perl-Carp \
"
