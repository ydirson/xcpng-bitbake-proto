# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libica"
PE = "0"
PV = "4.4.0"
PR = "1.el10"
PACKAGES = ""
PROVIDES = ""


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libica-4.4.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3ea79ba81dc18bad7557c76641da899fbcd1d6617b6ffffbfac1b10399a2eed"
