# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jdependency"
PE = "0"
PV = "2.8.0"
PR = "7.el10"
PACKAGES = "jdependency jdependency-javadoc"
PROVIDES = "rpm/jdependency rpm/jdependency-javadoc"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/jdependency-2.8.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e62c4bf4de1fbe96de458ce612d595441bfea1cc71730528cb76f7298789eae"

URI_jdependency = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/jdependency-2.8.0-7.el10.noarch.rpm;name=jdependency;unpack=0"
SRC_URI += "${URI_jdependency}"
SRC_URI[jdependency.sha256sum] = "e894c267e3dfcc598918648a15d81c4be29406490585e1832fe983f349b9b7fe"
RDEPENDS:jdependency = " \
 objectweb-asm \
 apache-commons-io \
 javapackages-filesystem \
 java-21-openjdk-headless \
"

URI_jdependency-javadoc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/jdependency-javadoc-2.8.0-7.el10.noarch.rpm;name=jdependency-javadoc;unpack=0"
SRC_URI += "${URI_jdependency-javadoc}"
SRC_URI[jdependency-javadoc.sha256sum] = "4ca5f509eb0f9f32fd517a7eb9a01089d585ca7a284feae2a8e259c0b550ef9f"
RDEPENDS:jdependency-javadoc = " \
 javapackages-filesystem \
"
