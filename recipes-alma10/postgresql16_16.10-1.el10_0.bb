# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "postgresql16"
PE = "0"
PV = "16.10"
PR = "1.el10_0"
PACKAGES = "postgresql postgresql-contrib postgresql-docs postgresql-plperl postgresql-plpython3 postgresql-pltcl postgresql-private-devel postgresql-private-libs postgresql-server postgresql-server-devel postgresql-static postgresql-test postgresql-upgrade postgresql-upgrade-devel postgresql-test-rpm-macros"
PROVIDES = "rpm/postgresql rpm/postgresql-contrib rpm/postgresql-docs rpm/postgresql-plperl rpm/postgresql-plpython3 rpm/postgresql-pltcl rpm/postgresql-private-devel rpm/postgresql-private-libs rpm/postgresql-server rpm/postgresql-server-devel rpm/postgresql-static rpm/postgresql-test rpm/postgresql-upgrade rpm/postgresql-upgrade-devel rpm/postgresql-test-rpm-macros"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/postgresql16-16.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f03a10acd2bbec2b8371b78c1b28f2f2bb47db326453ea094512ad376fdab93c"

URI_postgresql = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postgresql-16.10-1.el10_0.x86_64_v2.rpm;name=postgresql;unpack=0"
SRC_URI += "${URI_postgresql}"
SRC_URI[postgresql.sha256sum] = "34ac485f5ee794b738508ec52491db3d7276cae70a5f8e53c492a54330f481f2"
RDEPENDS:postgresql = " \
 zlib-ng-compat \
 lz4-libs \
 openssl-libs \
 readline \
 postgresql-private-libs \
 libzstd \
 glibc \
"

URI_postgresql-contrib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postgresql-contrib-16.10-1.el10_0.x86_64_v2.rpm;name=postgresql-contrib;unpack=0"
SRC_URI += "${URI_postgresql-contrib}"
SRC_URI[postgresql-contrib.sha256sum] = "c5f542e05ea572fdad6f302406e973ea6bd3ac3aeb8256ab0582cd311cdb6e94"
RDEPENDS:postgresql-contrib = " \
 zlib-ng-compat \
 perl-libs \
 libxslt \
 lz4-libs \
 openssl-libs \
 libxml2 \
 python3-libs \
 postgresql-private-libs \
 libzstd \
 uuid \
 glibc \
 libselinux \
 postgresql \
"

URI_postgresql-docs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postgresql-docs-16.10-1.el10_0.x86_64_v2.rpm;name=postgresql-docs;unpack=0"
SRC_URI += "${URI_postgresql-docs}"
SRC_URI[postgresql-docs.sha256sum] = "e091c51634679e62cc87f856726978115e355c7757a81eb7bc989e95f68f08cc"
RDEPENDS:postgresql-docs = " \
 glibc \
 postgresql \
"

URI_postgresql-plperl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postgresql-plperl-16.10-1.el10_0.x86_64_v2.rpm;name=postgresql-plperl;unpack=0"
SRC_URI += "${URI_postgresql-plperl}"
SRC_URI[postgresql-plperl.sha256sum] = "e80f43fae6d03f8330f8575e95110d3c69f00791997a09480dfed8160b8645c2"
RDEPENDS:postgresql-plperl = " \
 glibc \
 postgresql-server \
 perl-libs \
"

URI_postgresql-plpython3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postgresql-plpython3-16.10-1.el10_0.x86_64_v2.rpm;name=postgresql-plpython3;unpack=0"
SRC_URI += "${URI_postgresql-plpython3}"
SRC_URI[postgresql-plpython3.sha256sum] = "062ff30eedd06f13c83026f71b383bee3c9fa3388449af44b61aa4ef8dc5be83"
RDEPENDS:postgresql-plpython3 = " \
 glibc \
 postgresql-server \
 python3-libs \
"

URI_postgresql-pltcl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postgresql-pltcl-16.10-1.el10_0.x86_64_v2.rpm;name=postgresql-pltcl;unpack=0"
SRC_URI += "${URI_postgresql-pltcl}"
SRC_URI[postgresql-pltcl.sha256sum] = "c45a02a7df65e3ef3718015ead35a3ca43ca05f474b6a96800bbdee0a9c56f02"
RDEPENDS:postgresql-pltcl = " \
 glibc \
 postgresql-server \
 tcl \
"

URI_postgresql-private-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postgresql-private-devel-16.10-1.el10_0.x86_64_v2.rpm;name=postgresql-private-devel;unpack=0"
SRC_URI += "${URI_postgresql-private-devel}"
SRC_URI[postgresql-private-devel.sha256sum] = "d589eb24a9b50daf7b7d8a2fa0cbf0ca7d1b3d54e8d672d9b97a29a8b8888158"
RDEPENDS:postgresql-private-devel = " \
 openssl-devel \
 pkgconf-pkg-config \
 postgresql-private-libs \
"

URI_postgresql-private-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postgresql-private-libs-16.10-1.el10_0.x86_64_v2.rpm;name=postgresql-private-libs;unpack=0"
SRC_URI += "${URI_postgresql-private-libs}"
SRC_URI[postgresql-private-libs.sha256sum] = "be32fe717ae90f63cb925e367218327b809259e5c75cf6bd996def4215ad6542"
RDEPENDS:postgresql-private-libs = " \
 glibc \
 krb5-libs \
 openssl-libs \
 openldap \
"

URI_postgresql-server = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postgresql-server-16.10-1.el10_0.x86_64_v2.rpm;name=postgresql-server;unpack=0"
SRC_URI += "${URI_postgresql-server}"
SRC_URI[postgresql-server.sha256sum] = "671952fe10a4df9de8a3febce522ee9fd3ae43ecc66209f4fd6fa33e249ece0d"
RDEPENDS:postgresql-server = " \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 systemd-libs \
 util-linux \
 lz4-libs \
 openssl-libs \
 libxml2 \
 postgresql-private-libs \
 libzstd \
 krb5-libs \
 pam-libs \
 bash \
 glibc \
 libicu \
 openldap \
 postgresql \
"

URI_postgresql-server-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postgresql-server-devel-16.10-1.el10_0.x86_64_v2.rpm;name=postgresql-server-devel;unpack=0"
SRC_URI += "${URI_postgresql-server-devel}"
SRC_URI[postgresql-server-devel.sha256sum] = "244bfd215b4a357e4dc192ccd7ecdf4a0526e80b58e914db33fc4e78ca6bf638"
RDEPENDS:postgresql-server-devel = " \
 libicu-devel \
 postgresql-private-devel \
 postgresql-private-libs \
 bash \
 glibc \
 krb5-devel \
"

URI_postgresql-static = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postgresql-static-16.10-1.el10_0.x86_64_v2.rpm;name=postgresql-static;unpack=0"
SRC_URI += "${URI_postgresql-static}"
SRC_URI[postgresql-static.sha256sum] = "9346855312bdfcb4d295a3e23dad91990ca37f5a6c7437159e6f36bd4ae2d0db"
RDEPENDS:postgresql-static = " \
 postgresql-server-devel \
"

URI_postgresql-test = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postgresql-test-16.10-1.el10_0.x86_64_v2.rpm;name=postgresql-test;unpack=0"
SRC_URI += "${URI_postgresql-test}"
SRC_URI[postgresql-test.sha256sum] = "db4aeaa1b894f377b82c2e9b97604ff72af844b1501751bdb84fa6e3f3fa4dfb"
RDEPENDS:postgresql-test = " \
 postgresql-contrib \
 postgresql-server \
 postgresql-server-devel \
 bash \
 glibc \
"

URI_postgresql-upgrade = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postgresql-upgrade-16.10-1.el10_0.x86_64_v2.rpm;name=postgresql-upgrade;unpack=0"
SRC_URI += "${URI_postgresql-upgrade}"
SRC_URI[postgresql-upgrade.sha256sum] = "b29aec3cdb8de7db3102bd9c1392b2f84b490374053cfbdfe70134ea0bd2251c"
RDEPENDS:postgresql-upgrade = " \
 zlib-ng-compat \
 perl-libs \
 libxslt \
 libxml2 \
 python3-libs \
 postgresql-private-libs \
 libicu \
 krb5-libs \
 pam-libs \
 tcl \
 uuid \
 postgresql-server \
 glibc \
 libselinux \
 openldap \
"

URI_postgresql-upgrade-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postgresql-upgrade-devel-16.10-1.el10_0.x86_64_v2.rpm;name=postgresql-upgrade-devel;unpack=0"
SRC_URI += "${URI_postgresql-upgrade-devel}"
SRC_URI[postgresql-upgrade-devel.sha256sum] = "ce9ad2be24e0705e37158cbd1e4bc1a3de5fe71fe36e4d879a8ecad41dfbcfce"
RDEPENDS:postgresql-upgrade-devel = " \
 glibc \
 postgresql-upgrade \
 bash \
"

URI_postgresql-test-rpm-macros = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/postgresql-test-rpm-macros-16.10-1.el10_0.noarch.rpm;name=postgresql-test-rpm-macros;unpack=0"
SRC_URI += "${URI_postgresql-test-rpm-macros}"
SRC_URI[postgresql-test-rpm-macros.sha256sum] = "0a91c240bcbf51741f9381860e8d2d1a39b462ac2513d4c5e84faba5a11096c3"
RDEPENDS:postgresql-test-rpm-macros = " \
 postgresql-server \
"
