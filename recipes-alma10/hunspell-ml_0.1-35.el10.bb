# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-ml"
PE = "0"
PV = "0.1"
PR = "35.el10"
PACKAGES = "hunspell-ml"
PROVIDES = "rpm/hunspell-ml"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-ml-0.1-35.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "867ddb8316570e4179548d25337eeb22ba1cbcbeca91a2afc8dcaaa5e502ee45"

URI_hunspell-ml = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-ml-0.1-35.el10.noarch.rpm;name=hunspell-ml;unpack=0"
SRC_URI += "${URI_hunspell-ml}"
SRC_URI[hunspell-ml.sha256sum] = "e5fca9b493e029ab9a6f4dc6ab9328525e213df0d12279e84d727575e07b43e2"
RDEPENDS:hunspell-ml = " \
 hunspell-filesystem \
"
