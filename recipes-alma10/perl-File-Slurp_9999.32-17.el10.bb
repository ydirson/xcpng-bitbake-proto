# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-File-Slurp"
PE = "0"
PV = "9999.32"
PR = "17.el10"
PACKAGES = "perl-File-Slurp perl-File-Slurp-tests"
PROVIDES = "rpm/perl-File-Slurp rpm/perl-File-Slurp-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-File-Slurp-9999.32-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73985aa0a30785d2b39e409d94c89a73ede2e7f26b369fcdffa2b79f84226c09"

URI_perl-File-Slurp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-File-Slurp-9999.32-17.el10.noarch.rpm;name=perl-File-Slurp;unpack=0"
SRC_URI += "${URI_perl-File-Slurp}"
SRC_URI[perl-File-Slurp.sha256sum] = "7f33ac354ce0ecd2ddea02e5c39b0bc60ae28c833df894a523109b9e7f955490"
RDEPENDS:perl-File-Slurp = " \
 perl-libs \
 perl-Carp \
 perl-IO \
 perl-Fcntl \
 perl-POSIX \
 perl-File-Basename \
 perl-PathTools \
 perl-Errno \
 perl-Exporter \
 perl-File-Temp \
"

URI_perl-File-Slurp-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-File-Slurp-tests-9999.32-17.el10.noarch.rpm;name=perl-File-Slurp-tests;unpack=0"
SRC_URI += "${URI_perl-File-Slurp-tests}"
SRC_URI[perl-File-Slurp-tests.sha256sum] = "2d6e03396c94da1f062f2d0dc26a3473d925073188c18716ddfea0a46e185e15"
RDEPENDS:perl-File-Slurp-tests = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Socket \
 perl-overload \
 perl-Symbol \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Carp \
 perl-IO \
 perl-lib \
 bash \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-POSIX \
 perl-PathTools \
 perl-interpreter \
 perl-File-Slurp \
 perl-File-Temp \
"
