# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mingw-binutils"
PE = "0"
PV = "2.43.1"
PR = "2.el10"
PACKAGES = "mingw-binutils-generic mingw32-binutils mingw64-binutils ucrt64-binutils"
PROVIDES = "rpm/mingw-binutils-generic rpm/mingw32-binutils rpm/mingw64-binutils rpm/ucrt64-binutils"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/mingw-binutils-2.43.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d71368daa039e3a5a3c32dfe3e599bdfeac19ba3254d5a2108ea2ba778ad35b"

URI_mingw-binutils-generic = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw-binutils-generic-2.43.1-2.el10.x86_64_v2.rpm;name=mingw-binutils-generic;unpack=0"
SRC_URI += "${URI_mingw-binutils-generic}"
SRC_URI[mingw-binutils-generic.sha256sum] = "e29ff139cd012b81ffab08475aee5d37833f1a9a513aa5e6237dd974d56f4df0"
RDEPENDS:mingw-binutils-generic = " \
 glibc \
"

URI_mingw32-binutils = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw32-binutils-2.43.1-2.el10.x86_64_v2.rpm;name=mingw32-binutils;unpack=0"
SRC_URI += "${URI_mingw32-binutils}"
SRC_URI[mingw32-binutils.sha256sum] = "fd797f7c1165fca22ebb3d964ad205bf5e43c7d8a176d93831db6eb31b4eb4c5"
RDEPENDS:mingw32-binutils = " \
 glibc \
 mingw-binutils-generic \
 mingw32-filesystem \
"

URI_mingw64-binutils = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw64-binutils-2.43.1-2.el10.x86_64_v2.rpm;name=mingw64-binutils;unpack=0"
SRC_URI += "${URI_mingw64-binutils}"
SRC_URI[mingw64-binutils.sha256sum] = "8adbc875f82e5d50b971c10cd85058efc74a02c8f664c1065cc9feea8478ca2e"
RDEPENDS:mingw64-binutils = " \
 glibc \
 mingw-binutils-generic \
 mingw64-filesystem \
"

URI_ucrt64-binutils = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ucrt64-binutils-2.43.1-2.el10.x86_64_v2.rpm;name=ucrt64-binutils;unpack=0"
SRC_URI += "${URI_ucrt64-binutils}"
SRC_URI[ucrt64-binutils.sha256sum] = "0512dc8a5013c1001bcdb14bd4d19f0e719487b2acf9bf86558aae9c9b898f6c"
RDEPENDS:ucrt64-binutils = " \
 glibc \
 mingw-binutils-generic \
 ucrt64-filesystem \
"
