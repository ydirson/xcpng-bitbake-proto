# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "wayland-protocols"
PE = "0"
PV = "1.41"
PR = "1.el10"
PACKAGES = "wayland-protocols-devel"
PROVIDES = "rpm/wayland-protocols-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/wayland-protocols-1.41-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb9cfe5b4ea80b20543a3d1b72985012b43ba06d6e64ec8dfc0ca686ecfc4d27"

URI_wayland-protocols-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/wayland-protocols-devel-1.41-1.el10.noarch.rpm;name=wayland-protocols-devel;unpack=0"
SRC_URI += "${URI_wayland-protocols-devel}"
SRC_URI[wayland-protocols-devel.sha256sum] = "756d10f11e7abbbc31f91a8e83d4cf5867b807fd792f7482c5499875f90c817f"
RDEPENDS:wayland-protocols-devel = " \
 pkgconf-pkg-config \
"
