# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-ro"
PE = "0"
PV = "3.3.10"
PR = "10.el10"
PACKAGES = "hunspell-ro"
PROVIDES = "rpm/hunspell-ro"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-ro-3.3.10-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03254c8a25840978fb6f43ea99e37248b003464d9a4185dc10c9786b292ec52b"

URI_hunspell-ro = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-ro-3.3.10-10.el10.noarch.rpm;name=hunspell-ro;unpack=0"
SRC_URI += "${URI_hunspell-ro}"
SRC_URI[hunspell-ro.sha256sum] = "c49870ff88465a0528ebfe42d0744598ed345b0cf43db15678ba139423954dda"
RDEPENDS:hunspell-ro = " \
 hunspell \
"
