# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "setxkbmap"
PE = "0"
PV = "1.3.4"
PR = "4.el10"
PACKAGES = "setxkbmap"
PROVIDES = "rpm/setxkbmap"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/setxkbmap-1.3.4-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "170cc3bc8046576fdadcc7ea419f39ca8360d5bd8aa12e012e95d9f30e618c80"

URI_setxkbmap = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/setxkbmap-1.3.4-4.el10.x86_64_v2.rpm;name=setxkbmap;unpack=0"
SRC_URI += "${URI_setxkbmap}"
SRC_URI[setxkbmap.sha256sum] = "6d52da4e5884df743e8c66ff7cd644700f72b61a0548f49c1078c657b967b226"
RDEPENDS:setxkbmap = " \
 glibc \
 libxkbfile \
 libX11 \
 libXrandr \
"
