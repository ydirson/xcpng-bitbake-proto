# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "apache-logging-parent"
PE = "0"
PV = "9"
PR = "6.el10"
PACKAGES = "apache-logging-parent"
PROVIDES = "rpm/apache-logging-parent"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/apache-logging-parent-9-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c933c2b611769f2e82e2ba707385eb4ecdd9092498e4c8ba016513303f91a7c"

URI_apache-logging-parent = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/apache-logging-parent-9-6.el10.noarch.rpm;name=apache-logging-parent;unpack=0"
SRC_URI += "${URI_apache-logging-parent}"
SRC_URI[apache-logging-parent.sha256sum] = "4038489e17845a1991b13715982d2a6a72059b7b2e4b0286b0a12b8256631a7f"
RDEPENDS:apache-logging-parent = " \
 java-21-openjdk-headless \
 javapackages-filesystem \
 apache-parent \
"
