# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ucx"
PE = "0"
PV = "1.17.0"
PR = "2.el10"
PACKAGES = "ucx ucx-cma ucx-devel ucx-ib ucx-rdmacm"
PROVIDES = "rpm/ucx rpm/ucx-cma rpm/ucx-devel rpm/ucx-ib rpm/ucx-rdmacm"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ucx-1.17.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9cefeba6722fca26c06a79cc86e45495c1389c84e843b869b968073c647e743"

URI_ucx = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ucx-1.17.0-2.el10.x86_64_v2.rpm;name=ucx;unpack=0"
SRC_URI += "${URI_ucx}"
SRC_URI[ucx.sha256sum] = "7ed03b00f66c7738f5ef6014ee23f2a6a7085bf8e74e829f376b978932c88c0d"
RDEPENDS:ucx = " \
 glibc \
 libgcc \
 libstdc++ \
 libgomp \
"

URI_ucx-cma = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ucx-cma-1.17.0-2.el10.x86_64_v2.rpm;name=ucx-cma;unpack=0"
SRC_URI += "${URI_ucx-cma}"
SRC_URI[ucx-cma.sha256sum] = "d61d09df9d67939b5c68cdfb3406dcc8b8facafe1e9423182bea2b56877ca0d0"
RDEPENDS:ucx-cma = " \
 glibc \
 ucx \
"

URI_ucx-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ucx-devel-1.17.0-2.el10.x86_64_v2.rpm;name=ucx-devel;unpack=0"
SRC_URI += "${URI_ucx-devel}"
SRC_URI[ucx-devel.sha256sum] = "5a41b9ede31b2f5eb55a7681bd3131145549c7368e2dbacb97adaa5b614a9f2d"
RDEPENDS:ucx-devel = " \
 ucx \
 pkgconf-pkg-config \
 ucx-devel \
 rdma-core-devel \
"

URI_ucx-ib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ucx-ib-1.17.0-2.el10.x86_64_v2.rpm;name=ucx-ib;unpack=0"
SRC_URI += "${URI_ucx-ib}"
SRC_URI[ucx-ib.sha256sum] = "cceb7e4170fd08a65501c7aa2d4436ef19f6e8c3f32bb9806855d7972ad52d0c"
RDEPENDS:ucx-ib = " \
 glibc \
 ucx \
 libibverbs \
"

URI_ucx-rdmacm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ucx-rdmacm-1.17.0-2.el10.x86_64_v2.rpm;name=ucx-rdmacm;unpack=0"
SRC_URI += "${URI_ucx-rdmacm}"
SRC_URI[ucx-rdmacm.sha256sum] = "e1a13db8907988fc2de1736b062ffc967ce78969a7fcf1b96b3f52695062fa8b"
RDEPENDS:ucx-rdmacm = " \
 librdmacm \
 ucx \
 libibverbs \
 ucx-ib \
 glibc \
"
