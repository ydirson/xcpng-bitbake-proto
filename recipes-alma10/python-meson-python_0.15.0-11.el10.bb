# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-meson-python"
PE = "0"
PV = "0.15.0"
PR = "11.el10"
PACKAGES = "python3-meson-python"
PROVIDES = "rpm/python3-meson-python"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/python-meson-python-0.15.0-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b7adf5f1a01951824c32bd66572455fb768cbbe9136284b8cd6f6d0bca8869b"

URI_python3-meson-python = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-meson-python-0.15.0-11.el10.noarch.rpm;name=python3-meson-python;unpack=0"
SRC_URI += "${URI_python3-meson-python}"
SRC_URI[python3-meson-python.sha256sum] = "a335cb5ffeaa0193a9a55410240fa43a207f67eda88681b98ef33eba3baa0e46"
RDEPENDS:python3-meson-python = " \
 python3 \
 python3-pyproject-metadata \
 meson \
"
