# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "shell-color-prompt"
PE = "0"
PV = "0.4.2"
PR = "3.el10"
PACKAGES = "bash-color-prompt"
PROVIDES = "rpm/bash-color-prompt"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/shell-color-prompt-0.4.2-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "243b2bb9bf4612a8ffee707e0d76c77edc16f1476ea0142463db490e2f3149a1"

URI_bash-color-prompt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/bash-color-prompt-0.4.2-3.el10.noarch.rpm;name=bash-color-prompt;unpack=0"
SRC_URI += "${URI_bash-color-prompt}"
SRC_URI[bash-color-prompt.sha256sum] = "bb249cbbd02bd14a34ceddaf825766c65152e314fca2188a4a12099c54e5fb6f"
RDEPENDS:bash-color-prompt = ""
