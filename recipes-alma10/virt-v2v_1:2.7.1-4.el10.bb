# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "virt-v2v"
PE = "1"
PV = "2.7.1"
PR = "4.el10"
PACKAGES = "virt-v2v virt-v2v-bash-completion virt-v2v-man-pages-ja virt-v2v-man-pages-uk"
PROVIDES = "rpm/virt-v2v rpm/virt-v2v-bash-completion rpm/virt-v2v-man-pages-ja rpm/virt-v2v-man-pages-uk"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/virt-v2v-2.7.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f32cdc61ac39a01db3aaa2a205ec282ae0922befce465e3c4a9d5804e71661b5"

URI_virt-v2v = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/virt-v2v-2.7.1-4.el10.x86_64_v2.rpm;name=virt-v2v;unpack=0"
SRC_URI += "${URI_virt-v2v}"
SRC_URI[virt-v2v.sha256sum] = "eb8ab52c8e8d947ec95dc70cf49655ce1eef17e688578f7e2757cbf6ceb43bf8"
RDEPENDS:virt-v2v = " \
 curl \
 libnbd \
 edk2-ovmf \
 libvirt-client \
 unzip \
 nbdkit-basic-filters \
 nbdkit-basic-plugins \
 libosinfo \
 nbdkit-curl-plugin \
 qemu-img \
 json-c \
 nbdkit-nbd-plugin \
 nbdkit-server \
 nbdkit-ssh-plugin \
 libvirt-libs \
 nbdkit-vddk-plugin \
 openssh-clients \
 libxcrypt \
 libgcc \
 libxml2 \
 pcre2 \
 libguestfs \
 libguestfs-winsupport \
 libguestfs-xfs \
 mingw-srvany-redistributable \
 gzip \
 gawk \
 glib2 \
 glibc \
 guestfs-tools \
"

URI_virt-v2v-bash-completion = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/virt-v2v-bash-completion-2.7.1-4.el10.noarch.rpm;name=virt-v2v-bash-completion;unpack=0"
SRC_URI += "${URI_virt-v2v-bash-completion}"
SRC_URI[virt-v2v-bash-completion.sha256sum] = "f4050780f96334a159f9352800f64850fa51646201edeec922ebfdb894d839a5"
RDEPENDS:virt-v2v-bash-completion = " \
 virt-v2v \
 bash-completion \
"

URI_virt-v2v-man-pages-ja = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/virt-v2v-man-pages-ja-2.7.1-4.el10.noarch.rpm;name=virt-v2v-man-pages-ja;unpack=0"
SRC_URI += "${URI_virt-v2v-man-pages-ja}"
SRC_URI[virt-v2v-man-pages-ja.sha256sum] = "212c16714284cd8ab95372659475b6fcdddf91937798f0ee96c9b3084e5029e3"
RDEPENDS:virt-v2v-man-pages-ja = " \
 virt-v2v \
"

URI_virt-v2v-man-pages-uk = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/virt-v2v-man-pages-uk-2.7.1-4.el10.noarch.rpm;name=virt-v2v-man-pages-uk;unpack=0"
SRC_URI += "${URI_virt-v2v-man-pages-uk}"
SRC_URI[virt-v2v-man-pages-uk.sha256sum] = "66334ead4ea97d9a070c0b2d5de8639e380f0f24c1e3ae86cab2f7973b59cf4a"
RDEPENDS:virt-v2v-man-pages-uk = " \
 virt-v2v \
"
