# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libdatrie"
PE = "0"
PV = "0.2.13"
PR = "11.el10"
PACKAGES = "libdatrie libdatrie-devel"
PROVIDES = "rpm/libdatrie rpm/libdatrie-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libdatrie-0.2.13-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17c370d5a8fe65bc1e4f064583fac930b1f9da5fd71633d05d29e43d67847e19"

URI_libdatrie = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libdatrie-0.2.13-11.el10.x86_64_v2.rpm;name=libdatrie;unpack=0"
SRC_URI += "${URI_libdatrie}"
SRC_URI[libdatrie.sha256sum] = "a49f2abd4c95c366882fc1ab5aeebcf97e17ecd9dfd1bfb5dc4d498b9e281971"
RDEPENDS:libdatrie = " \
 glibc \
"

URI_libdatrie-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libdatrie-devel-0.2.13-11.el10.x86_64_v2.rpm;name=libdatrie-devel;unpack=0"
SRC_URI += "${URI_libdatrie-devel}"
SRC_URI[libdatrie-devel.sha256sum] = "5b97ef81bfadf5c2ff57bb0ac696a1a2133b1a5d900e0e095797e06184a4ff89"
RDEPENDS:libdatrie-devel = " \
 glibc \
 libdatrie \
 pkgconf-pkg-config \
"
