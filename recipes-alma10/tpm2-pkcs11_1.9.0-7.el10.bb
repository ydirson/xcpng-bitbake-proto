# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tpm2-pkcs11"
PE = "0"
PV = "1.9.0"
PR = "7.el10"
PACKAGES = "tpm2-pkcs11 tpm2-pkcs11-tools"
PROVIDES = "rpm/tpm2-pkcs11 rpm/tpm2-pkcs11-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tpm2-pkcs11-1.9.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "764903505ae45c84f14bd9df7ef1b5fd63640da77e7a61fcdcaf11c2f43597fd"

URI_tpm2-pkcs11 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tpm2-pkcs11-1.9.0-7.el10.x86_64_v2.rpm;name=tpm2-pkcs11;unpack=0"
SRC_URI += "${URI_tpm2-pkcs11}"
SRC_URI[tpm2-pkcs11.sha256sum] = "150a85a25b2eb0346ea5449515e31d15f7d6e6833b03f3efd740aa1bd0ed9115"
RDEPENDS:tpm2-pkcs11 = " \
 openssl-libs \
 libyaml \
 sqlite-libs \
 tpm2-tss \
 glibc \
 tpm2-tss-fapi \
"

URI_tpm2-pkcs11-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tpm2-pkcs11-tools-1.9.0-7.el10.x86_64_v2.rpm;name=tpm2-pkcs11-tools;unpack=0"
SRC_URI += "${URI_tpm2-pkcs11-tools}"
SRC_URI[tpm2-pkcs11-tools.sha256sum] = "4b8cc55c591294c02d0be736e45e274233174ecf695e588380d49a3041cd8e4a"
RDEPENDS:tpm2-pkcs11-tools = " \
 python3 \
 python3-pyyaml \
 python3-cryptography \
 python3-pyasn1-modules \
 python3-tpm2-pytss \
 bash \
"
