# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mockito"
PE = "0"
PV = "5.8.0"
PR = "6.el10"
PACKAGES = "mockito mockito-javadoc mockito-junit-jupiter"
PROVIDES = "rpm/mockito rpm/mockito-javadoc rpm/mockito-junit-jupiter"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/mockito-5.8.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1ad2203be1913819b3d7babc3b9f6594bbdcb742f3617e81ac922b728eb39a2"

URI_mockito = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mockito-5.8.0-6.el10.noarch.rpm;name=mockito;unpack=0"
SRC_URI += "${URI_mockito}"
SRC_URI[mockito.sha256sum] = "a1a180201d39a6383f5ae7c8fe3f93233561592fff3e001128c2e57d04d9f738"
RDEPENDS:mockito = " \
 junit \
 javapackages-filesystem \
 opentest4j \
 byte-buddy \
 byte-buddy-agent \
 objenesis \
"

URI_mockito-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mockito-javadoc-5.8.0-6.el10.noarch.rpm;name=mockito-javadoc;unpack=0"
SRC_URI += "${URI_mockito-javadoc}"
SRC_URI[mockito-javadoc.sha256sum] = "37cc2ac5ebff52e11bd65be19a579d17c5c7770b33180b70b69402ae3290ca48"
RDEPENDS:mockito-javadoc = " \
 javapackages-filesystem \
"

URI_mockito-junit-jupiter = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mockito-junit-jupiter-5.8.0-6.el10.noarch.rpm;name=mockito-junit-jupiter;unpack=0"
SRC_URI += "${URI_mockito-junit-jupiter}"
SRC_URI[mockito-junit-jupiter.sha256sum] = "58152f44610c43305c711bd3cd39cee7ea81206e4871c5ae5c547271d867f855"
RDEPENDS:mockito-junit-jupiter = " \
 junit5 \
 javapackages-filesystem \
 mockito \
"
