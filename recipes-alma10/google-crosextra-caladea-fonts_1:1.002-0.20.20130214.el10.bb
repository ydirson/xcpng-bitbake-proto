# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "google-crosextra-caladea-fonts"
PE = "1"
PV = "1.002"
PR = "0.20.20130214.el10"
PACKAGES = "google-crosextra-caladea-fonts"
PROVIDES = "rpm/google-crosextra-caladea-fonts"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/google-crosextra-caladea-fonts-1.002-0.20.20130214.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a1ef20435ff175411461233c51aa89aa718233cc4ac66fbe4eb1a7580ecba3a"

URI_google-crosextra-caladea-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-crosextra-caladea-fonts-1.002-0.20.20130214.el10.noarch.rpm;name=google-crosextra-caladea-fonts;unpack=0"
SRC_URI += "${URI_google-crosextra-caladea-fonts}"
SRC_URI[google-crosextra-caladea-fonts.sha256sum] = "9581d07eb1a6059023afd3e229d58e336f9ddb9e72455a31bd74c513a818a50f"
RDEPENDS:google-crosextra-caladea-fonts = " \
 fonts-filesystem \
"
