# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-pyqt6"
PE = "0"
PV = "6.8.0"
PR = "1.el10"
PACKAGES = "python-pyqt6-rpm-macros python3-pyqt6 python3-pyqt6-base python3-pyqt6-devel python-pyqt6-doc"
PROVIDES = "rpm/python-pyqt6-rpm-macros rpm/python3-pyqt6 rpm/python3-pyqt6-base rpm/python3-pyqt6-devel rpm/python-pyqt6-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-pyqt6-6.8.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd62af846fdcabde9d46d25f330337e0bb98b40131a370be49d62f7f5b712756"

URI_python-pyqt6-rpm-macros = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python-pyqt6-rpm-macros-6.8.0-1.el10.noarch.rpm;name=python-pyqt6-rpm-macros;unpack=0"
SRC_URI += "${URI_python-pyqt6-rpm-macros}"
SRC_URI[python-pyqt6-rpm-macros.sha256sum] = "bbf2336233c804db40942b9c17c179258171a9a46559c3ed7a749c7ec5372523"
RDEPENDS:python-pyqt6-rpm-macros = ""

URI_python3-pyqt6 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-pyqt6-6.8.0-1.el10.x86_64_v2.rpm;name=python3-pyqt6;unpack=0"
SRC_URI += "${URI_python3-pyqt6}"
SRC_URI[python3-pyqt6.sha256sum] = "13c019399247bd7cf3ee129b9c0e9dadd9928cf26c8822a4db1e423b5567e233"
RDEPENDS:python3-pyqt6 = " \
 python3 \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 qt6-qtpositioning \
 qt6-qtquick3d \
 qt6-qtremoteobjects \
 qt6-qtsensors \
 qt6-qtserialport \
 qt6-qtspeech \
 qt6-qtsvg \
 qt6-qttools-libs-designer \
 qt6-qttools-libs-help \
 qt6-qtwebchannel \
 libstdc++ \
 qt6-qtwebsockets \
 qt6-qtbase \
 python3-pyqt6-base \
 qt6-qtbase-gui \
 glibc \
 qt6-qtconnectivity \
"

URI_python3-pyqt6-base = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-pyqt6-base-6.8.0-1.el10.x86_64_v2.rpm;name=python3-pyqt6-base;unpack=0"
SRC_URI += "${URI_python3-pyqt6-base}"
SRC_URI[python3-pyqt6-base.sha256sum] = "7610f133d871d66b607d56cb5ef49687f4380b3070cd1d9ec5a252d40434c598"
RDEPENDS:python3-pyqt6-base = " \
 python3 \
 qt6-qtdeclarative \
 libgcc \
 python3-dbus \
 python3-libs \
 qt6-qtbase \
 python-pyqt6-rpm-macros \
 python3-pyqt6-sip \
 libstdc++ \
 bash \
 qt6-qtbase-gui \
 glibc \
 dbus-libs \
"

URI_python3-pyqt6-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-pyqt6-devel-6.8.0-1.el10.x86_64_v2.rpm;name=python3-pyqt6-devel;unpack=0"
SRC_URI += "${URI_python3-pyqt6-devel}"
SRC_URI[python3-pyqt6-devel.sha256sum] = "6fc85c0e0860d68e69c134bdea06783e80b0c8c0939ee720ffaed57b9d9d7d50"
RDEPENDS:python3-pyqt6-devel = " \
 qt6-qtbase-devel \
 python3-pyqt6 \
"

URI_python-pyqt6-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python-pyqt6-doc-6.8.0-1.el10.noarch.rpm;name=python-pyqt6-doc;unpack=0"
SRC_URI += "${URI_python-pyqt6-doc}"
SRC_URI[python-pyqt6-doc.sha256sum] = "5d3801ffb5ff35ffc7b86ae4d729ff1d8edd6885473ec5b915549b2462294c3f"
RDEPENDS:python-pyqt6-doc = ""
