# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-CPAN-Meta-Check"
PE = "0"
PV = "0.018"
PR = "6.el10"
PACKAGES = "perl-CPAN-Meta-Check perl-CPAN-Meta-Check-tests"
PROVIDES = "rpm/perl-CPAN-Meta-Check rpm/perl-CPAN-Meta-Check-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-CPAN-Meta-Check-0.018-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8abd12d22b3f5b249a430cd805f910fe875899b3210c1a6e1e9233bb68c28b19"

URI_perl-CPAN-Meta-Check = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-CPAN-Meta-Check-0.018-6.el10.noarch.rpm;name=perl-CPAN-Meta-Check;unpack=0"
SRC_URI += "${URI_perl-CPAN-Meta-Check}"
SRC_URI[perl-CPAN-Meta-Check.sha256sum] = "237e2ff71265658655835edb3cd56c36688517da1d12add750e0d97d78ff2910"
RDEPENDS:perl-CPAN-Meta-Check = " \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Requirements \
 perl-libs \
 perl-Module-Metadata \
 perl-Exporter \
 perl-base \
"

URI_perl-CPAN-Meta-Check-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-CPAN-Meta-Check-tests-0.018-6.el10.noarch.rpm;name=perl-CPAN-Meta-Check-tests;unpack=0"
SRC_URI += "${URI_perl-CPAN-Meta-Check-tests}"
SRC_URI[perl-CPAN-Meta-Check-tests.sha256sum] = "8585a99ed747563fc4789e88188e3f1fd9c8a5cc979752e78f676995a9703480"
RDEPENDS:perl-CPAN-Meta-Check-tests = " \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Check \
 perl-Test-Harness \
 perl-libs \
 perl-Scalar-List-Utils \
 perl-Test-Simple \
 perl-IO \
 perl-Module-Metadata \
 perl-IPC-Open3 \
 perl-PathTools \
 bash \
 perl-Env \
 perl-interpreter \
 perl-lib \
"
