# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ptyxis"
PE = "0"
PV = "47.10"
PR = "1.el10"
PACKAGES = "ptyxis"
PROVIDES = "rpm/ptyxis"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ptyxis-47.10-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b53f378499954b04c68754e5aa468cb3fab76e3603ad76d573e13fc5f32b710c"

URI_ptyxis = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ptyxis-47.10-1.el10.x86_64_v2.rpm;name=ptyxis;unpack=0"
SRC_URI += "${URI_ptyxis}"
SRC_URI[ptyxis.sha256sum] = "f7cd56c7ff521a244eca04a52abefb902258dc7c224767b5142e5bba008a6fdd"
RDEPENDS:ptyxis = " \
 libportal-gtk4 \
 libgcc \
 json-glib \
 pango \
 vte291-gtk4 \
 glib2 \
 libportal \
 glibc \
 gtk4 \
 hicolor-icon-theme \
 libadwaita \
"
