# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ongres-scram"
PE = "0"
PV = "2.1"
PR = "17.el10"
PACKAGES = "ongres-scram ongres-scram-client ongres-scram-javadoc ongres-scram-parent"
PROVIDES = "rpm/ongres-scram rpm/ongres-scram-client rpm/ongres-scram-javadoc rpm/ongres-scram-parent"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ongres-scram-2.1-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be0756cd1bee0bc8870a083827c0c1a75852da03e66107e00e0cd487160ca970"

URI_ongres-scram = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ongres-scram-2.1-17.el10.noarch.rpm;name=ongres-scram;unpack=0"
SRC_URI += "${URI_ongres-scram}"
SRC_URI[ongres-scram.sha256sum] = "e4ff13a79af57943125ea128e4837a011d64d07289f170b6eb5b8a529a736c08"
RDEPENDS:ongres-scram = " \
 ongres-stringprep \
 javapackages-filesystem \
"

URI_ongres-scram-client = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ongres-scram-client-2.1-17.el10.noarch.rpm;name=ongres-scram-client;unpack=0"
SRC_URI += "${URI_ongres-scram-client}"
SRC_URI[ongres-scram-client.sha256sum] = "fdcb361369420d31a0a978db78e407c1380539f7e96489e551132974a67accb4"
RDEPENDS:ongres-scram-client = " \
 javapackages-filesystem \
 ongres-scram \
"

URI_ongres-scram-javadoc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ongres-scram-javadoc-2.1-17.el10.noarch.rpm;name=ongres-scram-javadoc;unpack=0"
SRC_URI += "${URI_ongres-scram-javadoc}"
SRC_URI[ongres-scram-javadoc.sha256sum] = "12ddb7e5450a99a4237089d4df4d99cbe9f83c6e6be39e50c2a80e68f1e3b2f0"
RDEPENDS:ongres-scram-javadoc = " \
 javapackages-filesystem \
"

URI_ongres-scram-parent = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ongres-scram-parent-2.1-17.el10.noarch.rpm;name=ongres-scram-parent;unpack=0"
SRC_URI += "${URI_ongres-scram-parent}"
SRC_URI[ongres-scram-parent.sha256sum] = "2347277fb1a2b2418a57370a77a5b64a471cc03d753d3ef4e01e602a83f27607"
RDEPENDS:ongres-scram-parent = " \
 maven-compiler-plugin \
 javapackages-filesystem \
"
