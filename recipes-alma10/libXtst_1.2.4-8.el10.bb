# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libXtst"
PE = "0"
PV = "1.2.4"
PR = "8.el10"
PACKAGES = "libXtst libXtst-devel"
PROVIDES = "rpm/libXtst rpm/libXtst-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libXtst-1.2.4-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46e7284fead04bfafff58bb5d9bcc6d283b7b9467567acc271cec15fa0a3bbe2"

URI_libXtst = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXtst-1.2.4-8.el10.x86_64_v2.rpm;name=libXtst;unpack=0"
SRC_URI += "${URI_libXtst}"
SRC_URI[libXtst.sha256sum] = "d18442acb12779684f5dce6efaa378fe0cfcb7875988840bbc373253a3689723"
RDEPENDS:libXtst = " \
 glibc \
 libX11 \
 libXi \
 libXext \
"

URI_libXtst-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXtst-devel-1.2.4-8.el10.x86_64_v2.rpm;name=libXtst-devel;unpack=0"
SRC_URI += "${URI_libXtst-devel}"
SRC_URI[libXtst-devel.sha256sum] = "46da9e131da6aa47688afb1402ae93b76ff1ee4a25e01159dbc8bf317782d3c9"
RDEPENDS:libXtst-devel = " \
 libXext-devel \
 libXi-devel \
 pkgconf-pkg-config \
 libX11-devel \
 xorg-x11-proto-devel \
 libXtst \
"
