# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cglib"
PE = "0"
PV = "3.3.0"
PR = "16.el10"
PACKAGES = "cglib cglib-javadoc"
PROVIDES = "rpm/cglib rpm/cglib-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/cglib-3.3.0-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fedc18a2bb98a7fb7a820a867b8db49b4a149a9c0bebef362112433f20200059"

URI_cglib = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/cglib-3.3.0-16.el10.noarch.rpm;name=cglib;unpack=0"
SRC_URI += "${URI_cglib}"
SRC_URI[cglib.sha256sum] = "0e7d3eaa6eab5ccb79ce8a66b8481d4f18c6210fadb71ad76e939520b4f2876c"
RDEPENDS:cglib = " \
 objectweb-asm \
 javapackages-filesystem \
"

URI_cglib-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/cglib-javadoc-3.3.0-16.el10.noarch.rpm;name=cglib-javadoc;unpack=0"
SRC_URI += "${URI_cglib-javadoc}"
SRC_URI[cglib-javadoc.sha256sum] = "c1c9ccc7037769050022ff2352eb470f8f9168c9de1a435e6fe46ea307c4cbf8"
RDEPENDS:cglib-javadoc = " \
 javapackages-filesystem \
"
