# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pyparted"
PE = "1"
PV = "3.13.0"
PR = "7.el10"
PACKAGES = "python3-pyparted"
PROVIDES = "rpm/python3-pyparted"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/pyparted-3.13.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8287d1df75f0b0d69a17cd12055ca6fc3189b4d4bbc70147b2f673e3dd063469"

URI_python3-pyparted = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-pyparted-3.13.0-7.el10.x86_64_v2.rpm;name=python3-pyparted;unpack=0"
SRC_URI += "${URI_python3-pyparted}"
SRC_URI[python3-pyparted.sha256sum] = "56b53e56aebc907b419979e11187935c7c2aff89884e601030119e9e7ef6efe1"
RDEPENDS:python3-pyparted = " \
 glibc \
 parted \
 python3 \
"
