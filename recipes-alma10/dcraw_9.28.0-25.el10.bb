# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dcraw"
PE = "0"
PV = "9.28.0"
PR = "25.el10"
PACKAGES = "dcraw"
PROVIDES = "rpm/dcraw"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/dcraw-9.28.0-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47b4e3a6c5bc2685dc1173362d7edc59e81cc28f4da5e6c7c7e92d5e7ea4e097"

URI_dcraw = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dcraw-9.28.0-25.el10.x86_64_v2.rpm;name=dcraw;unpack=0"
SRC_URI += "${URI_dcraw}"
SRC_URI[dcraw.sha256sum] = "e2ae909b7482b8f0696002d343a53fa94442803f36994abae152aeec87e02c07"
RDEPENDS:dcraw = " \
 glibc \
 lcms2 \
 libjpeg-turbo \
 jasper-libs \
"
