# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lockdev"
PE = "0"
PV = "1.0.4"
PR = "0.46.20111007git.el10"
PACKAGES = "lockdev lockdev-devel"
PROVIDES = "rpm/lockdev rpm/lockdev-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/lockdev-1.0.4-0.46.20111007git.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26f1a55202c76faca8d2e24e48d789657e86c2f7b885f7788261221f2256cffb"

URI_lockdev = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/lockdev-1.0.4-0.46.20111007git.el10.x86_64_v2.rpm;name=lockdev;unpack=0"
SRC_URI += "${URI_lockdev}"
SRC_URI[lockdev.sha256sum] = "624dd1320dfae8f382ee796a159fcaa83fb49bae1f402117ad502cf421ecfed0"
RDEPENDS:lockdev = " \
 glibc \
 shadow-utils \
 bash \
 systemd \
"

URI_lockdev-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/lockdev-devel-1.0.4-0.46.20111007git.el10.x86_64_v2.rpm;name=lockdev-devel;unpack=0"
SRC_URI += "${URI_lockdev-devel}"
SRC_URI[lockdev-devel.sha256sum] = "d659b6211494657ea3c559569e5f34b578a2748e07d62e3878984e6af7ac7496"
RDEPENDS:lockdev-devel = " \
 pkgconf-pkg-config \
 lockdev \
"
