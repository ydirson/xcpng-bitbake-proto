# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libshout"
PE = "0"
PV = "2.4.6"
PR = "9.el10"
PACKAGES = "libshout libshout-devel"
PROVIDES = "rpm/libshout rpm/libshout-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libshout-2.4.6-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36e2a2bb7ae6205f66a2319dfaa130bbfcd4ed1d8a84146bf69891b778cbb8cd"

URI_libshout = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libshout-2.4.6-9.el10.x86_64_v2.rpm;name=libshout;unpack=0"
SRC_URI += "${URI_libshout}"
SRC_URI[libshout.sha256sum] = "885074f6f5692434e4b7d94da8d7f88a9067358aa2bf197c1ad05c97455ee46e"
RDEPENDS:libshout = " \
 libvorbis \
 libogg \
 speex \
 openssl-libs \
 glibc \
 libtheora \
"

URI_libshout-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libshout-devel-2.4.6-9.el10.x86_64_v2.rpm;name=libshout-devel;unpack=0"
SRC_URI += "${URI_libshout-devel}"
SRC_URI[libshout-devel.sha256sum] = "4460a5174602986b55c62e5e88a55fe10cfc08c743ca51b04e1219b518098373"
RDEPENDS:libshout-devel = " \
 libogg-devel \
 pkgconf-pkg-config \
 openssl-devel \
 libvorbis-devel \
 speex-devel \
 libshout \
 libtheora-devel \
"
