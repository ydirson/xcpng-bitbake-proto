# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "foomatic"
PE = "0"
PV = "4.0.13"
PR = "33.el10"
PACKAGES = "foomatic"
PROVIDES = "rpm/foomatic"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/foomatic-4.0.13-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1445313f9c2b3decf82ac9c1c0470204306a62bd65dd7ff0d1f67183c0d73de8"

URI_foomatic = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/foomatic-4.0.13-33.el10.x86_64_v2.rpm;name=foomatic;unpack=0"
SRC_URI += "${URI_foomatic}"
SRC_URI[foomatic.sha256sum] = "78676b2660f04cd5811cc036a38a855916ab631a3504d7f631ab5325c953f143"
RDEPENDS:foomatic = " \
 perl-libs \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-Getopt-Std \
 foomatic-db \
 dbus \
 cups \
 cups-filters \
 perl-vars \
 perl-Data-Dumper \
 libxml2 \
 perl-Encode \
 bash \
 perl-Exporter \
 ghostscript \
 perl-POSIX \
 colord \
 perl-PathTools \
 glibc \
 coreutils \
 perl-interpreter \
"
