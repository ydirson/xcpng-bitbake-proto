# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rasdaemon"
PE = "0"
PV = "0.8.0"
PR = "8.el10"
PACKAGES = "rasdaemon"
PROVIDES = "rpm/rasdaemon"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/rasdaemon-0.8.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d84d596b3c66e4b5026425bd4b8f6df4f9c89ff01870f686d638501d0a3757ac"

URI_rasdaemon = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rasdaemon-0.8.0-8.el10.x86_64_v2.rpm;name=rasdaemon;unpack=0"
SRC_URI += "${URI_rasdaemon}"
SRC_URI[rasdaemon.sha256sum] = "66edb902b86206319bc298ebbe64ff00315fe4822d5be9ed15732bd4abb9b4d0"
RDEPENDS:rasdaemon = " \
 perl-constant \
 systemd \
 perl-libs \
 dmidecode \
 perl-Getopt-Long \
 perl-POSIX \
 perl-File-Basename \
 sqlite-libs \
 hwdata \
 perl-File-Find \
 perl-DBD-SQLite \
 glibc \
 perl-interpreter \
 libtraceevent \
"
