# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "alsa-sof-firmware"
PE = "0"
PV = "2024.09.2"
PR = "2.el10"
PACKAGES = "alsa-sof-firmware alsa-sof-firmware-debug"
PROVIDES = "rpm/alsa-sof-firmware rpm/alsa-sof-firmware-debug"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/alsa-sof-firmware-2024.09.2-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58c0e411355e8b5c4c86e454ee025d454b8b6404832bef54528c492a8ef52007"

URI_alsa-sof-firmware = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/alsa-sof-firmware-2024.09.2-2.el10.noarch.rpm;name=alsa-sof-firmware;unpack=0"
SRC_URI += "${URI_alsa-sof-firmware}"
SRC_URI[alsa-sof-firmware.sha256sum] = "09a3ef60531490789653a054854413db524e57f7118145b3ee375197204b8bb5"
RDEPENDS:alsa-sof-firmware = ""

URI_alsa-sof-firmware-debug = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/alsa-sof-firmware-debug-2024.09.2-2.el10.noarch.rpm;name=alsa-sof-firmware-debug;unpack=0"
SRC_URI += "${URI_alsa-sof-firmware-debug}"
SRC_URI[alsa-sof-firmware-debug.sha256sum] = "8eb37932340c49ff7c093ade097a681dfc85c8e771231f9b4bbd48f26b460eec"
RDEPENDS:alsa-sof-firmware-debug = " \
 alsa-sof-firmware \
"
