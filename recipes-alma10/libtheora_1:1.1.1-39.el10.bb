# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libtheora"
PE = "1"
PV = "1.1.1"
PR = "39.el10"
PACKAGES = "libtheora theora-tools libtheora-devel libtheora-devel-docs"
PROVIDES = "rpm/libtheora rpm/theora-tools rpm/libtheora-devel rpm/libtheora-devel-docs"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libtheora-1.1.1-39.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d59c751702672463ff305f074ff5d72187e247b083ebb467b46a3a90fa9a69d3"

URI_libtheora = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libtheora-1.1.1-39.el10.x86_64_v2.rpm;name=libtheora;unpack=0"
SRC_URI += "${URI_libtheora}"
SRC_URI[libtheora.sha256sum] = "d05a3efac62fd4a950e48afc3f63c0dbf0ef70a047ef286385ea6cb56e536c7d"
RDEPENDS:libtheora = " \
 glibc \
 libogg \
"

URI_theora-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/theora-tools-1.1.1-39.el10.x86_64_v2.rpm;name=theora-tools;unpack=0"
SRC_URI += "${URI_theora-tools}"
SRC_URI[theora-tools.sha256sum] = "6afd3906b1032ec232630fd63965c07d97fb12b6d512a2468b7452fea1fe15ca"
RDEPENDS:theora-tools = " \
 libvorbis \
 libogg \
 libpng \
 glibc \
 sdl12-compat \
 libtheora \
"

URI_libtheora-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libtheora-devel-1.1.1-39.el10.x86_64_v2.rpm;name=libtheora-devel;unpack=0"
SRC_URI += "${URI_libtheora-devel}"
SRC_URI[libtheora-devel.sha256sum] = "8865527d7355398bdc91cbe201a7ae487d48ac87a07843f2a02ee48cd9b371d9"
RDEPENDS:libtheora-devel = " \
 libogg-devel \
 pkgconf-pkg-config \
 libtheora \
 libtheora-devel \
"

URI_libtheora-devel-docs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libtheora-devel-docs-1.1.1-39.el10.noarch.rpm;name=libtheora-devel-docs;unpack=0"
SRC_URI += "${URI_libtheora-devel-docs}"
SRC_URI[libtheora-devel-docs.sha256sum] = "eee7ee944279187569e2dde8dca98aec8a86ea7f934471fbc98d0e01d92b58fa"
RDEPENDS:libtheora-devel-docs = ""
