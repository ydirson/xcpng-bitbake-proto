# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Unix-Syslog"
PE = "0"
PV = "1.1"
PR = "53.el10"
PACKAGES = "perl-Unix-Syslog perl-Unix-Syslog-tests"
PROVIDES = "rpm/perl-Unix-Syslog rpm/perl-Unix-Syslog-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Unix-Syslog-1.1-53.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "067851405b993fd21ba6567783911d7bb4c935e259f45857036f0c2cb3d10e8a"

URI_perl-Unix-Syslog = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Unix-Syslog-1.1-53.el10.x86_64_v2.rpm;name=perl-Unix-Syslog;unpack=0"
SRC_URI += "${URI_perl-Unix-Syslog}"
SRC_URI[perl-Unix-Syslog.sha256sum] = "211175d5826302556f6dee04b5bf34f339fbb5dab444b7ef4b3107043bceecdf"
RDEPENDS:perl-Unix-Syslog = " \
 systemd \
 perl-libs \
 perl-vars \
 perl-DynaLoader \
 glibc \
 perl-Exporter \
"

URI_perl-Unix-Syslog-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Unix-Syslog-tests-1.1-53.el10.x86_64_v2.rpm;name=perl-Unix-Syslog-tests;unpack=0"
SRC_URI += "${URI_perl-Unix-Syslog-tests}"
SRC_URI[perl-Unix-Syslog-tests.sha256sum] = "90572daf879fc2c9c522b9df746dba729c5e6fdcf9c3ca35fbde890ffc129ce3"
RDEPENDS:perl-Unix-Syslog-tests = " \
 perl-Unix-Syslog \
 perl-interpreter \
 perl-Test-Harness \
 bash \
"
