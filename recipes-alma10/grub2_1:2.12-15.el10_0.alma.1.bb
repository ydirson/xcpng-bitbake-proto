# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "grub2"
PE = "1"
PV = "2.12"
PR = "15.el10_0.alma.1"
PACKAGES = "grub2-common grub2-efi-aa64-modules grub2-efi-x64 grub2-efi-x64-cdboot grub2-efi-x64-modules grub2-pc grub2-pc-modules grub2-ppc64le-modules grub2-tools grub2-tools-efi grub2-tools-extra grub2-tools-minimal grub2-efi-ia32 grub2-efi-ia32-cdboot grub2-efi-ia32-modules grub2-emu grub2-emu-modules grub2-pc-modules grub2-ppc64le-modules"
PROVIDES = "rpm/grub2-common rpm/grub2-efi-aa64-modules rpm/grub2-efi-x64 rpm/grub2-efi-x64-cdboot rpm/grub2-efi-x64-modules rpm/grub2-pc rpm/grub2-pc-modules rpm/grub2-ppc64le-modules rpm/grub2-tools rpm/grub2-tools-efi rpm/grub2-tools-extra rpm/grub2-tools-minimal rpm/grub2-efi-ia32 rpm/grub2-efi-ia32-cdboot rpm/grub2-efi-ia32-modules rpm/grub2-emu rpm/grub2-emu-modules rpm/grub2-pc-modules rpm/grub2-ppc64le-modules"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/grub2-2.12-15.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90e824b5c67e2c9cf8220916d846406e70d11c04db631843282576c3ccd700c9"

URI_grub2-common = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/grub2-common-2.12-15.el10_0.alma.1.noarch.rpm;name=grub2-common;unpack=0"
SRC_URI += "${URI_grub2-common}"
SRC_URI[grub2-common.sha256sum] = "10d34fa091dd5509dd851c15e1dcdd6c7267369e34578e39e62c6d8d9a580328"
RDEPENDS:grub2-common = " \
 coreutils \
 util-linux-core \
 bash \
 grep \
"

URI_grub2-efi-aa64-modules = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/grub2-efi-aa64-modules-2.12-15.el10_0.alma.1.noarch.rpm;name=grub2-efi-aa64-modules;unpack=0"
SRC_URI += "${URI_grub2-efi-aa64-modules}"
SRC_URI[grub2-efi-aa64-modules.sha256sum] = "2685ce5f8ee053b3c923cf8f3f3b35e9bd4a362ccca7d830a5d421414dba3482"
RDEPENDS:grub2-efi-aa64-modules = " \
 grub2-common \
"

URI_grub2-efi-x64 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/grub2-efi-x64-2.12-15.el10_0.alma.1.x86_64_v2.rpm;name=grub2-efi-x64;unpack=0"
SRC_URI += "${URI_grub2-efi-x64}"
SRC_URI[grub2-efi-x64.sha256sum] = "68fcce54de294db25ba4689f569cdf63b8282322170db0f878b6ce7141d4bee8"
RDEPENDS:grub2-efi-x64 = " \
 grub2-common \
 efi-filesystem \
 grub2-tools-minimal \
 grub2-tools \
"

URI_grub2-efi-x64-cdboot = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/grub2-efi-x64-cdboot-2.12-15.el10_0.alma.1.x86_64_v2.rpm;name=grub2-efi-x64-cdboot;unpack=0"
SRC_URI += "${URI_grub2-efi-x64-cdboot}"
SRC_URI[grub2-efi-x64-cdboot.sha256sum] = "152d413ba37d33dc314a6fddc7b956316bb7c15d3505658c2252708e6d98dd9d"
RDEPENDS:grub2-efi-x64-cdboot = " \
 grub2-common \
"

URI_grub2-efi-x64-modules = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/grub2-efi-x64-modules-2.12-15.el10_0.alma.1.noarch.rpm;name=grub2-efi-x64-modules;unpack=0"
SRC_URI += "${URI_grub2-efi-x64-modules}"
SRC_URI[grub2-efi-x64-modules.sha256sum] = "b6a5e895111465b5609ddfc06a19983ea21a98ab4e68a41c16565796056a8091"
RDEPENDS:grub2-efi-x64-modules = " \
 grub2-common \
"

URI_grub2-pc = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/grub2-pc-2.12-15.el10_0.alma.1.x86_64_v2.rpm;name=grub2-pc;unpack=0"
SRC_URI += "${URI_grub2-pc}"
SRC_URI[grub2-pc.sha256sum] = "ff6b1b2ff61a4cab2573539b8375b7a63946eaf9287033e7ab7528f6e1b55bea"
RDEPENDS:grub2-pc = " \
 grub2-tools-minimal \
 grub2-pc-modules \
 grub2-common \
 gettext-runtime \
 dracut \
 which \
 file \
 grub2-tools \
"

URI_grub2-pc-modules = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/grub2-pc-modules-2.12-15.el10_0.alma.1.noarch.rpm;name=grub2-pc-modules;unpack=0"
SRC_URI += "${URI_grub2-pc-modules}"
SRC_URI[grub2-pc-modules.sha256sum] = "9f462d4092a8b459dd2ccf0e90bc78bb6c9bc2e9baa40cd7011ce1701dbb1169"
RDEPENDS:grub2-pc-modules = " \
 grub2-common \
"

URI_grub2-ppc64le-modules = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/grub2-ppc64le-modules-2.12-15.el10_0.alma.1.noarch.rpm;name=grub2-ppc64le-modules;unpack=0"
SRC_URI += "${URI_grub2-ppc64le-modules}"
SRC_URI[grub2-ppc64le-modules.sha256sum] = "bdb7903060e02fd572719360c7c9f1116c4f1a72216e6910a4ad8896b304740f"
RDEPENDS:grub2-ppc64le-modules = " \
 grub2-common \
"

URI_grub2-tools = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/grub2-tools-2.12-15.el10_0.alma.1.x86_64_v2.rpm;name=grub2-tools;unpack=0"
SRC_URI += "${URI_grub2-tools}"
SRC_URI[grub2-tools.sha256sum] = "7e8b2af35350af492baff69b34d8bfbf66d354b6ec7907272b07a7223f739910"
RDEPENDS:grub2-tools = " \
 glibc \
 systemd \
 device-mapper-libs \
 os-prober \
 grep \
 grub2-common \
 gettext-runtime \
 bash \
 dracut \
 sed \
 file \
 xz-libs \
"

URI_grub2-tools-efi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/grub2-tools-efi-2.12-15.el10_0.alma.1.x86_64_v2.rpm;name=grub2-tools-efi;unpack=0"
SRC_URI += "${URI_grub2-tools-efi}"
SRC_URI[grub2-tools-efi.sha256sum] = "21e21b0dae36a28554bda628122191416db2e1b4f164e2e796df22de44528bc0"
RDEPENDS:grub2-tools-efi = " \
 device-mapper-libs \
 os-prober \
 grub2-common \
 gettext-runtime \
 glibc \
 file \
"

URI_grub2-tools-extra = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/grub2-tools-extra-2.12-15.el10_0.alma.1.x86_64_v2.rpm;name=grub2-tools-extra;unpack=0"
SRC_URI += "${URI_grub2-tools-extra}"
SRC_URI[grub2-tools-extra.sha256sum] = "054dc6451de63941bd1dccd017323126744ed9fc53e510be3637ed76f091bbcb"
RDEPENDS:grub2-tools-extra = " \
 device-mapper-libs \
 freetype \
 grub2-tools-minimal \
 os-prober \
 mtools \
 grub2-common \
 gettext-runtime \
 bash \
 glibc \
 file \
 xz-libs \
"

URI_grub2-tools-minimal = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/grub2-tools-minimal-2.12-15.el10_0.alma.1.x86_64_v2.rpm;name=grub2-tools-minimal;unpack=0"
SRC_URI += "${URI_grub2-tools-minimal}"
SRC_URI[grub2-tools-minimal.sha256sum] = "c6b54bda9f0a6ea8df565fa95e7dd018dff6b342057fdb0877fa2e54519cc805"
RDEPENDS:grub2-tools-minimal = " \
 device-mapper-libs \
 fuse-libs \
 grub2-common \
 gettext-runtime \
 bash \
 glibc \
 xz-libs \
"

URI_grub2-efi-ia32 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/grub2-efi-ia32-2.12-15.el10_0.alma.1.x86_64_v2.rpm;name=grub2-efi-ia32;unpack=0"
SRC_URI += "${URI_grub2-efi-ia32}"
SRC_URI[grub2-efi-ia32.sha256sum] = "c5d8da655c38eb487d7f894fde8ae1d89bcf92709cb22a161794d810b8e7c8a2"
RDEPENDS:grub2-efi-ia32 = " \
 grub2-common \
 efi-filesystem \
 grub2-tools-minimal \
 grub2-tools \
"

URI_grub2-efi-ia32-cdboot = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/grub2-efi-ia32-cdboot-2.12-15.el10_0.alma.1.x86_64_v2.rpm;name=grub2-efi-ia32-cdboot;unpack=0"
SRC_URI += "${URI_grub2-efi-ia32-cdboot}"
SRC_URI[grub2-efi-ia32-cdboot.sha256sum] = "b6c00167910f6000274fac82eb398e9f30fde9f43ddc1f3c14bbf7ebf69e603c"
RDEPENDS:grub2-efi-ia32-cdboot = " \
 grub2-common \
"

URI_grub2-efi-ia32-modules = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/grub2-efi-ia32-modules-2.12-15.el10_0.alma.1.noarch.rpm;name=grub2-efi-ia32-modules;unpack=0"
SRC_URI += "${URI_grub2-efi-ia32-modules}"
SRC_URI[grub2-efi-ia32-modules.sha256sum] = "6b763ab0a904555b348dd013b27455cf4efab9f09c99738f04965026a7e5c73f"
RDEPENDS:grub2-efi-ia32-modules = " \
 grub2-common \
 bash \
"

URI_grub2-emu = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/grub2-emu-2.12-15.el10_0.alma.1.x86_64_v2.rpm;name=grub2-emu;unpack=0"
SRC_URI += "${URI_grub2-emu}"
SRC_URI[grub2-emu.sha256sum] = "9229264354fc05df1333ce8bea380a580767fef39b0323aba371ebc33878f9e3"
RDEPENDS:grub2-emu = " \
 glibc \
 grub2-tools-minimal \
 libgcc \
 device-mapper-libs \
"

URI_grub2-emu-modules = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/grub2-emu-modules-2.12-15.el10_0.alma.1.x86_64_v2.rpm;name=grub2-emu-modules;unpack=0"
SRC_URI += "${URI_grub2-emu-modules}"
SRC_URI[grub2-emu-modules.sha256sum] = "e0e68e02c02e0ef557cce3a57968b36c42c2dfd6d9abe977946e92f3c2ce580c"
RDEPENDS:grub2-emu-modules = " \
 grub2-tools-minimal \
"

URI_grub2-pc-modules = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/grub2-pc-modules-2.12-15.el10_0.alma.1.noarch.rpm;name=grub2-pc-modules;unpack=0"
SRC_URI += "${URI_grub2-pc-modules}"
SRC_URI[grub2-pc-modules.sha256sum] = "9f462d4092a8b459dd2ccf0e90bc78bb6c9bc2e9baa40cd7011ce1701dbb1169"
RDEPENDS:grub2-pc-modules = " \
 grub2-common \
"

URI_grub2-ppc64le-modules = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/grub2-ppc64le-modules-2.12-15.el10_0.alma.1.noarch.rpm;name=grub2-ppc64le-modules;unpack=0"
SRC_URI += "${URI_grub2-ppc64le-modules}"
SRC_URI[grub2-ppc64le-modules.sha256sum] = "bdb7903060e02fd572719360c7c9f1116c4f1a72216e6910a4ad8896b304740f"
RDEPENDS:grub2-ppc64le-modules = " \
 grub2-common \
"
