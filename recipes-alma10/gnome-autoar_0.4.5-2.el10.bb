# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-autoar"
PE = "0"
PV = "0.4.5"
PR = "2.el10"
PACKAGES = "gnome-autoar gnome-autoar-devel"
PROVIDES = "rpm/gnome-autoar rpm/gnome-autoar-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-autoar-0.4.5-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8ece7f3b2f3c7365e29b0841c168ed4d9eb4460e4b14372e3b1d6c87e5c73b6"

URI_gnome-autoar = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-autoar-0.4.5-2.el10.x86_64_v2.rpm;name=gnome-autoar;unpack=0"
SRC_URI += "${URI_gnome-autoar}"
SRC_URI[gnome-autoar.sha256sum] = "e36d8c0eeba5a840f51401e75d9de7571544887029fc440d3279166e5a9dbea7"
RDEPENDS:gnome-autoar = " \
 libarchive \
 libgcc \
 glib2 \
 gtk3 \
 glibc \
"

URI_gnome-autoar-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gnome-autoar-devel-0.4.5-2.el10.x86_64_v2.rpm;name=gnome-autoar-devel;unpack=0"
SRC_URI += "${URI_gnome-autoar-devel}"
SRC_URI[gnome-autoar-devel.sha256sum] = "121c145fb5a0f51efc138fd26656115211066e80f4882c9cc711d02635c8b1f7"
RDEPENDS:gnome-autoar-devel = " \
 libarchive-devel \
 glib2-devel \
 pkgconf-pkg-config \
 gtk3-devel \
 gnome-autoar \
"
