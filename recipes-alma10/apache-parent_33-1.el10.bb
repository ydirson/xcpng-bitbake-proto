# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "apache-parent"
PE = "0"
PV = "33"
PR = "1.el10"
PACKAGES = "apache-parent"
PROVIDES = "rpm/apache-parent"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/apache-parent-33-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8449d9bd3f71dcfa872b6e6b34fa6970c1b0a7295c5334de372da1a04f073692"

URI_apache-parent = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/apache-parent-33-1.el10.noarch.rpm;name=apache-parent;unpack=0"
SRC_URI += "${URI_apache-parent}"
SRC_URI[apache-parent.sha256sum] = "f92863b365f1556848ad114a7a6c229f822c5119d806e2cec4fad50f377536fa"
RDEPENDS:apache-parent = " \
 maven-remote-resources-plugin \
 maven-enforcer-plugin \
 javapackages-filesystem \
 apache-resource-bundles \
"
