# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "firefox"
PE = "0"
PV = "140.4.0"
PR = "3.el10_0"
PACKAGES = "firefox firefox-x11"
PROVIDES = "rpm/firefox rpm/firefox-x11"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/firefox-140.4.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "155bd52477961fc080ce7ed45ae75018bd4c3f839083935ced2902d66c17b1c6"

URI_firefox = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/firefox-140.4.0-3.el10_0.x86_64_v2.rpm;name=firefox;unpack=0"
SRC_URI += "${URI_firefox}"
SRC_URI[firefox.sha256sum] = "690815c637d6810d871f70eadf92680a30848b506665906aecc9adf843923d60"
RDEPENDS:firefox = " \
 nss \
 pango \
 fontconfig \
 libX11 \
 libX11-xcb \
 nss-util \
 dbus-libs \
 libXcomposite \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXrandr \
 libXrender \
 libstdc++ \
 cairo \
 almalinux-indexhtml \
 cairo-gobject \
 alsa-lib \
 atk \
 zlib-ng-compat \
 libffi \
 libgcc \
 p11-kit-trust \
 gdk-pixbuf2 \
 libxcb \
 pciutils-libs \
 bash \
 freetype \
 harfbuzz \
 glib2 \
 gtk3 \
 glibc \
 mozilla-filesystem \
 libjpeg-turbo \
 nspr \
"

URI_firefox-x11 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/firefox-x11-140.4.0-3.el10_0.x86_64_v2.rpm;name=firefox-x11;unpack=0"
SRC_URI += "${URI_firefox-x11}"
SRC_URI[firefox-x11.sha256sum] = "99e5ba1c7766ec08d106b071f9c73e7d9da03ed7aee371d1360fce1bcc3925cc"
RDEPENDS:firefox-x11 = " \
 bash \
 firefox \
"
