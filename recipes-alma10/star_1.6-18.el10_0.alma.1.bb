# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "star"
PE = "0"
PV = "1.6"
PR = "18.el10_0.alma.1"
PACKAGES = "rmt scpio spax star"
PROVIDES = "rpm/rmt rpm/scpio rpm/spax rpm/star"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/star-1.6-18.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51f86774a1b318c62645e925590d14e6c290c82b117c74f252de51ad79fed197"

URI_rmt = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/rmt-1.6-18.el10_0.alma.1.x86_64_v2.rpm;name=rmt;unpack=0"
SRC_URI += "${URI_rmt}"
SRC_URI[rmt.sha256sum] = "b307649a25f79cb9818d5b14bc7cc6e7a8520afe330292f00dada0ef420bc6a8"
RDEPENDS:rmt = " \
 glibc \
"

URI_scpio = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/scpio-1.6-18.el10_0.alma.1.x86_64_v2.rpm;name=scpio;unpack=0"
SRC_URI += "${URI_scpio}"
SRC_URI[scpio.sha256sum] = "a9f59690557fee0a6c532df5ae74cc4cd25dc13f5f0f9fd757f437e9ed6626da"
RDEPENDS:scpio = " \
 glibc \
 libacl \
"

URI_spax = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/spax-1.6-18.el10_0.alma.1.x86_64_v2.rpm;name=spax;unpack=0"
SRC_URI += "${URI_spax}"
SRC_URI[spax.sha256sum] = "40d5ad6b60ec904f196ba2c9a36fa23eca1fef801106248f8685ea451fd1a2a0"
RDEPENDS:spax = " \
 glibc \
 alternatives \
 libacl \
 bash \
"

URI_star = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/star-1.6-18.el10_0.alma.1.x86_64_v2.rpm;name=star;unpack=0"
SRC_URI += "${URI_star}"
SRC_URI[star.sha256sum] = "f957b36262d2d20376341fb6a3275393493d118c2405e7925e599cd64f67d3b9"
RDEPENDS:star = " \
 glibc \
 libacl \
"
