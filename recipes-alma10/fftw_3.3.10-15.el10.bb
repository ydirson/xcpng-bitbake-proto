# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "fftw"
PE = "0"
PV = "3.3.10"
PR = "15.el10"
PACKAGES = "fftw fftw-devel fftw-libs fftw-libs-double fftw-libs-long fftw-libs-quad fftw-libs-single fftw-openmpi-devel fftw-openmpi-libs fftw-openmpi-libs-double fftw-openmpi-libs-long fftw-openmpi-libs-single fftw-openmpi-static fftw-static fftw-doc"
PROVIDES = "rpm/fftw rpm/fftw-devel rpm/fftw-libs rpm/fftw-libs-double rpm/fftw-libs-long rpm/fftw-libs-quad rpm/fftw-libs-single rpm/fftw-openmpi-devel rpm/fftw-openmpi-libs rpm/fftw-openmpi-libs-double rpm/fftw-openmpi-libs-long rpm/fftw-openmpi-libs-single rpm/fftw-openmpi-static rpm/fftw-static rpm/fftw-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/fftw-3.3.10-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59775f1311180a77b5bc05d626146267f0340a528d0d77a0347e9c6064db3031"

URI_fftw = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fftw-3.3.10-15.el10.x86_64_v2.rpm;name=fftw;unpack=0"
SRC_URI += "${URI_fftw}"
SRC_URI[fftw.sha256sum] = "211f5f1dcb503dfc9be730d59d1aa99f3f84892973f883ce110fb435d3a18b30"
RDEPENDS:fftw = " \
 fftw-libs-single \
 glibc \
 fftw-libs-double \
 fftw-libs-long \
 fftw-libs-quad \
"

URI_fftw-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fftw-devel-3.3.10-15.el10.x86_64_v2.rpm;name=fftw-devel;unpack=0"
SRC_URI += "${URI_fftw-devel}"
SRC_URI[fftw-devel.sha256sum] = "bd5eb3e5424184f146fbe213f548965b33cf46d057e281d13d7e09ca4ee2e8a5"
RDEPENDS:fftw-devel = " \
 fftw \
 fftw-libs \
 pkgconf-pkg-config \
"

URI_fftw-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fftw-libs-3.3.10-15.el10.x86_64_v2.rpm;name=fftw-libs;unpack=0"
SRC_URI += "${URI_fftw-libs}"
SRC_URI[fftw-libs.sha256sum] = "b829a5aa7281a5e0433308f212ce03d8bea70290055044a3955c929b0d8fb669"
RDEPENDS:fftw-libs = " \
 fftw-libs-single \
 fftw-libs-double \
 fftw-libs-long \
 fftw-libs-quad \
"

URI_fftw-libs-double = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fftw-libs-double-3.3.10-15.el10.x86_64_v2.rpm;name=fftw-libs-double;unpack=0"
SRC_URI += "${URI_fftw-libs-double}"
SRC_URI[fftw-libs-double.sha256sum] = "0acdb2a8bc477d8c52a7179222e3c41ebe6d2a138ecacff7f666c28f8db7ff76"
RDEPENDS:fftw-libs-double = " \
 glibc \
 libgcc \
 libgomp \
"

URI_fftw-libs-long = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fftw-libs-long-3.3.10-15.el10.x86_64_v2.rpm;name=fftw-libs-long;unpack=0"
SRC_URI += "${URI_fftw-libs-long}"
SRC_URI[fftw-libs-long.sha256sum] = "0b013af978aac025abb5078dcc21894360ae3b004d3aecefd691e71c7cc16e34"
RDEPENDS:fftw-libs-long = " \
 glibc \
 libgcc \
 libgomp \
"

URI_fftw-libs-quad = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fftw-libs-quad-3.3.10-15.el10.x86_64_v2.rpm;name=fftw-libs-quad;unpack=0"
SRC_URI += "${URI_fftw-libs-quad}"
SRC_URI[fftw-libs-quad.sha256sum] = "114709b92d53816968b71456680081df4e6f13c74bd0d83a85c5f2360c173ec7"
RDEPENDS:fftw-libs-quad = " \
 glibc \
 libgcc \
 libquadmath \
 libgomp \
"

URI_fftw-libs-single = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fftw-libs-single-3.3.10-15.el10.x86_64_v2.rpm;name=fftw-libs-single;unpack=0"
SRC_URI += "${URI_fftw-libs-single}"
SRC_URI[fftw-libs-single.sha256sum] = "2b046bb2a614d332d197eb2085b215f37135746dbbd3180a1fbd5a1af3d10fc9"
RDEPENDS:fftw-libs-single = " \
 glibc \
 libgcc \
 libgomp \
"

URI_fftw-openmpi-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fftw-openmpi-devel-3.3.10-15.el10.x86_64_v2.rpm;name=fftw-openmpi-devel;unpack=0"
SRC_URI += "${URI_fftw-openmpi-devel}"
SRC_URI[fftw-openmpi-devel.sha256sum] = "c3c0571f5ebe8ab08f3495febd5c4ae356ff2ac4f94a90bfc24ddb88278fc0b1"
RDEPENDS:fftw-openmpi-devel = " \
 openmpi-devel \
 fftw-openmpi-libs \
 fftw-devel \
 pkgconf-pkg-config \
"

URI_fftw-openmpi-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fftw-openmpi-libs-3.3.10-15.el10.x86_64_v2.rpm;name=fftw-openmpi-libs;unpack=0"
SRC_URI += "${URI_fftw-openmpi-libs}"
SRC_URI[fftw-openmpi-libs.sha256sum] = "7234692c868a1b83854e254724bee0d8fe57d1413d1e5945a2b5e51e92aeb4bd"
RDEPENDS:fftw-openmpi-libs = " \
 fftw-openmpi-libs-double \
 fftw-openmpi-libs-long \
 fftw-openmpi-libs-single \
"

URI_fftw-openmpi-libs-double = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fftw-openmpi-libs-double-3.3.10-15.el10.x86_64_v2.rpm;name=fftw-openmpi-libs-double;unpack=0"
SRC_URI += "${URI_fftw-openmpi-libs-double}"
SRC_URI[fftw-openmpi-libs-double.sha256sum] = "0814c58fe5b5294c344e1f820dae1c065b60feeab1514c14e9e3fd945602cdc2"
RDEPENDS:fftw-openmpi-libs-double = " \
 glibc \
 fftw-libs-double \
 openmpi \
"

URI_fftw-openmpi-libs-long = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fftw-openmpi-libs-long-3.3.10-15.el10.x86_64_v2.rpm;name=fftw-openmpi-libs-long;unpack=0"
SRC_URI += "${URI_fftw-openmpi-libs-long}"
SRC_URI[fftw-openmpi-libs-long.sha256sum] = "f55af2dd74c3978126a22e8be884330f2613af42d1989d722e745fe40f0f17e6"
RDEPENDS:fftw-openmpi-libs-long = " \
 glibc \
 fftw-libs-long \
 openmpi \
"

URI_fftw-openmpi-libs-single = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fftw-openmpi-libs-single-3.3.10-15.el10.x86_64_v2.rpm;name=fftw-openmpi-libs-single;unpack=0"
SRC_URI += "${URI_fftw-openmpi-libs-single}"
SRC_URI[fftw-openmpi-libs-single.sha256sum] = "954225258f69174b237a528e1894baad89329ad0b946531c9c3c5b919b18889e"
RDEPENDS:fftw-openmpi-libs-single = " \
 glibc \
 fftw-libs-single \
 openmpi \
"

URI_fftw-openmpi-static = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fftw-openmpi-static-3.3.10-15.el10.x86_64_v2.rpm;name=fftw-openmpi-static;unpack=0"
SRC_URI += "${URI_fftw-openmpi-static}"
SRC_URI[fftw-openmpi-static.sha256sum] = "6f292266036ef4cb0e5e81d1912121ab921b9e1e004e9c95673ed0bb491558e7"
RDEPENDS:fftw-openmpi-static = " \
 fftw-openmpi-devel \
 fftw-static \
"

URI_fftw-static = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fftw-static-3.3.10-15.el10.x86_64_v2.rpm;name=fftw-static;unpack=0"
SRC_URI += "${URI_fftw-static}"
SRC_URI[fftw-static.sha256sum] = "4aee5476ea85fbb4e1f95a0f4a80f74d23e8aee7e940cc5ee85a1b9aaab3d7b8"
RDEPENDS:fftw-static = " \
 fftw-devel \
"

URI_fftw-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/fftw-doc-3.3.10-15.el10.noarch.rpm;name=fftw-doc;unpack=0"
SRC_URI += "${URI_fftw-doc}"
SRC_URI[fftw-doc.sha256sum] = "917c89810134e4e21604b21b5c15ea5954b1e56eb885d7569c84556bd44b4893"
RDEPENDS:fftw-doc = ""
