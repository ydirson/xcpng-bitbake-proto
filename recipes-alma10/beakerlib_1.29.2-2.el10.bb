# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "beakerlib"
PE = "0"
PV = "1.29.2"
PR = "2.el10"
PACKAGES = "beakerlib beakerlib-vim-syntax"
PROVIDES = "rpm/beakerlib rpm/beakerlib-vim-syntax"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/beakerlib-1.29.2-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe721b133d3883812216526f3b018ee823de265eeed57bff3a4d757d8c192a6d"

URI_beakerlib = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/beakerlib-1.29.2-2.el10.noarch.rpm;name=beakerlib;unpack=0"
SRC_URI += "${URI_beakerlib}"
SRC_URI[beakerlib.sha256sum] = "7167fde03e50477c2a4acf8fd2cec3889c453cc3673a95b5a8d477c1aa5b0d23"
RDEPENDS:beakerlib = " \
 nfs-utils \
 yum-utils \
 iproute \
 util-linux \
 gzip \
 tar \
 grep \
 curl \
 time \
 bash \
 which \
 bc \
 sed \
 coreutils \
"

URI_beakerlib-vim-syntax = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/beakerlib-vim-syntax-1.29.2-2.el10.noarch.rpm;name=beakerlib-vim-syntax;unpack=0"
SRC_URI += "${URI_beakerlib-vim-syntax}"
SRC_URI[beakerlib-vim-syntax.sha256sum] = "1e341b08db69f0f52d4bb1a50b0f1e18eb0780f6fc862a0783cc947d7816cd63"
RDEPENDS:beakerlib-vim-syntax = " \
 vim-common \
"
