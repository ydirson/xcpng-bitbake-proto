# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "freeipmi"
PE = "0"
PV = "1.6.14"
PR = "4.el10"
PACKAGES = "freeipmi freeipmi-bmc-watchdog freeipmi-ipmidetectd freeipmi-ipmiseld freeipmi-devel"
PROVIDES = "rpm/freeipmi rpm/freeipmi-bmc-watchdog rpm/freeipmi-ipmidetectd rpm/freeipmi-ipmiseld rpm/freeipmi-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/freeipmi-1.6.14-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7522a0e502ca08fa9201f4bf77b6848eea1b5b2aa285f63d0ac950ebb9b1e40f"

URI_freeipmi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/freeipmi-1.6.14-4.el10.x86_64_v2.rpm;name=freeipmi;unpack=0"
SRC_URI += "${URI_freeipmi}"
SRC_URI[freeipmi.sha256sum] = "31f83d820f2a0b23f12687a77c5e2671f8e9de2b1e316542f85fb3db00336827"
RDEPENDS:freeipmi = " \
 glibc \
 systemd \
 bash \
 libgcrypt \
"

URI_freeipmi-bmc-watchdog = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/freeipmi-bmc-watchdog-1.6.14-4.el10.x86_64_v2.rpm;name=freeipmi-bmc-watchdog;unpack=0"
SRC_URI += "${URI_freeipmi-bmc-watchdog}"
SRC_URI[freeipmi-bmc-watchdog.sha256sum] = "68a65a8203ac669dcf3d70ad9a0df707a762803a3b48f4ebedcd485600bfa157"
RDEPENDS:freeipmi-bmc-watchdog = " \
 glibc \
 freeipmi \
 bash \
"

URI_freeipmi-ipmidetectd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/freeipmi-ipmidetectd-1.6.14-4.el10.x86_64_v2.rpm;name=freeipmi-ipmidetectd;unpack=0"
SRC_URI += "${URI_freeipmi-ipmidetectd}"
SRC_URI[freeipmi-ipmidetectd.sha256sum] = "3661044ab9859b5496971df101aad8ce3882e7689e4b58873680350ffc6fc317"
RDEPENDS:freeipmi-ipmidetectd = " \
 glibc \
 freeipmi \
 bash \
"

URI_freeipmi-ipmiseld = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/freeipmi-ipmiseld-1.6.14-4.el10.x86_64_v2.rpm;name=freeipmi-ipmiseld;unpack=0"
SRC_URI += "${URI_freeipmi-ipmiseld}"
SRC_URI[freeipmi-ipmiseld.sha256sum] = "9018af1eeed3e4d50a865df050aa8dd09c4b141745e50e1ac9e0774e0b24ee68"
RDEPENDS:freeipmi-ipmiseld = " \
 glibc \
 freeipmi \
 bash \
"

URI_freeipmi-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/freeipmi-devel-1.6.14-4.el10.x86_64_v2.rpm;name=freeipmi-devel;unpack=0"
SRC_URI += "${URI_freeipmi-devel}"
SRC_URI[freeipmi-devel.sha256sum] = "f9080e5269914240dde404e51b5f24b1789828383b157eeba76475bf85375cba"
RDEPENDS:freeipmi-devel = " \
 freeipmi \
 pkgconf-pkg-config \
"
