# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jsr-305"
PE = "0"
PV = "3.0.2"
PR = "17.el10"
PACKAGES = "jsr-305 jsr-305-javadoc"
PROVIDES = "rpm/jsr-305 rpm/jsr-305-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/jsr-305-3.0.2-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20d57e36d3f72485668302e797fc7ee933b11537dd7f8d8ebeb762a42313817d"

URI_jsr-305 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jsr-305-3.0.2-17.el10.noarch.rpm;name=jsr-305;unpack=0"
SRC_URI += "${URI_jsr-305}"
SRC_URI[jsr-305.sha256sum] = "25e06b527dee324df133c78a29f721650cb21804e8c1ca4c11065c85b40cafb0"
RDEPENDS:jsr-305 = " \
 javapackages-filesystem \
"

URI_jsr-305-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jsr-305-javadoc-3.0.2-17.el10.noarch.rpm;name=jsr-305-javadoc;unpack=0"
SRC_URI += "${URI_jsr-305-javadoc}"
SRC_URI[jsr-305-javadoc.sha256sum] = "05ec3149690d13975d63580718b98b60316ecf62cdd79528947340988ce76c84"
RDEPENDS:jsr-305-javadoc = " \
 javapackages-filesystem \
"
