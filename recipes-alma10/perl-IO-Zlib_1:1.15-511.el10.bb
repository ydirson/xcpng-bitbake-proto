# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-IO-Zlib"
PE = "1"
PV = "1.15"
PR = "511.el10"
PACKAGES = "perl-IO-Zlib perl-IO-Zlib-tests"
PROVIDES = "rpm/perl-IO-Zlib rpm/perl-IO-Zlib-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-IO-Zlib-1.15-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6250f68470385f3efde449ec5430637fa2c508c74f1105c712e8b39153bd008a"

URI_perl-IO-Zlib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-IO-Zlib-1.15-511.el10.noarch.rpm;name=perl-IO-Zlib;unpack=0"
SRC_URI += "${URI_perl-IO-Zlib}"
SRC_URI[perl-IO-Zlib.sha256sum] = "737006cd553813bd89a4aa7525c57f3b4eda977a41f7ea3d2e67c661251088c1"
RDEPENDS:perl-IO-Zlib = " \
 perl-libs \
 perl-Carp \
 perl-IO \
 perl-IO-Compress \
 gzip \
 perl-Fcntl \
 perl-Symbol \
 perl-Tie \
"

URI_perl-IO-Zlib-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-IO-Zlib-tests-1.15-511.el10.noarch.rpm;name=perl-IO-Zlib-tests;unpack=0"
SRC_URI += "${URI_perl-IO-Zlib-tests}"
SRC_URI[perl-IO-Zlib-tests.sha256sum] = "c1f20f95b799447be55d20acc87b438bfc689c726b2cfa761f742537898602b1"
RDEPENDS:perl-IO-Zlib-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-IO-Compress \
 perl-IO-Zlib \
 bash \
 perl-interpreter \
"
