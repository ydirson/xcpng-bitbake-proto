# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rust-ssh-key-dir"
PE = "0"
PV = "0.1.4"
PR = "9.el10"
PACKAGES = "ssh-key-dir"
PROVIDES = "rpm/ssh-key-dir"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/rust-ssh-key-dir-0.1.4-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50393507c31c9331fb8634e732f5645089061e749598142254997ffef058e5fc"

URI_ssh-key-dir = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ssh-key-dir-0.1.4-9.el10.x86_64_v2.rpm;name=ssh-key-dir;unpack=0"
SRC_URI += "${URI_ssh-key-dir}"
SRC_URI[ssh-key-dir.sha256sum] = "95ab8b46f682878f174d3a909cdfb26b73fc72c51b64fd9e79d241923ed5fb70"
RDEPENDS:ssh-key-dir = " \
 systemd \
 openssh-server \
 libgcc \
 bash \
 glibc \
"
