# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "luksmeta"
PE = "0"
PV = "9"
PR = "26.el10"
PACKAGES = "libluksmeta luksmeta libluksmeta-devel"
PROVIDES = "rpm/libluksmeta rpm/luksmeta rpm/libluksmeta-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/luksmeta-9-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2f83dc47cbcea8bbaecd3fd96442e8a9993f7db4038429f6c268ec99454129d"

URI_libluksmeta = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libluksmeta-9-26.el10.x86_64_v2.rpm;name=libluksmeta;unpack=0"
SRC_URI += "${URI_libluksmeta}"
SRC_URI[libluksmeta.sha256sum] = "91c47e246a651320f98e6a81c07c5570ed709a8d342e7215eca73bc97e351d29"
RDEPENDS:libluksmeta = " \
 glibc \
 cryptsetup-libs \
"

URI_luksmeta = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/luksmeta-9-26.el10.x86_64_v2.rpm;name=luksmeta;unpack=0"
SRC_URI += "${URI_luksmeta}"
SRC_URI[luksmeta.sha256sum] = "20441381edc462bbee6b06d6a92085815011ef950002037314e6717f7cf5b67f"
RDEPENDS:luksmeta = " \
 glibc \
 libluksmeta \
 cryptsetup-libs \
"

URI_libluksmeta-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libluksmeta-devel-9-26.el10.x86_64_v2.rpm;name=libluksmeta-devel;unpack=0"
SRC_URI += "${URI_libluksmeta-devel}"
SRC_URI[libluksmeta-devel.sha256sum] = "50a6e4b456760761d694f03e353c17729c272cc947cf085c4f317c238e7d6007"
RDEPENDS:libluksmeta-devel = " \
 libluksmeta \
 cryptsetup-devel \
 pkgconf-pkg-config \
"
