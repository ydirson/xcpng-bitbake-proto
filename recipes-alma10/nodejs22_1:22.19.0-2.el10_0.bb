# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "nodejs22"
PE = "1"
PV = "22.19.0"
PR = "2.el10_0"
PACKAGES = "nodejs nodejs-devel nodejs-docs nodejs-full-i18n nodejs-libs nodejs-npm v8-12.4-devel"
PROVIDES = "rpm/nodejs rpm/nodejs-devel rpm/nodejs-docs rpm/nodejs-full-i18n rpm/nodejs-libs rpm/nodejs-npm rpm/v8-12.4-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/nodejs22-22.19.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6a440399af7e1de6f82ca8df79e0a8a91685e65cff6635bcee04ce3e1528512"

URI_nodejs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nodejs-22.19.0-2.el10_0.x86_64_v2.rpm;name=nodejs;unpack=0"
SRC_URI += "${URI_nodejs}"
SRC_URI[nodejs.sha256sum] = "a43f82104dbf5c95d3de2391b52e66bcbabd831f468025931934c698283d0dc8"
RDEPENDS:nodejs = " \
 nodejs-libs \
 ca-certificates \
 openssl \
 libuv \
 glibc \
"

URI_nodejs-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nodejs-devel-22.19.0-2.el10_0.x86_64_v2.rpm;name=nodejs-devel;unpack=0"
SRC_URI += "${URI_nodejs-devel}"
SRC_URI[nodejs-devel.sha256sum] = "2abcdbb7b7fbff56534e90fe5df5c6255dea4563ed927056b5ae55f41b036ecc"
RDEPENDS:nodejs-devel = " \
 brotli-devel \
 zlib-ng-compat-devel \
 nodejs \
 pkgconf-pkg-config \
 openssl-devel \
 bash \
 libuv-devel \
 nodejs-libs \
 nodejs-packaging \
"

URI_nodejs-docs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nodejs-docs-22.19.0-2.el10_0.noarch.rpm;name=nodejs-docs;unpack=0"
SRC_URI += "${URI_nodejs-docs}"
SRC_URI[nodejs-docs.sha256sum] = "8cdb23c51a3ecf87bcc6fe86fd82d34cf8a2d89415cfbfd9b9c20fd3eba754c9"
RDEPENDS:nodejs-docs = " \
 nodejs \
"

URI_nodejs-full-i18n = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nodejs-full-i18n-22.19.0-2.el10_0.x86_64_v2.rpm;name=nodejs-full-i18n;unpack=0"
SRC_URI += "${URI_nodejs-full-i18n}"
SRC_URI[nodejs-full-i18n.sha256sum] = "8f43cc25c29e30c6ee8ae7cffc0d19dfb313206414306d1f77aa9c65bb53efe6"
RDEPENDS:nodejs-full-i18n = " \
 nodejs \
"

URI_nodejs-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nodejs-libs-22.19.0-2.el10_0.x86_64_v2.rpm;name=nodejs-libs;unpack=0"
SRC_URI += "${URI_nodejs-libs}"
SRC_URI[nodejs-libs.sha256sum] = "c34ffdc9b6cf00672d2bded68f56a41d5b83f01989b3de42f385b60cba0eea94"
RDEPENDS:nodejs-libs = " \
 zlib-ng-compat \
 openssl-libs \
 libgcc \
 libbrotli \
 sqlite-libs \
 libstdc++ \
 libuv \
 glibc \
"

URI_nodejs-npm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nodejs-npm-10.9.3-1.22.19.0.2.el10_0.x86_64_v2.rpm;name=nodejs-npm;unpack=0"
SRC_URI += "${URI_nodejs-npm}"
SRC_URI[nodejs-npm.sha256sum] = "9ea12fe2d822a10d60489cc594e7bf5c4429e516bcc4bbb771ddfa780fbb1772"
RDEPENDS:nodejs-npm = " \
 nodejs \
 bash \
"

URI_v8-12.4-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/v8-12.4-devel-12.4.254.21-1.22.19.0.2.el10_0.x86_64_v2.rpm;name=v8-12.4-devel;unpack=0"
SRC_URI += "${URI_v8-12.4-devel}"
SRC_URI[v8-12.4-devel.sha256sum] = "495b49562cd2ef98f3ddd0caaf4e5382d1d095c0bc7618c35d16c21d4faeffd9"
RDEPENDS:v8-12.4-devel = " \
 nodejs-libs \
 pkgconf-pkg-config \
 nodejs-devel \
"
