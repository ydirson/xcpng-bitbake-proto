# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-gd"
PE = "0"
PV = "2.6"
PR = "27.el10"
PACKAGES = "hunspell-gd"
PROVIDES = "rpm/hunspell-gd"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-gd-2.6-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "403905c22a3caa67f49d71a243bb6ca09bbb7f23af114adf27e8a129d624ed6c"

URI_hunspell-gd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-gd-2.6-27.el10.noarch.rpm;name=hunspell-gd;unpack=0"
SRC_URI += "${URI_hunspell-gd}"
SRC_URI[hunspell-gd.sha256sum] = "1402eb0b5cf71f3444872eabb5c2240c04d9e6bec78a4f536ccaf179db6976f1"
RDEPENDS:hunspell-gd = " \
 hunspell-filesystem \
"
