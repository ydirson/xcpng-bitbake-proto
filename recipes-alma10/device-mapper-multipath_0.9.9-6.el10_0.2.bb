# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "device-mapper-multipath"
PE = "0"
PV = "0.9.9"
PR = "6.el10_0.2"
PACKAGES = "device-mapper-multipath device-mapper-multipath-libs kpartx device-mapper-multipath-devel libdmmp libdmmp-devel"
PROVIDES = "rpm/device-mapper-multipath rpm/device-mapper-multipath-libs rpm/kpartx rpm/device-mapper-multipath-devel rpm/libdmmp rpm/libdmmp-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/device-mapper-multipath-0.9.9-6.el10_0.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "016edacd8f9e756020d9e2054c44ffaaa004a82a203fc32e8ecb5a651ae31b7d"

URI_device-mapper-multipath = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/device-mapper-multipath-0.9.9-6.el10_0.2.x86_64_v2.rpm;name=device-mapper-multipath;unpack=0"
SRC_URI += "${URI_device-mapper-multipath}"
SRC_URI[device-mapper-multipath.sha256sum] = "11f142bc711c78f96f6a868d03f0e84aa6e2a59d01068f15b6543128775cc7d4"
RDEPENDS:device-mapper-multipath = " \
 device-mapper \
 systemd \
 device-mapper-libs \
 systemd-libs \
 userspace-rcu \
 device-mapper-multipath-libs \
 libgcc \
 readline \
 libmount \
 kpartx \
 bash \
 glibc \
"

URI_device-mapper-multipath-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/device-mapper-multipath-libs-0.9.9-6.el10_0.2.x86_64_v2.rpm;name=device-mapper-multipath-libs;unpack=0"
SRC_URI += "${URI_device-mapper-multipath-libs}"
SRC_URI[device-mapper-multipath-libs.sha256sum] = "46843f871d45dc7d85bfb6464919277f814d5bd54c7ceefe82a8ab4b51433ce4"
RDEPENDS:device-mapper-multipath-libs = " \
 device-mapper-libs \
 libaio \
 systemd-libs \
 userspace-rcu \
 libgcc \
 libmount \
 glibc \
"

URI_kpartx = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kpartx-0.9.9-6.el10_0.2.x86_64_v2.rpm;name=kpartx;unpack=0"
SRC_URI += "${URI_kpartx}"
SRC_URI[kpartx.sha256sum] = "5934fbbbef5426eed32b0b40eb614ce95fffc1940d2410c4c54dbd250e663923"
RDEPENDS:kpartx = " \
 glibc \
 device-mapper-libs \
 bash \
"

URI_device-mapper-multipath-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/device-mapper-multipath-devel-0.9.9-6.el10_0.2.x86_64_v2.rpm;name=device-mapper-multipath-devel;unpack=0"
SRC_URI += "${URI_device-mapper-multipath-devel}"
SRC_URI[device-mapper-multipath-devel.sha256sum] = "829a461f51f6de83daaa35518382a1b1b3c75e8db08a9cecda8212ad6067066d"
RDEPENDS:device-mapper-multipath-devel = " \
 device-mapper-multipath \
 device-mapper-multipath-libs \
"

URI_libdmmp = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdmmp-0.9.9-6.el10_0.2.x86_64_v2.rpm;name=libdmmp;unpack=0"
SRC_URI += "${URI_libdmmp}"
SRC_URI[libdmmp.sha256sum] = "4d000bbaa483ea68e1246184cc73b30b04fa6256a4ba9353a3f9825b87104e0a"
RDEPENDS:libdmmp = " \
 glibc \
 json-c \
 device-mapper-multipath \
 device-mapper-multipath-libs \
"

URI_libdmmp-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdmmp-devel-0.9.9-6.el10_0.2.x86_64_v2.rpm;name=libdmmp-devel;unpack=0"
SRC_URI += "${URI_libdmmp-devel}"
SRC_URI[libdmmp-devel.sha256sum] = "d41dedf032efedcc5da39e8bcd5d25dd37e35c04388f00c54fff4e210530dac4"
RDEPENDS:libdmmp-devel = " \
 libdmmp \
 pkgconf-pkg-config \
"
