# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hplip"
PE = "0"
PV = "3.23.12"
PR = "8.el10"
PACKAGES = "hplip hplip-common hplip-libs libsane-hpaio"
PROVIDES = "rpm/hplip rpm/hplip-common rpm/hplip-libs rpm/libsane-hpaio"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hplip-3.23.12-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0849aa8d889694f68607556f8db5777bb65325fa521cfabe8f14a19ebc4b7838"

URI_hplip = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hplip-3.23.12-8.el10.x86_64_v2.rpm;name=hplip;unpack=0"
SRC_URI += "${URI_hplip}"
SRC_URI[hplip.sha256sum] = "487de0913659ea91992b9c64750cebd5b3498332a39a1b348e9c070d294ad225"
RDEPENDS:hplip = " \
 python3 \
 systemd \
 tar \
 cups-libs \
 curl \
 python3-dbus \
 cups \
 dbus-libs \
 hplip-libs \
 usbutils \
 libstdc++ \
 zlib-ng-compat \
 gnupg2 \
 libgcc \
 bash \
 gawk \
 glibc \
 coreutils \
 libjpeg-turbo \
"

URI_hplip-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hplip-common-3.23.12-8.el10.x86_64_v2.rpm;name=hplip-common;unpack=0"
SRC_URI += "${URI_hplip-common}"
SRC_URI[hplip-common.sha256sum] = "6ec55da1a530756f4039e008298899ac37e9ebb23765354e49e2733e9bf66b32"
RDEPENDS:hplip-common = ""

URI_hplip-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hplip-libs-3.23.12-8.el10.x86_64_v2.rpm;name=hplip-libs;unpack=0"
SRC_URI += "${URI_hplip-libs}"
SRC_URI[hplip-libs.sha256sum] = "4fcfc0ee9a68622346dabf6b2ab4dcc9ca6918426835abd2bda9d94986fad2ae"
RDEPENDS:hplip-libs = " \
 python3 \
 sane-backends-libs \
 net-snmp-libs \
 openssl-libs \
 cups-libs \
 avahi \
 avahi-libs \
 hplip-common \
 glibc \
 dbus-libs \
 libusb1 \
"

URI_libsane-hpaio = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libsane-hpaio-3.23.12-8.el10.x86_64_v2.rpm;name=libsane-hpaio;unpack=0"
SRC_URI += "${URI_libsane-hpaio}"
SRC_URI[libsane-hpaio.sha256sum] = "af462d8a33615dfdf63f248af4e50732f32b79c137c873a3c9a4ad22e2bc58f4"
RDEPENDS:libsane-hpaio = " \
 hplip-libs \
 net-snmp-libs \
 openssl-libs \
 cups-libs \
 avahi \
 avahi-libs \
 glibc \
 dbus-libs \
 sane-backends \
 libusb1 \
"
