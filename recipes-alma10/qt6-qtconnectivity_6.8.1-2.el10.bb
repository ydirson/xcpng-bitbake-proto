# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtconnectivity"
PE = "0"
PV = "6.8.1"
PR = "2.el10"
PACKAGES = "qt6-qtconnectivity qt6-qtconnectivity-devel qt6-qtconnectivity-examples qt6-qtconnectivity-tests"
PROVIDES = "rpm/qt6-qtconnectivity rpm/qt6-qtconnectivity-devel rpm/qt6-qtconnectivity-examples rpm/qt6-qtconnectivity-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtconnectivity-6.8.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "991b6ce804bb33301b924135f2196bee6124175ad36d002146441d1406bcf87f"

URI_qt6-qtconnectivity = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtconnectivity-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtconnectivity;unpack=0"
SRC_URI += "${URI_qt6-qtconnectivity}"
SRC_URI[qt6-qtconnectivity.sha256sum] = "94c0a5603e87087f2fc900508b11a0712cdaec87fbf8445e90bedd78f80b0f26"
RDEPENDS:qt6-qtconnectivity = " \
 glibc \
 bluez-libs \
 libstdc++ \
 qt6-qtbase \
"

URI_qt6-qtconnectivity-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtconnectivity-devel-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtconnectivity-devel;unpack=0"
SRC_URI += "${URI_qt6-qtconnectivity-devel}"
SRC_URI[qt6-qtconnectivity-devel.sha256sum] = "586d352c88372f07828cd398434d7c39ce616cb40ce84e11250dcb512400aa3c"
RDEPENDS:qt6-qtconnectivity-devel = " \
 qt6-qtconnectivity \
 qt6-qtbase-devel \
 cmake-filesystem \
 pkgconf-pkg-config \
"

URI_qt6-qtconnectivity-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtconnectivity-examples-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtconnectivity-examples;unpack=0"
SRC_URI += "${URI_qt6-qtconnectivity-examples}"
SRC_URI[qt6-qtconnectivity-examples.sha256sum] = "9fed638ae284f3d39f47da060b04f7445aad2b80879edff56f531bc8d85ad1cd"
RDEPENDS:qt6-qtconnectivity-examples = " \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
 qt6-qtconnectivity \
"

URI_qt6-qtconnectivity-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtconnectivity-tests-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtconnectivity-tests;unpack=0"
SRC_URI += "${URI_qt6-qtconnectivity-tests}"
SRC_URI[qt6-qtconnectivity-tests.sha256sum] = "61bdccb543ab0c15a19847f90b3c5d843cac2dc81590bf9cfdd0a857cd0bb556"
RDEPENDS:qt6-qtconnectivity-tests = " \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 glibc \
 qt6-qtconnectivity \
"
