# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "osinfo-db-tools"
PE = "0"
PV = "1.11.0"
PR = "8.el10"
PACKAGES = "osinfo-db-tools"
PROVIDES = "rpm/osinfo-db-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/osinfo-db-tools-1.11.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3bb84a5c7d3d75d6ffbc71f98cd1e5a17e473860761db68602702cd3ae99644"

URI_osinfo-db-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/osinfo-db-tools-1.11.0-8.el10.x86_64_v2.rpm;name=osinfo-db-tools;unpack=0"
SRC_URI += "${URI_osinfo-db-tools}"
SRC_URI[osinfo-db-tools.sha256sum] = "c2b3f41c15f1f4e0d29bab7248464c837fef8f940ac3a98b11356d4d6fd6677d"
RDEPENDS:osinfo-db-tools = " \
 libsoup3 \
 libarchive \
 libgcc \
 libxml2 \
 json-glib \
 glib2 \
 glibc \
"
