# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sblim-sfcb"
PE = "0"
PV = "1.4.9"
PR = "34.el10"
PACKAGES = "sblim-sfcb"
PROVIDES = "rpm/sblim-sfcb"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/sblim-sfcb-1.4.9-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d646ac12ed7d2990ab0591575ed882b24b99e102af223b755f0f5f405b73433"

URI_sblim-sfcb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sblim-sfcb-1.4.9-34.el10.x86_64_v2.rpm;name=sblim-sfcb;unpack=0"
SRC_URI += "${URI_sblim-sfcb}"
SRC_URI[sblim-sfcb.sha256sum] = "3930d66493360a86dddc729544d1dff2a1703e50e7018aaf810070fabece9ab6"
RDEPENDS:sblim-sfcb = " \
 systemd \
 perl-libs \
 zlib-ng-compat \
 perl-libwww-perl \
 perl-URI \
 cim-schema \
 openssl-libs \
 sblim-sfcCommon \
 perl-Getopt-Long \
 openslp \
 pam-libs \
 bash \
 libcurl \
 glibc \
 perl-interpreter \
"
