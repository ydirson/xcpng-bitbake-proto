# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xalan-j2"
PE = "0"
PV = "2.7.3"
PR = "6.el10"
PACKAGES = "xalan-j2 xalan-j2-manual xalan-j2-xsltc"
PROVIDES = "rpm/xalan-j2 rpm/xalan-j2-manual rpm/xalan-j2-xsltc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xalan-j2-2.7.3-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64e3ae8237ba53da4423ab93ecad5ed67688b62a220fd79ab8ea3753e3565710"

URI_xalan-j2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xalan-j2-2.7.3-6.el10.noarch.rpm;name=xalan-j2;unpack=0"
SRC_URI += "${URI_xalan-j2}"
SRC_URI[xalan-j2.sha256sum] = "db0ec0fa98f4dab3591ce03c0588da41781b6203dbd4b581f2313a0408b935af"
RDEPENDS:xalan-j2 = " \
 javapackages-filesystem \
 xerces-j2 \
"

URI_xalan-j2-manual = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xalan-j2-manual-2.7.3-6.el10.noarch.rpm;name=xalan-j2-manual;unpack=0"
SRC_URI += "${URI_xalan-j2-manual}"
SRC_URI[xalan-j2-manual.sha256sum] = "d1f667b9b692d5cc00c3b5a42f8a571aa9bd0bdd25b80dafe06474360fb6173b"
RDEPENDS:xalan-j2-manual = ""

URI_xalan-j2-xsltc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xalan-j2-xsltc-2.7.3-6.el10.noarch.rpm;name=xalan-j2-xsltc;unpack=0"
SRC_URI += "${URI_xalan-j2-xsltc}"
SRC_URI[xalan-j2-xsltc.sha256sum] = "52d55ccfe8453a8dbec18e7b62d947bbd0a92b34e069ea56e27b01227c788a73"
RDEPENDS:xalan-j2-xsltc = " \
 javapackages-filesystem \
 regexp \
 xerces-j2 \
 xalan-j2 \
 bcel \
 java_cup \
"
