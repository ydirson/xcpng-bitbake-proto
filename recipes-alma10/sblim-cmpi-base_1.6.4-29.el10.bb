# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sblim-cmpi-base"
PE = "0"
PV = "1.6.4"
PR = "29.el10"
PACKAGES = "sblim-cmpi-base sblim-cmpi-base-devel"
PROVIDES = "rpm/sblim-cmpi-base rpm/sblim-cmpi-base-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/sblim-cmpi-base-1.6.4-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a6ded2ebb68cb3ec8bc2a8ccc03f71e4d62e6071f193293fb53a8f42425f2ad"

URI_sblim-cmpi-base = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sblim-cmpi-base-1.6.4-29.el10.x86_64_v2.rpm;name=sblim-cmpi-base;unpack=0"
SRC_URI += "${URI_sblim-cmpi-base}"
SRC_URI[sblim-cmpi-base.sha256sum] = "b6eecae46d3048f60b24b8764f53a962281c0f123aa3faf359feec5e63bd0996"
RDEPENDS:sblim-cmpi-base = " \
 glibc \
 sblim-sfcb \
 sblim-indication_helper \
 bash \
"

URI_sblim-cmpi-base-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sblim-cmpi-base-devel-1.6.4-29.el10.x86_64_v2.rpm;name=sblim-cmpi-base-devel;unpack=0"
SRC_URI += "${URI_sblim-cmpi-base-devel}"
SRC_URI[sblim-cmpi-base-devel.sha256sum] = "14d25bd8f8a9a7f9bfe2d9498c60fb8e05682fd365a2a42c22d00c7beafb8816"
RDEPENDS:sblim-cmpi-base-devel = " \
 sblim-cmpi-base \
"
