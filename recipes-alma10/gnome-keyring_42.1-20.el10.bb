# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-keyring"
PE = "0"
PV = "42.1"
PR = "20.el10"
PACKAGES = "gnome-keyring gnome-keyring-pam"
PROVIDES = "rpm/gnome-keyring rpm/gnome-keyring-pam"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-keyring-42.1-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a13e498e88d4ffb69d21739142743c401d9af129dbc4288993ba54db37e2b73a"

URI_gnome-keyring = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-keyring-42.1-20.el10.x86_64_v2.rpm;name=gnome-keyring;unpack=0"
SRC_URI += "${URI_gnome-keyring}"
SRC_URI[gnome-keyring.sha256sum] = "2370975c17dd2e068b1b24f4aabbb3a8b019172546935c22705d23ce63adc83f"
RDEPENDS:gnome-keyring = " \
 gcr3 \
 gcr3-base \
 systemd-libs \
 openssh-clients \
 libgcrypt \
 bash \
 glib2 \
 glibc \
"

URI_gnome-keyring-pam = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-keyring-pam-42.1-20.el10.x86_64_v2.rpm;name=gnome-keyring-pam;unpack=0"
SRC_URI += "${URI_gnome-keyring-pam}"
SRC_URI[gnome-keyring-pam.sha256sum] = "33dae31095ee30ed2c0b41b823805952337176473d3e9c20a3c01099a26c57d0"
RDEPENDS:gnome-keyring-pam = " \
 pam \
 pam-libs \
 gnome-keyring \
 glibc \
 libselinux \
"
