# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libtracecmd"
PE = "0"
PV = "1.5.2"
PR = "1.el10"
PACKAGES = "libtracecmd libtracecmd-devel"
PROVIDES = "rpm/libtracecmd rpm/libtracecmd-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libtracecmd-1.5.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "421ce020743beeeaf6728c2924ab28bec67ebc36e68be3bee81574a598a2f220"

URI_libtracecmd = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libtracecmd-1.5.2-1.el10.x86_64_v2.rpm;name=libtracecmd;unpack=0"
SRC_URI += "${URI_libtracecmd}"
SRC_URI[libtracecmd.sha256sum] = "7b766ef69e29ce2c5c485f8b708f42d2510078058be363910f97879047fc7f98"
RDEPENDS:libtracecmd = " \
 zlib-ng-compat \
 libzstd \
 glibc \
 libtraceevent \
 libtracefs \
"

URI_libtracecmd-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libtracecmd-devel-1.5.2-1.el10.x86_64_v2.rpm;name=libtracecmd-devel;unpack=0"
SRC_URI += "${URI_libtracecmd-devel}"
SRC_URI[libtracecmd-devel.sha256sum] = "2e0ff4fecfe4518c3c79b0a872ba8f1c6b438d4a5fb771120a67c89862711c5c"
RDEPENDS:libtracecmd-devel = " \
 libtracefs-devel \
 libtracecmd \
 pkgconf-pkg-config \
"
