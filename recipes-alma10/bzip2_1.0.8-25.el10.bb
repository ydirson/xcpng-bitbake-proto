# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "bzip2"
PE = "0"
PV = "1.0.8"
PR = "25.el10"
PACKAGES = "bzip2 bzip2-libs bzip2-devel bzip2-static"
PROVIDES = "rpm/bzip2 rpm/bzip2-libs rpm/bzip2-devel rpm/bzip2-static"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/bzip2-1.0.8-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1e562378f9f7202184fb62c19174a0eee83777391f6d78166ed20a759682972"

URI_bzip2 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/bzip2-1.0.8-25.el10.x86_64_v2.rpm;name=bzip2;unpack=0"
SRC_URI += "${URI_bzip2}"
SRC_URI[bzip2.sha256sum] = "85da6062c8bff69fe8eaae120ba2fa6831eaf4f5ba214158b4ab510db18adf3f"
RDEPENDS:bzip2 = " \
 glibc \
 bash \
 bzip2-libs \
"

URI_bzip2-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/bzip2-libs-1.0.8-25.el10.x86_64_v2.rpm;name=bzip2-libs;unpack=0"
SRC_URI += "${URI_bzip2-libs}"
SRC_URI[bzip2-libs.sha256sum] = "aa03374c786a4929fee2f59dd53d08078acd3309f69d92887f4c7b83fe731f6c"
RDEPENDS:bzip2-libs = " \
 glibc \
"

URI_bzip2-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/bzip2-devel-1.0.8-25.el10.x86_64_v2.rpm;name=bzip2-devel;unpack=0"
SRC_URI += "${URI_bzip2-devel}"
SRC_URI[bzip2-devel.sha256sum] = "e77661d2c70cdd1c11158ec995aa2ae390ffd728fab4ec3e1141f72a2ca11fde"
RDEPENDS:bzip2-devel = " \
 bzip2-libs \
 pkgconf-pkg-config \
"

URI_bzip2-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/bzip2-static-1.0.8-25.el10.x86_64_v2.rpm;name=bzip2-static;unpack=0"
SRC_URI += "${URI_bzip2-static}"
SRC_URI[bzip2-static.sha256sum] = "901c347b01701bc65f3fbe7c95dd00cbb4f77f025256c6f26822ba10d2bb80da"
RDEPENDS:bzip2-static = ""
