# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-sphinx-theme-alabaster"
PE = "0"
PV = "0.7.16"
PR = "5.el10"
PACKAGES = "python3-sphinx-theme-alabaster"
PROVIDES = "rpm/python3-sphinx-theme-alabaster"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/python-sphinx-theme-alabaster-0.7.16-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9064eb74cfebe2ca59cac2b2b2beacca2e44b8d240979fabe02305494e79566"

URI_python3-sphinx-theme-alabaster = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-sphinx-theme-alabaster-0.7.16-5.el10.noarch.rpm;name=python3-sphinx-theme-alabaster;unpack=0"
SRC_URI += "${URI_python3-sphinx-theme-alabaster}"
SRC_URI[python3-sphinx-theme-alabaster.sha256sum] = "280419b4c99bfa2fb9de43d194205733880e1ccfa4876091cc5f00ff5f6856e1"
RDEPENDS:python3-sphinx-theme-alabaster = " \
 python3 \
"
