# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "iniparser"
PE = "0"
PV = "4.1"
PR = "18.el10"
PACKAGES = "iniparser iniparser-devel"
PROVIDES = "rpm/iniparser rpm/iniparser-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/iniparser-4.1-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82abb896c21fb97df2e4600c7394fe135098ec495cdafd57cd1c76f05cfe31b2"

URI_iniparser = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/iniparser-4.1-18.el10.x86_64_v2.rpm;name=iniparser;unpack=0"
SRC_URI += "${URI_iniparser}"
SRC_URI[iniparser.sha256sum] = "ad249d4dded3b5b142ff89b28c6021be97b9a968845e99e60c4eda186d8ed86b"
RDEPENDS:iniparser = " \
 glibc \
"

URI_iniparser-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/iniparser-devel-4.1-18.el10.x86_64_v2.rpm;name=iniparser-devel;unpack=0"
SRC_URI += "${URI_iniparser-devel}"
SRC_URI[iniparser-devel.sha256sum] = "f0cc2104fe9c44a8d384f18af805d15755ec4661ae92db7df4c6aac2f68c74c7"
RDEPENDS:iniparser-devel = " \
 iniparser \
"
