# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "powerpc-utils"
PE = "0"
PV = "1.3.13"
PR = "2.el10"
PACKAGES = ""
PROVIDES = ""


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/powerpc-utils-1.3.13-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8bbaf411443d2a355a475a606c54bbe27e7aad44402440116c80f9234edd32a"
