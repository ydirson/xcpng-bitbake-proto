# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-HTTP-Cookies"
PE = "0"
PV = "6.11"
PR = "5.el10"
PACKAGES = "perl-HTTP-Cookies perl-HTTP-Cookies-tests"
PROVIDES = "rpm/perl-HTTP-Cookies rpm/perl-HTTP-Cookies-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-HTTP-Cookies-6.11-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b07faa99c667cf1a14af6d7d7983eeffeafdb1803aa65ba28c3e6d9b3dfbda7"

URI_perl-HTTP-Cookies = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-HTTP-Cookies-6.11-5.el10.noarch.rpm;name=perl-HTTP-Cookies;unpack=0"
SRC_URI += "${URI_perl-HTTP-Cookies}"
SRC_URI[perl-HTTP-Cookies.sha256sum] = "e7ffbc35b09cc40b6edfea56219d51328b613cbf294372dcbf8fd3f9a39dca95"
RDEPENDS:perl-HTTP-Cookies = " \
 perl-libs \
 perl-Carp \
 perl-locale \
 perl-HTTP-Cookies \
 perl-HTTP-Date \
 perl-HTTP-Message \
"

URI_perl-HTTP-Cookies-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-HTTP-Cookies-tests-6.11-5.el10.noarch.rpm;name=perl-HTTP-Cookies-tests;unpack=0"
SRC_URI += "${URI_perl-HTTP-Cookies-tests}"
SRC_URI[perl-HTTP-Cookies-tests.sha256sum] = "920594576dbd6f750cafca8fae91a4939498979bc2ac4f4cd78fa33e9d3e0585"
RDEPENDS:perl-HTTP-Cookies-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-URI \
 perl-HTTP-Message \
 bash \
 perl-HTTP-Cookies \
 coreutils \
 perl-interpreter \
"
