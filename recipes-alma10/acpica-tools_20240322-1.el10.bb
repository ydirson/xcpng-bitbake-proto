# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "acpica-tools"
PE = "0"
PV = "20240322"
PR = "1.el10"
PACKAGES = "acpica-tools"
PROVIDES = "rpm/acpica-tools"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/acpica-tools-20240322-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e95c1bf7cd1b02ceeac8103eccdbaf706846674e89104d4da3920d1677b6401e"

URI_acpica-tools = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/acpica-tools-20240322-1.el10.x86_64_v2.rpm;name=acpica-tools;unpack=0"
SRC_URI += "${URI_acpica-tools}"
SRC_URI[acpica-tools.sha256sum] = "7f5bcf3a8fe0f0246b5a618f31f054c24297a5397d04722a27d35d224d7422ab"
RDEPENDS:acpica-tools = " \
 glibc \
 bash \
"
