# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-extensions-app"
PE = "0"
PV = "46.2"
PR = "4.el10"
PACKAGES = "gnome-extensions-app"
PROVIDES = "rpm/gnome-extensions-app"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-extensions-app-46.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d40869259647f5c054702f42a406f80359a1b1e374d1677fd8712de0fbe23c0"

URI_gnome-extensions-app = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-extensions-app-46.2-4.el10.x86_64_v2.rpm;name=gnome-extensions-app;unpack=0"
SRC_URI += "${URI_gnome-extensions-app}"
SRC_URI[gnome-extensions-app.sha256sum] = "f9f98943df4c91de736b347956395c6ecbdf6710f6546e2db26de50cc41518df"
RDEPENDS:gnome-extensions-app = " \
 gjs \
 libgcc \
 libX11 \
 bash \
 glib2 \
 glibc \
 gtk4 \
 libadwaita \
"
