# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "flatpak-rpm-macros"
PE = "0"
PV = "40"
PR = "6.el10"
PACKAGES = "flatpak-rpm-macros"
PROVIDES = "rpm/flatpak-rpm-macros"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/flatpak-rpm-macros-40-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0fb0aecea392275ca431b53a91ca5f9ead741b3773531ed10fd0e7cfaeac9dbb"

URI_flatpak-rpm-macros = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/flatpak-rpm-macros-40-6.el10.x86_64_v2.rpm;name=flatpak-rpm-macros;unpack=0"
SRC_URI += "${URI_flatpak-rpm-macros}"
SRC_URI[flatpak-rpm-macros.sha256sum] = "78dd79820d612ad7ebfda82e1bb0072e64e5f28a338f11ed2da6548a488e505a"
RDEPENDS:flatpak-rpm-macros = " \
 bash \
"
