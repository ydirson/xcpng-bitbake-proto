# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tuna"
PE = "0"
PV = "0.19"
PR = "9.el10"
PACKAGES = "tuna"
PROVIDES = "rpm/tuna"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/tuna-0.19-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a09330ea1bd77aa3c634e9e164187edb3621308a122702de24d781260c5ac6f"

URI_tuna = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/tuna-0.19-9.el10.noarch.rpm;name=tuna;unpack=0"
SRC_URI += "${URI_tuna}"
SRC_URI[tuna.sha256sum] = "c4df69d66d6337ac75d3cae2e593f4728d65e868e0bb350ce2b3c8684f44b17f"
RDEPENDS:tuna = " \
 python3 \
 python3-linux-procfs \
"
