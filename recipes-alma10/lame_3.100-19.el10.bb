# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lame"
PE = "0"
PV = "3.100"
PR = "19.el10"
PACKAGES = "lame lame-libs lame-devel"
PROVIDES = "rpm/lame rpm/lame-libs rpm/lame-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/lame-3.100-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "358f833c74f181c3e7bf96319fe0b9277c056c75cdb042b3285f1a875848a03d"

URI_lame = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lame-3.100-19.el10.x86_64_v2.rpm;name=lame;unpack=0"
SRC_URI += "${URI_lame}"
SRC_URI[lame.sha256sum] = "fff8cbdc17fdc4b465ada39aed10996fcb9b647538496a9e135fd2c56ac65b8c"
RDEPENDS:lame = " \
 glibc \
 lame-libs \
 ncurses-libs \
"

URI_lame-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lame-libs-3.100-19.el10.x86_64_v2.rpm;name=lame-libs;unpack=0"
SRC_URI += "${URI_lame-libs}"
SRC_URI[lame-libs.sha256sum] = "f62027bd2b4452548c36196f6e6334cab76c1720bbe1bcafcc48e243ac8a8e34"
RDEPENDS:lame-libs = " \
 glibc \
"

URI_lame-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/lame-devel-3.100-19.el10.x86_64_v2.rpm;name=lame-devel;unpack=0"
SRC_URI += "${URI_lame-devel}"
SRC_URI[lame-devel.sha256sum] = "5b81062821198ce991c8b2e5ff5516b56446771810588f307e1e0cbc4d87c56e"
RDEPENDS:lame-devel = " \
 lame-libs \
"
