# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cachefilesd"
PE = "0"
PV = "0.10.10"
PR = "20.el10"
PACKAGES = "cachefilesd"
PROVIDES = "rpm/cachefilesd"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/cachefilesd-0.10.10-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3af81aad13ba729799dbf4d04cb55a450d450329dfeab26ef9337052e71bd85b"

URI_cachefilesd = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cachefilesd-0.10.10-20.el10.x86_64_v2.rpm;name=cachefilesd;unpack=0"
SRC_URI += "${URI_cachefilesd}"
SRC_URI[cachefilesd.sha256sum] = "46d3eab44718ed0bbadfea2607519246e9b3f996a3228b31cfb8ec0a4fd1c15b"
RDEPENDS:cachefilesd = " \
 glibc \
 selinux-policy \
 systemd \
 bash \
"
