# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gdb"
PE = "0"
PV = "14.2"
PR = "4.1.el10_0"
PACKAGES = "gdb gdb-doc gdb-gdbserver gdb-headless gdb-minimal"
PROVIDES = "rpm/gdb rpm/gdb-doc rpm/gdb-gdbserver rpm/gdb-headless rpm/gdb-minimal"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gdb-14.2-4.1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65504fb43593dc5e768f3fc3aa6129cfc30489e4b8435597b05915b8cb1bfee4"

URI_gdb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gdb-14.2-4.1.el10_0.x86_64_v2.rpm;name=gdb;unpack=0"
SRC_URI += "${URI_gdb}"
SRC_URI[gdb.sha256sum] = "ee4e35627af5c0f53a7c763a0a4129331c52af608daa524b0993bb04c13694b4"
RDEPENDS:gdb = " \
 gdb-headless \
 bash \
"

URI_gdb-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gdb-doc-14.2-4.1.el10_0.noarch.rpm;name=gdb-doc;unpack=0"
SRC_URI += "${URI_gdb-doc}"
SRC_URI[gdb-doc.sha256sum] = "0b904a28a68facc4e7181e332ef547c737c8d246a610bb05a624722644842238"
RDEPENDS:gdb-doc = ""

URI_gdb-gdbserver = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gdb-gdbserver-14.2-4.1.el10_0.x86_64_v2.rpm;name=gdb-gdbserver;unpack=0"
SRC_URI += "${URI_gdb-gdbserver}"
SRC_URI[gdb-gdbserver.sha256sum] = "42648aff40cf32e5d3786404407c5539c4c20e007e99717814a650067bd00d74"
RDEPENDS:gdb-gdbserver = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_gdb-headless = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gdb-headless-14.2-4.1.el10_0.x86_64_v2.rpm;name=gdb-headless;unpack=0"
SRC_URI += "${URI_gdb-headless}"
SRC_URI[gdb-headless.sha256sum] = "7c34199832c8f1e00668992ce210762f3b22ba2e095aa6d1fdfa46234b0b5eef"
RDEPENDS:gdb-headless = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 source-highlight \
 libbabeltrace \
 elfutils-debuginfod-client \
 libgcc \
 readline \
 python3-libs \
 libstdc++ \
 bash \
 ncurses-libs \
 libipt \
 expat \
 glibc \
 xz-libs \
"

URI_gdb-minimal = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gdb-minimal-14.2-4.1.el10_0.x86_64_v2.rpm;name=gdb-minimal;unpack=0"
SRC_URI += "${URI_gdb-minimal}"
SRC_URI[gdb-minimal.sha256sum] = "2d68935eccbfe2e1e68bec4f343d46f1f9697bcc5f86098000b5fca6abddd62d"
RDEPENDS:gdb-minimal = " \
 gmp \
 zlib-ng-compat \
 mpfr \
 elfutils-debuginfod-client \
 libgcc \
 readline \
 libstdc++ \
 bash \
 ncurses-libs \
 glibc \
 xz-libs \
"
