# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libXft"
PE = "0"
PV = "2.3.8"
PR = "8.el10"
PACKAGES = "libXft libXft-devel"
PROVIDES = "rpm/libXft rpm/libXft-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libXft-2.3.8-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23015788c68a31b9529038c1c809348ea421cc096ec25100a208910dceaba930"

URI_libXft = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXft-2.3.8-8.el10.x86_64_v2.rpm;name=libXft;unpack=0"
SRC_URI += "${URI_libXft}"
SRC_URI[libXft.sha256sum] = "6c700a52a9c51c8f01e8f87c1a3734a25bd807d82223ade53ac2e46da071bf27"
RDEPENDS:libXft = " \
 freetype \
 fontconfig \
 libXrender \
 libX11 \
 glibc \
"

URI_libXft-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXft-devel-2.3.8-8.el10.x86_64_v2.rpm;name=libXft-devel;unpack=0"
SRC_URI += "${URI_libXft-devel}"
SRC_URI[libXft-devel.sha256sum] = "db4b4ce94ec3745f107e618deee3436df1031eed1bd95d47c869e003c8fb827e"
RDEPENDS:libXft-devel = " \
 libXft \
 freetype-devel \
 pkgconf-pkg-config \
 fontconfig-devel \
 libXrender-devel \
 xorg-x11-proto-devel \
"
