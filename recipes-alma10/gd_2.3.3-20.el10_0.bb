# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gd"
PE = "0"
PV = "2.3.3"
PR = "20.el10_0"
PACKAGES = "gd gd-devel gd-progs"
PROVIDES = "rpm/gd rpm/gd-devel rpm/gd-progs"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gd-2.3.3-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0cabd68275825bc0b2590a24098202a4075e8c7d562d74e761525eb21164f7f6"

URI_gd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gd-2.3.3-20.el10_0.x86_64_v2.rpm;name=gd;unpack=0"
SRC_URI += "${URI_gd}"
SRC_URI[gd.sha256sum] = "637b324de27b54360de5b7a033ab09012bbf020cd9a107c3e71e121caee264fa"
RDEPENDS:gd = " \
 zlib-ng-compat \
 freetype \
 libpng \
 libwebp \
 libXpm \
 fontconfig \
 libX11 \
 glibc \
 libjpeg-turbo \
 libtiff \
"

URI_gd-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gd-devel-2.3.3-20.el10_0.x86_64_v2.rpm;name=gd-devel;unpack=0"
SRC_URI += "${URI_gd-devel}"
SRC_URI[gd-devel.sha256sum] = "c2b183560f0e4af235cf8cb3772c78675ffb96b69ea2eccc32aa8460a7beafaa"
RDEPENDS:gd-devel = " \
 libtiff-devel \
 gd \
 zlib-ng-compat-devel \
 freetype-devel \
 libwebp-devel \
 pkgconf-pkg-config \
 libXpm-devel \
 fontconfig-devel \
 libX11-devel \
 libpng-devel \
 libjpeg-turbo-devel \
"

URI_gd-progs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gd-progs-2.3.3-20.el10_0.x86_64_v2.rpm;name=gd-progs;unpack=0"
SRC_URI += "${URI_gd-progs}"
SRC_URI[gd-progs.sha256sum] = "8f06773f8e99bb265a53cd54d48b7c0f999a8b8555a52fc3d0ca3f000ab11fe3"
RDEPENDS:gd-progs = " \
 glibc \
 gd \
 perl-interpreter \
 perl-libs \
"
