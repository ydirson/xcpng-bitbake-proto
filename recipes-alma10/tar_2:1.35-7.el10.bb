# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tar"
PE = "2"
PV = "1.35"
PR = "7.el10"
PACKAGES = "tar"
PROVIDES = "rpm/tar"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/tar-1.35-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a679a366749308018ac1d97c254dd63cb97876bd09b37f9c11e4d53f1fbfbba6"

URI_tar = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/tar-1.35-7.el10.x86_64_v2.rpm;name=tar;unpack=0"
SRC_URI += "${URI_tar}"
SRC_URI[tar.sha256sum] = "9347545384c81359347d7d5ab5557d5a6f80b7a17d0dd5e55283fb5e26394599"
RDEPENDS:tar = " \
 glibc \
 libselinux \
 libacl \
"
