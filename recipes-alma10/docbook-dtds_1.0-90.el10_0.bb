# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "docbook-dtds"
PE = "0"
PV = "1.0"
PR = "90.el10_0"
PACKAGES = "docbook-dtds"
PROVIDES = "rpm/docbook-dtds"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/docbook-dtds-1.0-90.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04e540a6be2803b8d3e364f4119be8302c93876ffcb87a6a1cf20a0d52300142"

URI_docbook-dtds = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/docbook-dtds-1.0-90.el10_0.noarch.rpm;name=docbook-dtds;unpack=0"
SRC_URI += "${URI_docbook-dtds}"
SRC_URI[docbook-dtds.sha256sum] = "694a9738894c0e53c89dd6138bb4b6ac1bc55fcfbd9a0a8f54eb89519eda624c"
RDEPENDS:docbook-dtds = " \
 sgml-common \
 libxml2 \
 bash \
 xml-common \
 sed \
 coreutils \
"
