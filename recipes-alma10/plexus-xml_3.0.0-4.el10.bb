# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "plexus-xml"
PE = "0"
PV = "3.0.0"
PR = "4.el10"
PACKAGES = "plexus-xml plexus-xml-javadoc"
PROVIDES = "rpm/plexus-xml rpm/plexus-xml-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/plexus-xml-3.0.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4dc9c8d3764189cdfb442cc7337de4ff842f792d53d485f69c812ef2b8275276"

URI_plexus-xml = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-xml-3.0.0-4.el10.noarch.rpm;name=plexus-xml;unpack=0"
SRC_URI += "${URI_plexus-xml}"
SRC_URI[plexus-xml.sha256sum] = "fcb2531a1bb6b5586a87131ee7326fa477bdc0c80c6f3e05c6478922cd4a535b"
RDEPENDS:plexus-xml = " \
 javapackages-filesystem \
"

URI_plexus-xml-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-xml-javadoc-3.0.0-4.el10.noarch.rpm;name=plexus-xml-javadoc;unpack=0"
SRC_URI += "${URI_plexus-xml-javadoc}"
SRC_URI[plexus-xml-javadoc.sha256sum] = "7a90eeddc2474a193621eb4544a78d3eb70c92e01198f9e27c29afd399aa1f80"
RDEPENDS:plexus-xml-javadoc = " \
 javapackages-filesystem \
"
