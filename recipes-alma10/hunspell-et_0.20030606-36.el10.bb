# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-et"
PE = "0"
PV = "0.20030606"
PR = "36.el10"
PACKAGES = "hunspell-et hyphen-et"
PROVIDES = "rpm/hunspell-et rpm/hyphen-et"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-et-0.20030606-36.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b93654425f4c20412e415e2ea49fbd418eb752516e0c03f4c00697f1fec07710"

URI_hunspell-et = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-et-0.20030606-36.el10.noarch.rpm;name=hunspell-et;unpack=0"
SRC_URI += "${URI_hunspell-et}"
SRC_URI[hunspell-et.sha256sum] = "4ffd1c67424d6215898eabbdecd88db54f3b79c87ce28eb9018158c9bf83aa7e"
RDEPENDS:hunspell-et = " \
 hunspell-filesystem \
"

URI_hyphen-et = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-et-0.20030606-36.el10.noarch.rpm;name=hyphen-et;unpack=0"
SRC_URI += "${URI_hyphen-et}"
SRC_URI[hyphen-et.sha256sum] = "fb4bbd09eb2d4fd2112e4835c8176e44504234f209f2a4d49cbec1f761e40bff"
RDEPENDS:hyphen-et = " \
 hyphen \
"
