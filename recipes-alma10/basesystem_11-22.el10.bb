# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "basesystem"
PE = "0"
PV = "11"
PR = "22.el10"
PACKAGES = "basesystem"
PROVIDES = "rpm/basesystem"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/basesystem-11-22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f070b25ac356ab7d10f1309f5cc966d1e9cf1ffd619d149cbafcb970418e42b"

URI_basesystem = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/basesystem-11-22.el10.noarch.rpm;name=basesystem;unpack=0"
SRC_URI += "${URI_basesystem}"
SRC_URI[basesystem.sha256sum] = "ce290f8c5998442e68cbc7e2351f43c2d5bb05a9d109058fc457487b9c267796"
RDEPENDS:basesystem = " \
 setup \
 filesystem \
"
