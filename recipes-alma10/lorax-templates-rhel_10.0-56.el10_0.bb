# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lorax-templates-rhel"
PE = "0"
PV = "10.0"
PR = "56.el10_0"
PACKAGES = "lorax-templates-rhel"
PROVIDES = "rpm/lorax-templates-rhel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/lorax-templates-rhel-10.0-56.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74e6c7675027f23a79d142413a4325b4a1b7b078c28485b830a5fc37c8d02ada"

URI_lorax-templates-rhel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lorax-templates-rhel-10.0-56.el10_0.noarch.rpm;name=lorax-templates-rhel;unpack=0"
SRC_URI += "${URI_lorax-templates-rhel}"
SRC_URI[lorax-templates-rhel.sha256sum] = "a99291f3a50987d5f8751098d40865a99a442a9c682ecb17630ae12a58e071c0"
RDEPENDS:lorax-templates-rhel = " \
 lorax \
"
