# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "expect"
PE = "0"
PV = "5.45.4"
PR = "25.el10"
PACKAGES = "expect expect-devel expectk"
PROVIDES = "rpm/expect rpm/expect-devel rpm/expectk"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/expect-5.45.4-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "566537e993f0603a013e20fe709ab6c30f0a88e090b00540cb756c4ed7d1e377"

URI_expect = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/expect-5.45.4-25.el10.x86_64_v2.rpm;name=expect;unpack=0"
SRC_URI += "${URI_expect}"
SRC_URI[expect.sha256sum] = "d606f0bd7b28984e132562971f0f29a094ade44b34be401820da2c8f19cbbc25"
RDEPENDS:expect = " \
 glibc \
 bash \
 tcl \
"

URI_expect-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/expect-devel-5.45.4-25.el10.x86_64_v2.rpm;name=expect-devel;unpack=0"
SRC_URI += "${URI_expect-devel}"
SRC_URI[expect-devel.sha256sum] = "5457df4a1a606752b7c9604053ca7e90ffdb17661eb508756acfd05447e51db2"
RDEPENDS:expect-devel = " \
 expect \
"

URI_expectk = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/expectk-5.45.4-25.el10.x86_64_v2.rpm;name=expectk;unpack=0"
SRC_URI += "${URI_expectk}"
SRC_URI[expectk.sha256sum] = "4f222671191cf07f21057b6d96df09121639b253030d33aaa801e1c7ae729ac9"
RDEPENDS:expectk = " \
 expect \
 bash \
"
