# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-da"
PE = "0"
PV = "1.7.42"
PR = "26.el10"
PACKAGES = "hunspell-da"
PROVIDES = "rpm/hunspell-da"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-da-1.7.42-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d160ee57f9b2213198fabce896df50100c8fb2f02133d8d95e5fa04e41a7152"

URI_hunspell-da = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-da-1.7.42-26.el10.noarch.rpm;name=hunspell-da;unpack=0"
SRC_URI += "${URI_hunspell-da}"
SRC_URI[hunspell-da.sha256sum] = "76a4cdd63010ca07074c28525bc7808e31e08140dc0f4ee89983cad4450d8433"
RDEPENDS:hunspell-da = " \
 hunspell-filesystem \
"
