# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gpsd"
PE = "1"
PV = "3.25"
PR = "17.el10"
PACKAGES = "gpsd gpsd-clients python3-gpsd gpsd-xclients"
PROVIDES = "rpm/gpsd rpm/gpsd-clients rpm/python3-gpsd rpm/gpsd-xclients"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gpsd-3.25-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4d7e5df2b297a2bfb26135be1a5c4a56011a3275f968082e415316730cf9236"

URI_gpsd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gpsd-3.25-17.el10.x86_64_v2.rpm;name=gpsd;unpack=0"
SRC_URI += "${URI_gpsd}"
SRC_URI[gpsd.sha256sum] = "ab3f41063c738beb00509ef08e5c8dd300ecfd8cc85e1b27f106c13f8ba309ba"
RDEPENDS:gpsd = " \
 systemd \
 systemd-udev \
 ncurses-libs \
 bash \
 glibc \
 bluez-libs \
 dbus-libs \
 libusb1 \
"

URI_gpsd-clients = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gpsd-clients-3.25-17.el10.x86_64_v2.rpm;name=gpsd-clients;unpack=0"
SRC_URI += "${URI_gpsd-clients}"
SRC_URI[gpsd-clients.sha256sum] = "432d2e4cd8eb412a55a555feffb78c0da1fec95c807aa526f4d0f77aecfcc55e"
RDEPENDS:gpsd-clients = " \
 python3 \
 python3-gpsd \
 ncurses-libs \
 bash \
 glibc \
 bluez-libs \
 dbus-libs \
 libusb1 \
"

URI_python3-gpsd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-gpsd-3.25-17.el10.x86_64_v2.rpm;name=python3-gpsd;unpack=0"
SRC_URI += "${URI_python3-gpsd}"
SRC_URI[python3-gpsd.sha256sum] = "629a67b2cdbc993ddc1240fcc2a0f69d2f3ffaee33d6141a40bf6d43b7160c64"
RDEPENDS:python3-gpsd = " \
 glibc \
 python3-pyserial \
 python3 \
"

URI_gpsd-xclients = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gpsd-xclients-3.25-17.el10.x86_64_v2.rpm;name=gpsd-xclients;unpack=0"
SRC_URI += "${URI_gpsd-xclients}"
SRC_URI[gpsd-xclients.sha256sum] = "6a66567b5f3f00d589703f499d9f905aceb27f91678c500f217728f5863c1108"
RDEPENDS:gpsd-xclients = " \
 python3 \
 python3-gobject \
 python3-gpsd \
 python3-cairo \
 gtk3 \
"
