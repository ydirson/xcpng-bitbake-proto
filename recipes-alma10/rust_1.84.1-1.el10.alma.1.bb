# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rust"
PE = "0"
PV = "1.84.1"
PR = "1.el10.alma.1"
PACKAGES = "cargo clippy rust rust-analyzer rust-debugger-common rust-doc rust-gdb rust-lldb rust-src rust-std-static rust-std-static-wasm32-unknown-unknown rust-std-static-wasm32-wasip1 rust-toolset rust-toolset-srpm-macros rustfmt rust-std-static-x86_64-unknown-none"
PROVIDES = "rpm/cargo rpm/clippy rpm/rust rpm/rust-analyzer rpm/rust-debugger-common rpm/rust-doc rpm/rust-gdb rpm/rust-lldb rpm/rust-src rpm/rust-std-static rpm/rust-std-static-wasm32-unknown-unknown rpm/rust-std-static-wasm32-wasip1 rpm/rust-toolset rpm/rust-toolset-srpm-macros rpm/rustfmt rpm/rust-std-static-x86_64-unknown-none"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/rust-1.84.1-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf745025ec1a69ac5b37ea47ce397bbeacb2076958af550fd75dde17010f8430"

URI_cargo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cargo-1.84.1-1.el10.alma.1.x86_64_v2.rpm;name=cargo;unpack=0"
SRC_URI += "${URI_cargo}"
SRC_URI[cargo.sha256sum] = "c3df202dd25a271c8ca38b5bfba5ba260b69c976db39aa7ea0e8848893507f3a"
RDEPENDS:cargo = " \
 zlib-ng-compat \
 openssl-libs \
 libgcc \
 sqlite-libs \
 libcurl \
 glibc \
 rust \
"

URI_clippy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/clippy-1.84.1-1.el10.alma.1.x86_64_v2.rpm;name=clippy;unpack=0"
SRC_URI += "${URI_clippy}"
SRC_URI[clippy.sha256sum] = "bb3684fb5b40445f3c98e49602487db27fc7aafa6c2bc5a399781410ab65c5db"
RDEPENDS:clippy = " \
 glibc \
 cargo \
 libgcc \
 rust \
"

URI_rust = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rust-1.84.1-1.el10.alma.1.x86_64_v2.rpm;name=rust;unpack=0"
SRC_URI += "${URI_rust}"
SRC_URI[rust.sha256sum] = "bc7256adb2a65ec375175e637ab48e1e15a73c47e5517dd29942189dea7a29b7"
RDEPENDS:rust = " \
 rust-std-static \
 libgcc \
 libstdc++ \
 gcc \
 glibc \
 llvm-libs \
"

URI_rust-analyzer = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rust-analyzer-1.84.1-1.el10.alma.1.x86_64_v2.rpm;name=rust-analyzer;unpack=0"
SRC_URI += "${URI_rust-analyzer}"
SRC_URI[rust-analyzer.sha256sum] = "ea56437fa2723236c05cf7cca76ddc798c02dcfe40b9b9b6c7c3f2babdf575b4"
RDEPENDS:rust-analyzer = " \
 glibc \
 libgcc \
 rust \
"

URI_rust-debugger-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rust-debugger-common-1.84.1-1.el10.alma.1.noarch.rpm;name=rust-debugger-common;unpack=0"
SRC_URI += "${URI_rust-debugger-common}"
SRC_URI[rust-debugger-common.sha256sum] = "22a9279a7f43b518000e35310a11f18180f1c352bbb1af51fc930d4345b434b0"
RDEPENDS:rust-debugger-common = ""

URI_rust-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rust-doc-1.84.1-1.el10.alma.1.x86_64_v2.rpm;name=rust-doc;unpack=0"
SRC_URI += "${URI_rust-doc}"
SRC_URI[rust-doc.sha256sum] = "e02ce4f93efcfc5545f076cf93a7649df8289676a95e2745ea2f162a9d5f9004"
RDEPENDS:rust-doc = ""

URI_rust-gdb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rust-gdb-1.84.1-1.el10.alma.1.noarch.rpm;name=rust-gdb;unpack=0"
SRC_URI += "${URI_rust-gdb}"
SRC_URI[rust-gdb.sha256sum] = "f284758e9c96a8df555632a726f82c9d603f97513ed8fd1f09de26c6ed09529d"
RDEPENDS:rust-gdb = " \
 gdb \
 bash \
 rust-debugger-common \
"

URI_rust-lldb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rust-lldb-1.84.1-1.el10.alma.1.noarch.rpm;name=rust-lldb;unpack=0"
SRC_URI += "${URI_rust-lldb}"
SRC_URI[rust-lldb.sha256sum] = "dca121858c27f7c20d73e9d98b3ead55d16054c6092fd525631239f0dd54c1ec"
RDEPENDS:rust-lldb = " \
 python3-lldb \
 bash \
 lldb \
 rust-debugger-common \
"

URI_rust-src = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rust-src-1.84.1-1.el10.alma.1.noarch.rpm;name=rust-src;unpack=0"
SRC_URI += "${URI_rust-src}"
SRC_URI[rust-src.sha256sum] = "5a019d19671ad02bf6eae025554e36b59c551d7f3cf2dc0ed6cd66977262bde0"
RDEPENDS:rust-src = ""

URI_rust-std-static = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rust-std-static-1.84.1-1.el10.alma.1.x86_64_v2.rpm;name=rust-std-static;unpack=0"
SRC_URI += "${URI_rust-std-static}"
SRC_URI[rust-std-static.sha256sum] = "3caf91f6303d28731a1cb7c85006db1fa310ef65df57a1d0a0393119a64411d4"
RDEPENDS:rust-std-static = " \
 glibc \
 glibc-devel \
 libgcc \
 rust \
"

URI_rust-std-static-wasm32-unknown-unknown = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rust-std-static-wasm32-unknown-unknown-1.84.1-1.el10.alma.1.noarch.rpm;name=rust-std-static-wasm32-unknown-unknown;unpack=0"
SRC_URI += "${URI_rust-std-static-wasm32-unknown-unknown}"
SRC_URI[rust-std-static-wasm32-unknown-unknown.sha256sum] = "4713be8b3848700eec03791f3ceb3fdbc1046d2b52d2670f25db226908266a13"
RDEPENDS:rust-std-static-wasm32-unknown-unknown = " \
 lld \
 rust \
"

URI_rust-std-static-wasm32-wasip1 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rust-std-static-wasm32-wasip1-1.84.1-1.el10.alma.1.noarch.rpm;name=rust-std-static-wasm32-wasip1;unpack=0"
SRC_URI += "${URI_rust-std-static-wasm32-wasip1}"
SRC_URI[rust-std-static-wasm32-wasip1.sha256sum] = "9f0102246f20338a2e595fed8ce5c025e2a4c5502addef8b2e73c8f157062361"
RDEPENDS:rust-std-static-wasm32-wasip1 = " \
 lld \
 rust \
"

URI_rust-toolset = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rust-toolset-1.84.1-1.el10.alma.1.noarch.rpm;name=rust-toolset;unpack=0"
SRC_URI += "${URI_rust-toolset}"
SRC_URI[rust-toolset.sha256sum] = "d3dff9e6d77c083a30172899c00e41dff695fd84148e422cdda5c74b6e87d0ec"
RDEPENDS:rust-toolset = " \
 python3 \
 cargo \
 rust \
 rust-toolset-srpm-macros \
"

URI_rust-toolset-srpm-macros = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rust-toolset-srpm-macros-1.84.1-1.el10.alma.1.noarch.rpm;name=rust-toolset-srpm-macros;unpack=0"
SRC_URI += "${URI_rust-toolset-srpm-macros}"
SRC_URI[rust-toolset-srpm-macros.sha256sum] = "5e979d839e63bf29b9b9e16ecf38a308e01ce223cf6261c6eb9102f97bf04955"
RDEPENDS:rust-toolset-srpm-macros = ""

URI_rustfmt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rustfmt-1.84.1-1.el10.alma.1.x86_64_v2.rpm;name=rustfmt;unpack=0"
SRC_URI += "${URI_rustfmt}"
SRC_URI[rustfmt.sha256sum] = "68403b3ab1740e61ed99a3876d6ecefe77a24ba900d2ebcc0cfa278755b05057"
RDEPENDS:rustfmt = " \
 glibc \
 cargo \
 libgcc \
 rust \
"

URI_rust-std-static-x86_64-unknown-none = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/rust-std-static-x86_64-unknown-none-1.84.1-1.el10.alma.1.x86_64_v2.rpm;name=rust-std-static-x86_64-unknown-none;unpack=0"
SRC_URI += "${URI_rust-std-static-x86_64-unknown-none}"
SRC_URI[rust-std-static-x86_64-unknown-none.sha256sum] = "8480bb2d7ea04143acad8d0cdf883f5c544fa1b0d1535432c1d2ffb6513b771d"
RDEPENDS:rust-std-static-x86_64-unknown-none = " \
 lld \
 rust \
"
