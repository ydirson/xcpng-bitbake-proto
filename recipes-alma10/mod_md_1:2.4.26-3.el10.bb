# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mod_md"
PE = "1"
PV = "2.4.26"
PR = "3.el10"
PACKAGES = "mod_md"
PROVIDES = "rpm/mod_md"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mod_md-2.4.26-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97a147ad5e361f5843ffd2346642040cfc96f68330d0b2a1e9aa58e4f06808d3"

URI_mod_md = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mod_md-2.4.26-3.el10.x86_64_v2.rpm;name=mod_md;unpack=0"
SRC_URI += "${URI_mod_md}"
SRC_URI[mod_md.sha256sum] = "0489160681cb070dcd7258c26bbdeb625d7bfe19a1da88577d6569413188f106"
RDEPENDS:mod_md = " \
 httpd-core \
 jansson \
 openssl-libs \
 apr \
 apr-util \
 libcurl \
 glibc \
 mod_ssl \
"
