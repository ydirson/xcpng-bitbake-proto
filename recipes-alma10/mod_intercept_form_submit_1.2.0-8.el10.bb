# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mod_intercept_form_submit"
PE = "0"
PV = "1.2.0"
PR = "8.el10"
PACKAGES = "mod_intercept_form_submit"
PROVIDES = "rpm/mod_intercept_form_submit"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mod_intercept_form_submit-1.2.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "148e91b56387ced5bdb8e9a8ab930875b4c5c4d96792b08acac04d956b8620aa"

URI_mod_intercept_form_submit = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mod_intercept_form_submit-1.2.0-8.el10.x86_64_v2.rpm;name=mod_intercept_form_submit;unpack=0"
SRC_URI += "${URI_mod_intercept_form_submit}"
SRC_URI[mod_intercept_form_submit.sha256sum] = "e79cbe61700c3b2ba047dc1c4cddc688fb5a26a7baa84a5b27c8b1d3fc572de2"
RDEPENDS:mod_intercept_form_submit = " \
 glibc \
 mod_authnz_pam \
 httpd-core \
"
