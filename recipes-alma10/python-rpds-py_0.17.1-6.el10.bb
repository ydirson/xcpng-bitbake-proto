# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-rpds-py"
PE = "0"
PV = "0.17.1"
PR = "6.el10"
PACKAGES = "python3-rpds-py"
PROVIDES = "rpm/python3-rpds-py"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/python-rpds-py-0.17.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "525001367df8ed8a6db3d1d7d856d1cebb45df2b68811498649d47a45ce1d00e"

URI_python3-rpds-py = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-rpds-py-0.17.1-6.el10.x86_64_v2.rpm;name=python3-rpds-py;unpack=0"
SRC_URI += "${URI_python3-rpds-py}"
SRC_URI[python3-rpds-py.sha256sum] = "4325866c8a203fa3f441376ef94a5b9b09edc55664955c6fdf64275d3b849c72"
RDEPENDS:python3-rpds-py = " \
 glibc \
 libgcc \
 python3 \
"
