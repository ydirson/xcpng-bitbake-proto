# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "valkey"
PE = "0"
PV = "8.0.6"
PR = "1.el10_0"
PACKAGES = "valkey valkey-devel valkey-compat-redis"
PROVIDES = "rpm/valkey rpm/valkey-devel rpm/valkey-compat-redis"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/valkey-8.0.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dff164439671cf0b111b915001b7132f35f844a0d79eecaed47c09412805cb86"

URI_valkey = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/valkey-8.0.6-1.el10_0.x86_64_v2.rpm;name=valkey;unpack=0"
SRC_URI += "${URI_valkey}"
SRC_URI[valkey.sha256sum] = "4f7d942d44cfa0799193559473d58149a80d3e3f97992503a6648c6d99ffafcf"
RDEPENDS:valkey = " \
 logrotate \
 systemd-libs \
 openssl-libs \
 bash \
 glibc \
"

URI_valkey-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/valkey-devel-8.0.6-1.el10_0.x86_64_v2.rpm;name=valkey-devel;unpack=0"
SRC_URI += "${URI_valkey-devel}"
SRC_URI[valkey-devel.sha256sum] = "8110b906fee8f14466c9769da98e752c3f7b8d67a40cc0051d3d9a08f476ec80"
RDEPENDS:valkey-devel = ""

URI_valkey-compat-redis = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/valkey-compat-redis-8.0.6-1.el10_0.noarch.rpm;name=valkey-compat-redis;unpack=0"
SRC_URI += "${URI_valkey-compat-redis}"
SRC_URI[valkey-compat-redis.sha256sum] = "2a74d861da8e46f619d1b243e3166b85ad2a471db6895e397fae5a268f7a0c42"
RDEPENDS:valkey-compat-redis = " \
 valkey \
 bash \
"
