# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "execstack"
PE = "0"
PV = "0.5.0"
PR = "31.el10"
PACKAGES = "execstack"
PROVIDES = "rpm/execstack"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/execstack-0.5.0-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10c9fdaab21769239aa1d8e9aeaaca729f295690b5a90bc1bc0b9a8bef73c5c0"

URI_execstack = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/execstack-0.5.0-31.el10.x86_64_v2.rpm;name=execstack;unpack=0"
SRC_URI += "${URI_execstack}"
SRC_URI[execstack.sha256sum] = "03a7f057dbb23b66649797b60d88fd7ca1c7a084cd3c1fa41f24d87fe3c99a31"
RDEPENDS:execstack = " \
 coreutils \
 util-linux \
 gawk \
 grep \
 elfutils-libelf \
 glibc \
 libselinux \
 findutils \
"
