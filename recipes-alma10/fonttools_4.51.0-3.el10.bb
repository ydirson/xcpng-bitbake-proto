# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "fonttools"
PE = "0"
PV = "4.51.0"
PR = "3.el10"
PACKAGES = "fonttools python3-fonttools"
PROVIDES = "rpm/fonttools rpm/python3-fonttools"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/fonttools-4.51.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7a98f2337722849e369c6dc3b8638e783b4a1049f18cb5e997ba53e74cebd4d"

URI_fonttools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/fonttools-4.51.0-3.el10.x86_64_v2.rpm;name=fonttools;unpack=0"
SRC_URI += "${URI_fonttools}"
SRC_URI[fonttools.sha256sum] = "1a9340dfd514db9812abbcb0dddab12fa7e3f9c680734916f2d21b979dc3e440"
RDEPENDS:fonttools = " \
 python3 \
 python3-fonttools \
 python3-setuptools \
"

URI_python3-fonttools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-fonttools-4.51.0-3.el10.x86_64_v2.rpm;name=python3-fonttools;unpack=0"
SRC_URI += "${URI_python3-fonttools}"
SRC_URI[python3-fonttools.sha256sum] = "5335b3ad0d3c58cfafb37fa49bca224cc487b1be843195b131b64c97c6aa5330"
RDEPENDS:python3-fonttools = " \
 python3 \
 python3-fs \
 python3-scipy \
 python3-brotli \
 python3-lxml \
 glibc \
"
