# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "oddjob"
PE = "0"
PV = "0.34.7"
PR = "14.el10"
PACKAGES = "oddjob oddjob-mkhomedir"
PROVIDES = "rpm/oddjob rpm/oddjob-mkhomedir"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/oddjob-0.34.7-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b97fde5e82ebf060825bf527c18d7137af01f8608b88315a55415c3c9454f5b1"

URI_oddjob = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/oddjob-0.34.7-14.el10.x86_64_v2.rpm;name=oddjob;unpack=0"
SRC_URI += "${URI_oddjob}"
SRC_URI[oddjob.sha256sum] = "90fcf857ea2dd6f521c589ea0e5c26219c3fe28d47951f4493a87656fe326b7f"
RDEPENDS:oddjob = " \
 systemd \
 libxml2 \
 bash \
 dbus \
 glibc \
 libselinux \
 psmisc \
 dbus-libs \
"

URI_oddjob-mkhomedir = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/oddjob-mkhomedir-0.34.7-14.el10.x86_64_v2.rpm;name=oddjob-mkhomedir;unpack=0"
SRC_URI += "${URI_oddjob-mkhomedir}"
SRC_URI[oddjob-mkhomedir.sha256sum] = "a096c2d86aa4d26c0665a6cdcf7a4e951446b45e98f3531563b656a31a0ae99a"
RDEPENDS:oddjob-mkhomedir = " \
 glibc \
 oddjob \
 grep \
 pam-libs \
 libselinux \
 bash \
 sed \
 dbus-tools \
 psmisc \
 dbus-libs \
"
