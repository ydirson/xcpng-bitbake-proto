# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "maven-verifier"
PE = "0"
PV = "2.0.0~M1"
PR = "8.el10"
PACKAGES = "maven-verifier maven-verifier-javadoc"
PROVIDES = "rpm/maven-verifier rpm/maven-verifier-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/maven-verifier-2.0.0~M1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e104c833ef888548be8f8ddbee24a3729cc23d072dc8c0792d1e5c9e1d8004f"

URI_maven-verifier = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-verifier-2.0.0~M1-8.el10.noarch.rpm;name=maven-verifier;unpack=0"
SRC_URI += "${URI_maven-verifier}"
SRC_URI[maven-verifier.sha256sum] = "9b7c8bc068af8563171cb1eac31e160d0ce2073bdbc52a7188fbfd78bdc988ad"
RDEPENDS:maven-verifier = " \
 maven-shared-utils \
 javapackages-filesystem \
"

URI_maven-verifier-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-verifier-javadoc-2.0.0~M1-8.el10.noarch.rpm;name=maven-verifier-javadoc;unpack=0"
SRC_URI += "${URI_maven-verifier-javadoc}"
SRC_URI[maven-verifier-javadoc.sha256sum] = "d507aee1a0cd113026d13dd20498faf90c0c92775b668d05ad3e44cd1164b0e6"
RDEPENDS:maven-verifier-javadoc = " \
 javapackages-filesystem \
"
