# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-sc"
PE = "0"
PV = "0.20081101"
PR = "37.el10"
PACKAGES = "hunspell-sc"
PROVIDES = "rpm/hunspell-sc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-sc-0.20081101-37.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6c39ebb429007ea8e7e659575d501959954904f9328f228bfc460dc22c0c9f4"

URI_hunspell-sc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-sc-0.20081101-37.el10.noarch.rpm;name=hunspell-sc;unpack=0"
SRC_URI += "${URI_hunspell-sc}"
SRC_URI[hunspell-sc.sha256sum] = "ede87c3f26935a8ba6a442b2381a0cbba19e180fd0ae4469b9910c280eba7fcf"
RDEPENDS:hunspell-sc = " \
 hunspell \
"
