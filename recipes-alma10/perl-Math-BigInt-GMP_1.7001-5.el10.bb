# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Math-BigInt-GMP"
PE = "0"
PV = "1.7001"
PR = "5.el10"
PACKAGES = "perl-Math-BigInt-GMP perl-Math-BigInt-GMP-tests"
PROVIDES = "rpm/perl-Math-BigInt-GMP rpm/perl-Math-BigInt-GMP-tests"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-Math-BigInt-GMP-1.7001-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a768fdea35d0fe406187f7f8936400eb3a49e3d5814cbf1e29feadfa66842013"

URI_perl-Math-BigInt-GMP = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Math-BigInt-GMP-1.7001-5.el10.x86_64_v2.rpm;name=perl-Math-BigInt-GMP;unpack=0"
SRC_URI += "${URI_perl-Math-BigInt-GMP}"
SRC_URI[perl-Math-BigInt-GMP.sha256sum] = "8ef594d37776d1d5f5899457dac833ae89e7465a71392c383560a72e37d33240"
RDEPENDS:perl-Math-BigInt-GMP = " \
 glibc \
 gmp \
 perl-Math-BigInt \
 perl-libs \
"

URI_perl-Math-BigInt-GMP-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Math-BigInt-GMP-tests-1.7001-5.el10.x86_64_v2.rpm;name=perl-Math-BigInt-GMP-tests;unpack=0"
SRC_URI += "${URI_perl-Math-BigInt-GMP-tests}"
SRC_URI[perl-Math-BigInt-GMP-tests.sha256sum] = "65d0c99ed4eaddd666fd007d38dcb64a1248acdcc1bbbb07ed7b697ba92c4150"
RDEPENDS:perl-Math-BigInt-GMP-tests = " \
 perl-threads \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Math-BigInt \
 bash \
 perl-Math-BigInt-GMP \
 perl-Exporter \
"
