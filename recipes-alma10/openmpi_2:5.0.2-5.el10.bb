# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "openmpi"
PE = "2"
PV = "5.0.2"
PR = "5.el10"
PACKAGES = "openmpi openmpi-devel openmpi-java python3-openmpi openmpi-doc openmpi-java-devel"
PROVIDES = "rpm/openmpi rpm/openmpi-devel rpm/openmpi-java rpm/python3-openmpi rpm/openmpi-doc rpm/openmpi-java-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/openmpi-5.0.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a882da33c66460da6dc0506790a40815aa58ca3f26b3b7620416e942f12af750"

URI_openmpi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/openmpi-5.0.2-5.el10.x86_64_v2.rpm;name=openmpi;unpack=0"
SRC_URI += "${URI_openmpi}"
SRC_URI[openmpi.sha256sum] = "d9cb9ec915d64eb082bd73d830025c97cc758ac734f70a89c00056f2c5aa5407"
RDEPENDS:openmpi = " \
 prrte \
 openssh-clients \
 libevent \
 libgcc \
 libgfortran \
 libquadmath \
 hwloc-libs \
 environment-modules \
 libfabric \
 ucx \
 pmix \
 glibc \
"

URI_openmpi-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/openmpi-devel-5.0.2-5.el10.x86_64_v2.rpm;name=openmpi-devel;unpack=0"
SRC_URI += "${URI_openmpi-devel}"
SRC_URI[openmpi-devel.sha256sum] = "94943e79a9578177241bd971b19a8f4097c0ba8d57e7bfd2b0e87f6933737152"
RDEPENDS:openmpi-devel = " \
 python3 \
 openmpi \
 pkgconf-pkg-config \
 rpm-mpi-hooks \
 pmix \
 glibc \
 gcc-gfortran \
"

URI_openmpi-java = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/openmpi-java-5.0.2-5.el10.x86_64_v2.rpm;name=openmpi-java;unpack=0"
SRC_URI += "${URI_openmpi-java}"
SRC_URI[openmpi-java.sha256sum] = "149e838f9575ea30ac02576c34e06370b23c42dd43f9600943724315069d27f1"
RDEPENDS:openmpi-java = " \
 java-21-openjdk-headless \
 openmpi \
"

URI_python3-openmpi = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-openmpi-5.0.2-5.el10.x86_64_v2.rpm;name=python3-openmpi;unpack=0"
SRC_URI += "${URI_python3-openmpi}"
SRC_URI[python3-openmpi.sha256sum] = "8b3f577e3ce015b59bdcc1398e75d55f688f19106f5605461ae1888f4283fa80"
RDEPENDS:python3-openmpi = " \
 python3 \
 openmpi \
"

URI_openmpi-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/openmpi-doc-5.0.2-5.el10.noarch.rpm;name=openmpi-doc;unpack=0"
SRC_URI += "${URI_openmpi-doc}"
SRC_URI[openmpi-doc.sha256sum] = "40b6d9872dfec863da29805e693d58f5ff1e3dbd025cf1f2056bb7a7f69c3332"
RDEPENDS:openmpi-doc = ""

URI_openmpi-java-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/openmpi-java-devel-5.0.2-5.el10.x86_64_v2.rpm;name=openmpi-java-devel;unpack=0"
SRC_URI += "${URI_openmpi-java-devel}"
SRC_URI[openmpi-java-devel.sha256sum] = "162e55d1d2b7772db3b0d7b3e3d2f9ba3c8d0d560a729d3db69193fde534ac11"
RDEPENDS:openmpi-java-devel = " \
 openmpi-java \
 perl-interpreter \
 perl-libs \
 java-21-openjdk-devel \
"
