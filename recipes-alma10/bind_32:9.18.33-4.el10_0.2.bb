# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "bind"
PE = "32"
PV = "9.18.33"
PR = "4.el10_0.2"
PACKAGES = "bind bind-chroot bind-dnssec-utils bind-libs bind-license bind-utils bind-devel bind-doc"
PROVIDES = "rpm/bind rpm/bind-chroot rpm/bind-dnssec-utils rpm/bind-libs rpm/bind-license rpm/bind-utils rpm/bind-devel rpm/bind-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/bind-9.18.33-4.el10_0.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e94685c38b51872a58126deb9a7c01880dbbebf21d520b6b156dc8254c89057"

URI_bind = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/bind-9.18.33-4.el10_0.2.x86_64_v2.rpm;name=bind;unpack=0"
SRC_URI += "${URI_bind}"
SRC_URI[bind.sha256sum] = "474ed71742cff44f0f31dd5594e2a7e82c2992de458b0e2921b39f17eaeba359"
RDEPENDS:bind = " \
 glibc-common \
 shadow-utils \
 zlib-ng-compat \
 bind-libs \
 openssl-libs \
 json-c \
 grep \
 libxml2 \
 libcap \
 fstrm \
 libmaxminddb \
 libuv \
 bash \
 libnghttp2 \
 glibc \
 coreutils \
 protobuf-c \
 lmdb-libs \
"

URI_bind-chroot = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/bind-chroot-9.18.33-4.el10_0.2.x86_64_v2.rpm;name=bind-chroot;unpack=0"
SRC_URI += "${URI_bind-chroot}"
SRC_URI[bind-chroot.sha256sum] = "10c1313c4ba4f608af59deb7698e2aa117ecbc5fb1437bb9670354f3f286c9a0"
RDEPENDS:bind-chroot = " \
 bind \
 bash \
 grep \
"

URI_bind-dnssec-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/bind-dnssec-utils-9.18.33-4.el10_0.2.x86_64_v2.rpm;name=bind-dnssec-utils;unpack=0"
SRC_URI += "${URI_bind-dnssec-utils}"
SRC_URI[bind-dnssec-utils.sha256sum] = "f92b92df6e5f8fae4eeb4b2e3fbdf8eb94b7654cdd25aefa52af73a375a3793f"
RDEPENDS:bind-dnssec-utils = " \
 glibc \
 bind-libs \
"

URI_bind-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/bind-libs-9.18.33-4.el10_0.2.x86_64_v2.rpm;name=bind-libs;unpack=0"
SRC_URI += "${URI_bind-libs}"
SRC_URI[bind-libs.sha256sum] = "d5565376d637ec4af5b63735a6b0db29cd734622867ce7329c079b668e481fb7"
RDEPENDS:bind-libs = " \
 zlib-ng-compat \
 bind-license \
 openssl-libs \
 json-c \
 libxml2 \
 libmaxminddb \
 fstrm \
 krb5-libs \
 libcom_err \
 libuv \
 libnghttp2 \
 glibc \
 protobuf-c \
 lmdb-libs \
"

URI_bind-license = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/bind-license-9.18.33-4.el10_0.2.noarch.rpm;name=bind-license;unpack=0"
SRC_URI += "${URI_bind-license}"
SRC_URI[bind-license.sha256sum] = "bb81e250595f5da9b569c3ac03115910f28d9faa14c99e5296e260b6950a565f"
RDEPENDS:bind-license = ""

URI_bind-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/bind-utils-9.18.33-4.el10_0.2.x86_64_v2.rpm;name=bind-utils;unpack=0"
SRC_URI += "${URI_bind-utils}"
SRC_URI[bind-utils.sha256sum] = "b78c628b4b84815f2b7b2f924a5df68dc3739aa0d89d025a02b7b7e8ab192d70"
RDEPENDS:bind-utils = " \
 bind-libs \
 krb5-libs \
 libidn2 \
 glibc \
 protobuf-c \
 lmdb-libs \
"

URI_bind-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/bind-devel-9.18.33-4.el10_0.2.x86_64_v2.rpm;name=bind-devel;unpack=0"
SRC_URI += "${URI_bind-devel}"
SRC_URI[bind-devel.sha256sum] = "b623e50406412d0a1f812c1f33befc23c5115e84a1c11b49d22bbbf27cd11658"
RDEPENDS:bind-devel = " \
 libxml2-devel \
 bind-libs \
 fstrm-devel \
 libcap-devel \
 openssl-devel \
 libmaxminddb-devel \
 lmdb-devel \
 krb5-devel \
 protobuf-c-devel \
 json-c-devel \
"

URI_bind-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/bind-doc-9.18.33-4.el10_0.2.noarch.rpm;name=bind-doc;unpack=0"
SRC_URI += "${URI_bind-doc}"
SRC_URI[bind-doc.sha256sum] = "f3b77d17c084a53a89188b9e49368a24d1a2220f32e1750e2a2311568c4f9b2a"
RDEPENDS:bind-doc = " \
 python3-sphinx_rtd_theme \
 bind-license \
"
