# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Devel-Symdump"
PE = "1"
PV = "2.18"
PR = "31.el10"
PACKAGES = "perl-Devel-Symdump perl-Devel-Symdump-tests"
PROVIDES = "rpm/perl-Devel-Symdump rpm/perl-Devel-Symdump-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Devel-Symdump-2.18-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5da4b3748b0a179880baa44ce17f976fff4033097f589d7de4830123ddb6b30"

URI_perl-Devel-Symdump = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Devel-Symdump-2.18-31.el10.noarch.rpm;name=perl-Devel-Symdump;unpack=0"
SRC_URI += "${URI_perl-Devel-Symdump}"
SRC_URI[perl-Devel-Symdump.sha256sum] = "097d58f504b8d47500b899f327635d57583071394979bd8266e13acb24e1c4bc"
RDEPENDS:perl-Devel-Symdump = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-Devel-Symdump \
 perl-B \
 perl-Exporter \
"

URI_perl-Devel-Symdump-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Devel-Symdump-tests-2.18-31.el10.noarch.rpm;name=perl-Devel-Symdump-tests;unpack=0"
SRC_URI += "${URI_perl-Devel-Symdump-tests}"
SRC_URI[perl-Devel-Symdump-tests.sha256sum] = "49b341cb8079168b2cf737d160322b431e3488c0a19f3d27f7d8db02f89bde4d"
RDEPENDS:perl-Devel-Symdump-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 bash \
 perl-Devel-Symdump \
 perl-interpreter \
 perl-lib \
"
