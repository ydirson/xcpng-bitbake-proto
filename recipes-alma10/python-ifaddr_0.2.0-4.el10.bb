# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-ifaddr"
PE = "0"
PV = "0.2.0"
PR = "4.el10"
PACKAGES = "python3-ifaddr"
PROVIDES = "rpm/python3-ifaddr"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-ifaddr-0.2.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "379a0883242f1b177da795464b50a17c450d94198a051d853e4295fb3734b4de"

URI_python3-ifaddr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-ifaddr-0.2.0-4.el10.noarch.rpm;name=python3-ifaddr;unpack=0"
SRC_URI += "${URI_python3-ifaddr}"
SRC_URI[python3-ifaddr.sha256sum] = "9b1c5084c9ea1b552d50b9e8b9a44bcfd409b30222d4ac634472b4a044844ecc"
RDEPENDS:python3-ifaddr = " \
 python3 \
"
