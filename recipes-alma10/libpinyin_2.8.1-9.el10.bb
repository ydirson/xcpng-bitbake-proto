# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libpinyin"
PE = "0"
PV = "2.8.1"
PR = "9.el10"
PACKAGES = "libpinyin libpinyin-data libzhuyin libpinyin-devel libpinyin-tools"
PROVIDES = "rpm/libpinyin rpm/libpinyin-data rpm/libzhuyin rpm/libpinyin-devel rpm/libpinyin-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libpinyin-2.8.1-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f81e2854d6b2e2b9c9023dde19a5e496419551a04170aab2211f057ee5bc2c7"

URI_libpinyin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libpinyin-2.8.1-9.el10.x86_64_v2.rpm;name=libpinyin;unpack=0"
SRC_URI += "${URI_libpinyin}"
SRC_URI[libpinyin.sha256sum] = "a5e040605dd2fb022e7334abad412433011c5bc71bc184eec60cef58e17a3183"
RDEPENDS:libpinyin = " \
 kyotocabinet-libs \
 libgcc \
 libstdc++ \
 glib2 \
 libpinyin-data \
 glibc \
"

URI_libpinyin-data = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libpinyin-data-2.8.1-9.el10.x86_64_v2.rpm;name=libpinyin-data;unpack=0"
SRC_URI += "${URI_libpinyin-data}"
SRC_URI[libpinyin-data.sha256sum] = "4da90df2a0d7429758e26d4a33b24bf49e8f667a201797b004a2044326ec8c76"
RDEPENDS:libpinyin-data = " \
 libpinyin \
"

URI_libzhuyin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libzhuyin-2.8.1-9.el10.x86_64_v2.rpm;name=libzhuyin;unpack=0"
SRC_URI += "${URI_libzhuyin}"
SRC_URI[libzhuyin.sha256sum] = "1b20fe9aae25558d8b187cdd01ed62dc632c474788d631027872ec656537f84c"
RDEPENDS:libzhuyin = " \
 kyotocabinet-libs \
 libgcc \
 libstdc++ \
 glib2 \
 libpinyin \
 glibc \
"

URI_libpinyin-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libpinyin-devel-2.8.1-9.el10.x86_64_v2.rpm;name=libpinyin-devel;unpack=0"
SRC_URI += "${URI_libpinyin-devel}"
SRC_URI[libpinyin-devel.sha256sum] = "97d236cede536b6fd91a90cfe5643b9570f942771ae12aff5727fb336b634b90"
RDEPENDS:libpinyin-devel = " \
 libzhuyin \
 glib2-devel \
 pkgconf-pkg-config \
 libpinyin \
"

URI_libpinyin-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libpinyin-tools-2.8.1-9.el10.x86_64_v2.rpm;name=libpinyin-tools;unpack=0"
SRC_URI += "${URI_libpinyin-tools}"
SRC_URI[libpinyin-tools.sha256sum] = "862b8510c0b4ec1062c7e45e8a37d8a4d8b7c8a51d260e9e3138b64bb3fa2777"
RDEPENDS:libpinyin-tools = " \
 kyotocabinet-libs \
 libgcc \
 libstdc++ \
 glib2 \
 libpinyin \
 glibc \
"
