# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tog-pegasus"
PE = "2"
PV = "2.14.1"
PR = "76.el10"
PACKAGES = "tog-pegasus tog-pegasus-libs tog-pegasus-devel tog-pegasus-test"
PROVIDES = "rpm/tog-pegasus rpm/tog-pegasus-libs rpm/tog-pegasus-devel rpm/tog-pegasus-test"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tog-pegasus-2.14.1-76.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f9275018ec9d3f55904f6908c50d071e77e5e239572291312687687290b3fe1"

URI_tog-pegasus = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tog-pegasus-2.14.1-76.el10.x86_64_v2.rpm;name=tog-pegasus;unpack=0"
SRC_URI += "${URI_tog-pegasus}"
SRC_URI[tog-pegasus.sha256sum] = "d583ccdb8858aac301c7436440867f539d7990163676586b8de308df6402fb06"
RDEPENDS:tog-pegasus = " \
 net-snmp-libs \
 ca-certificates \
 libxcrypt \
 openssl \
 libgcc \
 policycoreutils \
 tog-pegasus-libs \
 libstdc++ \
 bash \
 glibc \
"

URI_tog-pegasus-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tog-pegasus-libs-2.14.1-76.el10.x86_64_v2.rpm;name=tog-pegasus-libs;unpack=0"
SRC_URI += "${URI_tog-pegasus-libs}"
SRC_URI[tog-pegasus-libs.sha256sum] = "cddb09607f20c067a0967d0a5a8eb250418512ac805a2590815a9ab530a4f769"
RDEPENDS:tog-pegasus-libs = " \
 shadow-utils \
 net-snmp-libs \
 libxcrypt \
 libgcc \
 openssl-libs \
 openslp \
 pam-libs \
 libstdc++ \
 bash \
 glibc \
"

URI_tog-pegasus-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/tog-pegasus-devel-2.14.1-76.el10.x86_64_v2.rpm;name=tog-pegasus-devel;unpack=0"
SRC_URI += "${URI_tog-pegasus-devel}"
SRC_URI[tog-pegasus-devel.sha256sum] = "caa9e6f4fd5e55dad4bee8e1a33515364c849c4288b90593f6319443987400a3"
RDEPENDS:tog-pegasus-devel = " \
 tog-pegasus \
 bash \
"

URI_tog-pegasus-test = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/tog-pegasus-test-2.14.1-76.el10.x86_64_v2.rpm;name=tog-pegasus-test;unpack=0"
SRC_URI += "${URI_tog-pegasus-test}"
SRC_URI[tog-pegasus-test.sha256sum] = "eb3a6f44b0fd61db42b1ade6f53824f19d4cb33d07aa202b4108ff115ba19152"
RDEPENDS:tog-pegasus-test = " \
 net-snmp-libs \
 libxcrypt \
 libgcc \
 make \
 tog-pegasus \
 tog-pegasus-libs \
 libstdc++ \
 glibc \
"
