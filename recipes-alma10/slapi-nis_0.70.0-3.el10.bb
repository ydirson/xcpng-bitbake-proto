# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "slapi-nis"
PE = "0"
PV = "0.70.0"
PR = "3.el10"
PACKAGES = "slapi-nis"
PROVIDES = "rpm/slapi-nis"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/slapi-nis-0.70.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a73e18fae4c4cd8f28bb31eeec4a78d05cb68b3ab57067e1c2a29f07880232ba"

URI_slapi-nis = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/slapi-nis-0.70.0-3.el10.x86_64_v2.rpm;name=slapi-nis;unpack=0"
SRC_URI += "${URI_slapi-nis}"
SRC_URI[slapi-nis.sha256sum] = "6685f0442063f92d7babc2119a561a9db0a3512999be69a1a1a4568815352b29"
RDEPENDS:slapi-nis = " \
 nss \
 pam-libs \
 libsss_nss_idmap \
 389-ds-base \
 nss-util \
 bash \
 glibc \
 openldap \
 nspr \
"
