# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "plexus-utils"
PE = "0"
PV = "3.5.1"
PR = "8.el10"
PACKAGES = "plexus-utils plexus-utils-javadoc"
PROVIDES = "rpm/plexus-utils rpm/plexus-utils-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/plexus-utils-3.5.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "059027fd76e75a340b23291c0e9d2625cdf861a4d14f2e068f3df34d5bcfac39"

URI_plexus-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/plexus-utils-3.5.1-8.el10.noarch.rpm;name=plexus-utils;unpack=0"
SRC_URI += "${URI_plexus-utils}"
SRC_URI[plexus-utils.sha256sum] = "c75047b690cd8f68ffb3a56515e19589648901a68b55637539926349d50200da"
RDEPENDS:plexus-utils = " \
 javapackages-filesystem \
"

URI_plexus-utils-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-utils-javadoc-3.5.1-8.el10.noarch.rpm;name=plexus-utils-javadoc;unpack=0"
SRC_URI += "${URI_plexus-utils-javadoc}"
SRC_URI[plexus-utils-javadoc.sha256sum] = "f50fbe943396bba8b2ab01e6aa4339bbc40c9497c044a761b6a3e8358d0ea2e4"
RDEPENDS:plexus-utils-javadoc = " \
 javapackages-filesystem \
"
