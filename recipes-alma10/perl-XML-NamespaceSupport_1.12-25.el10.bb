# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-XML-NamespaceSupport"
PE = "0"
PV = "1.12"
PR = "25.el10"
PACKAGES = "perl-XML-NamespaceSupport perl-XML-NamespaceSupport-tests"
PROVIDES = "rpm/perl-XML-NamespaceSupport rpm/perl-XML-NamespaceSupport-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-XML-NamespaceSupport-1.12-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d16deda6b8b35ec8a580021a3e9a593327fda3c83b2cdee6dbd3d82c87940989"

URI_perl-XML-NamespaceSupport = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-XML-NamespaceSupport-1.12-25.el10.noarch.rpm;name=perl-XML-NamespaceSupport;unpack=0"
SRC_URI += "${URI_perl-XML-NamespaceSupport}"
SRC_URI[perl-XML-NamespaceSupport.sha256sum] = "aadce69e4bd85d3228b052dfcfec1483f0cfc5417ea57a6094e0db8572ba467f"
RDEPENDS:perl-XML-NamespaceSupport = " \
 perl-constant \
 perl-libs \
 perl-vars \
"

URI_perl-XML-NamespaceSupport-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-XML-NamespaceSupport-tests-1.12-25.el10.noarch.rpm;name=perl-XML-NamespaceSupport-tests;unpack=0"
SRC_URI += "${URI_perl-XML-NamespaceSupport-tests}"
SRC_URI[perl-XML-NamespaceSupport-tests.sha256sum] = "4d84e105880f34492a77107122fd2d3a8f9e8499018149c78a1a3b4be3fd549a"
RDEPENDS:perl-XML-NamespaceSupport-tests = " \
 perl-constant \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-XML-NamespaceSupport \
 bash \
 perl-interpreter \
"
