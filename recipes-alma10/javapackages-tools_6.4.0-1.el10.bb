# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "javapackages-tools"
PE = "0"
PV = "6.4.0"
PR = "1.el10"
PACKAGES = "javapackages-filesystem javapackages-tools javapackages-common javapackages-compat javapackages-generators javapackages-local-openjdk21 maven-local-openjdk21 python3-javapackages"
PROVIDES = "rpm/javapackages-filesystem rpm/javapackages-tools rpm/javapackages-common rpm/javapackages-compat rpm/javapackages-generators rpm/javapackages-local-openjdk21 rpm/maven-local-openjdk21 rpm/python3-javapackages"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/javapackages-tools-6.4.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f5200cb1e3df9c60b3ddb953403ed8e95bd305965dfac61094f39a8a65708b0"

URI_javapackages-filesystem = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/javapackages-filesystem-6.4.0-1.el10.noarch.rpm;name=javapackages-filesystem;unpack=0"
SRC_URI += "${URI_javapackages-filesystem}"
SRC_URI[javapackages-filesystem.sha256sum] = "5ec49522c2266cab0594b13ef86d5c2e60294c3dca82f6cb67acf71a7ef73132"
RDEPENDS:javapackages-filesystem = ""

URI_javapackages-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/javapackages-tools-6.4.0-1.el10.noarch.rpm;name=javapackages-tools;unpack=0"
SRC_URI += "${URI_javapackages-tools}"
SRC_URI[javapackages-tools.sha256sum] = "a264043f2abdd857d29bcde9cee5c51cb448e3f6397d40e442084a3b260a0845"
RDEPENDS:javapackages-tools = " \
 coreutils \
 bash \
 findutils \
 javapackages-filesystem \
"

URI_javapackages-common = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/javapackages-common-6.4.0-1.el10.noarch.rpm;name=javapackages-common;unpack=0"
SRC_URI += "${URI_javapackages-common}"
SRC_URI[javapackages-common.sha256sum] = "238af1385b639bb0d9b85f341d1a08504a370bef83ffe23ec632bfb31e331360"
RDEPENDS:javapackages-common = " \
 javapackages-generators \
"

URI_javapackages-compat = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/javapackages-compat-6.4.0-1.el10.noarch.rpm;name=javapackages-compat;unpack=0"
SRC_URI += "${URI_javapackages-compat}"
SRC_URI[javapackages-compat.sha256sum] = "b28c8b44803cbf63e1155edc16a9ff873e10c9c68b5694a599de9812ed2ca588"
RDEPENDS:javapackages-compat = " \
 javapackages-local-openjdk21 \
"

URI_javapackages-generators = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/javapackages-generators-6.4.0-1.el10.noarch.rpm;name=javapackages-generators;unpack=0"
SRC_URI += "${URI_javapackages-generators}"
SRC_URI[javapackages-generators.sha256sum] = "eb9d8ef15a4c48e0ea76468a1340b84ee1a3bf993c5c715ab58f94fab29c319f"
RDEPENDS:javapackages-generators = " \
 python3 \
 python3-javapackages \
 javapackages-tools \
"

URI_javapackages-local-openjdk21 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/javapackages-local-openjdk21-6.4.0-1.el10.noarch.rpm;name=javapackages-local-openjdk21;unpack=0"
SRC_URI += "${URI_javapackages-local-openjdk21}"
SRC_URI[javapackages-local-openjdk21.sha256sum] = "ea6ea030fe0fb3cd602c9f6889273917b7b04d3f0827ecc57f918c950636df1d"
RDEPENDS:javapackages-local-openjdk21 = " \
 javapackages-common \
 java-21-openjdk-devel \
 xmvn-generator \
 ant-openjdk21 \
 xmvn-tools \
"

URI_maven-local-openjdk21 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-local-openjdk21-6.4.0-1.el10.noarch.rpm;name=maven-local-openjdk21;unpack=0"
SRC_URI += "${URI_maven-local-openjdk21}"
SRC_URI[maven-local-openjdk21.sha256sum] = "9866a5ec515f915dba847e1ef00afddf5d8a0a86e94e3eed11aff71ba4fe784e"
RDEPENDS:maven-local-openjdk21 = " \
 maven-surefire-plugin \
 maven-jar-plugin \
 javapackages-tools \
 javapackages-local-openjdk21 \
 maven-compiler-plugin \
 java-21-openjdk-devel \
 maven-resources-plugin \
 xmvn-minimal \
 xmvn-mojo \
 xmvn-toolchain-openjdk21 \
"

URI_python3-javapackages = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-javapackages-6.4.0-1.el10.noarch.rpm;name=python3-javapackages;unpack=0"
SRC_URI += "${URI_python3-javapackages}"
SRC_URI[python3-javapackages.sha256sum] = "bd35a0fe99a7d25a30133fd6ba01054ebc64a161ac460075b5704da90472be50"
RDEPENDS:python3-javapackages = " \
 python3 \
 python3-lxml \
"
