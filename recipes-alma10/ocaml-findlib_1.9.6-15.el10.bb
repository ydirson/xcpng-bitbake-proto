# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ocaml-findlib"
PE = "0"
PV = "1.9.6"
PR = "15.el10"
PACKAGES = "ocaml-findlib ocaml-findlib-devel"
PROVIDES = "rpm/ocaml-findlib rpm/ocaml-findlib-devel"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/ocaml-findlib-1.9.6-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64c0e16b25c5e2fe0526039418cd2878f7de47330364481bca333ee55bce0502"

URI_ocaml-findlib = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-findlib-1.9.6-15.el10.x86_64_v2.rpm;name=ocaml-findlib;unpack=0"
SRC_URI += "${URI_ocaml-findlib}"
SRC_URI[ocaml-findlib.sha256sum] = "ded5c6d3a87da27f523ee80f43309feb15fe18c11589290377e286dcdb5808a9"
RDEPENDS:ocaml-findlib = " \
 glibc \
 ocaml \
 ocaml-runtime \
 ocaml-compiler-libs \
"

URI_ocaml-findlib-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-findlib-devel-1.9.6-15.el10.x86_64_v2.rpm;name=ocaml-findlib-devel;unpack=0"
SRC_URI += "${URI_ocaml-findlib-devel}"
SRC_URI[ocaml-findlib-devel.sha256sum] = "ae6efb86745749af95ef45b111de340e1de085b18239bb1c2e87dc1215d43093"
RDEPENDS:ocaml-findlib-devel = " \
 ocaml-runtime \
 ocaml \
 ocaml-compiler-libs \
 ocaml-findlib \
"
