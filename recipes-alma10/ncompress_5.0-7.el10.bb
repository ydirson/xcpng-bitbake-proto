# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ncompress"
PE = "0"
PV = "5.0"
PR = "7.el10"
PACKAGES = "ncompress"
PROVIDES = "rpm/ncompress"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/ncompress-5.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7aed2f34f622802caac40a50d0f03cfebdaec1f20f6ad71dcd0188c4302131fb"

URI_ncompress = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ncompress-5.0-7.el10.x86_64_v2.rpm;name=ncompress;unpack=0"
SRC_URI += "${URI_ncompress}"
SRC_URI[ncompress.sha256sum] = "59c04d9244d1c161fd40a8b32a869e5f038319ea9a9e31e34632bb951675c16f"
RDEPENDS:ncompress = " \
 glibc \
"
