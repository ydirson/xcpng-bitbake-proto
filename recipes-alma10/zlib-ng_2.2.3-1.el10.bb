# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "zlib-ng"
PE = "0"
PV = "2.2.3"
PR = "1.el10"
PACKAGES = "zlib-ng-compat zlib-ng-compat-devel zlib-ng zlib-ng-compat-static zlib-ng-devel"
PROVIDES = "rpm/zlib-ng-compat rpm/zlib-ng-compat-devel rpm/zlib-ng rpm/zlib-ng-compat-static rpm/zlib-ng-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/zlib-ng-2.2.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6fdbe5183ce8aa4ecf4a3e8ab3d2eceb2ae770c7f9c1df2832025bcc476e0e6"

URI_zlib-ng-compat = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/zlib-ng-compat-2.2.3-1.el10.x86_64_v2.rpm;name=zlib-ng-compat;unpack=0"
SRC_URI += "${URI_zlib-ng-compat}"
SRC_URI[zlib-ng-compat.sha256sum] = "17bccac72ad9f6b68091227fa46d0f18b243be913c21ea5fee3fc6ac567489fc"
RDEPENDS:zlib-ng-compat = " \
 glibc \
"

URI_zlib-ng-compat-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/zlib-ng-compat-devel-2.2.3-1.el10.x86_64_v2.rpm;name=zlib-ng-compat-devel;unpack=0"
SRC_URI += "${URI_zlib-ng-compat-devel}"
SRC_URI[zlib-ng-compat-devel.sha256sum] = "4596a282fff2b1255f686afd85a1c74bdddd86daaa3b1cfb6133dee0c0e29ae0"
RDEPENDS:zlib-ng-compat-devel = " \
 zlib-ng-compat \
 cmake-filesystem \
 pkgconf-pkg-config \
"

URI_zlib-ng = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/zlib-ng-2.2.3-1.el10.x86_64_v2.rpm;name=zlib-ng;unpack=0"
SRC_URI += "${URI_zlib-ng}"
SRC_URI[zlib-ng.sha256sum] = "b45affe0338acfd049e64a520fe8f6671c0afa51427bfb2e72c16bf0ae328864"
RDEPENDS:zlib-ng = " \
 glibc \
"

URI_zlib-ng-compat-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/zlib-ng-compat-static-2.2.3-1.el10.x86_64_v2.rpm;name=zlib-ng-compat-static;unpack=0"
SRC_URI += "${URI_zlib-ng-compat-static}"
SRC_URI[zlib-ng-compat-static.sha256sum] = "56a52beb251bcb9543317a71d0365424c3c426676885563f3b9214ff3aeb29b7"
RDEPENDS:zlib-ng-compat-static = " \
 zlib-ng-compat-devel \
"

URI_zlib-ng-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/zlib-ng-devel-2.2.3-1.el10.x86_64_v2.rpm;name=zlib-ng-devel;unpack=0"
SRC_URI += "${URI_zlib-ng-devel}"
SRC_URI[zlib-ng-devel.sha256sum] = "baefc4c645309398e58dcdf4d4dd261ccc64930c9d2a8051f9a1170192dd8d54"
RDEPENDS:zlib-ng-devel = " \
 zlib-ng \
 cmake-filesystem \
 pkgconf-pkg-config \
"
