# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "apache-commons-io"
PE = "1"
PV = "2.16.1"
PR = "1.el10"
PACKAGES = "apache-commons-io apache-commons-io-javadoc"
PROVIDES = "rpm/apache-commons-io rpm/apache-commons-io-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/apache-commons-io-2.16.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73602d09a41387fb339cc0072b7c92f7fefd1fa1f4819022c929eaf8bf6bd1cb"

URI_apache-commons-io = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/apache-commons-io-2.16.1-1.el10.noarch.rpm;name=apache-commons-io;unpack=0"
SRC_URI += "${URI_apache-commons-io}"
SRC_URI[apache-commons-io.sha256sum] = "b29187542abdeef31689604378ac582bc2b8babbd6e6ce3e03dba97fd029456e"
RDEPENDS:apache-commons-io = " \
 javapackages-filesystem \
"

URI_apache-commons-io-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/apache-commons-io-javadoc-2.16.1-1.el10.noarch.rpm;name=apache-commons-io-javadoc;unpack=0"
SRC_URI += "${URI_apache-commons-io-javadoc}"
SRC_URI[apache-commons-io-javadoc.sha256sum] = "76bc81a0946a9c82e44e1e83aae110f68cfbce2a7014bb2e17bee273e4ce5743"
RDEPENDS:apache-commons-io-javadoc = " \
 javapackages-filesystem \
"
