# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "atinject"
PE = "0"
PV = "1.0.5"
PR = "13.el10"
PACKAGES = "atinject atinject-javadoc"
PROVIDES = "rpm/atinject rpm/atinject-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/atinject-1.0.5-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca5df060fad608586212bfef7d8ffc30c08509a88bea1b01ca9946380244dc6a"

URI_atinject = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/atinject-1.0.5-13.el10.noarch.rpm;name=atinject;unpack=0"
SRC_URI += "${URI_atinject}"
SRC_URI[atinject.sha256sum] = "abb0c2700f08ce1ff6e0844e977f62fc473fbbe307daa293220bf4ea6711d3e5"
RDEPENDS:atinject = " \
 javapackages-filesystem \
"

URI_atinject-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/atinject-javadoc-1.0.5-13.el10.noarch.rpm;name=atinject-javadoc;unpack=0"
SRC_URI += "${URI_atinject-javadoc}"
SRC_URI[atinject-javadoc.sha256sum] = "62d56ebf7d9a14f2c5b56249b82fa8823c98dadcc6b5461211aa2c68912f44cd"
RDEPENDS:atinject-javadoc = " \
 javapackages-filesystem \
"
