# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tracer"
PE = "0"
PV = "1.1"
PR = "3.el10"
PACKAGES = "python3-tracer tracer-common"
PROVIDES = "rpm/python3-tracer rpm/tracer-common"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/tracer-1.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9a15d6b356feeba18652ce52703f67714eba09ce61b47b9480545d29d4943ed"

URI_python3-tracer = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-tracer-1.1-3.el10.noarch.rpm;name=python3-tracer;unpack=0"
SRC_URI += "${URI_python3-tracer}"
SRC_URI[python3-tracer.sha256sum] = "66551fa5238e17afa35b188ec785fc0c2515e82360d14e76e9b3bf7e1c07052f"
RDEPENDS:python3-tracer = " \
 python3 \
 python3-psutil \
 python3-rpm \
 python3-dbus \
 python3-six \
 tracer-common \
 python3-distro \
"

URI_tracer-common = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/tracer-common-1.1-3.el10.noarch.rpm;name=tracer-common;unpack=0"
SRC_URI += "${URI_tracer-common}"
SRC_URI[tracer-common.sha256sum] = "0ca023264e5f5f3326f56e517e316f56ed915758ce895141f71a2c09e0ff6c66"
RDEPENDS:tracer-common = ""
