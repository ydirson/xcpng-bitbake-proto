# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "time"
PE = "0"
PV = "1.9"
PR = "25.el10"
PACKAGES = "time"
PROVIDES = "rpm/time"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/time-1.9-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb7dffd230a01ab86765ce7d23847855e26634c75a2fe1fd373599e701c08aef"

URI_time = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/time-1.9-25.el10.x86_64_v2.rpm;name=time;unpack=0"
SRC_URI += "${URI_time}"
SRC_URI[time.sha256sum] = "aaf7a2446716e11b0c5445bf9f03825bbd4f21ab1343c40ace49a7d71324bc47"
RDEPENDS:time = " \
 glibc \
"
