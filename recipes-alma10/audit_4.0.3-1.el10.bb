# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "audit"
PE = "0"
PV = "4.0.3"
PR = "1.el10"
PACKAGES = "audispd-plugins audispd-plugins-zos audit audit-libs audit-rules audit-libs-devel python3-audit"
PROVIDES = "rpm/audispd-plugins rpm/audispd-plugins-zos rpm/audit rpm/audit-libs rpm/audit-rules rpm/audit-libs-devel rpm/python3-audit"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/audit-4.0.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cdd9d3649e2140bf43dff886716c58dcb983ca7ed9eefb7c41def27737c24db6"

URI_audispd-plugins = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/audispd-plugins-4.0.3-1.el10.x86_64_v2.rpm;name=audispd-plugins;unpack=0"
SRC_URI += "${URI_audispd-plugins}"
SRC_URI[audispd-plugins.sha256sum] = "3629ac3ba33559ee006ab593734b776532545578ee3720b0fabbaa16e70c07b1"
RDEPENDS:audispd-plugins = " \
 audit \
 audit-libs \
 libcap-ng \
 krb5-libs \
 glibc \
"

URI_audispd-plugins-zos = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/audispd-plugins-zos-4.0.3-1.el10.x86_64_v2.rpm;name=audispd-plugins-zos;unpack=0"
SRC_URI += "${URI_audispd-plugins-zos}"
SRC_URI[audispd-plugins-zos.sha256sum] = "a142b27256c82239e1f9bc822ccc89db90072ed7631a47f0bc002fd407e7e1d6"
RDEPENDS:audispd-plugins-zos = " \
 audit \
 audit-libs \
 libcap-ng \
 glibc \
 openldap \
"

URI_audit = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/audit-4.0.3-1.el10.x86_64_v2.rpm;name=audit;unpack=0"
SRC_URI += "${URI_audit}"
SRC_URI[audit.sha256sum] = "b9e0c6f906fa90a90e06276536ea51e0abfafe0e523cbe7735b1a069597b2f08"
RDEPENDS:audit = " \
 systemd \
 audit-libs \
 audit-rules \
 krb5-libs \
 bash \
 glibc \
 coreutils \
"

URI_audit-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/audit-libs-4.0.3-1.el10.x86_64_v2.rpm;name=audit-libs;unpack=0"
SRC_URI += "${URI_audit-libs}"
SRC_URI[audit-libs.sha256sum] = "3ea9acdb8d7b4fc0126370cd22b53114e4379107f77a22443ba68fa551c204a3"
RDEPENDS:audit-libs = " \
 glibc \
 libcap-ng \
"

URI_audit-rules = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/audit-rules-4.0.3-1.el10.x86_64_v2.rpm;name=audit-rules;unpack=0"
SRC_URI += "${URI_audit-rules}"
SRC_URI[audit-rules.sha256sum] = "bbf964c3ec8b2d599bb50e44b304754c6711334ef11898a016ab04665d56890f"
RDEPENDS:audit-rules = " \
 glibc \
 audit-libs \
 bash \
"

URI_audit-libs-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/audit-libs-devel-4.0.3-1.el10.x86_64_v2.rpm;name=audit-libs-devel;unpack=0"
SRC_URI += "${URI_audit-libs-devel}"
SRC_URI[audit-libs-devel.sha256sum] = "ecbf5ce11111421d06d40258ee5b49de81844b14391a3e6b7a48946cc7af6a24"
RDEPENDS:audit-libs-devel = " \
 audit-libs \
 libcap-ng-devel \
 kernel-headers \
 pkgconf-pkg-config \
"

URI_python3-audit = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-audit-4.0.3-1.el10.x86_64_v2.rpm;name=python3-audit;unpack=0"
SRC_URI += "${URI_python3-audit}"
SRC_URI[python3-audit.sha256sum] = "ff04b7cbfe47f87e32203790228f4dd67b8b62adc3b3ec7f74a36ff494e60f04"
RDEPENDS:python3-audit = " \
 glibc \
 audit-libs \
 python3 \
 libcap-ng \
"
