# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-PerlIO-via-QuotedPrint"
PE = "0"
PV = "0.10"
PR = "511.el10"
PACKAGES = "perl-PerlIO-via-QuotedPrint perl-PerlIO-via-QuotedPrint-tests"
PROVIDES = "rpm/perl-PerlIO-via-QuotedPrint rpm/perl-PerlIO-via-QuotedPrint-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-PerlIO-via-QuotedPrint-0.10-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afce2ee316a9d9ef139803f38992354c0bee43b7475cc6f01f36e4abe7abe590"

URI_perl-PerlIO-via-QuotedPrint = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-PerlIO-via-QuotedPrint-0.10-511.el10.noarch.rpm;name=perl-PerlIO-via-QuotedPrint;unpack=0"
SRC_URI += "${URI_perl-PerlIO-via-QuotedPrint}"
SRC_URI[perl-PerlIO-via-QuotedPrint.sha256sum] = "9ada7dfa5482247b7a3b596f8f4cb802450a4366a817730c8560bb7a8a780611"
RDEPENDS:perl-PerlIO-via-QuotedPrint = " \
 perl-libs \
 perl-MIME-Base64 \
"

URI_perl-PerlIO-via-QuotedPrint-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-PerlIO-via-QuotedPrint-tests-0.10-511.el10.noarch.rpm;name=perl-PerlIO-via-QuotedPrint-tests;unpack=0"
SRC_URI += "${URI_perl-PerlIO-via-QuotedPrint-tests}"
SRC_URI[perl-PerlIO-via-QuotedPrint-tests.sha256sum] = "8539c23fed3d6962fba6e53536480a8c01ea0f60e7dabddefc30137f09454db1"
RDEPENDS:perl-PerlIO-via-QuotedPrint-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 bash \
 perl-PerlIO-via-QuotedPrint \
 perl-interpreter \
"
