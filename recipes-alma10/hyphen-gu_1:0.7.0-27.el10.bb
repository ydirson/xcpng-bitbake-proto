# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-gu"
PE = "1"
PV = "0.7.0"
PR = "27.el10"
PACKAGES = "hyphen-gu"
PROVIDES = "rpm/hyphen-gu"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-gu-0.7.0-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43495cf9a1f8c9cb324b6ebdc1db87207f896bee3dbe3dbf9fedc452c4b2b28e"

URI_hyphen-gu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-gu-0.7.0-27.el10.noarch.rpm;name=hyphen-gu;unpack=0"
SRC_URI += "${URI_hyphen-gu}"
SRC_URI[hyphen-gu.sha256sum] = "f40c2723dc9206e3dfd083cab8e9f723d516ea007e303783eb47529c88884f45"
RDEPENDS:hyphen-gu = " \
 hyphen \
"
