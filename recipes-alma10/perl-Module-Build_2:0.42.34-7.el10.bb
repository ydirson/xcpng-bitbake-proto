# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Module-Build"
PE = "2"
PV = "0.42.34"
PR = "7.el10"
PACKAGES = "perl-Module-Build perl-Module-Build-tests"
PROVIDES = "rpm/perl-Module-Build rpm/perl-Module-Build-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Module-Build-0.42.34-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "691695adbbd2d5b3919864a855f7a132a8166fa4f91cd7bfce6728e7b6ae81ad"

URI_perl-Module-Build = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Module-Build-0.42.34-7.el10.noarch.rpm;name=perl-Module-Build;unpack=0"
SRC_URI += "${URI_perl-Module-Build}"
SRC_URI[perl-Module-Build.sha256sum] = "5a3ae36574d432531f5738b4db075b970b352014c25de2347c7346fa9f032ac1"
RDEPENDS:perl-Module-Build = " \
 perl-libs \
 perl-Software-License \
 perl-Getopt-Long \
 perl-podlators \
 perl-inc-latest \
 perl-CPAN-Meta \
 perl-Test-Harness \
 perl-Carp \
 perl-version \
 perl-Text-ParseWords \
 perl-Data-Dumper \
 perl-Module-Build \
 perl-Module-Metadata \
 perl-ExtUtils-Install \
 perl-ExtUtils-MakeMaker \
 perl-ExtUtils-Manifest \
 perl-ExtUtils-ParseXS \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Copy \
 perl-PathTools \
 perl-Perl-OSType \
 perl-File-Find \
 perl-interpreter \
 perl-File-Path \
 perl-Pod-Html \
"

URI_perl-Module-Build-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Module-Build-tests-0.42.34-7.el10.noarch.rpm;name=perl-Module-Build-tests;unpack=0"
SRC_URI += "${URI_perl-Module-Build-tests}"
SRC_URI[perl-Module-Build-tests.sha256sum] = "3fb26ee9507e403c8627065905196896dc3d695ae5e2065d46a54be8f201bdd6"
RDEPENDS:perl-Module-Build-tests = " \
 perl-libs \
 perl-CPAN-Meta \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Carp \
 perl-vars \
 perl-CPAN-Meta-YAML \
 perl-version \
 perl-Text-ParseWords \
 perl-lib \
 perl-Data-Dumper \
 perl-Module-Build \
 perl-Encode \
 bash \
 perl-Exporter \
 perl-base \
 perl-ExtUtils-Install \
 perl-File-Basename \
 perl-PathTools \
 perl-File-Find \
 perl-interpreter \
 perl-File-Path \
 perl-File-Temp \
"
