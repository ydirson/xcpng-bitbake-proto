# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-fr"
PE = "0"
PV = "6.2"
PR = "18.el10"
PACKAGES = "hunspell-fr"
PROVIDES = "rpm/hunspell-fr"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-fr-6.2-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59b6251454d5fd08fd22e64a4c0fe11b716d88fa5178e8fae078ee092977c045"

URI_hunspell-fr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-fr-6.2-18.el10.noarch.rpm;name=hunspell-fr;unpack=0"
SRC_URI += "${URI_hunspell-fr}"
SRC_URI[hunspell-fr.sha256sum] = "2b5df6c43bc714afe728c27b30e0d5cf4cdb86f332de0ee9aefda48ada4a4746"
RDEPENDS:hunspell-fr = " \
 hunspell-filesystem \
"
