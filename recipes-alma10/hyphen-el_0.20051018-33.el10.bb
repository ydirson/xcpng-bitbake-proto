# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-el"
PE = "0"
PV = "0.20051018"
PR = "33.el10"
PACKAGES = "hyphen-el"
PROVIDES = "rpm/hyphen-el"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-el-0.20051018-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c9910cdee605cd327d55f215d2b5cd8b6fa913d9d7cdbf43edf14c99a78276de"

URI_hyphen-el = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-el-0.20051018-33.el10.noarch.rpm;name=hyphen-el;unpack=0"
SRC_URI += "${URI_hyphen-el}"
SRC_URI[hyphen-el.sha256sum] = "09e9e94fe1246ee18ccc04b938ab2bd478d9851f25a2301f62729d79b64846b7"
RDEPENDS:hyphen-el = " \
 hyphen \
"
