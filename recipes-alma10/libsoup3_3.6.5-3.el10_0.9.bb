# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libsoup3"
PE = "0"
PV = "3.6.5"
PR = "3.el10_0.9"
PACKAGES = "libsoup3 libsoup3-devel libsoup3-doc"
PROVIDES = "rpm/libsoup3 rpm/libsoup3-devel rpm/libsoup3-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libsoup3-3.6.5-3.el10_0.9.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "453d666add1121ca4a6581aab2c2b385061954b031bb7d657b54d0e735cf6458"

URI_libsoup3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libsoup3-3.6.5-3.el10_0.9.x86_64_v2.rpm;name=libsoup3;unpack=0"
SRC_URI += "${URI_libsoup3}"
SRC_URI[libsoup3.sha256sum] = "346e9f1709892c4f189709f9cff662d3bb03415340efdd6993c94abbfac8692d"
RDEPENDS:libsoup3 = " \
 zlib-ng-compat \
 libpsl \
 libbrotli \
 sqlite-libs \
 krb5-libs \
 glib2 \
 libnghttp2 \
 glibc \
"

URI_libsoup3-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libsoup3-devel-3.6.5-3.el10_0.9.x86_64_v2.rpm;name=libsoup3-devel;unpack=0"
SRC_URI += "${URI_libsoup3-devel}"
SRC_URI[libsoup3-devel.sha256sum] = "27fb92d56ba060e8877d5c6900f076e798d5d15b4bdbd21f77a01091cdd3b81c"
RDEPENDS:libsoup3-devel = " \
 sysprof-capture-devel \
 brotli-devel \
 libsoup3 \
 glib2-devel \
 zlib-ng-compat-devel \
 pkgconf-pkg-config \
 libnghttp2-devel \
 krb5-devel \
 sqlite-devel \
 libpsl-devel \
"

URI_libsoup3-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libsoup3-doc-3.6.5-3.el10_0.9.noarch.rpm;name=libsoup3-doc;unpack=0"
SRC_URI += "${URI_libsoup3-doc}"
SRC_URI[libsoup3-doc.sha256sum] = "063378dbed913a29843308d35a16af1f76f0a6b1d3d42d1fd66f01017d35ac0d"
RDEPENDS:libsoup3-doc = ""
