# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-experimental"
PE = "0"
PV = "0.032"
PR = "511.el10"
PACKAGES = "perl-experimental perl-experimental-tests"
PROVIDES = "rpm/perl-experimental rpm/perl-experimental-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-experimental-0.032-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "028e66b84037246879966dbccc31ff70e6e702dae84303ad2fb2f98344ae7b82"

URI_perl-experimental = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-experimental-0.032-511.el10.noarch.rpm;name=perl-experimental;unpack=0"
SRC_URI += "${URI_perl-experimental}"
SRC_URI[perl-experimental.sha256sum] = "df3ccd55d1cdaf5ccd090abed5605e8579ebb0f572768badfd59f1837f3284d9"
RDEPENDS:perl-experimental = " \
 perl-experimental \
 perl-libs \
 perl-Carp \
 perl-version \
"

URI_perl-experimental-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-experimental-tests-0.032-511.el10.noarch.rpm;name=perl-experimental-tests;unpack=0"
SRC_URI += "${URI_perl-experimental-tests}"
SRC_URI[perl-experimental-tests.sha256sum] = "73533a5907387fb38b0c2f337dabd14d5a415f14a62dff16603fe7efbed9ae87"
RDEPENDS:perl-experimental-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-experimental \
 bash \
 perl-interpreter \
"
