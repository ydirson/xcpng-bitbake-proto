# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-common-sense"
PE = "0"
PV = "3.7.5"
PR = "20.el10"
PACKAGES = "perl-common-sense perl-common-sense-tests"
PROVIDES = "rpm/perl-common-sense rpm/perl-common-sense-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-common-sense-3.7.5-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "711da0a1b0162da3b1fa4562c1546b788a411da859d68afd82addcda66c0b829"

URI_perl-common-sense = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-common-sense-3.7.5-20.el10.x86_64_v2.rpm;name=perl-common-sense;unpack=0"
SRC_URI += "${URI_perl-common-sense}"
SRC_URI[perl-common-sense.sha256sum] = "2ff023d19e2f0c859f7afaf77c9e9d65c1217659a18ae149325d4c4df078dae8"
RDEPENDS:perl-common-sense = " \
 perl-libs \
"

URI_perl-common-sense-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-common-sense-tests-3.7.5-20.el10.x86_64_v2.rpm;name=perl-common-sense-tests;unpack=0"
SRC_URI += "${URI_perl-common-sense-tests}"
SRC_URI[perl-common-sense-tests.sha256sum] = "568415b2d901ceb42339a213e598e81ad72c40832e0407b527b09e4c5280b6d0"
RDEPENDS:perl-common-sense-tests = " \
 perl-interpreter \
 perl-Test-Harness \
 bash \
 perl-common-sense \
"
