# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gdm"
PE = "1"
PV = "47.0"
PR = "7.el10_0"
PACKAGES = "gdm gdm-devel gdm-pam-extensions-devel"
PROVIDES = "rpm/gdm rpm/gdm-devel rpm/gdm-pam-extensions-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gdm-47.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0146cd90cef83e7c61cf9d3986b4d8fb191708b0aa582e7d3d9180724bda7ac9"

URI_gdm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gdm-47.0-7.el10_0.x86_64_v2.rpm;name=gdm;unpack=0"
SRC_URI += "${URI_gdm}"
SRC_URI[gdm.sha256sum] = "aa2cbfa25f02c72acbccf1f409e1dc45d178c4914982cc34e4c07e4f321885c3"
RDEPENDS:gdm = " \
 python3 \
 systemd \
 systemd-libs \
 keyutils-libs \
 libXau \
 libselinux \
 accountsservice \
 accountsservice-libs \
 util-linux \
 json-glib \
 gnome-keyring-pam \
 dbus-daemon \
 dconf \
 almalinux-logos \
 gnome-session \
 gnome-session-wayland-session \
 gnome-settings-daemon \
 shadow-utils \
 gnome-shell \
 python3-pam \
 audit-libs \
 libgcc \
 pam \
 libgudev \
 pam-libs \
 bash \
 glib2 \
 glibc \
 iso-codes \
"

URI_gdm-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gdm-devel-47.0-7.el10_0.x86_64_v2.rpm;name=gdm-devel;unpack=0"
SRC_URI += "${URI_gdm-devel}"
SRC_URI[gdm-devel.sha256sum] = "057dc129b8ced1b643a85bff203bc432c768c8cd4fa4c0ca14422b72ca7665b8"
RDEPENDS:gdm-devel = " \
 glib2-devel \
 systemd-devel \
 pkgconf-pkg-config \
 libselinux-devel \
 gdm \
 gdm-pam-extensions-devel \
"

URI_gdm-pam-extensions-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gdm-pam-extensions-devel-47.0-7.el10_0.x86_64_v2.rpm;name=gdm-pam-extensions-devel;unpack=0"
SRC_URI += "${URI_gdm-pam-extensions-devel}"
SRC_URI[gdm-pam-extensions-devel.sha256sum] = "70b293147bdcd86f3c975271e5cddd0079c32d83ac160946cbab5879285b44e9"
RDEPENDS:gdm-pam-extensions-devel = " \
 pam-devel \
 pkgconf-pkg-config \
"
