# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ocaml-fileutils"
PE = "0"
PV = "0.6.4"
PR = "12.el10"
PACKAGES = "ocaml-fileutils ocaml-fileutils-devel"
PROVIDES = "rpm/ocaml-fileutils rpm/ocaml-fileutils-devel"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/ocaml-fileutils-0.6.4-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0bdd29ebfae5b6766d8e66242bea182daa75d196329cdfa521cd03bc82137e7"

URI_ocaml-fileutils = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-fileutils-0.6.4-12.el10.x86_64_v2.rpm;name=ocaml-fileutils;unpack=0"
SRC_URI += "${URI_ocaml-fileutils}"
SRC_URI[ocaml-fileutils.sha256sum] = "ce883206388585a4867cd65f9d9272983db8a25086806e36f76ddb386ddc8da6"
RDEPENDS:ocaml-fileutils = " \
 glibc \
 ocaml-runtime \
"

URI_ocaml-fileutils-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-fileutils-devel-0.6.4-12.el10.x86_64_v2.rpm;name=ocaml-fileutils-devel;unpack=0"
SRC_URI += "${URI_ocaml-fileutils-devel}"
SRC_URI[ocaml-fileutils-devel.sha256sum] = "fcb79a9d47a89110bf86e3370ee98032db3ffffe198937326f18dc5c7e4a3c14"
RDEPENDS:ocaml-fileutils-devel = " \
 ocaml-runtime \
 ocaml \
 ocaml-fileutils \
"
