# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "texinfo"
PE = "0"
PV = "7.1"
PR = "6.el10"
PACKAGES = "info texinfo texinfo-tex"
PROVIDES = "rpm/info rpm/texinfo rpm/texinfo-tex"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/texinfo-7.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c9360dd44db430539915cb2b3485684c02157f5645932849b9021209bffe0a4"

URI_info = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/info-7.1-6.el10.x86_64_v2.rpm;name=info;unpack=0"
SRC_URI += "${URI_info}"
SRC_URI[info.sha256sum] = "00c7a0e7ff17a7e3fa6f31cdc8e1be2a6ccde49c2d422e6828e92dba8cd84e0f"
RDEPENDS:info = " \
 glibc \
 bash \
 ncurses-libs \
"

URI_texinfo = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/texinfo-7.1-6.el10.x86_64_v2.rpm;name=texinfo;unpack=0"
SRC_URI += "${URI_texinfo}"
SRC_URI[texinfo.sha256sum] = "b4ab93ac969dda24d027898bb9e264802d0465ced9ddd46ca45cdafeb7328fa0"
RDEPENDS:texinfo = " \
 perl-libs \
 perl-Storable \
 perl-Getopt-Long \
 perl-Symbol \
 perl-Carp \
 perl-vars \
 perl-Unicode-EastAsianWidth \
 perl-Text-Unidecode \
 perl-IPC-Open3 \
 perl-Data-Dumper \
 perl-MIME-Base64 \
 perl-Unicode-Normalize \
 perl-DynaLoader \
 perl-Encode \
 perl-Exporter \
 perl-File-Basename \
 perl-POSIX \
 perl-File-Copy \
 perl-PathTools \
 perl-if \
 perl-interpreter \
 perl-File-Path \
 perl-Pod-Simple \
 perl-libintl-perl \
"

URI_texinfo-tex = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/texinfo-tex-7.1-6.el10.x86_64_v2.rpm;name=texinfo-tex;unpack=0"
SRC_URI += "${URI_texinfo-tex}"
SRC_URI[texinfo-tex.sha256sum] = "242163545bbfe2208f455aeadf237addb1336a22108e339dbd356436df1a9332"
RDEPENDS:texinfo-tex = " \
 texlive-texlive-scripts-extra \
 texinfo \
 bash \
 texlive-epsf \
 texlive-collection-basic \
"
