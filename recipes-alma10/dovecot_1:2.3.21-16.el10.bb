# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dovecot"
PE = "1"
PV = "2.3.21"
PR = "16.el10"
PACKAGES = "dovecot dovecot-mysql dovecot-pgsql dovecot-pigeonhole dovecot-devel"
PROVIDES = "rpm/dovecot rpm/dovecot-mysql rpm/dovecot-pgsql rpm/dovecot-pigeonhole rpm/dovecot-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/dovecot-2.3.21-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd90972662bb363f798daceac39160a4f4dc9a3b5324ccc6eb43ee7bdb4feb22"

URI_dovecot = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dovecot-2.3.21-16.el10.x86_64_v2.rpm;name=dovecot;unpack=0"
SRC_URI += "${URI_dovecot}"
SRC_URI[dovecot.sha256sum] = "c73370da437ffc7638800dfa3b4d61bad342ce0a9b4339db63235a2352c8270c"
RDEPENDS:dovecot = " \
 systemd \
 systemd-libs \
 krb5-libs \
 libcap \
 libcom_err \
 openldap \
 xz-libs \
 shadow-utils \
 zlib-ng-compat \
 libxcrypt \
 openssl \
 openssl-libs \
 libzstd \
 sqlite-libs \
 pam-libs \
 bash \
 expat \
 libicu \
 bzip2-libs \
 lz4-libs \
 glibc \
"

URI_dovecot-mysql = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dovecot-mysql-2.3.21-16.el10.x86_64_v2.rpm;name=dovecot-mysql;unpack=0"
SRC_URI += "${URI_dovecot-mysql}"
SRC_URI[dovecot-mysql.sha256sum] = "07d496a8714be88ea36a0cf9a5f2440d415f6aa15bd9b5fe9d3a0ec153ef0f35"
RDEPENDS:dovecot-mysql = " \
 glibc \
 mariadb-connector-c \
 dovecot \
"

URI_dovecot-pgsql = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dovecot-pgsql-2.3.21-16.el10.x86_64_v2.rpm;name=dovecot-pgsql;unpack=0"
SRC_URI += "${URI_dovecot-pgsql}"
SRC_URI[dovecot-pgsql.sha256sum] = "f5cfb609f6ffb93ced77c666c3b9181f9f9d2fea155a52dda1b87143ef9f4841"
RDEPENDS:dovecot-pgsql = " \
 glibc \
 libpq \
 dovecot \
"

URI_dovecot-pigeonhole = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dovecot-pigeonhole-2.3.21-16.el10.x86_64_v2.rpm;name=dovecot-pigeonhole;unpack=0"
SRC_URI += "${URI_dovecot-pigeonhole}"
SRC_URI[dovecot-pigeonhole.sha256sum] = "9ef18635790a0fca84bf1b0a4cb9f3c4f8082121c782166737f54030d52b9a9e"
RDEPENDS:dovecot-pigeonhole = " \
 glibc \
 dovecot \
"

URI_dovecot-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/dovecot-devel-2.3.21-16.el10.x86_64_v2.rpm;name=dovecot-devel;unpack=0"
SRC_URI += "${URI_dovecot-devel}"
SRC_URI[dovecot-devel.sha256sum] = "aa75df8e601756a7088cd4a0eed5ea963acd8b01af547828e63022bf393c8d33"
RDEPENDS:dovecot-devel = " \
 dovecot \
"
