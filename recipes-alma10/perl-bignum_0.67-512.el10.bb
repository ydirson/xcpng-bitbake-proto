# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-bignum"
PE = "0"
PV = "0.67"
PR = "512.el10"
PACKAGES = "perl-bignum perl-bignum-tests"
PROVIDES = "rpm/perl-bignum rpm/perl-bignum-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-bignum-0.67-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed821cd6d5cd40a6f651d85631bd8bf3df9448f13e14c7ffd4510ce94b451887"

URI_perl-bignum = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-bignum-0.67-512.el10.noarch.rpm;name=perl-bignum;unpack=0"
SRC_URI += "${URI_perl-bignum}"
SRC_URI[perl-bignum.sha256sum] = "93cc32a35c0b74c751bd1351dc9547f34cb5ac6d6b0fe78631b33bb29192a0e1"
RDEPENDS:perl-bignum = " \
 perl-constant \
 perl-Math-BigInt \
 perl-libs \
 perl-Carp \
 perl-overload \
 perl-Exporter \
"

URI_perl-bignum-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-bignum-tests-0.67-512.el10.noarch.rpm;name=perl-bignum-tests;unpack=0"
SRC_URI += "${URI_perl-bignum-tests}"
SRC_URI[perl-bignum-tests.sha256sum] = "feba4e6275546aa400a4bfffc50532d2738e282ab6389c8e8f1ff118bfd7e399"
RDEPENDS:perl-bignum-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 bash \
 perl-Math-BigInt-GMP \
 perl-interpreter \
 perl-bignum \
"
