# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "weldr-client"
PE = "0"
PV = "35.11"
PR = "4.el10"
PACKAGES = "weldr-client weldr-client-tests"
PROVIDES = "rpm/weldr-client rpm/weldr-client-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/weldr-client-35.11-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75a08e6c458a4fe38872cd20f18410ec4a135841782538569f2df73aa2e2ce81"

URI_weldr-client = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/weldr-client-35.11-4.el10.x86_64_v2.rpm;name=weldr-client;unpack=0"
SRC_URI += "${URI_weldr-client}"
SRC_URI[weldr-client.sha256sum] = "9f2127a5850e84a2adfac131143d4c2e7731a163d53a89b08c0c9b10787ae33e"
RDEPENDS:weldr-client = " \
 glibc \
 diffutils \
"

URI_weldr-client-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/weldr-client-tests-35.11-4.el10.x86_64_v2.rpm;name=weldr-client-tests;unpack=0"
SRC_URI += "${URI_weldr-client-tests}"
SRC_URI[weldr-client-tests.sha256sum] = "32351f5a0042e1cf1fb2b7c66a39fcb3ef0d7b0be75ab339f4b730e6ecd3fe4a"
RDEPENDS:weldr-client-tests = " \
 glibc \
 createrepo_c \
"
