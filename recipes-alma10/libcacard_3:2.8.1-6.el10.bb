# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libcacard"
PE = "3"
PV = "2.8.1"
PR = "6.el10"
PACKAGES = "libcacard libcacard-devel"
PROVIDES = "rpm/libcacard rpm/libcacard-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libcacard-2.8.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1accf08a22ae5a46953e00ea869ad7ef9fbde714f8e621c5a984ae9085a09cb2"

URI_libcacard = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libcacard-2.8.1-6.el10.x86_64_v2.rpm;name=libcacard;unpack=0"
SRC_URI += "${URI_libcacard}"
SRC_URI[libcacard.sha256sum] = "82fa72d1968e1c158ac61c369d64d8dcc26076c5114ea168a214075c70587d75"
RDEPENDS:libcacard = " \
 nss \
 pcsc-lite-libs \
 glib2 \
 glibc \
 nspr \
"

URI_libcacard-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libcacard-devel-2.8.1-6.el10.x86_64_v2.rpm;name=libcacard-devel;unpack=0"
SRC_URI += "${URI_libcacard-devel}"
SRC_URI[libcacard-devel.sha256sum] = "7b1593b4f6c933fd770748088218765103b19cb84ff9046bbd530813a860f0e9"
RDEPENDS:libcacard-devel = " \
 glib2-devel \
 libcacard \
 nss-devel \
 pkgconf-pkg-config \
 pcsc-lite-devel \
"
