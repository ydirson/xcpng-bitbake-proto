# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtbase"
PE = "0"
PV = "6.8.1"
PR = "9.el10_0"
PACKAGES = "qt6-qtbase qt6-qtbase-common qt6-qtbase-devel qt6-qtbase-gui qt6-qtbase-mysql qt6-qtbase-odbc qt6-qtbase-postgresql qt6-qtbase-examples qt6-qtbase-private-devel qt6-qtbase-static qt6-qtbase-tests"
PROVIDES = "rpm/qt6-qtbase rpm/qt6-qtbase-common rpm/qt6-qtbase-devel rpm/qt6-qtbase-gui rpm/qt6-qtbase-mysql rpm/qt6-qtbase-odbc rpm/qt6-qtbase-postgresql rpm/qt6-qtbase-examples rpm/qt6-qtbase-private-devel rpm/qt6-qtbase-static rpm/qt6-qtbase-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtbase-6.8.1-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb6fd63e1a88acfe5d40a2bc4793af2a5d933f75074e9c7a00a1f7d0b69b09f8"

URI_qt6-qtbase = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtbase-6.8.1-9.el10_0.x86_64_v2.rpm;name=qt6-qtbase;unpack=0"
SRC_URI += "${URI_qt6-qtbase}"
SRC_URI[qt6-qtbase.sha256sum] = "ea42dcd75028dd685060dbe701ef906db4340b18e4a3c975c74580f53d6dfe9c"
RDEPENDS:qt6-qtbase = " \
 zlib-ng-compat \
 systemd-libs \
 qt6-filesystem \
 libproxy \
 libgcc \
 openssl-libs \
 libbrotli \
 libzstd \
 sqlite-libs \
 krb5-libs \
 libstdc++ \
 pcre2-utf16 \
 glib2 \
 qt6-qtbase-common \
 glibc \
 libicu \
 dbus-libs \
"

URI_qt6-qtbase-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtbase-common-6.8.1-9.el10_0.noarch.rpm;name=qt6-qtbase-common;unpack=0"
SRC_URI += "${URI_qt6-qtbase-common}"
SRC_URI[qt6-qtbase-common.sha256sum] = "2baa8d2e46e918b540c61a8d7ff2f4ff040d6624caf3bceac5644eb9a2a19949"
RDEPENDS:qt6-qtbase-common = " \
 qt6-qtbase \
"

URI_qt6-qtbase-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtbase-devel-6.8.1-9.el10_0.x86_64_v2.rpm;name=qt6-qtbase-devel;unpack=0"
SRC_URI += "${URI_qt6-qtbase-devel}"
SRC_URI[qt6-qtbase-devel.sha256sum] = "2952a148a77a6cd27d4bfafb3bcfc2daa87b60b689b8ce6d9097be32ffd10dcf"
RDEPENDS:qt6-qtbase-devel = " \
 cmake-filesystem \
 libglvnd-devel \
 libgcc \
 qt6-qtbase-odbc \
 pkgconf-pkg-config \
 qt6-qtbase \
 libzstd \
 qt6-qtbase-devel \
 libstdc++ \
 bash \
 qt6-qtbase-gui \
 pcre2-utf16 \
 qt6-rpm-macros \
 glibc \
 qt6-qtbase-mysql \
 libxkbcommon-devel \
 vulkan-loader-devel \
 qt6-qtbase-postgresql \
"

URI_qt6-qtbase-gui = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtbase-gui-6.8.1-9.el10_0.x86_64_v2.rpm;name=qt6-qtbase-gui;unpack=0"
SRC_URI += "${URI_qt6-qtbase-gui}"
SRC_URI[qt6-qtbase-gui.sha256sum] = "e4345c9e339e95cafc12abbe8ea8925a46a095e12478814e64e5a790c757270d"
RDEPENDS:qt6-qtbase-gui = " \
 xcb-util-wm \
 systemd-libs \
 libpng \
 mtdev \
 cups-libs \
 libICE \
 fontconfig \
 libSM \
 libX11 \
 libX11-xcb \
 glx-utils \
 libdrm \
 libstdc++ \
 zlib-ng-compat \
 libglvnd-egl \
 libglvnd-glx \
 libglvnd-opengl \
 libgcc \
 libxcb \
 bash \
 mesa-libgbm \
 libxkbcommon \
 libxkbcommon-x11 \
 freetype \
 xcb-util-image \
 harfbuzz \
 qt6-qtbase \
 libinput \
 glib2 \
 glibc \
 xcb-util-cursor \
 libjpeg-turbo \
 xcb-util-keysyms \
 xcb-util-renderutil \
"

URI_qt6-qtbase-mysql = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtbase-mysql-6.8.1-9.el10_0.x86_64_v2.rpm;name=qt6-qtbase-mysql;unpack=0"
SRC_URI += "${URI_qt6-qtbase-mysql}"
SRC_URI[qt6-qtbase-mysql.sha256sum] = "479de4110c590402db15b1e70cfe75add2c2c9e6b973fecbc8cc16edb969f197"
RDEPENDS:qt6-qtbase-mysql = " \
 cmake-filesystem \
 qt6-qtbase \
 libstdc++ \
 mariadb-connector-c \
 glibc \
"

URI_qt6-qtbase-odbc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtbase-odbc-6.8.1-9.el10_0.x86_64_v2.rpm;name=qt6-qtbase-odbc;unpack=0"
SRC_URI += "${URI_qt6-qtbase-odbc}"
SRC_URI[qt6-qtbase-odbc.sha256sum] = "bbadb0982e9946eb210b0f8061c5a1920cf7b549c638e60c73067a7b21e32ee8"
RDEPENDS:qt6-qtbase-odbc = " \
 cmake-filesystem \
 qt6-qtbase \
 libstdc++ \
 unixODBC \
 glibc \
"

URI_qt6-qtbase-postgresql = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtbase-postgresql-6.8.1-9.el10_0.x86_64_v2.rpm;name=qt6-qtbase-postgresql;unpack=0"
SRC_URI += "${URI_qt6-qtbase-postgresql}"
SRC_URI[qt6-qtbase-postgresql.sha256sum] = "39059be783823b365a6c248c03cad4c2a111f80774e17e5fbee1a93d73d51354"
RDEPENDS:qt6-qtbase-postgresql = " \
 cmake-filesystem \
 libpq \
 qt6-qtbase \
 libstdc++ \
 glibc \
"

URI_qt6-qtbase-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtbase-examples-6.8.1-9.el10_0.x86_64_v2.rpm;name=qt6-qtbase-examples;unpack=0"
SRC_URI += "${URI_qt6-qtbase-examples}"
SRC_URI[qt6-qtbase-examples.sha256sum] = "5a8602568559da02077e1e74fcc3a3b12496bde897ab21ebc9ca885952add926"
RDEPENDS:qt6-qtbase-examples = " \
 python3 \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qtbase-private-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtbase-private-devel-6.8.1-9.el10_0.x86_64_v2.rpm;name=qt6-qtbase-private-devel;unpack=0"
SRC_URI += "${URI_qt6-qtbase-private-devel}"
SRC_URI[qt6-qtbase-private-devel.sha256sum] = "9f938d0bd6ca54e61bd39e54abfbbf7a0163454d8bbfdfdf51858a3b5aec5272"
RDEPENDS:qt6-qtbase-private-devel = " \
 qt6-qtbase-gui \
 qt6-qtbase-devel \
 cmake-filesystem \
 cups-devel \
"

URI_qt6-qtbase-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtbase-static-6.8.1-9.el10_0.x86_64_v2.rpm;name=qt6-qtbase-static;unpack=0"
SRC_URI += "${URI_qt6-qtbase-static}"
SRC_URI[qt6-qtbase-static.sha256sum] = "a3e4d4410035698e01a842f9aad8c907b6b33d7a022049c8285cc3d3dbb84da8"
RDEPENDS:qt6-qtbase-static = " \
 glib2-devel \
 cmake-filesystem \
 zlib-ng-compat-devel \
 fontconfig-devel \
 qt6-qtbase-devel \
 libxkbcommon-devel \
 libinput-devel \
"

URI_qt6-qtbase-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtbase-tests-6.8.1-9.el10_0.x86_64_v2.rpm;name=qt6-qtbase-tests;unpack=0"
SRC_URI += "${URI_qt6-qtbase-tests}"
SRC_URI[qt6-qtbase-tests.sha256sum] = "1d80a298b72450f49bfdabffcfe3ecf052ffd59c273f91a684a0560e635cc69e"
RDEPENDS:qt6-qtbase-tests = " \
 python3 \
 perl-constant \
 perl-libs \
 libgcc \
 qt6-qtbase \
 libxcb \
 libstdc++ \
 bash \
 qt6-qtbase-gui \
 glibc \
 perl-interpreter \
"
