# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rubygem-coderay"
PE = "0"
PV = "1.1.3"
PR = "9.el10"
PACKAGES = "rubygem-coderay rubygem-coderay-doc"
PROVIDES = "rpm/rubygem-coderay rpm/rubygem-coderay-doc"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/rubygem-coderay-1.1.3-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f242909d6e7e48adb540595f5a555ef6a353688c06219804d4975f78c6b575af"

URI_rubygem-coderay = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-coderay-1.1.3-9.el10.noarch.rpm;name=rubygem-coderay;unpack=0"
SRC_URI += "${URI_rubygem-coderay}"
SRC_URI[rubygem-coderay.sha256sum] = "e78e32bfe72cdb2c3d8b09721a5bf050ec322f85bf1a682891997a80ac4057ff"
RDEPENDS:rubygem-coderay = " \
 rubygems \
 ruby \
"

URI_rubygem-coderay-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-coderay-doc-1.1.3-9.el10.noarch.rpm;name=rubygem-coderay-doc;unpack=0"
SRC_URI += "${URI_rubygem-coderay-doc}"
SRC_URI[rubygem-coderay-doc.sha256sum] = "98b407fffa9ba385dbbab5191f79c98cb2701597c598348b82a3eb22991a131b"
RDEPENDS:rubygem-coderay-doc = " \
 rubygem-coderay \
"
