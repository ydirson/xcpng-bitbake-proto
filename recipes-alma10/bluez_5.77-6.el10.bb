# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "bluez"
PE = "0"
PV = "5.77"
PR = "6.el10"
PACKAGES = "bluez bluez-libs bluez-cups bluez-obexd bluez-libs-devel bluez-hid2hci bluez-mesh"
PROVIDES = "rpm/bluez rpm/bluez-libs rpm/bluez-cups rpm/bluez-obexd rpm/bluez-libs-devel rpm/bluez-hid2hci rpm/bluez-mesh"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/bluez-5.77-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "564642bb75e9e458b3caabf7c172f21be4b2d8059e8f4f14635c8478b065bb9e"

URI_bluez = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/bluez-5.77-6.el10.x86_64_v2.rpm;name=bluez;unpack=0"
SRC_URI += "${URI_bluez}"
SRC_URI[bluez.sha256sum] = "d8feb923bd15b16a1c554eddf61881d8c1c02562ffb2421d04e1056badad1fde"
RDEPENDS:bluez = " \
 systemd \
 systemd-libs \
 readline \
 bash \
 glib2 \
 dbus \
 glibc \
 dbus-libs \
"

URI_bluez-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/bluez-libs-5.77-6.el10.x86_64_v2.rpm;name=bluez-libs;unpack=0"
SRC_URI += "${URI_bluez-libs}"
SRC_URI[bluez-libs.sha256sum] = "bb47c35df47758606f83e6728e8ec3ff2c46fbb71a1d1bcc6ecea2cb73f43f1c"
RDEPENDS:bluez-libs = " \
 glibc \
"

URI_bluez-cups = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/bluez-cups-5.77-6.el10.x86_64_v2.rpm;name=bluez-cups;unpack=0"
SRC_URI += "${URI_bluez-cups}"
SRC_URI[bluez-cups.sha256sum] = "3fbb6587ca7088d955bf435191daaccd930043ab5b934ae2d5b9ab5fbbc5e2be"
RDEPENDS:bluez-cups = " \
 cups \
 glib2 \
 glibc \
 bluez \
 dbus-libs \
"

URI_bluez-obexd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/bluez-obexd-5.77-6.el10.x86_64_v2.rpm;name=bluez-obexd;unpack=0"
SRC_URI += "${URI_bluez-obexd}"
SRC_URI[bluez-obexd.sha256sum] = "86a97a473f5a5f2a58845b113690aef38386cf0f1d208b4fe2c5b85ff5692e7b"
RDEPENDS:bluez-obexd = " \
 libical \
 bash \
 glib2 \
 glibc \
 bluez \
 bluez-libs \
 dbus-libs \
"

URI_bluez-libs-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/bluez-libs-devel-5.77-6.el10.x86_64_v2.rpm;name=bluez-libs-devel;unpack=0"
SRC_URI += "${URI_bluez-libs-devel}"
SRC_URI[bluez-libs-devel.sha256sum] = "b935e5432642ec93ada1d960e8b53977ae9e73fd17eb292cdda3d87a665349ce"
RDEPENDS:bluez-libs-devel = " \
 glibc \
 bluez-libs \
 pkgconf-pkg-config \
"

URI_bluez-hid2hci = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/bluez-hid2hci-5.77-6.el10.x86_64_v2.rpm;name=bluez-hid2hci;unpack=0"
SRC_URI += "${URI_bluez-hid2hci}"
SRC_URI[bluez-hid2hci.sha256sum] = "f6992473424858e83fb1f6028b4d01f385a7badd75d9a2918cbc6bc6db7f869b"
RDEPENDS:bluez-hid2hci = " \
 glibc \
 bluez \
 bash \
 systemd-libs \
"

URI_bluez-mesh = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/bluez-mesh-5.77-6.el10.x86_64_v2.rpm;name=bluez-mesh;unpack=0"
SRC_URI += "${URI_bluez-mesh}"
SRC_URI[bluez-mesh.sha256sum] = "8ae6db1c1092c9e02bc15e1a0df371dcbd35cdcb1bbc2914978c1c0ca5dac61f"
RDEPENDS:bluez-mesh = " \
 libell \
 json-c \
 readline \
 bash \
 glibc \
 bluez \
 bluez-libs \
"
