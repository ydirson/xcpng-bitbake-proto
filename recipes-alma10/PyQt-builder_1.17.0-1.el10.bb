# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "PyQt-builder"
PE = "0"
PV = "1.17.0"
PR = "1.el10"
PACKAGES = "PyQt-builder"
PROVIDES = "rpm/PyQt-builder"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/PyQt-builder-1.17.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7aa4b20f1fd0fc1cd84909247d59b9b465abf2d3ac8fc0f146386b9ed4474f10"

URI_PyQt-builder = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/PyQt-builder-1.17.0-1.el10.noarch.rpm;name=PyQt-builder;unpack=0"
SRC_URI += "${URI_PyQt-builder}"
SRC_URI[PyQt-builder.sha256sum] = "9e17a436cd8d2ac637998ebe8ea203862897d769565a39fc8b37d420c7220779"
RDEPENDS:PyQt-builder = " \
 python3 \
 python3-packaging \
 sip6 \
"
