# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-de"
PE = "0"
PV = "0.20060120"
PR = "35.el10"
PACKAGES = "hyphen-de"
PROVIDES = "rpm/hyphen-de"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-de-0.20060120-35.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb5ad9dcb3e3bb848db57b45b065787205defb26d3144fa07d5cbe0bd75e6067"

URI_hyphen-de = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-de-0.20060120-35.el10.noarch.rpm;name=hyphen-de;unpack=0"
SRC_URI += "${URI_hyphen-de}"
SRC_URI[hyphen-de.sha256sum] = "fc68cd21736cdc8c2ca2837aa164b293eb2a8d07a1229b24ccc20c878c22f4d2"
RDEPENDS:hyphen-de = " \
 hyphen \
"
