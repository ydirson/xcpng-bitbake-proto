# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rubygem-rouge"
PE = "0"
PV = "4.2.0"
PR = "3.el10"
PACKAGES = "rubygem-rouge rubygem-rouge-doc"
PROVIDES = "rpm/rubygem-rouge rpm/rubygem-rouge-doc"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/rubygem-rouge-4.2.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e7b3d2726f28093f29ea9c808ca72882370201a04f46adcbd0bd0c43ff6e8fa"

URI_rubygem-rouge = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-rouge-4.2.0-3.el10.noarch.rpm;name=rubygem-rouge;unpack=0"
SRC_URI += "${URI_rubygem-rouge}"
SRC_URI[rubygem-rouge.sha256sum] = "68874a0dcdb6f8d446d43b978500eb65f2afd8a0f6751d0dbea8b6df2dbcf43c"
RDEPENDS:rubygem-rouge = " \
 rubygems \
 ruby \
"

URI_rubygem-rouge-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-rouge-doc-4.2.0-3.el10.noarch.rpm;name=rubygem-rouge-doc;unpack=0"
SRC_URI += "${URI_rubygem-rouge-doc}"
SRC_URI[rubygem-rouge-doc.sha256sum] = "575dd440a33bfe8d4052b0f99eb4581f8f98fc5768c80f6444d258364c1239f0"
RDEPENDS:rubygem-rouge-doc = " \
 rubygem-rouge \
"
