# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-Config"
PE = "0"
PV = "0.008"
PR = "32.el10"
PACKAGES = "perl-ExtUtils-Config"
PROVIDES = "rpm/perl-ExtUtils-Config"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-ExtUtils-Config-0.008-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8cd1ee7dfb3eb3a8788ee53da0e6d8dcbb94db9f554e25d4d97bbf64179cd76"

URI_perl-ExtUtils-Config = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-ExtUtils-Config-0.008-32.el10.noarch.rpm;name=perl-ExtUtils-Config;unpack=0"
SRC_URI += "${URI_perl-ExtUtils-Config}"
SRC_URI[perl-ExtUtils-Config.sha256sum] = "5069eb1c79437f1b76a160cf8c4df55afa16bf59b89ee10a8d2756be3b478e15"
RDEPENDS:perl-ExtUtils-Config = " \
 perl-libs \
 perl-Data-Dumper \
"
