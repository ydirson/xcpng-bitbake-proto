# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ledmon"
PE = "0"
PV = "1.1.0"
PR = "1.el10_0.1"
PACKAGES = "ledmon ledmon-libs ledmon-devel"
PROVIDES = "rpm/ledmon rpm/ledmon-libs rpm/ledmon-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/ledmon-1.1.0-1.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2fdb8f27430db9a1f405eae0d81098ecaf38c9e1f19b25b76b0e903c169fbbfc"

URI_ledmon = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/ledmon-1.1.0-1.el10_0.1.x86_64_v2.rpm;name=ledmon;unpack=0"
SRC_URI += "${URI_ledmon}"
SRC_URI[ledmon.sha256sum] = "84ffba80473d64c366cb5f8b0cce8d6d49493f0e38e0b7b68c3a8bb2a53f33d3"
RDEPENDS:ledmon = " \
 sg3_utils-libs \
 systemd-libs \
 pciutils-libs \
 bash \
 glibc \
"

URI_ledmon-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ledmon-libs-1.1.0-1.el10_0.1.x86_64_v2.rpm;name=ledmon-libs;unpack=0"
SRC_URI += "${URI_ledmon-libs}"
SRC_URI[ledmon-libs.sha256sum] = "9938e13c4c60e38371a0c0adf318eac3c17aed683d86dc3efc5fd08da2c2f714"
RDEPENDS:ledmon-libs = " \
 glibc \
 sg3_utils-libs \
 pciutils-libs \
"

URI_ledmon-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ledmon-devel-1.1.0-1.el10_0.1.x86_64_v2.rpm;name=ledmon-devel;unpack=0"
SRC_URI += "${URI_ledmon-devel}"
SRC_URI[ledmon-devel.sha256sum] = "83ea56bd2014ec6938fdf3dff77af5c26b85df8036dd704a1aefd9cc4f804c82"
RDEPENDS:ledmon-devel = " \
 sg3_utils-devel \
 pkgconf-pkg-config \
 ledmon-libs \
 pciutils-devel \
"
