# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dogtag-pki"
PE = "0"
PV = "11.6.0"
PR = "1.el10"
PACKAGES = "idm-pki-acme idm-pki-base idm-pki-ca idm-pki-java idm-pki-kra idm-pki-server idm-pki-tools python3-idm-pki idm-pki"
PROVIDES = "rpm/idm-pki-acme rpm/idm-pki-base rpm/idm-pki-ca rpm/idm-pki-java rpm/idm-pki-kra rpm/idm-pki-server rpm/idm-pki-tools rpm/python3-idm-pki rpm/idm-pki"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/dogtag-pki-11.6.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4278d102eedc519aa1be41fc64f014924e32abeeb49b5090eaea5ab59ce29975"

URI_idm-pki-acme = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/idm-pki-acme-11.6.0-1.el10.noarch.rpm;name=idm-pki-acme;unpack=0"
SRC_URI += "${URI_idm-pki-acme}"
SRC_URI[idm-pki-acme.sha256sum] = "0859d7e497939f50c123813aba5ab4ac23fc302bd6c25b2ad4162a588b05bf3c"
RDEPENDS:idm-pki-acme = " \
 bash \
 idm-pki-server \
"

URI_idm-pki-base = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/idm-pki-base-11.6.0-1.el10.noarch.rpm;name=idm-pki-base;unpack=0"
SRC_URI += "${URI_idm-pki-base}"
SRC_URI[idm-pki-base.sha256sum] = "dfd92c0e03a82be669d4a815d58a2e48e4c0ef6d52e0a1ce25f459fffaa7bf22"
RDEPENDS:idm-pki-base = " \
 nss \
 bash \
 python3-idm-pki \
"

URI_idm-pki-ca = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/idm-pki-ca-11.6.0-1.el10.noarch.rpm;name=idm-pki-ca;unpack=0"
SRC_URI += "${URI_idm-pki-ca}"
SRC_URI[idm-pki-ca.sha256sum] = "e67767a5e6195a08eb5f4613a1f92d5006855983eb3390b35cb16c8f2a23c145"
RDEPENDS:idm-pki-ca = " \
 systemd \
 bash \
 idm-pki-server \
"

URI_idm-pki-java = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/idm-pki-java-11.6.0-1.el10.noarch.rpm;name=idm-pki-java;unpack=0"
SRC_URI += "${URI_idm-pki-java}"
SRC_URI[idm-pki-java.sha256sum] = "a4676580e22e44de5b5a93a1f74352a1855bc5d7d30d8eb8a31c2d74e51c7041"
RDEPENDS:idm-pki-java = " \
 httpcomponents-client \
 apache-commons-codec \
 apache-commons-cli \
 apache-commons-io \
 apache-commons-lang3 \
 apache-commons-logging \
 apache-commons-net \
 idm-jss \
 idm-ldapjdk \
 idm-pki-base \
 slf4j \
 slf4j-jdk14 \
 java-21-openjdk-headless \
"

URI_idm-pki-kra = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/idm-pki-kra-11.6.0-1.el10.noarch.rpm;name=idm-pki-kra;unpack=0"
SRC_URI += "${URI_idm-pki-kra}"
SRC_URI[idm-pki-kra.sha256sum] = "c976fd99119bbef7ed6ce46102699486847b114a43141b678c1ee1e639dde694"
RDEPENDS:idm-pki-kra = " \
 systemd \
 bash \
 idm-pki-server \
"

URI_idm-pki-server = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/idm-pki-server-11.6.0-1.el10.noarch.rpm;name=idm-pki-server;unpack=0"
SRC_URI += "${URI_idm-pki-server}"
SRC_URI[idm-pki-server.sha256sum] = "2311f08e8b5e6e1c48b27f89553363a280cf826ad0aa99f73b0ef5411f8c9014"
RDEPENDS:idm-pki-server = " \
 python3 \
 systemd \
 keyutils \
 policycoreutils-python-utils \
 java-21-openjdk-devel \
 python3-libselinux \
 idm-jss-tomcat \
 python3-lxml \
 idm-pki-tools \
 selinux-policy-targeted \
 tomcat9 \
 openldap-clients \
 shadow-utils \
 openssl \
 bash \
 ipa-healthcheck-core \
 python3-policycoreutils \
 hostname \
 policycoreutils \
 procps-ng \
"

URI_idm-pki-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/idm-pki-tools-11.6.0-1.el10.x86_64_v2.rpm;name=idm-pki-tools;unpack=0"
SRC_URI += "${URI_idm-pki-tools}"
SRC_URI[idm-pki-tools.sha256sum] = "30d9eeeb409543fd8de26bdd7ad61f50d16f3c488108ef8b1c0239aea210ad29"
RDEPENDS:idm-pki-tools = " \
 nss \
 openssl \
 libgcc \
 p11-kit-trust \
 nss-tools \
 libstdc++ \
 bash \
 idm-pki-java \
 glibc \
 file \
 openldap \
 openldap-clients \
 nspr \
"

URI_python3-idm-pki = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-idm-pki-11.6.0-1.el10.noarch.rpm;name=python3-idm-pki;unpack=0"
SRC_URI += "${URI_python3-idm-pki}"
SRC_URI[python3-idm-pki.sha256sum] = "b587a2f30e0bc7ee501dad7aea575d54c7eba7277cb3428a99b58dab986616f5"
RDEPENDS:python3-idm-pki = " \
 python3 \
 python3-ldap \
 python3-requests \
 python3-cryptography \
 python3-six \
 idm-pki-base \
 python3-lxml \
"

URI_idm-pki = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/idm-pki-11.6.0-1.el10.x86_64_v2.rpm;name=idm-pki;unpack=0"
SRC_URI += "${URI_idm-pki}"
SRC_URI[idm-pki.sha256sum] = "d0ec2565f92188b0a72cd029510a960a098335bf66841255449fe3b2f077376a"
RDEPENDS:idm-pki = " \
 python3-idm-pki \
 idm-pki-acme \
 idm-pki-base \
 idm-pki-ca \
 idm-pki-java \
 idm-pki-kra \
 idm-pki-server \
 idm-pki-tools \
"
