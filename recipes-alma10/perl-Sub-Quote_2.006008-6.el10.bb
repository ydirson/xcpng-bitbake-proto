# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Sub-Quote"
PE = "0"
PV = "2.006008"
PR = "6.el10"
PACKAGES = "perl-Sub-Quote perl-Sub-Quote-tests"
PROVIDES = "rpm/perl-Sub-Quote rpm/perl-Sub-Quote-tests"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-Sub-Quote-2.006008-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac2dc02fac9e452c2933b5fa70e11741b82b4bd1203fc7969221d931a701fa0c"

URI_perl-Sub-Quote = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Sub-Quote-2.006008-6.el10.noarch.rpm;name=perl-Sub-Quote;unpack=0"
SRC_URI += "${URI_perl-Sub-Quote}"
SRC_URI[perl-Sub-Quote.sha256sum] = "2a18532a85736aebc894131255d3a77acbb294566776ea7c0d2feb41ee3a504c"
RDEPENDS:perl-Sub-Quote = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-XString \
 perl-Exporter \
 perl-Sub-Quote \
"

URI_perl-Sub-Quote-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Sub-Quote-tests-2.006008-6.el10.noarch.rpm;name=perl-Sub-Quote-tests;unpack=0"
SRC_URI += "${URI_perl-Sub-Quote-tests}"
SRC_URI[perl-Sub-Quote-tests.sha256sum] = "bf5ed26ad802771b6529620bbcfee4d1bfe618cb6c4a660ca037444b49dceaa7"
RDEPENDS:perl-Sub-Quote-tests = " \
 perl-constant \
 perl-threads \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-Scalar-List-Utils \
 perl-Sub-Quote \
 perl-overload \
 bash \
 perl-B \
 perl-interpreter \
 perl-Data-Dumper \
 perl-Exporter \
 perl-lib \
"
