# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-Helpers"
PE = "0"
PV = "0.026"
PR = "26.el10"
PACKAGES = "perl-ExtUtils-Helpers"
PROVIDES = "rpm/perl-ExtUtils-Helpers"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-ExtUtils-Helpers-0.026-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "902f2ec5eb38fe2a36e7b54d32b9db120c53f6c0cd68b282c6718ef8700984c0"

URI_perl-ExtUtils-Helpers = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-ExtUtils-Helpers-0.026-26.el10.noarch.rpm;name=perl-ExtUtils-Helpers;unpack=0"
SRC_URI += "${URI_perl-ExtUtils-Helpers}"
SRC_URI[perl-ExtUtils-Helpers.sha256sum] = "7f4f2bace8d7ae5e135fb369227e31cd5606eb3c0268c3acea68ed447d4cf062"
RDEPENDS:perl-ExtUtils-Helpers = " \
 perl-libs \
 perl-Carp \
 perl-Text-ParseWords \
 perl-File-Basename \
 perl-PathTools \
 perl-Exporter \
"
