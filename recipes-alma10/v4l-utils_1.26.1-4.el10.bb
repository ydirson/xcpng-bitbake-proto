# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "v4l-utils"
PE = "0"
PV = "1.26.1"
PR = "4.el10"
PACKAGES = "libv4l libv4l-devel libdvbv5 libdvbv5-devel libdvbv5-gconv v4l-utils v4l-utils-devel-tools"
PROVIDES = "rpm/libv4l rpm/libv4l-devel rpm/libdvbv5 rpm/libdvbv5-devel rpm/libdvbv5-gconv rpm/v4l-utils rpm/v4l-utils-devel-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/v4l-utils-1.26.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc4d8fb9384e6a37203883743c8a56dd8404275cbc971987341ebe42ecee734f"

URI_libv4l = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libv4l-1.26.1-4.el10.x86_64_v2.rpm;name=libv4l;unpack=0"
SRC_URI += "${URI_libv4l}"
SRC_URI[libv4l.sha256sum] = "e1b736f322e1ea5f917b0dbc21d7099e8dc11d75f5f5259584e9833538a13b60"
RDEPENDS:libv4l = " \
 glibc \
 libjpeg-turbo \
"

URI_libv4l-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libv4l-devel-1.26.1-4.el10.x86_64_v2.rpm;name=libv4l-devel;unpack=0"
SRC_URI += "${URI_libv4l-devel}"
SRC_URI[libv4l-devel.sha256sum] = "c33fde29ebcae6748a88ae8cf5677ccfb01a4daa1c13dc7aded6501b9f625787"
RDEPENDS:libv4l-devel = " \
 libv4l \
 libv4l-devel \
 pkgconf-pkg-config \
 libjpeg-turbo-devel \
"

URI_libdvbv5 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdvbv5-1.26.1-4.el10.x86_64_v2.rpm;name=libdvbv5;unpack=0"
SRC_URI += "${URI_libdvbv5}"
SRC_URI[libdvbv5.sha256sum] = "fc029a1cd81e9dfbc1c9478e5b4287006ffd7e3eb0b8f28539d92a1bbccdf331"
RDEPENDS:libdvbv5 = " \
 glibc \
 systemd-libs \
"

URI_libdvbv5-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdvbv5-devel-1.26.1-4.el10.x86_64_v2.rpm;name=libdvbv5-devel;unpack=0"
SRC_URI += "${URI_libdvbv5-devel}"
SRC_URI[libdvbv5-devel.sha256sum] = "9c73f192bfd3c7ccab1d0d22f7fe2cb0700ad2ca401fbda874015a72604ce607"
RDEPENDS:libdvbv5-devel = " \
 systemd-devel \
 pkgconf-pkg-config \
 libdvbv5 \
"

URI_libdvbv5-gconv = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdvbv5-gconv-1.26.1-4.el10.x86_64_v2.rpm;name=libdvbv5-gconv;unpack=0"
SRC_URI += "${URI_libdvbv5-gconv}"
SRC_URI[libdvbv5-gconv.sha256sum] = "774e34719501d33b73f9393af58fe109bad4de06596a4dbac5386bf6fa21c750"
RDEPENDS:libdvbv5-gconv = " \
 glibc \
 glibc-gconv-extra \
"

URI_v4l-utils = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/v4l-utils-1.26.1-4.el10.x86_64_v2.rpm;name=v4l-utils;unpack=0"
SRC_URI += "${URI_v4l-utils}"
SRC_URI[v4l-utils.sha256sum] = "e13e480e9f35c5d7e2488dc896c75e4f99ea7c1a915e1af648a6017af016d2b1"
RDEPENDS:v4l-utils = " \
 systemd-libs \
 systemd-udev \
 libgcc \
 libstdc++ \
 libdvbv5 \
 glibc \
 libv4l \
"

URI_v4l-utils-devel-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/v4l-utils-devel-tools-1.26.1-4.el10.x86_64_v2.rpm;name=v4l-utils-devel-tools;unpack=0"
SRC_URI += "${URI_v4l-utils-devel-tools}"
SRC_URI[v4l-utils-devel-tools.sha256sum] = "aa830bb52a4bee44c4d478ec53ebe4c815d405f4b2c3fe144efcae5c78a97c9a"
RDEPENDS:v4l-utils-devel-tools = " \
 glibc \
 libv4l \
 libgcc \
 libstdc++ \
"
