# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "exempi"
PE = "0"
PV = "2.6.4"
PR = "7.el10"
PACKAGES = "exempi exempi-devel"
PROVIDES = "rpm/exempi rpm/exempi-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/exempi-2.6.4-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6348e0587f41507c098f1cae54e1ace5104115fd5f506cdad1ea1dc1e2a3473b"

URI_exempi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/exempi-2.6.4-7.el10.x86_64_v2.rpm;name=exempi;unpack=0"
SRC_URI += "${URI_exempi}"
SRC_URI[exempi.sha256sum] = "2c9598a467d0d69f2dd06f3350914eedb3a2e13f4e62f043514afe4060bff5bb"
RDEPENDS:exempi = " \
 zlib-ng-compat \
 libgcc \
 libstdc++ \
 expat \
 glibc \
"

URI_exempi-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/exempi-devel-2.6.4-7.el10.x86_64_v2.rpm;name=exempi-devel;unpack=0"
SRC_URI += "${URI_exempi-devel}"
SRC_URI[exempi-devel.sha256sum] = "64e7c94bb18ad74cda8e59adf2d1e1a2fe848f9b57a4ff0c38f94e095497d1be"
RDEPENDS:exempi-devel = " \
 pkgconf-pkg-config \
 exempi \
"
