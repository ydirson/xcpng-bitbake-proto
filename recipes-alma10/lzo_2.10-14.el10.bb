# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lzo"
PE = "0"
PV = "2.10"
PR = "14.el10"
PACKAGES = "lzo lzo-devel lzo-minilzo"
PROVIDES = "rpm/lzo rpm/lzo-devel rpm/lzo-minilzo"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/lzo-2.10-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f0c2b15e4596db5264452218836957af851794e5da27dd25a33518fdab11d34"

URI_lzo = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/lzo-2.10-14.el10.x86_64_v2.rpm;name=lzo;unpack=0"
SRC_URI += "${URI_lzo}"
SRC_URI[lzo.sha256sum] = "c877a6d9863a75c04dc9af854c17794b6ff3f2a752895f4d7979839ad5b5ad63"
RDEPENDS:lzo = " \
 glibc \
"

URI_lzo-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lzo-devel-2.10-14.el10.x86_64_v2.rpm;name=lzo-devel;unpack=0"
SRC_URI += "${URI_lzo-devel}"
SRC_URI[lzo-devel.sha256sum] = "7e9fad26b00449eae7e466678353c3a15a2baf62dde5cbdf406ee375232d119e"
RDEPENDS:lzo-devel = " \
 zlib-ng-compat-devel \
 lzo \
 pkgconf-pkg-config \
 lzo-minilzo \
"

URI_lzo-minilzo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lzo-minilzo-2.10-14.el10.x86_64_v2.rpm;name=lzo-minilzo;unpack=0"
SRC_URI += "${URI_lzo-minilzo}"
SRC_URI[lzo-minilzo.sha256sum] = "9272782d8dbbd586a5dbc96cc3955dac2fd24b391af64d1a4884c8e318dfed79"
RDEPENDS:lzo-minilzo = " \
 glibc \
"
