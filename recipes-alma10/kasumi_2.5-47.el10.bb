# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "kasumi"
PE = "0"
PV = "2.5"
PR = "47.el10"
PACKAGES = "kasumi-common kasumi-unicode"
PROVIDES = "rpm/kasumi-common rpm/kasumi-unicode"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/kasumi-2.5-47.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90f5a438241368e25cbb4f625c4507a256c38220f6d8cc66a1940311f35b7358"

URI_kasumi-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/kasumi-common-2.5-47.el10.noarch.rpm;name=kasumi-common;unpack=0"
SRC_URI += "${URI_kasumi-common}"
SRC_URI[kasumi-common.sha256sum] = "8bfc9f29c27c5c43121fe73a5f920928e71f1a3c1ddd3ccf19e4d5a4df1b5548"
RDEPENDS:kasumi-common = ""

URI_kasumi-unicode = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/kasumi-unicode-2.5-47.el10.x86_64_v2.rpm;name=kasumi-unicode;unpack=0"
SRC_URI += "${URI_kasumi-unicode}"
SRC_URI[kasumi-unicode.sha256sum] = "bc17d117cd156df7559b4f7e6da8068823793abc4ebecd82c90d591abc0be615"
RDEPENDS:kasumi-unicode = " \
 kasumi-common \
 libgcc \
 libstdc++ \
 glib2 \
 gtk3 \
 glibc \
 anthy-unicode \
"
