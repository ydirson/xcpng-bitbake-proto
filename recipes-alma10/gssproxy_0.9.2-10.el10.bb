# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gssproxy"
PE = "0"
PV = "0.9.2"
PR = "10.el10"
PACKAGES = "gssproxy"
PROVIDES = "rpm/gssproxy"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/gssproxy-0.9.2-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0bb5f03189587d5d8722c4f3a20a133c7e0702f411bfd64b4843c50074b740ac"

URI_gssproxy = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/gssproxy-0.9.2-10.el10.x86_64_v2.rpm;name=gssproxy;unpack=0"
SRC_URI += "${URI_gssproxy}"
SRC_URI[gssproxy.sha256sum] = "5e084d73094f2018898c71eeeed8a23af5481732edae754c42f3c382c619f5f6"
RDEPENDS:gssproxy = " \
 systemd \
 libverto \
 systemd-libs \
 libverto-libev \
 keyutils-libs \
 krb5-libs \
 libref_array \
 bash \
 popt \
 glibc \
 libselinux \
 libini_config \
"
