# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ps_mem"
PE = "0"
PV = "3.14"
PR = "9.el10"
PACKAGES = "ps_mem"
PROVIDES = "rpm/ps_mem"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ps_mem-3.14-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb067e489d7145c5093c6d31a52af230c49194edb0f59d923878d332a3825ddb"

URI_ps_mem = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ps_mem-3.14-9.el10.noarch.rpm;name=ps_mem;unpack=0"
SRC_URI += "${URI_ps_mem}"
SRC_URI[ps_mem.sha256sum] = "6a27caedfefe09f58effa5f13aea004a97940aaa7c84f7a44514ba0290abd9af"
RDEPENDS:ps_mem = " \
 python3 \
"
