# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-CGI"
PE = "0"
PV = "4.61"
PR = "5.el10"
PACKAGES = "perl-CGI perl-CGI-tests"
PROVIDES = "rpm/perl-CGI rpm/perl-CGI-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-CGI-4.61-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc30d44455e4f399f4ec8b5e91463e002490cf4faddc65d09d866ce437fcb302"

URI_perl-CGI = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-CGI-4.61-5.el10.noarch.rpm;name=perl-CGI;unpack=0"
SRC_URI += "${URI_perl-CGI}"
SRC_URI[perl-CGI.sha256sum] = "7185a3fbb653fc610d9933b2f6e30c40a7d203e255dcfbda2032f0285c8a3191"
RDEPENDS:perl-CGI = " \
 perl-libs \
 perl-Carp \
 perl-Text-ParseWords \
 perl-overload \
 perl-PathTools \
 perl-parent \
 perl-HTML-Parser \
 perl-Exporter \
 perl-CGI \
 perl-File-Temp \
"

URI_perl-CGI-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-CGI-tests-4.61-5.el10.noarch.rpm;name=perl-CGI-tests;unpack=0"
SRC_URI += "${URI_perl-CGI-tests}"
SRC_URI[perl-CGI-tests.sha256sum] = "20a0a05f8300ccf3e2501f940dd06d0d1442385dc04549407bef505420292156"
RDEPENDS:perl-CGI-tests = " \
 perl-Test-Warn \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-FileHandle \
 perl-IO \
 perl-FindBin \
 perl-POSIX \
 perl-Encode \
 perl-overload \
 bash \
 perl-PathTools \
 perl-interpreter \
 perl-CGI \
 perl-lib \
"
