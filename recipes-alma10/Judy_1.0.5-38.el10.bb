# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "Judy"
PE = "0"
PV = "1.0.5"
PR = "38.el10"
PACKAGES = "Judy Judy-devel"
PROVIDES = "rpm/Judy rpm/Judy-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/Judy-1.0.5-38.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7819a0532ca6fe4d23e5397c8cb0880f2c14c3d05a83643743dbd9bbbc115cc"

URI_Judy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/Judy-1.0.5-38.el10.x86_64_v2.rpm;name=Judy;unpack=0"
SRC_URI += "${URI_Judy}"
SRC_URI[Judy.sha256sum] = "860fe7c6a748b945c37038454ff7fab7812c95306679e89a9b60b304c3bfe2dd"
RDEPENDS:Judy = " \
 glibc \
"

URI_Judy-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/Judy-devel-1.0.5-38.el10.x86_64_v2.rpm;name=Judy-devel;unpack=0"
SRC_URI += "${URI_Judy-devel}"
SRC_URI[Judy-devel.sha256sum] = "7f01548f4e70e571256d54898649fa63a3dc843094c0008fd3af762874b0e4b3"
RDEPENDS:Judy-devel = " \
 Judy \
"
