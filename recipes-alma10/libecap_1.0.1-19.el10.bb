# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libecap"
PE = "0"
PV = "1.0.1"
PR = "19.el10"
PACKAGES = "libecap libecap-devel"
PROVIDES = "rpm/libecap rpm/libecap-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libecap-1.0.1-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c48825cb8b931dcec8d6a832253ec96b29124b8a254faaf5da9df5a009b34664"

URI_libecap = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libecap-1.0.1-19.el10.x86_64_v2.rpm;name=libecap;unpack=0"
SRC_URI += "${URI_libecap}"
SRC_URI[libecap.sha256sum] = "53ef1ee98f4e6efc28250aa33c70fe0d5014f4d6623500c63612ca0ea9f60d21"
RDEPENDS:libecap = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_libecap-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libecap-devel-1.0.1-19.el10.x86_64_v2.rpm;name=libecap-devel;unpack=0"
SRC_URI += "${URI_libecap-devel}"
SRC_URI[libecap-devel.sha256sum] = "0bde2cb9e446e01219ebea41933752a6d894032792b6e9b1014feb02bf6975c9"
RDEPENDS:libecap-devel = " \
 libecap \
 pkgconf-pkg-config \
"
