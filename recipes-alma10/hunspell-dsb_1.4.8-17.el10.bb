# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-dsb"
PE = "0"
PV = "1.4.8"
PR = "17.el10"
PACKAGES = "hunspell-dsb"
PROVIDES = "rpm/hunspell-dsb"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-dsb-1.4.8-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30d95bb1e25dd198eb01816806a355d97ba9927c46112b5e883995f8e47c5394"

URI_hunspell-dsb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-dsb-1.4.8-17.el10.noarch.rpm;name=hunspell-dsb;unpack=0"
SRC_URI += "${URI_hunspell-dsb}"
SRC_URI[hunspell-dsb.sha256sum] = "3e3c99b9cb667cfee1a29b5e203a429d925501926c42ddc808ae3a784264e749"
RDEPENDS:hunspell-dsb = " \
 hunspell-filesystem \
"
