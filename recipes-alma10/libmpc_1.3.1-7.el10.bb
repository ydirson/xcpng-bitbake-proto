# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libmpc"
PE = "0"
PV = "1.3.1"
PR = "7.el10"
PACKAGES = "libmpc libmpc-devel libmpc-doc"
PROVIDES = "rpm/libmpc rpm/libmpc-devel rpm/libmpc-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libmpc-1.3.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66a86c91b84ff5c85e1f01f96e9b9d287d680e34baf9fd96a98c4c474d15ded1"

URI_libmpc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libmpc-1.3.1-7.el10.x86_64_v2.rpm;name=libmpc;unpack=0"
SRC_URI += "${URI_libmpc}"
SRC_URI[libmpc.sha256sum] = "70b3ff7fee3c35bb5fc707d627c01af302fa048172d86252b47281fde2fd5725"
RDEPENDS:libmpc = " \
 glibc \
 gmp \
 mpfr \
"

URI_libmpc-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libmpc-devel-1.3.1-7.el10.x86_64_v2.rpm;name=libmpc-devel;unpack=0"
SRC_URI += "${URI_libmpc-devel}"
SRC_URI[libmpc-devel.sha256sum] = "2fd38f7a74dbca060d73e40f38bef14eb5300ce3b47a2c5c4ba8ea4e91263b14"
RDEPENDS:libmpc-devel = " \
 libmpc \
 mpfr-devel \
 gmp-devel \
"

URI_libmpc-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libmpc-doc-1.3.1-7.el10.noarch.rpm;name=libmpc-doc;unpack=0"
SRC_URI += "${URI_libmpc-doc}"
SRC_URI[libmpc-doc.sha256sum] = "552b8d30f8a2c375b7126429604378ff269ee908106ff49e5027eff30a7cc24b"
RDEPENDS:libmpc-doc = ""
