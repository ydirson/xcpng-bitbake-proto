# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "php-pecl-redis6"
PE = "0"
PV = "6.1.0"
PR = "2.el10"
PACKAGES = "php-pecl-redis6"
PROVIDES = "rpm/php-pecl-redis6"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/php-pecl-redis6-6.1.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70d542f40289dac2cbdd3a68f8d8a54b8e9f3176997034aaf7fbe3fa2b98fd16"

URI_php-pecl-redis6 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/php-pecl-redis6-6.1.0-2.el10.x86_64_v2.rpm;name=php-pecl-redis6;unpack=0"
SRC_URI += "${URI_php-pecl-redis6}"
SRC_URI[php-pecl-redis6.sha256sum] = "8f37eb834ded85753cc3a8697592dad2096db759d564fdf04dbf36ed2e14a433"
RDEPENDS:php-pecl-redis6 = " \
 glibc \
 lz4-libs \
 php-common \
 libzstd \
"
