# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libguestfs"
PE = "1"
PV = "1.54.0"
PR = "5.el10.alma.1"
PACKAGES = "libguestfs libguestfs-appliance libguestfs-bash-completion libguestfs-inspect-icons libguestfs-rescue libguestfs-rsync libguestfs-xfs perl-Sys-Guestfs python3-libguestfs libguestfs-devel libguestfs-man-pages-ja libguestfs-man-pages-uk ocaml-libguestfs ocaml-libguestfs-devel"
PROVIDES = "rpm/libguestfs rpm/libguestfs-appliance rpm/libguestfs-bash-completion rpm/libguestfs-inspect-icons rpm/libguestfs-rescue rpm/libguestfs-rsync rpm/libguestfs-xfs rpm/perl-Sys-Guestfs rpm/python3-libguestfs rpm/libguestfs-devel rpm/libguestfs-man-pages-ja rpm/libguestfs-man-pages-uk rpm/ocaml-libguestfs rpm/ocaml-libguestfs-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libguestfs-1.54.0-5.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71818de14e471cf0a8f6b7dbaafabef2169dc772787a5556c79a23a979cb61aa"

URI_libguestfs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libguestfs-1.54.0-5.el10.alma.1.x86_64_v2.rpm;name=libguestfs;unpack=0"
SRC_URI += "${URI_libguestfs}"
SRC_URI[libguestfs.sha256sum] = "ade694e3c4c7f28295080bf55c6fb90522c3b372346fe8b5323e9ee5aaede7ba"
RDEPENDS:libguestfs = " \
 systemd-libs \
 tar \
 ncurses-libs \
 libselinux \
 hexedit \
 hivex-libs \
 less \
 libacl \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 qemu-img \
 json-c \
 libvirt-daemon-driver-storage-core \
 libcap \
 vim-minimal \
 libconfig \
 libtirpc \
 libvirt-libs \
 selinux-policy \
 xz \
 qemu-kvm-core \
 augeas-libs \
 libgcc \
 libxml2 \
 grep \
 bash \
 pcre2 \
 libguestfs-appliance \
 fuse \
 fuse-libs \
 readline \
 man-db \
 glibc \
 coreutils \
 rpm-libs \
"

URI_libguestfs-appliance = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libguestfs-appliance-1.54.0-5.el10.alma.1.x86_64_v2.rpm;name=libguestfs-appliance;unpack=0"
SRC_URI += "${URI_libguestfs-appliance}"
SRC_URI[libguestfs-appliance.sha256sum] = "d1a0f612557f7f1860f57b0b965e8ffdfe503164bab75abecade2069e941e547"
RDEPENDS:libguestfs-appliance = " \
 systemd \
 glibc-gconv-extra \
 systemd-libs \
 cryptsetup \
 iproute \
 systemd-udev \
 tar \
 kmod \
 procps-ng \
 libselinux \
 scrub \
 hivex-libs \
 less \
 libacl \
 util-linux \
 psmisc \
 diffutils \
 dhcpcd \
 json-c \
 acl \
 libcap \
 supermin \
 dosfstools \
 sed \
 libtirpc \
 xz \
 e2fsprogs \
 zstd \
 augeas-libs \
 attr \
 kernel \
 libgcc \
 grep \
 libxml2 \
 parted \
 bash \
 clevis-luks \
 pcre2 \
 binutils \
 file \
 findutils \
 bzip2 \
 lsscsi \
 lvm2 \
 gzip \
 gawk \
 lzop \
 policycoreutils \
 mdadm \
 glibc \
 coreutils \
 cpio \
 rpm-libs \
"

URI_libguestfs-bash-completion = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libguestfs-bash-completion-1.54.0-5.el10.alma.1.noarch.rpm;name=libguestfs-bash-completion;unpack=0"
SRC_URI += "${URI_libguestfs-bash-completion}"
SRC_URI[libguestfs-bash-completion.sha256sum] = "dc2b79c1bb0c1e6e58f9c4d2cacfc3a403bf0d00a39a2c6f37bcff160d4652bb"
RDEPENDS:libguestfs-bash-completion = " \
 bash-completion \
"

URI_libguestfs-inspect-icons = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libguestfs-inspect-icons-1.54.0-5.el10.alma.1.noarch.rpm;name=libguestfs-inspect-icons;unpack=0"
SRC_URI += "${URI_libguestfs-inspect-icons}"
SRC_URI[libguestfs-inspect-icons.sha256sum] = "40dad531d6c74229422705d1f972756555cb77fc42e698925b32768acb192b3e"
RDEPENDS:libguestfs-inspect-icons = " \
 icoutils \
 netpbm-progs \
 libguestfs \
"

URI_libguestfs-rescue = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libguestfs-rescue-1.54.0-5.el10.alma.1.x86_64_v2.rpm;name=libguestfs-rescue;unpack=0"
SRC_URI += "${URI_libguestfs-rescue}"
SRC_URI[libguestfs-rescue.sha256sum] = "d3df3074e7ba38e37380e9768533aa0e058e0b89852cb814ef6e4404c6815f18"
RDEPENDS:libguestfs-rescue = " \
 lsof \
 openssh-clients \
 libgcc \
 libxml2 \
 iputils \
 pciutils \
 vim-minimal \
 libconfig \
 strace \
 libguestfs \
 glibc \
"

URI_libguestfs-rsync = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libguestfs-rsync-1.54.0-5.el10.alma.1.x86_64_v2.rpm;name=libguestfs-rsync;unpack=0"
SRC_URI += "${URI_libguestfs-rsync}"
SRC_URI[libguestfs-rsync.sha256sum] = "ceb78208a649ebbc9e7d10d9b0f27d47647d8b0741bc161b58172a0c02378a7b"
RDEPENDS:libguestfs-rsync = " \
 rsync \
 libguestfs \
"

URI_libguestfs-xfs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libguestfs-xfs-1.54.0-5.el10.alma.1.x86_64_v2.rpm;name=libguestfs-xfs;unpack=0"
SRC_URI += "${URI_libguestfs-xfs}"
SRC_URI[libguestfs-xfs.sha256sum] = "0def00f238655dd27e78d6e872285fc3f2465922adafd434ae375a46a11fc578"
RDEPENDS:libguestfs-xfs = " \
 xfsprogs \
 libguestfs \
"

URI_perl-Sys-Guestfs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Sys-Guestfs-1.54.0-5.el10.alma.1.x86_64_v2.rpm;name=perl-Sys-Guestfs;unpack=0"
SRC_URI += "${URI_perl-Sys-Guestfs}"
SRC_URI[perl-Sys-Guestfs.sha256sum] = "6bf136b3547f937c9432324caabc0713ccfa69be450cb8c24323c8a8a4a2f1cc"
RDEPENDS:perl-Sys-Guestfs = " \
 glibc \
 perl-libs \
 perl-vars \
 libguestfs \
"

URI_python3-libguestfs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-libguestfs-1.54.0-5.el10.alma.1.x86_64_v2.rpm;name=python3-libguestfs;unpack=0"
SRC_URI += "${URI_python3-libguestfs}"
SRC_URI[python3-libguestfs.sha256sum] = "ff69c7c66790df20f0a6c0a43168aab3c7ccf48c256c92e879e183c9849afb17"
RDEPENDS:python3-libguestfs = " \
 glibc \
 python3 \
 libguestfs \
"

URI_libguestfs-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libguestfs-devel-1.54.0-5.el10.alma.1.x86_64_v2.rpm;name=libguestfs-devel;unpack=0"
SRC_URI += "${URI_libguestfs-devel}"
SRC_URI[libguestfs-devel.sha256sum] = "b66553ac2e5fccef93537a431a41751bc62040898119c0a06d79bcac154c00f8"
RDEPENDS:libguestfs-devel = " \
 pkgconf-pkg-config \
 libguestfs \
"

URI_libguestfs-man-pages-ja = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libguestfs-man-pages-ja-1.54.0-5.el10.alma.1.noarch.rpm;name=libguestfs-man-pages-ja;unpack=0"
SRC_URI += "${URI_libguestfs-man-pages-ja}"
SRC_URI[libguestfs-man-pages-ja.sha256sum] = "8bb280f47b9465c6e44a1eb58e5a694b5038ef5932d05f7af6f75a68fc324dc7"
RDEPENDS:libguestfs-man-pages-ja = " \
 libguestfs \
"

URI_libguestfs-man-pages-uk = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libguestfs-man-pages-uk-1.54.0-5.el10.alma.1.noarch.rpm;name=libguestfs-man-pages-uk;unpack=0"
SRC_URI += "${URI_libguestfs-man-pages-uk}"
SRC_URI[libguestfs-man-pages-uk.sha256sum] = "75bdb5d7df406792ec5e5d7cec2cad944e880a73ceec6f6db8d14710a38cf74d"
RDEPENDS:libguestfs-man-pages-uk = " \
 libguestfs \
"

URI_ocaml-libguestfs = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-libguestfs-1.54.0-5.el10.alma.1.x86_64_v2.rpm;name=ocaml-libguestfs;unpack=0"
SRC_URI += "${URI_ocaml-libguestfs}"
SRC_URI[ocaml-libguestfs.sha256sum] = "be6d66847b20f16aa149d2adf5ca67585537516dc67dc4ca3154788fed5321cd"
RDEPENDS:ocaml-libguestfs = " \
 glibc \
 ocaml-runtime \
 libguestfs \
"

URI_ocaml-libguestfs-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-libguestfs-devel-1.54.0-5.el10.alma.1.x86_64_v2.rpm;name=ocaml-libguestfs-devel;unpack=0"
SRC_URI += "${URI_ocaml-libguestfs-devel}"
SRC_URI[ocaml-libguestfs-devel.sha256sum] = "59a4b5d282a8dc7b8544fd7c9f8b3cc24d18ad1766968f8a467acecde34cb8ce"
RDEPENDS:ocaml-libguestfs-devel = " \
 ocaml-runtime \
 ocaml \
 ocaml-libguestfs \
"
