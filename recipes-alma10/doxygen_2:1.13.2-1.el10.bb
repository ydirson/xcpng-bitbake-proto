# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "doxygen"
PE = "2"
PV = "1.13.2"
PR = "1.el10"
PACKAGES = "doxygen doxygen-latex"
PROVIDES = "rpm/doxygen rpm/doxygen-latex"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/doxygen-1.13.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edec03c9427fb8e7d921142551658fd1afcd64dafb6b231b7b99d02b95a4f4ef"

URI_doxygen = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/doxygen-1.13.2-1.el10.x86_64_v2.rpm;name=doxygen;unpack=0"
SRC_URI += "${URI_doxygen}"
SRC_URI[doxygen.sha256sum] = "bbf4a04c2a3cd66ac638a394ea38a3b4ad7dd5f76f19eab17a7ecdd603752164"
RDEPENDS:doxygen = " \
 libgcc \
 libstdc++ \
 glibc \
 graphviz \
 perl-interpreter \
"

URI_doxygen-latex = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/doxygen-latex-1.13.2-1.el10.x86_64_v2.rpm;name=doxygen-latex;unpack=0"
SRC_URI += "${URI_doxygen-latex}"
SRC_URI[doxygen-latex.sha256sum] = "0cdca04d50b7045edda852ec0b60d64f37c005d256024727b75adc40f051b7a3"
RDEPENDS:doxygen-latex = " \
 texlive-etoc \
 texlive-varwidth \
 texlive-multirow \
 texlive-wasy \
 texlive-natbib \
 texlive-wasysym \
 texlive-xcolor \
 texlive-fancyhdr \
 texlive-newunicodechar \
 texlive-fancyvrb \
 doxygen \
 texlive-float \
 texlive-xtab \
 texlive-geometry \
 texlive-graphics \
 texlive-adjustbox \
 texlive-psnfss \
 texlive-pspicture \
 texlive-hanging \
 texlive-amsfonts \
 texlive-appendix \
 texlive-hyperref \
 texlive-iftex \
 texlive-import \
 texlive-bibtex \
 texlive-sectsty \
 texlive-caption \
 texlive-latex \
 texlive-stackengine \
 texlive-tabu \
 texlive-listings \
 texlive-collection-latexrecommended \
 texlive-makeindex \
 texlive-tocloft \
 texlive-tools \
 texlive-dvips \
 texlive-ulem \
 texlive-epstopdf \
"
