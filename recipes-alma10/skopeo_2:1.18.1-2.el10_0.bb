# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "skopeo"
PE = "2"
PV = "1.18.1"
PR = "2.el10_0"
PACKAGES = "skopeo skopeo-tests"
PROVIDES = "rpm/skopeo rpm/skopeo-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/skopeo-1.18.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e57829a647b8fbc804aeae830a547724063aa34265a9b9f209cdb1c81986ea7b"

URI_skopeo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/skopeo-1.18.1-2.el10_0.x86_64_v2.rpm;name=skopeo;unpack=0"
SRC_URI += "${URI_skopeo}"
SRC_URI[skopeo.sha256sum] = "0657f2cd95a4b03563e22f5ced4903e3046d89dde9c44b8b593b4f047f72ab94"
RDEPENDS:skopeo = " \
 glibc \
 containers-common \
 gpgme \
 shadow-utils-subid \
"

URI_skopeo-tests = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/skopeo-tests-1.18.1-2.el10_0.x86_64_v2.rpm;name=skopeo-tests;unpack=0"
SRC_URI += "${URI_skopeo-tests}"
SRC_URI[skopeo-tests.sha256sum] = "423183422a81bf3dacb7fbf0df2229b1885e0ec7c75476ae5d00fed62ca6c70f"
RDEPENDS:skopeo-tests = " \
 gnupg2 \
 openssl \
 jq \
 httpd-tools \
 skopeo \
 crun \
 bash \
 coreutils \
 golang \
 podman \
"
