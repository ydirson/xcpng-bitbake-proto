# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "freerdp"
PE = "2"
PV = "3.10.3"
PR = "3.el10_0"
PACKAGES = "freerdp freerdp-libs libwinpr freerdp-devel freerdp-server libwinpr-devel"
PROVIDES = "rpm/freerdp rpm/freerdp-libs rpm/libwinpr rpm/freerdp-devel rpm/freerdp-server rpm/libwinpr-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/freerdp-3.10.3-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd282b2d3af2630de35e4859db972c14fd3fc0354a11457aad8dec26eb9e1bc6"

URI_freerdp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/freerdp-3.10.3-3.el10_0.x86_64_v2.rpm;name=freerdp;unpack=0"
SRC_URI += "${URI_freerdp}"
SRC_URI[freerdp.sha256sum] = "3aa1857c2329cd6b4f5cbdf12b330bda22fa20d92194c4601ab666a100e0fc3a"
RDEPENDS:freerdp = " \
 libXfixes \
 libXi \
 libwayland-client \
 libXinerama \
 libwayland-cursor \
 freerdp-libs \
 libXrandr \
 libwinpr \
 libX11 \
 libXrender \
 glibc \
 libxkbcommon \
 libXcursor \
 libXext \
"

URI_freerdp-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/freerdp-libs-3.10.3-3.el10_0.x86_64_v2.rpm;name=freerdp-libs;unpack=0"
SRC_URI += "${URI_freerdp-libs}"
SRC_URI[freerdp-libs.sha256sum] = "93045ccd30de1262c9f7d8c7a3e816e434ec88cc5522b1f46ab4d988b8965e65"
RDEPENDS:freerdp-libs = " \
 cups-libs \
 libX11 \
 libXdamage \
 libXext \
 libXfixes \
 libXinerama \
 libstdc++ \
 cairo \
 libXtst \
 fdk-aac-free \
 libusb1 \
 alsa-lib \
 zlib-ng-compat \
 pulseaudio-libs \
 openssl-libs \
 libgcc \
 libwinpr \
 pam-libs \
 opus \
 libxkbfile \
 lame-libs \
 gsm \
 fuse3-libs \
 glibc \
"

URI_libwinpr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libwinpr-3.10.3-3.el10_0.x86_64_v2.rpm;name=libwinpr;unpack=0"
SRC_URI += "${URI_libwinpr}"
SRC_URI[libwinpr.sha256sum] = "4633824bd3706d4c456c7aebe5174c59e59ad4acf5e93f729d603251329e33c2"
RDEPENDS:libwinpr = " \
 libpng \
 openssl-libs \
 libgcc \
 json-c \
 libwebp \
 krb5-libs \
 libcom_err \
 glibc \
 libicu \
 libjpeg-turbo \
"

URI_freerdp-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/freerdp-devel-3.10.3-3.el10_0.x86_64_v2.rpm;name=freerdp-devel;unpack=0"
SRC_URI += "${URI_freerdp-devel}"
SRC_URI[freerdp-devel.sha256sum] = "a216440a8057f80c8b512c58af571c398e6410b129eaa505e04c41dd705b53ad"
RDEPENDS:freerdp-devel = " \
 cmake-filesystem \
 freerdp-libs \
 zlib-ng-compat-devel \
 freerdp-devel \
 pkgconf-pkg-config \
 cmake \
 libwinpr-devel \
"

URI_freerdp-server = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/freerdp-server-3.10.3-3.el10_0.x86_64_v2.rpm;name=freerdp-server;unpack=0"
SRC_URI += "${URI_freerdp-server}"
SRC_URI[freerdp-server.sha256sum] = "5ae7a1fea44090c0fb13ba28776cbd828eadac8a476bfb87d0b7d3661c916da6"
RDEPENDS:freerdp-server = " \
 glibc \
 freerdp-libs \
 libwinpr \
"

URI_libwinpr-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libwinpr-devel-3.10.3-3.el10_0.x86_64_v2.rpm;name=libwinpr-devel;unpack=0"
SRC_URI += "${URI_libwinpr-devel}"
SRC_URI[libwinpr-devel.sha256sum] = "07ca073e7e6254db4ebe413269c4b087d9a791903d29d20bdd3fc8da9d2be549"
RDEPENDS:libwinpr-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 libwinpr \
 openssl-devel \
 cmake \
 libwinpr-devel \
"
