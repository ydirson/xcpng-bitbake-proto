# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jackson-annotations"
PE = "0"
PV = "2.16.1"
PR = "3.el10"
PACKAGES = "jackson-annotations jackson-annotations-javadoc"
PROVIDES = "rpm/jackson-annotations rpm/jackson-annotations-javadoc"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/jackson-annotations-2.16.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63cb09cf4c0c27e9f73a038e0aada5652812f0fc75c71a3d594172b88e9fcbb4"

URI_jackson-annotations = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/jackson-annotations-2.16.1-3.el10.noarch.rpm;name=jackson-annotations;unpack=0"
SRC_URI += "${URI_jackson-annotations}"
SRC_URI[jackson-annotations.sha256sum] = "2f1697a337d0d016b21139d460ca9795369fa188641fd036769f1f6bafc66f21"
RDEPENDS:jackson-annotations = " \
 javapackages-filesystem \
 java-21-openjdk-headless \
"

URI_jackson-annotations-javadoc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/jackson-annotations-javadoc-2.16.1-3.el10.noarch.rpm;name=jackson-annotations-javadoc;unpack=0"
SRC_URI += "${URI_jackson-annotations-javadoc}"
SRC_URI[jackson-annotations-javadoc.sha256sum] = "2d3d4a78528ae3318f63cd460e69f98e8a836a4dd7b2cd0d57cf18ef8e45a31b"
RDEPENDS:jackson-annotations-javadoc = " \
 javapackages-filesystem \
"
