# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-initial-setup"
PE = "0"
PV = "46.alpha"
PR = "15.el10_0.alma.1"
PACKAGES = "gnome-initial-setup"
PROVIDES = "rpm/gnome-initial-setup"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-initial-setup-46.alpha-15.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49b19bae36623fb1b835bd11cef242b713a593bd8079856a3911cd5aef8df005"

URI_gnome-initial-setup = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-initial-setup-46.alpha-15.el10_0.alma.1.x86_64_v2.rpm;name=gnome-initial-setup;unpack=0"
SRC_URI += "${URI_gnome-initial-setup}"
SRC_URI[gnome-initial-setup.sha256sum] = "4bdbd659492b52ddf8a82aadf57cd21b90a21ea035d4ad34d9a758ae42e53016"
RDEPENDS:gnome-initial-setup = " \
 libpwquality \
 pango \
 fontconfig \
 krb5-libs \
 ibus-libs \
 NetworkManager-libnm \
 libnma-gtk4 \
 tecla \
 accountsservice-libs \
 gnome-desktop4 \
 cairo \
 libadwaita \
 shadow-utils \
 libgcc \
 gdk-pixbuf2 \
 libsecret \
 bash \
 gdm \
 geoclue2-libs \
 geocode-glib \
 libgweather \
 polkit \
 polkit-libs \
 glib2 \
 glibc \
 gtk4 \
"
