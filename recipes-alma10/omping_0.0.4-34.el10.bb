# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "omping"
PE = "0"
PV = "0.0.4"
PR = "34.el10"
PACKAGES = "omping"
PROVIDES = "rpm/omping"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/omping-0.0.4-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b841578900ea601e90d05cd99207c0cac4e1193fe5d232b3686ca89ca0ec6e9"

URI_omping = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/omping-0.0.4-34.el10.x86_64_v2.rpm;name=omping;unpack=0"
SRC_URI += "${URI_omping}"
SRC_URI[omping.sha256sum] = "236b95ebb01cd4600f64b7aff6250f903cac313f906bb85d9f0b509da382b623"
RDEPENDS:omping = " \
 glibc \
"
