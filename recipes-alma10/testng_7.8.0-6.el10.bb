# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "testng"
PE = "0"
PV = "7.8.0"
PR = "6.el10"
PACKAGES = "testng testng-javadoc"
PROVIDES = "rpm/testng rpm/testng-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/testng-7.8.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64061d0f77d7554475f1beaa268210339dcee18978671424f1e13493727af516"

URI_testng = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/testng-7.8.0-6.el10.noarch.rpm;name=testng;unpack=0"
SRC_URI += "${URI_testng}"
SRC_URI[testng.sha256sum] = "830f1e96c8bbddf3ec25d59dc87e04e35a29ff470040b0fd68f8270c062db8df"
RDEPENDS:testng = " \
 beust-jcommander \
 javapackages-filesystem \
 slf4j \
"

URI_testng-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/testng-javadoc-7.8.0-6.el10.noarch.rpm;name=testng-javadoc;unpack=0"
SRC_URI += "${URI_testng-javadoc}"
SRC_URI[testng-javadoc.sha256sum] = "496cf6d9426edff11c2a8ff218848995c6df2cbb9c95fe50de27c33d88b378f2"
RDEPENDS:testng-javadoc = " \
 javapackages-filesystem \
"
