# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "realtime-tests"
PE = "0"
PV = "2.8"
PR = "5.el10"
PACKAGES = "realtime-tests"
PROVIDES = "rpm/realtime-tests"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/realtime-tests-2.8-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3cdd4069d00781fbd7f2332cfe3b8f7ad5f60bdffd7620a898bbadd09389a63c"

URI_realtime-tests = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/realtime-tests-2.8-5.el10.x86_64_v2.rpm;name=realtime-tests;unpack=0"
SRC_URI += "${URI_realtime-tests}"
SRC_URI[realtime-tests.sha256sum] = "2690cdbd3fefb4cc7e9295cea422e1452415280cf5e65d949bab8275f0531932"
RDEPENDS:realtime-tests = " \
 python3 \
 numactl-libs \
 bash \
 bc \
 glibc \
 kernel-tools-libs \
"
