# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-pefile"
PE = "0"
PV = "2024.8.26"
PR = "1.el10"
PACKAGES = "python3-pefile"
PROVIDES = "rpm/python3-pefile"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-pefile-2024.8.26-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "acb055151db09f46ba83f3b4c1067daf96b86be614d96015cb5be8002dba690a"

URI_python3-pefile = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-pefile-2024.8.26-1.el10.noarch.rpm;name=python3-pefile;unpack=0"
SRC_URI += "${URI_python3-pefile}"
SRC_URI[python3-pefile.sha256sum] = "bd82fa1247b92c9f1398eefd3c8c3f5053d781fb8cf3218f437af2665a3f8a0e"
RDEPENDS:python3-pefile = " \
 python3 \
"
