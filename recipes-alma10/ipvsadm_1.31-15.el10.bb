# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ipvsadm"
PE = "0"
PV = "1.31"
PR = "15.el10"
PACKAGES = "ipvsadm"
PROVIDES = "rpm/ipvsadm"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ipvsadm-1.31-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e062034871b4237cda779dc54bef77ef78a629dda5cf6a44241affff6e63869"

URI_ipvsadm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ipvsadm-1.31-15.el10.x86_64_v2.rpm;name=ipvsadm;unpack=0"
SRC_URI += "${URI_ipvsadm}"
SRC_URI[ipvsadm.sha256sum] = "98c41326fd0f7e81f50909e5eea2d67ae86e76619b0873e35897ccf39a79c2d8"
RDEPENDS:ipvsadm = " \
 systemd \
 libnl3 \
 bash \
 popt \
 glibc \
"
