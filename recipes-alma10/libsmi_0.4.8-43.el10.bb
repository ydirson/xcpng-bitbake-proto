# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libsmi"
PE = "0"
PV = "0.4.8"
PR = "43.el10"
PACKAGES = "libsmi libsmi-devel"
PROVIDES = "rpm/libsmi rpm/libsmi-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libsmi-0.4.8-43.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5323dd9483f581fdfd799bac7b946ca01568d887c78208284e2ef8f81abe871"

URI_libsmi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libsmi-0.4.8-43.el10.x86_64_v2.rpm;name=libsmi;unpack=0"
SRC_URI += "${URI_libsmi}"
SRC_URI[libsmi.sha256sum] = "9b007e53df94dcdfa3a1b15c9a3dc7323bbe34bd2c980bf5a1611dbc6ab4a87b"
RDEPENDS:libsmi = " \
 glibc \
 wget \
 gawk \
 bash \
"

URI_libsmi-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libsmi-devel-0.4.8-43.el10.x86_64_v2.rpm;name=libsmi-devel;unpack=0"
SRC_URI += "${URI_libsmi-devel}"
SRC_URI[libsmi-devel.sha256sum] = "1ecb12d87766425e92a3094e72bdd49113a78957b172293780755429462e871f"
RDEPENDS:libsmi-devel = " \
 pkgconf-pkg-config \
 libsmi \
"
