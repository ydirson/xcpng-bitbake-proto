# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-uz"
PE = "0"
PV = "0.6"
PR = "33.el10"
PACKAGES = "hunspell-uz"
PROVIDES = "rpm/hunspell-uz"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-uz-0.6-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a77307dd07d58536021c7dbfd5461cb1b61639ed8096edcb25962677f4e7d5bd"

URI_hunspell-uz = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-uz-0.6-33.el10.noarch.rpm;name=hunspell-uz;unpack=0"
SRC_URI += "${URI_hunspell-uz}"
SRC_URI[hunspell-uz.sha256sum] = "40a213284ef11c12d0dcaf014084bba6e36d9d0337272c2a8666bf151fbd35e4"
RDEPENDS:hunspell-uz = " \
 hunspell-filesystem \
"
