# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pcre2"
PE = "0"
PV = "10.44"
PR = "1.el10.3"
PACKAGES = "pcre2 pcre2-syntax pcre2-devel pcre2-utf16 pcre2-utf32 pcre2-static pcre2-tools"
PROVIDES = "rpm/pcre2 rpm/pcre2-syntax rpm/pcre2-devel rpm/pcre2-utf16 rpm/pcre2-utf32 rpm/pcre2-static rpm/pcre2-tools"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/pcre2-10.44-1.el10.3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd146047014814af463edb813aa001efb38d969f856c09052256ffe5f6ed9b7f"

URI_pcre2 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/pcre2-10.44-1.el10.3.x86_64_v2.rpm;name=pcre2;unpack=0"
SRC_URI += "${URI_pcre2}"
SRC_URI[pcre2.sha256sum] = "c6ec12b1f6071c5a8943cd3a99c23a85f7ff5ada8c1fad31342cc210c08330dd"
RDEPENDS:pcre2 = " \
 glibc \
 pcre2-syntax \
"

URI_pcre2-syntax = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/pcre2-syntax-10.44-1.el10.3.noarch.rpm;name=pcre2-syntax;unpack=0"
SRC_URI += "${URI_pcre2-syntax}"
SRC_URI[pcre2-syntax.sha256sum] = "19c69f01525569ff4fc2b5c51eaee0e3a8733be7863e0fdc06446bc828581c1e"
RDEPENDS:pcre2-syntax = ""

URI_pcre2-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcre2-devel-10.44-1.el10.3.x86_64_v2.rpm;name=pcre2-devel;unpack=0"
SRC_URI += "${URI_pcre2-devel}"
SRC_URI[pcre2-devel.sha256sum] = "fe6c3c486115bf50c7f7fa00ab9b16d7c60f5cf3b116d2c7f3da258ec9f4dda7"
RDEPENDS:pcre2-devel = " \
 pkgconf-pkg-config \
 pcre2-devel \
 pcre2-utf16 \
 pcre2-utf32 \
 bash \
 pcre2 \
"

URI_pcre2-utf16 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcre2-utf16-10.44-1.el10.3.x86_64_v2.rpm;name=pcre2-utf16;unpack=0"
SRC_URI += "${URI_pcre2-utf16}"
SRC_URI[pcre2-utf16.sha256sum] = "50f939b51212dcffb0901ecb7986de963f5b5cc398b1a470c9868cd0bc77bcf3"
RDEPENDS:pcre2-utf16 = " \
 glibc \
 pcre2-syntax \
"

URI_pcre2-utf32 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcre2-utf32-10.44-1.el10.3.x86_64_v2.rpm;name=pcre2-utf32;unpack=0"
SRC_URI += "${URI_pcre2-utf32}"
SRC_URI[pcre2-utf32.sha256sum] = "60b51475dd496f7755461dad2b6f89b11d63547bce14c74b3795aa4c7a8c6c43"
RDEPENDS:pcre2-utf32 = " \
 glibc \
 pcre2-syntax \
"

URI_pcre2-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/pcre2-static-10.44-1.el10.3.x86_64_v2.rpm;name=pcre2-static;unpack=0"
SRC_URI += "${URI_pcre2-static}"
SRC_URI[pcre2-static.sha256sum] = "fee72dbf13149fde7317c832ea3e0b90a07c3b6f935857df6af7985d062f81a3"
RDEPENDS:pcre2-static = " \
 pcre2-devel \
"

URI_pcre2-tools = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/pcre2-tools-10.44-1.el10.3.x86_64_v2.rpm;name=pcre2-tools;unpack=0"
SRC_URI += "${URI_pcre2-tools}"
SRC_URI[pcre2-tools.sha256sum] = "c1534eba8b101caba8da4aabf5c68cc6437368384b92b7347e86352c70e7a5b1"
RDEPENDS:pcre2-tools = " \
 readline \
 pcre2-utf16 \
 pcre2-utf32 \
 pcre2 \
 glibc \
"
