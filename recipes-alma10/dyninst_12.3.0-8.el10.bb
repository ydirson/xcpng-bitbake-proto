# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dyninst"
PE = "0"
PV = "12.3.0"
PR = "8.el10"
PACKAGES = "dyninst dyninst-devel dyninst-doc dyninst-testsuite"
PROVIDES = "rpm/dyninst rpm/dyninst-devel rpm/dyninst-doc rpm/dyninst-testsuite"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/dyninst-12.3.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55903fbf78683bc66de91aecf6dbd4add750fc9f49dede11074a0115697760ba"

URI_dyninst = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dyninst-12.3.0-8.el10.x86_64_v2.rpm;name=dyninst;unpack=0"
SRC_URI += "${URI_dyninst}"
SRC_URI[dyninst.sha256sum] = "08a925c007b939950250588bff253284f38c5c4fecfe71bbe031a48a40ccac85"
RDEPENDS:dyninst = " \
 boost-filesystem \
 elfutils-debuginfod-client \
 libgcc \
 elfutils-libelf \
 libgomp \
 elfutils-libs \
 boost-thread \
 libstdc++ \
 glibc \
 tbb \
"

URI_dyninst-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/dyninst-devel-12.3.0-8.el10.x86_64_v2.rpm;name=dyninst-devel;unpack=0"
SRC_URI += "${URI_dyninst-devel}"
SRC_URI[dyninst-devel.sha256sum] = "445b6b131da8f3025d33ad9d04b5e88edcaf7277f25f0a394aa8102a11999368"
RDEPENDS:dyninst-devel = " \
 cmake-filesystem \
 tbb-devel \
 dyninst \
 boost-devel \
"

URI_dyninst-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/dyninst-doc-12.3.0-8.el10.x86_64_v2.rpm;name=dyninst-doc;unpack=0"
SRC_URI += "${URI_dyninst-doc}"
SRC_URI[dyninst-doc.sha256sum] = "d3206997843dbdc3737fe2ee8c8e5c10b0bd2a471657c2415b26c4169b65364b"
RDEPENDS:dyninst-doc = ""

URI_dyninst-testsuite = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/dyninst-testsuite-12.3.0-8.el10.x86_64_v2.rpm;name=dyninst-testsuite;unpack=0"
SRC_URI += "${URI_dyninst-testsuite}"
SRC_URI[dyninst-testsuite.sha256sum] = "b6c9192333c62ce05cd52cc528eb3215b9f5e786f635e7a464d5f8f32cdc7a60"
RDEPENDS:dyninst-testsuite = " \
 libgcc \
 dyninst \
 libstdc++ \
 dyninst-devel \
 glibc \
 tbb \
"
