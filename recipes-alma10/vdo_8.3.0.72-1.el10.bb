# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "vdo"
PE = "0"
PV = "8.3.0.72"
PR = "1.el10"
PACKAGES = "vdo vdo-support"
PROVIDES = "rpm/vdo rpm/vdo-support"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/vdo-8.3.0.72-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81edaf9950b5832b56a6c92104a62532303a6116e46f98a216f054af5372800a"

URI_vdo = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/vdo-8.3.0.72-1.el10.x86_64_v2.rpm;name=vdo;unpack=0"
SRC_URI += "${URI_vdo}"
SRC_URI[vdo.sha256sum] = "95972d8bfcf3a143480b1eb4d73b095bc7618d9f029e6eb1a00957b68d9bcb76"
RDEPENDS:vdo = " \
 glibc \
 libblkid \
 libuuid \
 zlib-ng-compat \
"

URI_vdo-support = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/vdo-support-8.3.0.72-1.el10.x86_64_v2.rpm;name=vdo-support;unpack=0"
SRC_URI += "${URI_vdo-support}"
SRC_URI[vdo-support.sha256sum] = "c72901ace42dd59c9d4a6881af721a72a87c3b5afc7a0a495cdcc8df41a922cd"
RDEPENDS:vdo-support = " \
 glibc \
 libuuid \
 zlib-ng-compat \
 bash \
"
