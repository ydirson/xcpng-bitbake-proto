# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "automake"
PE = "0"
PV = "1.16.5"
PR = "20.el10"
PACKAGES = "automake"
PROVIDES = "rpm/automake"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/automake-1.16.5-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80f107bb111a12b3d5e8e06c599571cb846bbd9e72a22984ab25934991e68dfe"

URI_automake = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/automake-1.16.5-20.el10.noarch.rpm;name=automake;unpack=0"
SRC_URI += "${URI_automake}"
SRC_URI[automake.sha256sum] = "0fbb3412d07c6fd8a763ec636e2902d52a592eb0e5f5f2b315375b214d370032"
RDEPENDS:automake = " \
 perl-constant \
 perl-threads \
 perl-File-stat \
 perl-libs \
 perl-Carp \
 perl-interpreter \
 perl-IO \
 perl-Class-Struct \
 autoconf \
 perl-Getopt-Long \
 perl-File-Basename \
 perl-Thread-Queue \
 bash \
 perl-PathTools \
 perl-Errno \
 perl-Exporter \
 perl-File-Path \
"
