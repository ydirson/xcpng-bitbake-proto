# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "plocate"
PE = "0"
PV = "1.1.22"
PR = "10.el10"
PACKAGES = "plocate"
PROVIDES = "rpm/plocate"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/plocate-1.1.22-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c5dcfe4d2d3bde50626267c8eeca6e8fa71049fcad8a422dc53bb6c6eec2166"

URI_plocate = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/plocate-1.1.22-10.el10.x86_64_v2.rpm;name=plocate;unpack=0"
SRC_URI += "${URI_plocate}"
SRC_URI[plocate.sha256sum] = "b8f2152d9515263fd2f3e77e532f31cb4b0dfe50a8400a120104860059a82c44"
RDEPENDS:plocate = " \
 libgcc \
 libzstd \
 libstdc++ \
 bash \
 glibc \
 liburing \
"
