# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Digest-HMAC"
PE = "0"
PV = "1.04"
PR = "12.el10"
PACKAGES = "perl-Digest-HMAC perl-Digest-HMAC-tests"
PROVIDES = "rpm/perl-Digest-HMAC rpm/perl-Digest-HMAC-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Digest-HMAC-1.04-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56ad3e550f89d26fbae65232a92fa7fc0c27963fefd2e822a662b82c0fd8c5d7"

URI_perl-Digest-HMAC = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Digest-HMAC-1.04-12.el10.noarch.rpm;name=perl-Digest-HMAC;unpack=0"
SRC_URI += "${URI_perl-Digest-HMAC}"
SRC_URI[perl-Digest-HMAC.sha256sum] = "a176690243964e69f44a2ca0b1e146c063a8b3442687dcb16fdc5132f5cdc4db"
RDEPENDS:perl-Digest-HMAC = " \
 perl-libs \
 perl-vars \
 perl-Digest-HMAC \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Exporter \
"

URI_perl-Digest-HMAC-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Digest-HMAC-tests-1.04-12.el10.noarch.rpm;name=perl-Digest-HMAC-tests;unpack=0"
SRC_URI += "${URI_perl-Digest-HMAC-tests}"
SRC_URI[perl-Digest-HMAC-tests.sha256sum] = "b7a11a2185d7ad37034d54a4e8d2f083228eecf8567717d1f831d814c67a25eb"
RDEPENDS:perl-Digest-HMAC-tests = " \
 perl-Digest-HMAC \
 perl-interpreter \
 perl-Test-Harness \
 bash \
"
