# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnutls"
PE = "0"
PV = "3.8.9"
PR = "9.el10_0.14"
PACKAGES = "gnutls gnutls-c++ gnutls-dane gnutls-devel gnutls-fips gnutls-utils"
PROVIDES = "rpm/gnutls rpm/gnutls-c++ rpm/gnutls-dane rpm/gnutls-devel rpm/gnutls-fips rpm/gnutls-utils"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/gnutls-3.8.9-9.el10_0.14.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e4b539d7faa9859b0e56a17dc13e1c6acb1063f0a7f767fe1d9b02e2abc795f"

URI_gnutls = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/gnutls-3.8.9-9.el10_0.14.x86_64_v2.rpm;name=gnutls;unpack=0"
SRC_URI += "${URI_gnutls}"
SRC_URI[gnutls.sha256sum] = "d22a2cc124b117ccd1b4f381a1c3713b0b8033cf9853d0d848b90b200d3d427a"
RDEPENDS:gnutls = " \
 crypto-policies \
 p11-kit \
 p11-kit-trust \
 libtasn1 \
 glibc \
 libidn2 \
 libunistring \
"

URI_gnutls-c++ = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnutls-c++-3.8.9-9.el10_0.14.x86_64_v2.rpm;name=gnutls-c++;unpack=0"
SRC_URI += "${URI_gnutls-c++}"
SRC_URI[gnutls-c++.sha256sum] = "211d6a9bfb399bbf85c96ecb36fd2d4a49cb1023b5bce96942b9de75fdc01730"
RDEPENDS:gnutls-c++ = " \
 gnutls \
 libgcc \
 p11-kit \
 libstdc++ \
 libtasn1 \
 glibc \
 libidn2 \
 libunistring \
"

URI_gnutls-dane = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnutls-dane-3.8.9-9.el10_0.14.x86_64_v2.rpm;name=gnutls-dane;unpack=0"
SRC_URI += "${URI_gnutls-dane}"
SRC_URI[gnutls-dane.sha256sum] = "dabe94a9ed2b17e6f2bc4174b0f34edcabe876a4904ecca4b117f4cd76db5885"
RDEPENDS:gnutls-dane = " \
 gnutls \
 p11-kit \
 unbound-libs \
 libtasn1 \
 glibc \
 libidn2 \
 libunistring \
"

URI_gnutls-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnutls-devel-3.8.9-9.el10_0.14.x86_64_v2.rpm;name=gnutls-devel;unpack=0"
SRC_URI += "${URI_gnutls-devel}"
SRC_URI[gnutls-devel.sha256sum] = "b45d7b48942fa423fa2ab542af892798a658cd4110024600d72276795b85f1de"
RDEPENDS:gnutls-devel = " \
 p11-kit-devel \
 gnutls-c++ \
 gnutls \
 gnutls-dane \
 gnutls-devel \
 libidn2-devel \
 pkgconf-pkg-config \
 libtasn1-devel \
"

URI_gnutls-fips = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnutls-fips-3.8.9-9.el10_0.14.x86_64_v2.rpm;name=gnutls-fips;unpack=0"
SRC_URI += "${URI_gnutls-fips}"
SRC_URI[gnutls-fips.sha256sum] = "c16b09f98843719af018143e61e4e3a6b5c801db27185b57135ceec8ad968758"
RDEPENDS:gnutls-fips = " \
 gnutls \
"

URI_gnutls-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnutls-utils-3.8.9-9.el10_0.14.x86_64_v2.rpm;name=gnutls-utils;unpack=0"
SRC_URI += "${URI_gnutls-utils}"
SRC_URI[gnutls-utils.sha256sum] = "7cf0611dcf1920e97c97c8df2387b72d10dc066ccf3a1b8beb48393bfaf9a19d"
RDEPENDS:gnutls-utils = " \
 glibc \
 gnutls \
 libtasn1 \
 gnutls-dane \
"
