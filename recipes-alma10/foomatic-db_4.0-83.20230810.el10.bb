# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "foomatic-db"
PE = "0"
PV = "4.0"
PR = "83.20230810.el10"
PACKAGES = "foomatic-db foomatic-db-filesystem foomatic-db-ppds"
PROVIDES = "rpm/foomatic-db rpm/foomatic-db-filesystem rpm/foomatic-db-ppds"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/foomatic-db-4.0-83.20230810.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c9350b6032e919e9ad096edc2a0d31b719dc9490f4e879cb9ca21734b7b4594d"

URI_foomatic-db = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/foomatic-db-4.0-83.20230810.el10.noarch.rpm;name=foomatic-db;unpack=0"
SRC_URI += "${URI_foomatic-db}"
SRC_URI[foomatic-db.sha256sum] = "fddd2241609ecb95753200c574816a073ff3d36a6b2c662083ba27f90d546449"
RDEPENDS:foomatic-db = " \
 foomatic-db-filesystem \
 foomatic-db-ppds \
"

URI_foomatic-db-filesystem = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/foomatic-db-filesystem-4.0-83.20230810.el10.noarch.rpm;name=foomatic-db-filesystem;unpack=0"
SRC_URI += "${URI_foomatic-db-filesystem}"
SRC_URI[foomatic-db-filesystem.sha256sum] = "8704026291f9001e792b611b3b1f41dc5a42c9dec1afc5b6b35a77bdb8572910"
RDEPENDS:foomatic-db-filesystem = ""

URI_foomatic-db-ppds = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/foomatic-db-ppds-4.0-83.20230810.el10.noarch.rpm;name=foomatic-db-ppds;unpack=0"
SRC_URI += "${URI_foomatic-db-ppds}"
SRC_URI[foomatic-db-ppds.sha256sum] = "8dd5a509edb634e5744f284a826ecb6e8ce6c8407bb775793f77ff44c46b5f67"
RDEPENDS:foomatic-db-ppds = " \
 cups \
 sed \
 foomatic-db-filesystem \
"
