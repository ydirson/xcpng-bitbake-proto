# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Canary-Stability"
PE = "0"
PV = "2013"
PR = "20.el10"
PACKAGES = "perl-Canary-Stability perl-Canary-Stability-tests"
PROVIDES = "rpm/perl-Canary-Stability rpm/perl-Canary-Stability-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Canary-Stability-2013-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dfd152325503ee7e659704d46bca51c44ef4a1cf5767ac44023f971d4bae9ee4"

URI_perl-Canary-Stability = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Canary-Stability-2013-20.el10.noarch.rpm;name=perl-Canary-Stability;unpack=0"
SRC_URI += "${URI_perl-Canary-Stability}"
SRC_URI[perl-Canary-Stability.sha256sum] = "194ee7035be0369d4510dc47e280a861de037cbb89992dc8d76b0acfbb2b00e6"
RDEPENDS:perl-Canary-Stability = " \
 perl-ExtUtils-MakeMaker \
 perl-libs \
"

URI_perl-Canary-Stability-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Canary-Stability-tests-2013-20.el10.noarch.rpm;name=perl-Canary-Stability-tests;unpack=0"
SRC_URI += "${URI_perl-Canary-Stability-tests}"
SRC_URI[perl-Canary-Stability-tests.sha256sum] = "7387fbcdc867f580e9321459e422e4ab0731f9ba27886a25b316cb009868680f"
RDEPENDS:perl-Canary-Stability-tests = " \
 perl-interpreter \
 perl-Test-Harness \
 bash \
 perl-Canary-Stability \
"
