# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Devel-CheckLib"
PE = "0"
PV = "1.16"
PR = "14.el10"
PACKAGES = "perl-Devel-CheckLib perl-Devel-CheckLib-tests"
PROVIDES = "rpm/perl-Devel-CheckLib rpm/perl-Devel-CheckLib-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Devel-CheckLib-1.16-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d2c9364fb0b3660b8cde91e3e17395dda3c1ff45f063f5900551ea911dd6032"

URI_perl-Devel-CheckLib = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Devel-CheckLib-1.16-14.el10.noarch.rpm;name=perl-Devel-CheckLib;unpack=0"
SRC_URI += "${URI_perl-Devel-CheckLib}"
SRC_URI[perl-Devel-CheckLib.sha256sum] = "48e9483735990448da8fceba21ae2f243bfff393faee784bfb51e918c62acb84"
RDEPENDS:perl-Devel-CheckLib = " \
 perl-libs \
 perl-interpreter \
 perl-vars \
 redhat-rpm-config \
 perl-Text-ParseWords \
 perl-Devel-CheckLib \
 perl-PathTools \
 perl-Exporter \
 perl-File-Temp \
"

URI_perl-Devel-CheckLib-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Devel-CheckLib-tests-1.16-14.el10.noarch.rpm;name=perl-Devel-CheckLib-tests;unpack=0"
SRC_URI += "${URI_perl-Devel-CheckLib-tests}"
SRC_URI[perl-Devel-CheckLib-tests.sha256sum] = "25247aa223f1a57f84119eab2862fd8a3014f645ec9be2b5441a283e6005108c"
RDEPENDS:perl-Devel-CheckLib-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-vars \
 perl-IO \
 perl-Capture-Tiny \
 perl-File-Temp \
 perl-Devel-CheckLib \
 bash \
 perl-PathTools \
 gcc \
 perl-interpreter \
 perl-Exporter \
 perl-lib \
"
