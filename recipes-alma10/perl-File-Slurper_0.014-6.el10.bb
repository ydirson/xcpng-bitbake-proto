# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-File-Slurper"
PE = "0"
PV = "0.014"
PR = "6.el10"
PACKAGES = "perl-File-Slurper perl-File-Slurper-tests"
PROVIDES = "rpm/perl-File-Slurper rpm/perl-File-Slurper-tests"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-File-Slurper-0.014-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "caff91f996528db8a21f8711ed9aadf60744d1b799f28fae6e5091b829599137"

URI_perl-File-Slurper = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-File-Slurper-0.014-6.el10.noarch.rpm;name=perl-File-Slurper;unpack=0"
SRC_URI += "${URI_perl-File-Slurper}"
SRC_URI[perl-File-Slurper.sha256sum] = "ced1d761edae5d771b11178e61bb1cf2ea53fd0cf705ecf99c32c974e97581ad"
RDEPENDS:perl-File-Slurper = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-Encode \
 perl-Exporter \
"

URI_perl-File-Slurper-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-File-Slurper-tests-0.014-6.el10.noarch.rpm;name=perl-File-Slurper-tests;unpack=0"
SRC_URI += "${URI_perl-File-Slurper-tests}"
SRC_URI[perl-File-Slurper-tests.sha256sum] = "a97c7ca6771e641e435971f5f6e75fc19e6c02d9a1b4df2cdb70ca32e0d2823b"
RDEPENDS:perl-File-Slurper-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Test-Warnings \
 perl-FindBin \
 bash \
 perl-PathTools \
 perl-interpreter \
 perl-File-Slurper \
 perl-File-Temp \
"
