# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "maturin"
PE = "0"
PV = "1.4.0"
PR = "3.el10"
PACKAGES = "maturin"
PROVIDES = "rpm/maturin"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/maturin-1.4.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba029c2994c817332e096b85c180aa50bb0952be0c208a3d9957ea3a0bd7c4d6"

URI_maturin = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/maturin-1.4.0-3.el10.x86_64_v2.rpm;name=maturin;unpack=0"
SRC_URI += "${URI_maturin}"
SRC_URI[maturin.sha256sum] = "abfb73fef01e2c989adb8af5a8ac4b97ace29ce0b33d3a93af73667ea7948275"
RDEPENDS:maturin = " \
 glibc \
 libgcc \
 python3 \
"
