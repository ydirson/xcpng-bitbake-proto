# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "psmisc"
PE = "0"
PV = "23.6"
PR = "8.el10"
PACKAGES = "psmisc"
PROVIDES = "rpm/psmisc"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/psmisc-23.6-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7cd0fd96ac2c599319fe48214d62705de7745be03edce1d4892484c3d95503b"

URI_psmisc = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/psmisc-23.6-8.el10.x86_64_v2.rpm;name=psmisc;unpack=0"
SRC_URI += "${URI_psmisc}"
SRC_URI[psmisc.sha256sum] = "c97e8ac9bd12fc011bb6c13edb971d075606bc4dd7684a374b16ecb6ca196359"
RDEPENDS:psmisc = " \
 glibc \
 ncurses-libs \
"
