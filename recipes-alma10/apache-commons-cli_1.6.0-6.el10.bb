# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "apache-commons-cli"
PE = "0"
PV = "1.6.0"
PR = "6.el10"
PACKAGES = "apache-commons-cli apache-commons-cli-javadoc"
PROVIDES = "rpm/apache-commons-cli rpm/apache-commons-cli-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/apache-commons-cli-1.6.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2d07a331697c837cbed13fa4ba3cb8ca003dfe177f08d791d181fb011c05193"

URI_apache-commons-cli = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/apache-commons-cli-1.6.0-6.el10.noarch.rpm;name=apache-commons-cli;unpack=0"
SRC_URI += "${URI_apache-commons-cli}"
SRC_URI[apache-commons-cli.sha256sum] = "b8ee3cb004963d02e09cd9bfbf7de6309acfbeee715061e6432fb353ab282411"
RDEPENDS:apache-commons-cli = " \
 javapackages-filesystem \
"

URI_apache-commons-cli-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/apache-commons-cli-javadoc-1.6.0-6.el10.noarch.rpm;name=apache-commons-cli-javadoc;unpack=0"
SRC_URI += "${URI_apache-commons-cli-javadoc}"
SRC_URI[apache-commons-cli-javadoc.sha256sum] = "f09c21817095b9b17793a2f0530f8c8c73c494cf70a4e62d2dead37c6235e36f"
RDEPENDS:apache-commons-cli-javadoc = " \
 javapackages-filesystem \
"
