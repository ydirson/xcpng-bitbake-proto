# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "asio"
PE = "0"
PV = "1.30.2"
PR = "2.el10"
PACKAGES = "asio-devel"
PROVIDES = "rpm/asio-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/asio-1.30.2-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4633fc818b0e3528b88d7c49911e566e6cddd51ffd536af0379ba24b87d08428"

URI_asio-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/asio-devel-1.30.2-2.el10.x86_64_v2.rpm;name=asio-devel;unpack=0"
SRC_URI += "${URI_asio-devel}"
SRC_URI[asio-devel.sha256sum] = "0222f086a11f03b320314b4c73a0b5ac9f99b748d8549059d82cd3cb3566d3ff"
RDEPENDS:asio-devel = " \
 pkgconf-pkg-config \
"
