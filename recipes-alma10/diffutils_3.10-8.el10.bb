# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "diffutils"
PE = "0"
PV = "3.10"
PR = "8.el10"
PACKAGES = "diffutils"
PROVIDES = "rpm/diffutils"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/diffutils-3.10-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "501ccdf93023df9dab2dff3afb4f70b7c8cdf232d687acc497685e4e5fce0eb8"

URI_diffutils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/diffutils-3.10-8.el10.x86_64_v2.rpm;name=diffutils;unpack=0"
SRC_URI += "${URI_diffutils}"
SRC_URI[diffutils.sha256sum] = "d8f825235c3d0d6bf1fef7e4a3644f298d45095d69056b2497df0506ca1d3d61"
RDEPENDS:diffutils = " \
 glibc \
"
