# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qdox"
PE = "0"
PV = "2.1.0"
PR = "6.el10"
PACKAGES = "qdox qdox-javadoc"
PROVIDES = "rpm/qdox rpm/qdox-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/qdox-2.1.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f30092bbe08f6d8c5209ed04313cad28ecc3315bb9cd18f34c1fad7572763a52"

URI_qdox = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qdox-2.1.0-6.el10.noarch.rpm;name=qdox;unpack=0"
SRC_URI += "${URI_qdox}"
SRC_URI[qdox.sha256sum] = "559d192f763e2fd72209aac3bffcebc2f106d1a157043f2d1eb70258fc5d29f8"
RDEPENDS:qdox = " \
 javapackages-filesystem \
"

URI_qdox-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qdox-javadoc-2.1.0-6.el10.noarch.rpm;name=qdox-javadoc;unpack=0"
SRC_URI += "${URI_qdox-javadoc}"
SRC_URI[qdox-javadoc.sha256sum] = "cf4d5e01885c6fed8c04ecb4b6f59eb37de5644b38db2eaca610321f297051d1"
RDEPENDS:qdox-javadoc = " \
 javapackages-filesystem \
"
