# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "kronosnet"
PE = "0"
PV = "1.30"
PR = "1.el10"
PACKAGES = "libknet1 libknet1-devel libnozzle1-devel"
PROVIDES = "rpm/libknet1 rpm/libknet1-devel rpm/libnozzle1-devel"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/kronosnet-1.30-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0e95b95d3b0b739de54c19b66dec344a8967245bed5b6e664637c32f1371196"

URI_libknet1 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libknet1-1.30-1.el10.x86_64_v2.rpm;name=libknet1;unpack=0"
SRC_URI += "${URI_libknet1}"
SRC_URI[libknet1.sha256sum] = "362bef23e1f0ab94de96fe5131cd6a7eb56de8c7a01128778110362b97aad294"
RDEPENDS:libknet1 = " \
 glibc \
"

URI_libknet1-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libknet1-devel-1.30-1.el10.x86_64_v2.rpm;name=libknet1-devel;unpack=0"
SRC_URI += "${URI_libknet1-devel}"
SRC_URI[libknet1-devel.sha256sum] = "58d5e2c559c2cd39db78ffd463fdaa534fa8f24297960d752f88ee9937359b83"
RDEPENDS:libknet1-devel = " \
 libknet1 \
 pkgconf-pkg-config \
"

URI_libnozzle1-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libnozzle1-devel-1.30-1.el10.x86_64_v2.rpm;name=libnozzle1-devel;unpack=0"
SRC_URI += "${URI_libnozzle1-devel}"
SRC_URI[libnozzle1-devel.sha256sum] = "226dae19cb5fcf951e61c280990dbf1eaf8a512beba24955420513a03e5c1269"
RDEPENDS:libnozzle1-devel = " \
 pkgconf-pkg-config \
"
