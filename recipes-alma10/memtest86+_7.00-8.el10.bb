# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "memtest86+"
PE = "0"
PV = "7.00"
PR = "8.el10"
PACKAGES = "memtest86+"
PROVIDES = "rpm/memtest86+"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/memtest86+-7.00-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3eee3e78315c9aa3527cc8931d7afff320e1c005eacc715131ccbed23224fbe8"

URI_memtest86+ = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/memtest86+-7.00-8.el10.x86_64_v2.rpm;name=memtest86+;unpack=0"
SRC_URI += "${URI_memtest86+}"
SRC_URI[memtest86+.sha256sum] = "7a9b57c0dd974319bc98478a1d868ea390985757dd4fbbca5312139a497cc84c"
RDEPENDS:memtest86+ = " \
 systemd-udev \
 bash \
"
