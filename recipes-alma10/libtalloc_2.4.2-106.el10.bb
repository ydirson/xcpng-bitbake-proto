# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libtalloc"
PE = "0"
PV = "2.4.2"
PR = "106.el10"
PACKAGES = "libtalloc python3-talloc libtalloc-devel python3-talloc-devel"
PROVIDES = "rpm/libtalloc rpm/python3-talloc rpm/libtalloc-devel rpm/python3-talloc-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libtalloc-2.4.2-106.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "757d1b7ad309016c65b6e88ae0a0479e5e277007a3d3faff006630f1c2d9e53c"

URI_libtalloc = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libtalloc-2.4.2-106.el10.x86_64_v2.rpm;name=libtalloc;unpack=0"
SRC_URI += "${URI_libtalloc}"
SRC_URI[libtalloc.sha256sum] = "e9783236f819cb43849c111ce6adfcd488617adf72890f7bdc22dac0db1f793b"
RDEPENDS:libtalloc = " \
 glibc \
"

URI_python3-talloc = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-talloc-2.4.2-106.el10.x86_64_v2.rpm;name=python3-talloc;unpack=0"
SRC_URI += "${URI_python3-talloc}"
SRC_URI[python3-talloc.sha256sum] = "81ee159c426f4bb6c615744306ea36150032aca26bb982a3b67cccf57a8590a1"
RDEPENDS:python3-talloc = " \
 glibc \
 python3 \
 libtalloc \
 python3-libs \
"

URI_libtalloc-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libtalloc-devel-2.4.2-106.el10.x86_64_v2.rpm;name=libtalloc-devel;unpack=0"
SRC_URI += "${URI_libtalloc-devel}"
SRC_URI[libtalloc-devel.sha256sum] = "84f821ba49a1a1d49c4942f97e427678ad0e7655821a5dbd607c3e88a39ad239"
RDEPENDS:libtalloc-devel = " \
 pkgconf-pkg-config \
 libtalloc \
"

URI_python3-talloc-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-talloc-devel-2.4.2-106.el10.x86_64_v2.rpm;name=python3-talloc-devel;unpack=0"
SRC_URI += "${URI_python3-talloc-devel}"
SRC_URI[python3-talloc-devel.sha256sum] = "72b5accef4aadb322d79b0a7b6bcb7107a1469aeb432b88a758fae54fac24cd7"
RDEPENDS:python3-talloc-devel = " \
 python3-talloc \
 pkgconf-pkg-config \
"
