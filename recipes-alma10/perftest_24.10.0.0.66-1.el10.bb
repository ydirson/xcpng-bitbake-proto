# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perftest"
PE = "0"
PV = "24.10.0.0.66"
PR = "1.el10"
PACKAGES = "perftest"
PROVIDES = "rpm/perftest"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perftest-24.10.0.0.66-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9618c10216b5af2834741f499f9adba41a0d3d13ee1468efe6f62f5c517db628"

URI_perftest = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/perftest-24.10.0.0.66-1.el10.x86_64_v2.rpm;name=perftest;unpack=0"
SRC_URI += "${URI_perftest}"
SRC_URI[perftest.sha256sum] = "dee09c0c37effa484fd760211103b915e9e9f1166261cb832c3c78183a04c070"
RDEPENDS:perftest = " \
 librdmacm \
 libibumad \
 pciutils-libs \
 libibverbs \
 glibc \
"
