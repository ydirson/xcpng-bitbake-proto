# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "augeas"
PE = "0"
PV = "1.14.2"
PR = "0.2.20240909git2de06e0.el10"
PACKAGES = "augeas augeas-libs augeas-devel augeas-bash-completion augeas-static"
PROVIDES = "rpm/augeas rpm/augeas-libs rpm/augeas-devel rpm/augeas-bash-completion rpm/augeas-static"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/augeas-1.14.2-0.2.20240909git2de06e0.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f208219a9299bd707f030433441cad73a7afdd74d501b98d58653a1482bf54b6"

URI_augeas = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/augeas-1.14.2-0.2.20240909git2de06e0.el10.x86_64_v2.rpm;name=augeas;unpack=0"
SRC_URI += "${URI_augeas}"
SRC_URI[augeas.sha256sum] = "ec66d116ab931109d5b21851bd87cb687296f6ae26503808dfe2c69594810a66"
RDEPENDS:augeas = " \
 glibc \
 libgcc \
 readline \
 augeas-libs \
"

URI_augeas-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/augeas-libs-1.14.2-0.2.20240909git2de06e0.el10.x86_64_v2.rpm;name=augeas-libs;unpack=0"
SRC_URI += "${URI_augeas-libs}"
SRC_URI[augeas-libs.sha256sum] = "0cbe769e503218d7f9b03a36e51ac9e67c1206d5b62de98c68ed09d66bededda"
RDEPENDS:augeas-libs = " \
 glibc \
 libselinux \
 libxml2 \
"

URI_augeas-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/augeas-devel-1.14.2-0.2.20240909git2de06e0.el10.x86_64_v2.rpm;name=augeas-devel;unpack=0"
SRC_URI += "${URI_augeas-devel}"
SRC_URI[augeas-devel.sha256sum] = "ed86d0529e54df3265d9cff61ecceb9bc94f07e206dbc2a371a9fc312d28a004"
RDEPENDS:augeas-devel = " \
 libxml2-devel \
 libselinux-devel \
 pkgconf-pkg-config \
 augeas-libs \
"

URI_augeas-bash-completion = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/augeas-bash-completion-1.14.2-0.2.20240909git2de06e0.el10.noarch.rpm;name=augeas-bash-completion;unpack=0"
SRC_URI += "${URI_augeas-bash-completion}"
SRC_URI[augeas-bash-completion.sha256sum] = "e7d9e32a7c6b714de1899692f642cf2469dd04715c3c1f8199fd7fed2a98c654"
RDEPENDS:augeas-bash-completion = " \
 augeas \
 bash-completion \
"

URI_augeas-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/augeas-static-1.14.2-0.2.20240909git2de06e0.el10.x86_64_v2.rpm;name=augeas-static;unpack=0"
SRC_URI += "${URI_augeas-static}"
SRC_URI[augeas-static.sha256sum] = "d2b8e6a36bf631242b0de6b4ee36570d1e112138f053d95c7b3676ab74f71b0f"
RDEPENDS:augeas-static = " \
 augeas-devel \
"
