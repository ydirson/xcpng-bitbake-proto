# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "espeak-ng"
PE = "0"
PV = "1.51.1"
PR = "10.el10"
PACKAGES = "espeak-ng espeak-ng-devel espeak-ng-doc espeak-ng-vim"
PROVIDES = "rpm/espeak-ng rpm/espeak-ng-devel rpm/espeak-ng-doc rpm/espeak-ng-vim"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/espeak-ng-1.51.1-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3c9c77e407cfffddd3c267682cb400ddb67921e65f5e0d55f816e8b3fd1eb8d"

URI_espeak-ng = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/espeak-ng-1.51.1-10.el10.x86_64_v2.rpm;name=espeak-ng;unpack=0"
SRC_URI += "${URI_espeak-ng}"
SRC_URI[espeak-ng.sha256sum] = "ec21f6ca495e3c28ebf078f95068c4304fc2950ed4c560cbd05b0eecef7ad992"
RDEPENDS:espeak-ng = " \
 glibc \
 libgcc \
 libstdc++ \
 pcaudiolib \
"

URI_espeak-ng-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/espeak-ng-devel-1.51.1-10.el10.x86_64_v2.rpm;name=espeak-ng-devel;unpack=0"
SRC_URI += "${URI_espeak-ng-devel}"
SRC_URI[espeak-ng-devel.sha256sum] = "565fa28bc7d41857bfc2dce9a5ffba57a5d246af285fc73663a0ae679b790765"
RDEPENDS:espeak-ng-devel = " \
 espeak-ng \
 pkgconf-pkg-config \
"

URI_espeak-ng-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/espeak-ng-doc-1.51.1-10.el10.noarch.rpm;name=espeak-ng-doc;unpack=0"
SRC_URI += "${URI_espeak-ng-doc}"
SRC_URI[espeak-ng-doc.sha256sum] = "8b3fa2371d571da614cedff3259e40599d89706637c37791e59cc52f013e4586"
RDEPENDS:espeak-ng-doc = " \
 espeak-ng \
"

URI_espeak-ng-vim = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/espeak-ng-vim-1.51.1-10.el10.noarch.rpm;name=espeak-ng-vim;unpack=0"
SRC_URI += "${URI_espeak-ng-vim}"
SRC_URI[espeak-ng-vim.sha256sum] = "6d082223202d267338e95793a4c97dd94364af6bb9886a81d7bd41f74c741197"
RDEPENDS:espeak-ng-vim = " \
 espeak-ng \
"
