# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Module-Manifest-Skip"
PE = "0"
PV = "0.23"
PR = "32.el10"
PACKAGES = "perl-Module-Manifest-Skip perl-Module-Manifest-Skip-tests"
PROVIDES = "rpm/perl-Module-Manifest-Skip rpm/perl-Module-Manifest-Skip-tests"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-Module-Manifest-Skip-0.23-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "412ecc7b36a636c593b99ed62cfa8bc39f9addb26e7d0e6622ec44e881a5a0c4"

URI_perl-Module-Manifest-Skip = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Module-Manifest-Skip-0.23-32.el10.noarch.rpm;name=perl-Module-Manifest-Skip;unpack=0"
SRC_URI += "${URI_perl-Module-Manifest-Skip}"
SRC_URI[perl-Module-Manifest-Skip.sha256sum] = "6241f3f989762becbd516af2c39eaf2590869e7a77d28c79c4d88ddbd08b65aa"
RDEPENDS:perl-Module-Manifest-Skip = " \
 perl-File-ShareDir \
 perl-PathTools \
 perl-libs \
 perl-Moo \
"

URI_perl-Module-Manifest-Skip-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Module-Manifest-Skip-tests-0.23-32.el10.noarch.rpm;name=perl-Module-Manifest-Skip-tests;unpack=0"
SRC_URI += "${URI_perl-Module-Manifest-Skip-tests}"
SRC_URI[perl-Module-Manifest-Skip-tests.sha256sum] = "b31aa6c059ea452a99aaca27d2caea194250de15056278fbff4c403afc835f08"
RDEPENDS:perl-Module-Manifest-Skip-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Module-Manifest-Skip \
 bash \
 perl-base \
 perl-PathTools \
 coreutils \
 perl-interpreter \
 perl-Exporter \
 perl-lib \
"
