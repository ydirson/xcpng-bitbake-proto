# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "psacct"
PE = "0"
PV = "6.6.4"
PR = "24.el10"
PACKAGES = "psacct"
PROVIDES = "rpm/psacct"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/psacct-6.6.4-24.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c7a67a7ab8fb77888de9f30d8086f665cead1561f0565a897c776ac0d0f1426"

URI_psacct = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/psacct-6.6.4-24.el10.x86_64_v2.rpm;name=psacct;unpack=0"
SRC_URI += "${URI_psacct}"
SRC_URI[psacct.sha256sum] = "e98392d64f774a54cec03b0ef0138e0791c4a3914618e3727b766d78edccb11d"
RDEPENDS:psacct = " \
 glibc \
 coreutils \
 systemd \
 bash \
"
