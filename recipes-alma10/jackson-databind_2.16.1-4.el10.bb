# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jackson-databind"
PE = "0"
PV = "2.16.1"
PR = "4.el10"
PACKAGES = "jackson-databind"
PROVIDES = "rpm/jackson-databind"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/jackson-databind-2.16.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e5a62e9cc4277eefb7bc2db831d462cc334dfb87189a7a30afb0256505855ba"

URI_jackson-databind = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/jackson-databind-2.16.1-4.el10.noarch.rpm;name=jackson-databind;unpack=0"
SRC_URI += "${URI_jackson-databind}"
SRC_URI[jackson-databind.sha256sum] = "be70d84e96c6922349d2f6befa4df6f849bcd6447721da25be4f4e0766f8b260"
RDEPENDS:jackson-databind = " \
 jackson-core \
 java-21-openjdk-headless \
 javapackages-filesystem \
 jackson-annotations \
"
