# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libmng"
PE = "0"
PV = "2.0.3"
PR = "23.el10"
PACKAGES = "libmng libmng-devel"
PROVIDES = "rpm/libmng rpm/libmng-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libmng-2.0.3-23.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1165ca10258fb4e944156ddc2c8f001acc3d393ad0babd5f529fc9b4b17c298"

URI_libmng = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libmng-2.0.3-23.el10.x86_64_v2.rpm;name=libmng;unpack=0"
SRC_URI += "${URI_libmng}"
SRC_URI[libmng.sha256sum] = "5f7dacb59d11b3222e3420b97c38b8a12ce723f1ce8e81c79c391e480e2506f1"
RDEPENDS:libmng = " \
 glibc \
 lcms2 \
 zlib-ng-compat \
 libjpeg-turbo \
"

URI_libmng-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libmng-devel-2.0.3-23.el10.x86_64_v2.rpm;name=libmng-devel;unpack=0"
SRC_URI += "${URI_libmng-devel}"
SRC_URI[libmng-devel.sha256sum] = "13fb568ffb40032dfb51dce65dc62622b0d48a87b6c64c08287907763b43ae1c"
RDEPENDS:libmng-devel = " \
 zlib-ng-compat-devel \
 libmng \
 pkgconf-pkg-config \
 libjpeg-turbo-devel \
"
