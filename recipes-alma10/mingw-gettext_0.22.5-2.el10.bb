# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mingw-gettext"
PE = "0"
PV = "0.22.5"
PR = "2.el10"
PACKAGES = "mingw32-gettext mingw32-gettext-static mingw64-gettext mingw64-gettext-static"
PROVIDES = "rpm/mingw32-gettext rpm/mingw32-gettext-static rpm/mingw64-gettext rpm/mingw64-gettext-static"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/mingw-gettext-0.22.5-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ce35be21b7411f2e466a5b3927200a6e67b2ecf6c7a7bd8502ad4ce27fe9197"

URI_mingw32-gettext = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw32-gettext-0.22.5-2.el10.noarch.rpm;name=mingw32-gettext;unpack=0"
SRC_URI += "${URI_mingw32-gettext}"
SRC_URI[mingw32-gettext.sha256sum] = "e9f5ee7c4d5aeca440b4f5c22ed3483cb32ded79446ef9115a972d52e7c5683b"
RDEPENDS:mingw32-gettext = " \
 mingw32-libstdc++ \
 mingw32-termcap \
 mingw32-win-iconv \
 bash \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-libgcc \
"

URI_mingw32-gettext-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw32-gettext-static-0.22.5-2.el10.noarch.rpm;name=mingw32-gettext-static;unpack=0"
SRC_URI += "${URI_mingw32-gettext-static}"
SRC_URI[mingw32-gettext-static.sha256sum] = "0d5b6173f9f9494c0162c2282740f1fef0f4ebbc65aa9edf1b587d51291a38a3"
RDEPENDS:mingw32-gettext-static = " \
 mingw32-gettext \
"

URI_mingw64-gettext = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw64-gettext-0.22.5-2.el10.noarch.rpm;name=mingw64-gettext;unpack=0"
SRC_URI += "${URI_mingw64-gettext}"
SRC_URI[mingw64-gettext.sha256sum] = "8c5702b0564d39add67758de6038693e9846cae844e183cc3f68b31b7b2ab1f6"
RDEPENDS:mingw64-gettext = " \
 mingw64-crt \
 mingw64-filesystem \
 bash \
 mingw64-libstdc++ \
 mingw64-termcap \
 mingw64-win-iconv \
"

URI_mingw64-gettext-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw64-gettext-static-0.22.5-2.el10.noarch.rpm;name=mingw64-gettext-static;unpack=0"
SRC_URI += "${URI_mingw64-gettext-static}"
SRC_URI[mingw64-gettext-static.sha256sum] = "2828eadba7ed7d6fc8edb2b4853371beb951ebe1172d95ec5480bfb5880b8313"
RDEPENDS:mingw64-gettext-static = " \
 mingw64-gettext \
"
