# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Compress-Bzip2"
PE = "0"
PV = "2.28"
PR = "21.el10"
PACKAGES = "perl-Compress-Bzip2 perl-Compress-Bzip2-tests"
PROVIDES = "rpm/perl-Compress-Bzip2 rpm/perl-Compress-Bzip2-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Compress-Bzip2-2.28-21.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "459acab7a24e44a2ca7b242cabff647c5dfc24b6d8fded4884842e9def9054b6"

URI_perl-Compress-Bzip2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Compress-Bzip2-2.28-21.el10.x86_64_v2.rpm;name=perl-Compress-Bzip2;unpack=0"
SRC_URI += "${URI_perl-Compress-Bzip2}"
SRC_URI[perl-Compress-Bzip2.sha256sum] = "35d79baa95a15670513365bd03a594adb22ffaa5bb94ea9daf1d8e2c70958109"
RDEPENDS:perl-Compress-Bzip2 = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 bzip2-libs \
 perl-Fcntl \
 perl-Getopt-Std \
 perl-AutoLoader \
 glibc \
 perl-Exporter \
"

URI_perl-Compress-Bzip2-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Compress-Bzip2-tests-2.28-21.el10.noarch.rpm;name=perl-Compress-Bzip2-tests;unpack=0"
SRC_URI += "${URI_perl-Compress-Bzip2-tests}"
SRC_URI[perl-Compress-Bzip2-tests.sha256sum] = "8fc234951d21417dd8afaad80f24e321e3880b2693c1af6d1b90c64ab19350ff"
RDEPENDS:perl-Compress-Bzip2-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 bzip2 \
 perl-Compress-Bzip2 \
 perl-Fcntl \
 perl-File-Copy \
 bash \
 perl-PathTools \
 coreutils \
 perl-interpreter \
"
