# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rubygem-rspec-expectations"
PE = "0"
PV = "3.13.0"
PR = "3.el10"
PACKAGES = "rubygem-rspec-expectations rubygem-rspec-expectations-doc"
PROVIDES = "rpm/rubygem-rspec-expectations rpm/rubygem-rspec-expectations-doc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/rubygem-rspec-expectations-3.13.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "787c8876a6b56ed609b69d0275889434eb133ccc9836f7c6513cf09f0460db68"

URI_rubygem-rspec-expectations = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/rubygem-rspec-expectations-3.13.0-3.el10.noarch.rpm;name=rubygem-rspec-expectations;unpack=0"
SRC_URI += "${URI_rubygem-rspec-expectations}"
SRC_URI[rubygem-rspec-expectations.sha256sum] = "ff5bed8bb05ef080d4dc87ba6e7e846f2b597eb169556ce3736fb95c3b347954"
RDEPENDS:rubygem-rspec-expectations = " \
 rubygems \
 rubygem-rspec-support \
 rubygem-diff-lcs \
"

URI_rubygem-rspec-expectations-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-rspec-expectations-doc-3.13.0-3.el10.noarch.rpm;name=rubygem-rspec-expectations-doc;unpack=0"
SRC_URI += "${URI_rubygem-rspec-expectations-doc}"
SRC_URI[rubygem-rspec-expectations-doc.sha256sum] = "bc5ab9a7dc2011e2ed7c7618242ee0c5a8f1ed4b511c90d18f23581067e17391"
RDEPENDS:rubygem-rspec-expectations-doc = " \
 rubygem-rspec-expectations \
"
