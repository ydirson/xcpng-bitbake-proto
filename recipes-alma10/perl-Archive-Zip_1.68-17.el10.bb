# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Archive-Zip"
PE = "0"
PV = "1.68"
PR = "17.el10"
PACKAGES = "perl-Archive-Zip perl-Archive-Zip-tests"
PROVIDES = "rpm/perl-Archive-Zip rpm/perl-Archive-Zip-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Archive-Zip-1.68-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c323ff2cd8b13352af74bcd2b2589677448c5b09099dd248133dc2a59e8b13f1"

URI_perl-Archive-Zip = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Archive-Zip-1.68-17.el10.noarch.rpm;name=perl-Archive-Zip;unpack=0"
SRC_URI += "${URI_perl-Archive-Zip}"
SRC_URI[perl-Archive-Zip.sha256sum] = "ce9feae604b05530be7795a673c1594b0e001a71fe59c13f5b9a52ff76c4cb5f"
RDEPENDS:perl-Archive-Zip = " \
 perl-libs \
 perl-FileHandle \
 perl-Archive-Zip \
 perl-Carp \
 perl-vars \
 perl-IO \
 perl-Compress-Raw-Zlib \
 perl-lib \
 perl-Time-Local \
 perl-Encode \
 perl-Exporter \
 perl-constant \
 perl-File-Basename \
 perl-File-Copy \
 perl-PathTools \
 perl-File-Find \
 perl-interpreter \
 perl-File-Path \
 perl-File-Temp \
"

URI_perl-Archive-Zip-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Archive-Zip-tests-1.68-17.el10.noarch.rpm;name=perl-Archive-Zip-tests;unpack=0"
SRC_URI += "${URI_perl-Archive-Zip-tests}"
SRC_URI[perl-Archive-Zip-tests.sha256sum] = "2df0e93e40bfc7de1aae39536503a01358092998b841178be2e7832cf4bff68c"
RDEPENDS:perl-Archive-Zip-tests = " \
 perl-constant \
 zip \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Carp \
 perl-IO \
 unzip \
 perl-IO-Compress \
 perl-Archive-Zip \
 perl-File-Temp \
 bash \
 perl-PathTools \
 perl-File-Find \
 perl-interpreter \
 perl-File-Path \
 perl-Exporter \
 perl-lib \
"
