# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sysfsutils"
PE = "0"
PV = "2.1.1"
PR = "14.el10"
PACKAGES = "libsysfs sysfsutils libsysfs-devel"
PROVIDES = "rpm/libsysfs rpm/sysfsutils rpm/libsysfs-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/sysfsutils-2.1.1-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "497a44a969634395fd31cf14a5812d82d84c98fd3df4ac3e867b4db03b1c8eb9"

URI_libsysfs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libsysfs-2.1.1-14.el10.x86_64_v2.rpm;name=libsysfs;unpack=0"
SRC_URI += "${URI_libsysfs}"
SRC_URI[libsysfs.sha256sum] = "90f6651750a89f481f297c46898e5c0c85986fd792691c8b2867abb0b4eb2756"
RDEPENDS:libsysfs = " \
 glibc \
"

URI_sysfsutils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sysfsutils-2.1.1-14.el10.x86_64_v2.rpm;name=sysfsutils;unpack=0"
SRC_URI += "${URI_sysfsutils}"
SRC_URI[sysfsutils.sha256sum] = "9f4e23ab77c8f8e230383616b7b49cf6183de666d5872836cb58694ddfae505d"
RDEPENDS:sysfsutils = " \
 glibc \
 libsysfs \
"

URI_libsysfs-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libsysfs-devel-2.1.1-14.el10.x86_64_v2.rpm;name=libsysfs-devel;unpack=0"
SRC_URI += "${URI_libsysfs-devel}"
SRC_URI[libsysfs-devel.sha256sum] = "e66da9a5658ea4ae80dc9e292a584c0d9e46cdb93ed2aa9feefb0eb643ce6676"
RDEPENDS:libsysfs-devel = " \
 libsysfs \
 pkgconf-pkg-config \
"
