# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-ko"
PE = "0"
PV = "0.7.0"
PR = "21.el10"
PACKAGES = "hunspell-ko"
PROVIDES = "rpm/hunspell-ko"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-ko-0.7.0-21.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53d69df68a8c629987fcc792bcc973fb030653497e89854f74ee26d2bbe068e4"

URI_hunspell-ko = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-ko-0.7.0-21.el10.noarch.rpm;name=hunspell-ko;unpack=0"
SRC_URI += "${URI_hunspell-ko}"
SRC_URI[hunspell-ko.sha256sum] = "5a7e24be9b90c98216c0870e883f9297c1dddc4cc9f0b6d3b48064a138ee8381"
RDEPENDS:hunspell-ko = " \
 hunspell-filesystem \
"
