# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Crypt-PasswdMD5"
PE = "0"
PV = "1.4.1"
PR = "3.el10"
PACKAGES = "perl-Crypt-PasswdMD5"
PROVIDES = "rpm/perl-Crypt-PasswdMD5"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-Crypt-PasswdMD5-1.4.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e40b8e4065531111a55be31708482195fa30473c0d6247dc83313cc2d6df01b4"

URI_perl-Crypt-PasswdMD5 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Crypt-PasswdMD5-1.4.1-3.el10.noarch.rpm;name=perl-Crypt-PasswdMD5;unpack=0"
SRC_URI += "${URI_perl-Crypt-PasswdMD5}"
SRC_URI[perl-Crypt-PasswdMD5.sha256sum] = "fab70b6af22f4a1c120b3485c2ca1ea54589558e2b5387a5d5191806371951ab"
RDEPENDS:perl-Crypt-PasswdMD5 = " \
 perl-Digest-MD5 \
 perl-Exporter \
 perl-libs \
 perl-libs \
"
