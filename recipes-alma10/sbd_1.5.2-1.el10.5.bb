# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sbd"
PE = "0"
PV = "1.5.2"
PR = "1.el10.5"
PACKAGES = "sbd sbd-tests"
PROVIDES = "rpm/sbd rpm/sbd-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/sbd-1.5.2-1.el10.5.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ee905b192911bdb909c69a39bb546149f17783ba149b0f74afe02f4cc5b8965"

URI_sbd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sbd-1.5.2-1.el10.5.x86_64_v2.rpm;name=sbd;unpack=0"
SRC_URI += "${URI_sbd}"
SRC_URI[sbd.sha256sum] = "6f37642ae3cc2cb9b597e43d2fe4cfef1289c99fbe55f3574000b8f377c6a423"
RDEPENDS:sbd = " \
 libqb \
 libuuid \
 systemd \
 libaio \
 pacemaker-libs \
 pacemaker-cluster-libs \
 corosynclib \
 pkgconf-pkg-config \
 bash \
 glib2 \
 glibc \
"

URI_sbd-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sbd-tests-1.5.2-1.el10.5.x86_64_v2.rpm;name=sbd-tests;unpack=0"
SRC_URI += "${URI_sbd-tests}"
SRC_URI[sbd-tests.sha256sum] = "a5f84906ade96183f4d1c93dee54c28b9c8824d1b9050e4a004784303cfdd5b8"
RDEPENDS:sbd-tests = " \
 libqb \
 libuuid \
 libaio \
 pacemaker-cluster-libs \
 pacemaker-libs \
 corosynclib \
 libxml2 \
 bash \
 glib2 \
 glibc \
"
