# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Module-Runtime"
PE = "0"
PV = "0.016"
PR = "24.el10"
PACKAGES = "perl-Module-Runtime perl-Module-Runtime-tests"
PROVIDES = "rpm/perl-Module-Runtime rpm/perl-Module-Runtime-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Module-Runtime-0.016-24.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb4e4a0e7583e30fbc8aca9b44ab0df08f7f46ca2d51f74aa1752935153b480d"

URI_perl-Module-Runtime = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Module-Runtime-0.016-24.el10.noarch.rpm;name=perl-Module-Runtime;unpack=0"
SRC_URI += "${URI_perl-Module-Runtime}"
SRC_URI[perl-Module-Runtime.sha256sum] = "12207527d7822fa2bf80666543990efe8ff1773a0f5e77517287a120704c873b"
RDEPENDS:perl-Module-Runtime = " \
 perl-libs \
"

URI_perl-Module-Runtime-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Module-Runtime-tests-0.016-24.el10.noarch.rpm;name=perl-Module-Runtime-tests;unpack=0"
SRC_URI += "${URI_perl-Module-Runtime-tests}"
SRC_URI[perl-Module-Runtime-tests.sha256sum] = "1edbb37698aaaf5fff79db9b6e2b02ab29f5f0fe5b4039fe491e937f45aa3cd1"
RDEPENDS:perl-Module-Runtime-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Module-Runtime \
 bash \
 perl-interpreter \
"
