# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Encode-EUCJPASCII"
PE = "0"
PV = "0.03"
PR = "45.el10"
PACKAGES = "perl-Encode-EUCJPASCII perl-Encode-EUCJPASCII-tests"
PROVIDES = "rpm/perl-Encode-EUCJPASCII rpm/perl-Encode-EUCJPASCII-tests"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-Encode-EUCJPASCII-0.03-45.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e7970278a37fe4b352ceb8f8a3c91facfb31c7b354088d6ea13dff93f3935d5"

URI_perl-Encode-EUCJPASCII = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Encode-EUCJPASCII-0.03-45.el10.x86_64_v2.rpm;name=perl-Encode-EUCJPASCII;unpack=0"
SRC_URI += "${URI_perl-Encode-EUCJPASCII}"
SRC_URI[perl-Encode-EUCJPASCII.sha256sum] = "e14dd2321d4a1339da355f4a42300cad3ea3a9666a832dae2eeabf0ea2aec387"
RDEPENDS:perl-Encode-EUCJPASCII = " \
 perl-libs \
 perl-libs \
 perl-Encode \
 glibc \
 perl-base \
"

URI_perl-Encode-EUCJPASCII-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Encode-EUCJPASCII-tests-0.03-45.el10.x86_64_v2.rpm;name=perl-Encode-EUCJPASCII-tests;unpack=0"
SRC_URI += "${URI_perl-Encode-EUCJPASCII-tests}"
SRC_URI[perl-Encode-EUCJPASCII-tests.sha256sum] = "095972abb453994c64ebbce0156d69344a1980db9caa67e784905e5e3dcdcdbd"
RDEPENDS:perl-Encode-EUCJPASCII-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 bash \
 perl-Encode-EUCJPASCII \
 perl-interpreter \
"
