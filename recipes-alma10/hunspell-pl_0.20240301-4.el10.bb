# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-pl"
PE = "0"
PV = "0.20240301"
PR = "4.el10"
PACKAGES = "hunspell-pl"
PROVIDES = "rpm/hunspell-pl"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-pl-0.20240301-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c823c1b3abf7c1e54c98980461161071a6285fa3b60e58970efff157c124d39"

URI_hunspell-pl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-pl-0.20240301-4.el10.noarch.rpm;name=hunspell-pl;unpack=0"
SRC_URI += "${URI_hunspell-pl}"
SRC_URI[hunspell-pl.sha256sum] = "4f9948654e40426bae6f8678f54bb4f3ad253f8a13501f214103f97368856ab2"
RDEPENDS:hunspell-pl = " \
 hunspell \
"
