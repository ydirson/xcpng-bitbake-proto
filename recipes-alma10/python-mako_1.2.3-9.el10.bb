# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-mako"
PE = "0"
PV = "1.2.3"
PR = "9.el10"
PACKAGES = "python3-mako"
PROVIDES = "rpm/python3-mako"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-mako-1.2.3-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "08e9dcd95b2dc230d7092dce925933ba01a999826beecfe0c3dadf3002584543"

URI_python3-mako = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-mako-1.2.3-9.el10.noarch.rpm;name=python3-mako;unpack=0"
SRC_URI += "${URI_python3-mako}"
SRC_URI[python3-mako.sha256sum] = "e5f25b78e1174e1d8426e33282b5ec26a4be221793a86615ed53075d9b9cb8e4"
RDEPENDS:python3-mako = " \
 python3 \
 python3-markupsafe \
"
