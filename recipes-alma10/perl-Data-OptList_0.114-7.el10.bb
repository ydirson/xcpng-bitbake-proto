# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Data-OptList"
PE = "0"
PV = "0.114"
PR = "7.el10"
PACKAGES = "perl-Data-OptList perl-Data-OptList-tests"
PROVIDES = "rpm/perl-Data-OptList rpm/perl-Data-OptList-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Data-OptList-0.114-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a0425c2ee72a2ea0f6d4e8c2bcd3dd55a28f3d070807b5cb30fa4cfa1df02f3"

URI_perl-Data-OptList = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Data-OptList-0.114-7.el10.noarch.rpm;name=perl-Data-OptList;unpack=0"
SRC_URI += "${URI_perl-Data-OptList}"
SRC_URI[perl-Data-OptList.sha256sum] = "17d77bab02dba929a5be184e62880e37c910c973863d679a3de19a385296d919"
RDEPENDS:perl-Data-OptList = " \
 perl-Sub-Install \
 perl-Params-Util \
 perl-Scalar-List-Utils \
 perl-libs \
"

URI_perl-Data-OptList-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Data-OptList-tests-0.114-7.el10.noarch.rpm;name=perl-Data-OptList-tests;unpack=0"
SRC_URI += "${URI_perl-Data-OptList-tests}"
SRC_URI[perl-Data-OptList-tests.sha256sum] = "376033246a965d592760b6c127eca03aa47aae0320df6de2c3c2e58ee2699ab0"
RDEPENDS:perl-Data-OptList-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-ExtUtils-MakeMaker \
 perl-Test-Simple \
 perl-Sub-Install \
 perl-PathTools \
 bash \
 perl-interpreter \
 perl-Data-OptList \
"
