# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libecpg"
PE = "0"
PV = "16.1"
PR = "14.el10_0"
PACKAGES = "libecpg libpgtypes libecpg-devel"
PROVIDES = "rpm/libecpg rpm/libpgtypes rpm/libecpg-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libecpg-16.1-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5360f9ee85e182b17865958a74e712fc17860ddf58b216d64c96fe3e0cd144a"

URI_libecpg = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libecpg-16.1-14.el10_0.x86_64_v2.rpm;name=libecpg;unpack=0"
SRC_URI += "${URI_libecpg}"
SRC_URI[libecpg.sha256sum] = "89fec9585275e5e74e188f60b117418376478bb98acda1d4f3c054fc06095671"
RDEPENDS:libecpg = " \
 glibc \
 libpgtypes \
 libpq \
"

URI_libpgtypes = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libpgtypes-16.1-14.el10_0.x86_64_v2.rpm;name=libpgtypes;unpack=0"
SRC_URI += "${URI_libpgtypes}"
SRC_URI[libpgtypes.sha256sum] = "77271110eaa19526855b49f4bbb0791f275aecb999d86ed316acba6caa5de8af"
RDEPENDS:libpgtypes = " \
 glibc \
"

URI_libecpg-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libecpg-devel-16.1-14.el10_0.x86_64_v2.rpm;name=libecpg-devel;unpack=0"
SRC_URI += "${URI_libecpg-devel}"
SRC_URI[libecpg-devel.sha256sum] = "ef1f86222de72f57980c3c6427339bc90434783512c9978f1ad9a42b63fcbea2"
RDEPENDS:libecpg-devel = " \
 libecpg \
 pkgconf-pkg-config \
 libpgtypes \
 libecpg-devel \
 glibc \
 libpq-devel \
"
