# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Sub-Install"
PE = "0"
PV = "0.929"
PR = "8.el10"
PACKAGES = "perl-Sub-Install perl-Sub-Install-tests"
PROVIDES = "rpm/perl-Sub-Install rpm/perl-Sub-Install-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Sub-Install-0.929-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a63fe870fc1b3f428623eb616035862308489e106bd5a360a1e6fef51f7fa7cf"

URI_perl-Sub-Install = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Sub-Install-0.929-8.el10.noarch.rpm;name=perl-Sub-Install;unpack=0"
SRC_URI += "${URI_perl-Sub-Install}"
SRC_URI[perl-Sub-Install.sha256sum] = "92cb80f1f0a99a083dfa317fc12b0af726536ae91a0f07a11d4ac62b760d81d7"
RDEPENDS:perl-Sub-Install = " \
 perl-B \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
"

URI_perl-Sub-Install-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Sub-Install-tests-0.929-8.el10.noarch.rpm;name=perl-Sub-Install-tests;unpack=0"
SRC_URI += "${URI_perl-Sub-Install-tests}"
SRC_URI[perl-Sub-Install-tests.sha256sum] = "e5bab7c73d6cd1fabbe43d1b8b66e59b029a9d7e0775d8fe0bd030e2b25446f8"
RDEPENDS:perl-Sub-Install-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-ExtUtils-MakeMaker \
 perl-Scalar-List-Utils \
 perl-Sub-Install \
 bash \
 perl-PathTools \
 perl-interpreter \
"
