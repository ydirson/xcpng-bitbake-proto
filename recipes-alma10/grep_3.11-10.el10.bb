# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "grep"
PE = "0"
PV = "3.11"
PR = "10.el10"
PACKAGES = "grep"
PROVIDES = "rpm/grep"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/grep-3.11-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3745576ba23183034076504856d70d771b3c27cac662ef18fd5e01b8828a264f"

URI_grep = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/grep-3.11-10.el10.x86_64_v2.rpm;name=grep;unpack=0"
SRC_URI += "${URI_grep}"
SRC_URI[grep.sha256sum] = "b0c5ef874347ff443b763d42bbc7f102c7ed19ab01436839e163cd0f0f3a5f7a"
RDEPENDS:grep = " \
 glibc \
 bash \
 pcre2 \
"
