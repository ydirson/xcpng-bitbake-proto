# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Module-Install-GithubMeta"
PE = "0"
PV = "0.30"
PR = "29.el10"
PACKAGES = "perl-Module-Install-GithubMeta"
PROVIDES = "rpm/perl-Module-Install-GithubMeta"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-Module-Install-GithubMeta-0.30-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de81e9644b73fa439a9150c839fac8283ee591027b954ca756209c243c8a08e5"

URI_perl-Module-Install-GithubMeta = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Module-Install-GithubMeta-0.30-29.el10.noarch.rpm;name=perl-Module-Install-GithubMeta;unpack=0"
SRC_URI += "${URI_perl-Module-Install-GithubMeta}"
SRC_URI[perl-Module-Install-GithubMeta.sha256sum] = "53f08edcef1760fc2e8cdac3d42eb8f5eb24499cc0c99b940b96630df0a8fbf4"
RDEPENDS:perl-Module-Install-GithubMeta = " \
 perl-libs \
 perl-vars \
 perl-Module-Install \
 perl-PathTools \
 perl-base \
"
