# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lua"
PE = "0"
PV = "5.4.6"
PR = "7.el10"
PACKAGES = "lua-libs lua lua-devel lua-static"
PROVIDES = "rpm/lua-libs rpm/lua rpm/lua-devel rpm/lua-static"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/lua-5.4.6-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a1dcfcad7f371256f2f79ce4760e483fa1522d134cf898441302a13e8bcde9d"

URI_lua-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/lua-libs-5.4.6-7.el10.x86_64_v2.rpm;name=lua-libs;unpack=0"
SRC_URI += "${URI_lua-libs}"
SRC_URI[lua-libs.sha256sum] = "30d7e104d9990207bd6b279a47ad2d4d1bc6edf3f557916c18d40a6f50789cb8"
RDEPENDS:lua-libs = " \
 glibc \
"

URI_lua = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lua-5.4.6-7.el10.x86_64_v2.rpm;name=lua;unpack=0"
SRC_URI += "${URI_lua}"
SRC_URI[lua.sha256sum] = "3bb22b4928f4361b335191e3f492696867b8943d8a9b94e120fcd152c784c53b"
RDEPENDS:lua = " \
 glibc \
 readline \
 lua-libs \
"

URI_lua-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/lua-devel-5.4.6-7.el10.x86_64_v2.rpm;name=lua-devel;unpack=0"
SRC_URI += "${URI_lua-devel}"
SRC_URI[lua-devel.sha256sum] = "1ffc5144829f971b2818caffdd958e8496c010e29847fef0710191a5e632b086"
RDEPENDS:lua-devel = " \
 lua \
 pkgconf-pkg-config \
 lua-rpm-macros \
"

URI_lua-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/lua-static-5.4.6-7.el10.x86_64_v2.rpm;name=lua-static;unpack=0"
SRC_URI += "${URI_lua-static}"
SRC_URI[lua-static.sha256sum] = "a6028f3c484f5d588f222c7252290ec8d7aeedad70aceb39e42f093a87d24dbb"
RDEPENDS:lua-static = " \
 lua \
"
