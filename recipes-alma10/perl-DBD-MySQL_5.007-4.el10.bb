# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-DBD-MySQL"
PE = "0"
PV = "5.007"
PR = "4.el10"
PACKAGES = "perl-DBD-MySQL perl-DBD-MySQL-tests"
PROVIDES = "rpm/perl-DBD-MySQL rpm/perl-DBD-MySQL-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-DBD-MySQL-5.007-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "044be0633d025f4dad85783c7f35671f604b2e1d9307e9840cced1e754714755"

URI_perl-DBD-MySQL = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-DBD-MySQL-5.007-4.el10.x86_64_v2.rpm;name=perl-DBD-MySQL;unpack=0"
SRC_URI += "${URI_perl-DBD-MySQL}"
SRC_URI[perl-DBD-MySQL.sha256sum] = "54839d473702ff86226699cf1d4487294c2e6334b8ad2f16c0db629fb02db369"
RDEPENDS:perl-DBD-MySQL = " \
 perl-libs \
 perl-Carp \
 perl-DynaLoader \
 perl-DBI \
 perl-DBD-MySQL \
 glibc \
 mysql8.4-libs \
"

URI_perl-DBD-MySQL-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-DBD-MySQL-tests-5.007-4.el10.x86_64_v2.rpm;name=perl-DBD-MySQL-tests;unpack=0"
SRC_URI += "${URI_perl-DBD-MySQL-tests}"
SRC_URI[perl-DBD-MySQL-tests.sha256sum] = "cc65b7e67d9230ff06a042bb2a4b52211ae6da2ea4ce2b34b6c11891aee9bfed"
RDEPENDS:perl-DBD-MySQL-tests = " \
 perl-libs \
 mysql8.4 \
 perl-B \
 perl-Test-Deep \
 mysql8.4-server \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-CPAN-Meta-YAML \
 perl-vars \
 perl-DBD-MySQL \
 perl-DBI \
 perl-Data-Dumper \
 perl-Time-HiRes \
 shadow-utils \
 bash \
 perl-bignum \
 coreutils \
 perl-interpreter \
 perl-File-Path \
 perl-lib \
"
