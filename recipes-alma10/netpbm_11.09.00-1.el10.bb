# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "netpbm"
PE = "0"
PV = "11.09.00"
PR = "1.el10"
PACKAGES = "netpbm netpbm-progs netpbm-devel netpbm-doc"
PROVIDES = "rpm/netpbm rpm/netpbm-progs rpm/netpbm-devel rpm/netpbm-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/netpbm-11.09.00-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1bbb396ba66784a8f9e11cbf4ad30e4d8bf0f40ff620ef5eb782dc064f002dda"

URI_netpbm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/netpbm-11.09.00-1.el10.x86_64_v2.rpm;name=netpbm;unpack=0"
SRC_URI += "${URI_netpbm}"
SRC_URI[netpbm.sha256sum] = "eb1725c20bcc10f3d63b7868666039c9728ad7409058d0552f206ef0b8a04897"
RDEPENDS:netpbm = " \
 glibc \
"

URI_netpbm-progs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/netpbm-progs-11.09.00-1.el10.x86_64_v2.rpm;name=netpbm-progs;unpack=0"
SRC_URI += "${URI_netpbm-progs}"
SRC_URI[netpbm-progs.sha256sum] = "caf3ce363bd9ce3be4445c5c5ce1444725f49cf3609dfdde0844d201ca0d4d12"
RDEPENDS:netpbm-progs = " \
 perl-libs \
 libpng \
 jasper-libs \
 perl-Getopt-Long \
 libX11 \
 perl-IO \
 jbigkit-libs \
 zlib-ng-compat \
 libgcc \
 netpbm \
 libxml2 \
 bash \
 perl-English \
 perl-Errno \
 ghostscript \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-PathTools \
 glibc \
 perl-interpreter \
 libjpeg-turbo \
 perl-File-Temp \
 libtiff \
"

URI_netpbm-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/netpbm-devel-11.09.00-1.el10.x86_64_v2.rpm;name=netpbm-devel;unpack=0"
SRC_URI += "${URI_netpbm-devel}"
SRC_URI[netpbm-devel.sha256sum] = "556bcff136c950eee77f133b8efbdf1c97945634ef6fd2b6adb90db7f1380635"
RDEPENDS:netpbm-devel = " \
 netpbm \
"

URI_netpbm-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/netpbm-doc-11.09.00-1.el10.x86_64_v2.rpm;name=netpbm-doc;unpack=0"
SRC_URI += "${URI_netpbm-doc}"
SRC_URI[netpbm-doc.sha256sum] = "ce1839fbab5dc74657ddcc8a554d226c27c61d770e54be88a8b44117206df3f0"
RDEPENDS:netpbm-doc = " \
 netpbm-progs \
"
