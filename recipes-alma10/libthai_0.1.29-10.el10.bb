# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libthai"
PE = "0"
PV = "0.1.29"
PR = "10.el10"
PACKAGES = "libthai libthai-devel"
PROVIDES = "rpm/libthai rpm/libthai-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libthai-0.1.29-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1e6c1e4dd0ae81b2fc86b578cb5cb36580ee96bf723a7526aa2b4045d133e05"

URI_libthai = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libthai-0.1.29-10.el10.x86_64_v2.rpm;name=libthai;unpack=0"
SRC_URI += "${URI_libthai}"
SRC_URI[libthai.sha256sum] = "6979d0fb44801e8de1274632775f2db9d5ea3828dc6bcfee3ad595b2864ef26f"
RDEPENDS:libthai = " \
 glibc \
 libdatrie \
"

URI_libthai-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libthai-devel-0.1.29-10.el10.x86_64_v2.rpm;name=libthai-devel;unpack=0"
SRC_URI += "${URI_libthai-devel}"
SRC_URI[libthai-devel.sha256sum] = "448cbf10fa3494edc44771296453a4b7f4486e4bb48595a216be81d29a5f2003"
RDEPENDS:libthai-devel = " \
 libdatrie-devel \
 libthai \
 pkgconf-pkg-config \
"
