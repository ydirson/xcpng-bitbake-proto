# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-xh"
PE = "0"
PV = "0.20091030"
PR = "31.el10"
PACKAGES = "hunspell-xh"
PROVIDES = "rpm/hunspell-xh"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-xh-0.20091030-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "816881035013149721d825b923ecd2eefb6ec28c171cf20f62c44fce084dfe43"

URI_hunspell-xh = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-xh-0.20091030-31.el10.noarch.rpm;name=hunspell-xh;unpack=0"
SRC_URI += "${URI_hunspell-xh}"
SRC_URI[hunspell-xh.sha256sum] = "4586706e7775bd5175265a5340296929e71d7b60b4fae3af144738fed44e5f7b"
RDEPENDS:hunspell-xh = " \
 hunspell-filesystem \
"
