# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "apache-commons-collections4"
PE = "0"
PV = "4.4"
PR = "15.el10"
PACKAGES = "apache-commons-collections4 apache-commons-collections4-javadoc"
PROVIDES = "rpm/apache-commons-collections4 rpm/apache-commons-collections4-javadoc"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/apache-commons-collections4-4.4-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8e5a034e39624b442f0a09368db35d15c43b5fd438c9876bfc9e1157be90f6f"

URI_apache-commons-collections4 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/apache-commons-collections4-4.4-15.el10.noarch.rpm;name=apache-commons-collections4;unpack=0"
SRC_URI += "${URI_apache-commons-collections4}"
SRC_URI[apache-commons-collections4.sha256sum] = "62aaff781384e1a08422a2ff702e5f509cb88e53e560b8fddc833dd84adfe95c"
RDEPENDS:apache-commons-collections4 = " \
 javapackages-filesystem \
"

URI_apache-commons-collections4-javadoc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/apache-commons-collections4-javadoc-4.4-15.el10.noarch.rpm;name=apache-commons-collections4-javadoc;unpack=0"
SRC_URI += "${URI_apache-commons-collections4-javadoc}"
SRC_URI[apache-commons-collections4-javadoc.sha256sum] = "0d30a5538d3d9331f94f270ef52f72f7b9e17b776512bc5880e0285d2b018dbe"
RDEPENDS:apache-commons-collections4-javadoc = " \
 javapackages-filesystem \
"
