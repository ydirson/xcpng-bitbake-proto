# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dnsconfd"
PE = "0"
PV = "1.7.2"
PR = "1.el10_0"
PACKAGES = "dnsconfd dnsconfd-dracut dnsconfd-micro dnsconfd-selinux dnsconfd-unbound"
PROVIDES = "rpm/dnsconfd rpm/dnsconfd-dracut rpm/dnsconfd-micro rpm/dnsconfd-selinux rpm/dnsconfd-unbound"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/dnsconfd-1.7.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "070e96e92da3df8266fa3b8fb41281db02649480d77a68e990579b047f3f0d94"

URI_dnsconfd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dnsconfd-1.7.2-1.el10_0.x86_64_v2.rpm;name=dnsconfd;unpack=0"
SRC_URI += "${URI_dnsconfd}"
SRC_URI[dnsconfd.sha256sum] = "64809991bc083461dd72ddaa1be887c733673cc42868813ed84e20912e1e5d1f"
RDEPENDS:dnsconfd = " \
 python3 \
 python3-pyyaml \
 shadow-utils \
 python3-dbus \
 dnsconfd-unbound \
 dnsconfd-selinux \
 polkit \
 bash \
 python3-gobject-base \
 dbus-common \
 python3-systemd \
"

URI_dnsconfd-dracut = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dnsconfd-dracut-1.7.2-1.el10_0.x86_64_v2.rpm;name=dnsconfd-dracut;unpack=0"
SRC_URI += "${URI_dnsconfd-dracut}"
SRC_URI[dnsconfd-dracut.sha256sum] = "1db601042b5440ff4706c674a1fa7a9f2d6a61596ee1eacefd9e5449209bcaec"
RDEPENDS:dnsconfd-dracut = " \
 unbound \
 dnsconfd-micro \
 bash \
 dracut \
 dracut-network \
"

URI_dnsconfd-micro = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dnsconfd-micro-1.7.2-1.el10_0.x86_64_v2.rpm;name=dnsconfd-micro;unpack=0"
SRC_URI += "${URI_dnsconfd-micro}"
SRC_URI[dnsconfd-micro.sha256sum] = "cc4d2698c5f7e76dc050a990212d572dc1547f65bb000faf91f2e627cad5cb66"
RDEPENDS:dnsconfd-micro = " \
 systemd-libs \
 dnsconfd \
 dnsconfd-selinux \
 unbound-dracut \
 glib2 \
 libcurl \
 glibc \
"

URI_dnsconfd-selinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dnsconfd-selinux-1.7.2-1.el10_0.noarch.rpm;name=dnsconfd-selinux;unpack=0"
SRC_URI += "${URI_dnsconfd-selinux}"
SRC_URI[dnsconfd-selinux.sha256sum] = "863d3f5304b66e20740ec9bee0c0297f1268efae295c90c484d4d841b48c151c"
RDEPENDS:dnsconfd-selinux = " \
 dnsconfd \
 policycoreutils-python-utils \
 policycoreutils \
 bash \
 selinux-policy \
 libselinux-utils \
 selinux-policy-targeted \
"

URI_dnsconfd-unbound = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dnsconfd-unbound-1.7.2-1.el10_0.noarch.rpm;name=dnsconfd-unbound;unpack=0"
SRC_URI += "${URI_dnsconfd-unbound}"
SRC_URI[dnsconfd-unbound.sha256sum] = "a10f267af8dad38dd79c6980bb2ceeac94983e6e11be3b6baa04a84e037c05bc"
RDEPENDS:dnsconfd-unbound = " \
 dnsconfd \
 bash \
 unbound \
"
