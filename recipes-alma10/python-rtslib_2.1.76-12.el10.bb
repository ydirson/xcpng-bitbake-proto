# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-rtslib"
PE = "0"
PV = "2.1.76"
PR = "12.el10"
PACKAGES = "python3-rtslib target-restore"
PROVIDES = "rpm/python3-rtslib rpm/target-restore"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-rtslib-2.1.76-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "703a3a888c5767f95d7f0a648ad2ee5100b151813cb598d5eef134b00f4a013d"

URI_python3-rtslib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-rtslib-2.1.76-12.el10.noarch.rpm;name=python3-rtslib;unpack=0"
SRC_URI += "${URI_python3-rtslib}"
SRC_URI[python3-rtslib.sha256sum] = "0f149a9599cea34d5b664410ea4fc1c8f9f966d202160588680808460fed7de4"
RDEPENDS:python3-rtslib = " \
 python3-pyudev \
 python3-six \
 python3 \
 python3-kmod \
"

URI_target-restore = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/target-restore-2.1.76-12.el10.noarch.rpm;name=target-restore;unpack=0"
SRC_URI += "${URI_target-restore}"
SRC_URI[target-restore.sha256sum] = "9417275655be4309a4bb98cffd336949452aa32301c1c85deed3645f28e07f12"
RDEPENDS:target-restore = " \
 python3 \
 systemd \
 bash \
 python3-rtslib \
"
