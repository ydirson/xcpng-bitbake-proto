# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jansi"
PE = "0"
PV = "2.4.1"
PR = "5.el10"
PACKAGES = "jansi jansi-javadoc"
PROVIDES = "rpm/jansi rpm/jansi-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/jansi-2.4.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e637485f942da49c69ee7a2c3ce10993ec8ac8e5293aa3a3459aebf1baf52bb0"

URI_jansi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jansi-2.4.1-5.el10.x86_64_v2.rpm;name=jansi;unpack=0"
SRC_URI += "${URI_jansi}"
SRC_URI[jansi.sha256sum] = "ee81a7e329e0dbe5094c3aaac44cb3824b9ee31967d3ce18cb64678753aef15e"
RDEPENDS:jansi = " \
 glibc \
 javapackages-filesystem \
"

URI_jansi-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jansi-javadoc-2.4.1-5.el10.noarch.rpm;name=jansi-javadoc;unpack=0"
SRC_URI += "${URI_jansi-javadoc}"
SRC_URI[jansi-javadoc.sha256sum] = "056dfe2526b3d183d7a4da8edcaa7eb51616866640beaab1693b3c2b41dc69a1"
RDEPENDS:jansi-javadoc = " \
 javapackages-filesystem \
"
