# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "linux-firmware"
PE = "0"
PV = "20251008"
PR = "15.8.el10_0"
PACKAGES = "amd-ucode-firmware atheros-firmware brcmfmac-firmware cirrus-audio-firmware dvb-firmware intel-audio-firmware intel-vsc-firmware iwlegacy-firmware iwlwifi-dvm-firmware iwlwifi-mvm-firmware libertas-firmware linux-firmware linux-firmware-whence mlxsw_spectrum-firmware mrvlprestera-firmware mt7xxx-firmware netronome-firmware nxpwireless-firmware qcom-firmware realtek-firmware tiwilink-firmware amd-gpu-firmware intel-gpu-firmware nvidia-gpu-firmware liquidio-firmware"
PROVIDES = "rpm/amd-ucode-firmware rpm/atheros-firmware rpm/brcmfmac-firmware rpm/cirrus-audio-firmware rpm/dvb-firmware rpm/intel-audio-firmware rpm/intel-vsc-firmware rpm/iwlegacy-firmware rpm/iwlwifi-dvm-firmware rpm/iwlwifi-mvm-firmware rpm/libertas-firmware rpm/linux-firmware rpm/linux-firmware-whence rpm/mlxsw_spectrum-firmware rpm/mrvlprestera-firmware rpm/mt7xxx-firmware rpm/netronome-firmware rpm/nxpwireless-firmware rpm/qcom-firmware rpm/realtek-firmware rpm/tiwilink-firmware rpm/amd-gpu-firmware rpm/intel-gpu-firmware rpm/nvidia-gpu-firmware rpm/liquidio-firmware"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/linux-firmware-20251008-15.8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3044de9bfc27638cc08a5983240765f2ccad14636a8882323d31f0191a6b3909"

URI_amd-ucode-firmware = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/amd-ucode-firmware-20251008-15.8.el10_0.noarch.rpm;name=amd-ucode-firmware;unpack=0"
SRC_URI += "${URI_amd-ucode-firmware}"
SRC_URI[amd-ucode-firmware.sha256sum] = "bf8e63ae8cbe6d61fb7cbabc7f585a461a01bfe8d94576822ca66e478a0a3ee4"
RDEPENDS:amd-ucode-firmware = " \
 linux-firmware-whence \
"

URI_atheros-firmware = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/atheros-firmware-20251008-15.8.el10_0.noarch.rpm;name=atheros-firmware;unpack=0"
SRC_URI += "${URI_atheros-firmware}"
SRC_URI[atheros-firmware.sha256sum] = "a6dd69faab9132430cbcf90d369eaa66f624ef9d77f43004040a591e59a830ab"
RDEPENDS:atheros-firmware = " \
 linux-firmware-whence \
"

URI_brcmfmac-firmware = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/brcmfmac-firmware-20251008-15.8.el10_0.noarch.rpm;name=brcmfmac-firmware;unpack=0"
SRC_URI += "${URI_brcmfmac-firmware}"
SRC_URI[brcmfmac-firmware.sha256sum] = "efcacc339533eba146809e2e698340ac87cbf1265c97284fe9630e080bc181a8"
RDEPENDS:brcmfmac-firmware = " \
 linux-firmware-whence \
"

URI_cirrus-audio-firmware = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cirrus-audio-firmware-20251008-15.8.el10_0.noarch.rpm;name=cirrus-audio-firmware;unpack=0"
SRC_URI += "${URI_cirrus-audio-firmware}"
SRC_URI[cirrus-audio-firmware.sha256sum] = "e08a5e51e2f1613b1362bd0b7b038a3edff327ea42fccc26593ff958c894d8c7"
RDEPENDS:cirrus-audio-firmware = " \
 linux-firmware-whence \
"

URI_dvb-firmware = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/dvb-firmware-20251008-15.8.el10_0.noarch.rpm;name=dvb-firmware;unpack=0"
SRC_URI += "${URI_dvb-firmware}"
SRC_URI[dvb-firmware.sha256sum] = "853443162d728ee59d2f68b37eb73a21b501eb59117f371941180bccb4d26bb9"
RDEPENDS:dvb-firmware = " \
 linux-firmware-whence \
"

URI_intel-audio-firmware = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/intel-audio-firmware-20251008-15.8.el10_0.noarch.rpm;name=intel-audio-firmware;unpack=0"
SRC_URI += "${URI_intel-audio-firmware}"
SRC_URI[intel-audio-firmware.sha256sum] = "dc7c8f11ce37a32b72a8b68a70ae272e6dd73b6e52a570a2001a9810d36a16b9"
RDEPENDS:intel-audio-firmware = " \
 linux-firmware-whence \
"

URI_intel-vsc-firmware = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/intel-vsc-firmware-20251008-15.8.el10_0.noarch.rpm;name=intel-vsc-firmware;unpack=0"
SRC_URI += "${URI_intel-vsc-firmware}"
SRC_URI[intel-vsc-firmware.sha256sum] = "83289148d1dece06839ad92b7fad99f12a8a38272f248afb98d782b7f9c8cb00"
RDEPENDS:intel-vsc-firmware = " \
 linux-firmware-whence \
"

URI_iwlegacy-firmware = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/iwlegacy-firmware-20251008-15.8.el10_0.noarch.rpm;name=iwlegacy-firmware;unpack=0"
SRC_URI += "${URI_iwlegacy-firmware}"
SRC_URI[iwlegacy-firmware.sha256sum] = "2c915fbc625a34cb8c6bab1ecf085ef1b5e5fc377e5a398e69009fafb2a1dd1b"
RDEPENDS:iwlegacy-firmware = " \
 linux-firmware-whence \
"

URI_iwlwifi-dvm-firmware = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/iwlwifi-dvm-firmware-20251008-15.8.el10_0.noarch.rpm;name=iwlwifi-dvm-firmware;unpack=0"
SRC_URI += "${URI_iwlwifi-dvm-firmware}"
SRC_URI[iwlwifi-dvm-firmware.sha256sum] = "5de42d26e2486696103361683afec3caf93d837e414c2f4af3b0fec8d05f89ec"
RDEPENDS:iwlwifi-dvm-firmware = " \
 linux-firmware-whence \
"

URI_iwlwifi-mvm-firmware = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/iwlwifi-mvm-firmware-20251008-15.8.el10_0.noarch.rpm;name=iwlwifi-mvm-firmware;unpack=0"
SRC_URI += "${URI_iwlwifi-mvm-firmware}"
SRC_URI[iwlwifi-mvm-firmware.sha256sum] = "9a81d80877f938d9da274eca6d0b128a510549c75e2648a78b46744b70663336"
RDEPENDS:iwlwifi-mvm-firmware = " \
 linux-firmware-whence \
"

URI_libertas-firmware = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libertas-firmware-20251008-15.8.el10_0.noarch.rpm;name=libertas-firmware;unpack=0"
SRC_URI += "${URI_libertas-firmware}"
SRC_URI[libertas-firmware.sha256sum] = "0e9b93f65419dd51ec8c60068c0402c820639a0f1965059a02dc257a5a1ec7b7"
RDEPENDS:libertas-firmware = " \
 linux-firmware-whence \
"

URI_linux-firmware = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/linux-firmware-20251008-15.8.el10_0.noarch.rpm;name=linux-firmware;unpack=0"
SRC_URI += "${URI_linux-firmware}"
SRC_URI[linux-firmware.sha256sum] = "2863cd19a648bdb8cb4a974fa734a671beb02d832c889fb3d3d5721d74dd8e8b"
RDEPENDS:linux-firmware = " \
 linux-firmware-whence \
"

URI_linux-firmware-whence = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/linux-firmware-whence-20251008-15.8.el10_0.noarch.rpm;name=linux-firmware-whence;unpack=0"
SRC_URI += "${URI_linux-firmware-whence}"
SRC_URI[linux-firmware-whence.sha256sum] = "83d7a70131cc1c9de149c17ffe5c2bff7ef652d869e979f51e0c9be5e7a9ef73"
RDEPENDS:linux-firmware-whence = ""

URI_mlxsw_spectrum-firmware = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/mlxsw_spectrum-firmware-20251008-15.8.el10_0.noarch.rpm;name=mlxsw_spectrum-firmware;unpack=0"
SRC_URI += "${URI_mlxsw_spectrum-firmware}"
SRC_URI[mlxsw_spectrum-firmware.sha256sum] = "d0055924195aa582b73888aa80fbe16898779ac24f72591d57a67fb14d544e01"
RDEPENDS:mlxsw_spectrum-firmware = " \
 linux-firmware-whence \
"

URI_mrvlprestera-firmware = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/mrvlprestera-firmware-20251008-15.8.el10_0.noarch.rpm;name=mrvlprestera-firmware;unpack=0"
SRC_URI += "${URI_mrvlprestera-firmware}"
SRC_URI[mrvlprestera-firmware.sha256sum] = "8b56b557442c8cb53ce4cb461da031ae20c18c6f66787e9a35df73c46121ffe0"
RDEPENDS:mrvlprestera-firmware = " \
 linux-firmware-whence \
"

URI_mt7xxx-firmware = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/mt7xxx-firmware-20251008-15.8.el10_0.noarch.rpm;name=mt7xxx-firmware;unpack=0"
SRC_URI += "${URI_mt7xxx-firmware}"
SRC_URI[mt7xxx-firmware.sha256sum] = "4d630e0febcf00ad4dbea7c628afe55814395705d9fb9e467e095c97ff9a7ed4"
RDEPENDS:mt7xxx-firmware = " \
 linux-firmware-whence \
"

URI_netronome-firmware = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/netronome-firmware-20251008-15.8.el10_0.noarch.rpm;name=netronome-firmware;unpack=0"
SRC_URI += "${URI_netronome-firmware}"
SRC_URI[netronome-firmware.sha256sum] = "392068aa187226c732903b6ed9c2c1fade2f2e0c7abc811c7d550fbb5d4c2dd8"
RDEPENDS:netronome-firmware = " \
 linux-firmware-whence \
"

URI_nxpwireless-firmware = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/nxpwireless-firmware-20251008-15.8.el10_0.noarch.rpm;name=nxpwireless-firmware;unpack=0"
SRC_URI += "${URI_nxpwireless-firmware}"
SRC_URI[nxpwireless-firmware.sha256sum] = "c00d5725f4a7ccb8dceca6c42bf98be0c38848f6e85aa9b7eaad25e14d77d5ac"
RDEPENDS:nxpwireless-firmware = " \
 linux-firmware-whence \
"

URI_qcom-firmware = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/qcom-firmware-20251008-15.8.el10_0.noarch.rpm;name=qcom-firmware;unpack=0"
SRC_URI += "${URI_qcom-firmware}"
SRC_URI[qcom-firmware.sha256sum] = "736aa3d1e3c8427ecb4d5ce0a1fd45946bdfe81ff3bc22f1d25e3e2aac573f02"
RDEPENDS:qcom-firmware = " \
 linux-firmware-whence \
 atheros-firmware \
"

URI_realtek-firmware = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/realtek-firmware-20251008-15.8.el10_0.noarch.rpm;name=realtek-firmware;unpack=0"
SRC_URI += "${URI_realtek-firmware}"
SRC_URI[realtek-firmware.sha256sum] = "2b65e3e0b2a79c6ca191186a396faa3add031d0c993d7c5354a927cfda253f7e"
RDEPENDS:realtek-firmware = " \
 linux-firmware-whence \
"

URI_tiwilink-firmware = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/tiwilink-firmware-20251008-15.8.el10_0.noarch.rpm;name=tiwilink-firmware;unpack=0"
SRC_URI += "${URI_tiwilink-firmware}"
SRC_URI[tiwilink-firmware.sha256sum] = "928ef584eff5d96fc90ab563d06aab1d9c3e8621df2dd04398c07e8df28ebed7"
RDEPENDS:tiwilink-firmware = " \
 linux-firmware-whence \
"

URI_amd-gpu-firmware = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/amd-gpu-firmware-20251008-15.8.el10_0.noarch.rpm;name=amd-gpu-firmware;unpack=0"
SRC_URI += "${URI_amd-gpu-firmware}"
SRC_URI[amd-gpu-firmware.sha256sum] = "abd5127e003af822203e6509c39eece4327786c94270178a089fbc9f19ed1edb"
RDEPENDS:amd-gpu-firmware = " \
 linux-firmware-whence \
"

URI_intel-gpu-firmware = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/intel-gpu-firmware-20251008-15.8.el10_0.noarch.rpm;name=intel-gpu-firmware;unpack=0"
SRC_URI += "${URI_intel-gpu-firmware}"
SRC_URI[intel-gpu-firmware.sha256sum] = "fb0123329ebc2fb07102293122e3115d6f857a8910cba0f8a9d6c7362bd8e519"
RDEPENDS:intel-gpu-firmware = " \
 linux-firmware-whence \
"

URI_nvidia-gpu-firmware = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nvidia-gpu-firmware-20251008-15.8.el10_0.noarch.rpm;name=nvidia-gpu-firmware;unpack=0"
SRC_URI += "${URI_nvidia-gpu-firmware}"
SRC_URI[nvidia-gpu-firmware.sha256sum] = "5ec71a637121108abe9a3366a01169e04fe45464f4093603eb94c875b5a9de4c"
RDEPENDS:nvidia-gpu-firmware = " \
 linux-firmware-whence \
 linux-firmware \
"

URI_liquidio-firmware = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/liquidio-firmware-20251008-15.8.el10_0.noarch.rpm;name=liquidio-firmware;unpack=0"
SRC_URI += "${URI_liquidio-firmware}"
SRC_URI[liquidio-firmware.sha256sum] = "bfba40e72ddcf7a33bb574723053acacf6a757f6d96e2e83c436daafb05e0080"
RDEPENDS:liquidio-firmware = " \
 linux-firmware-whence \
"
