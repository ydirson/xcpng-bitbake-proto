# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Digest-CRC"
PE = "0"
PV = "0.24"
PR = "11.el10"
PACKAGES = "perl-Digest-CRC perl-Digest-CRC-tests"
PROVIDES = "rpm/perl-Digest-CRC rpm/perl-Digest-CRC-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Digest-CRC-0.24-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48b0194654e8a414d3abe07b1933ebe224250a01a4fdd3f00b36ea6573482264"

URI_perl-Digest-CRC = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Digest-CRC-0.24-11.el10.x86_64_v2.rpm;name=perl-Digest-CRC;unpack=0"
SRC_URI += "${URI_perl-Digest-CRC}"
SRC_URI[perl-Digest-CRC.sha256sum] = "590f7a3e8aedbc09a36a92eb3988c29c382e56c6398eaff4c0e86ec4770835ed"
RDEPENDS:perl-Digest-CRC = " \
 perl-libs \
 perl-vars \
 perl-DynaLoader \
 perl-Symbol \
 glibc \
 perl-Exporter \
"

URI_perl-Digest-CRC-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Digest-CRC-tests-0.24-11.el10.x86_64_v2.rpm;name=perl-Digest-CRC-tests;unpack=0"
SRC_URI += "${URI_perl-Digest-CRC-tests}"
SRC_URI[perl-Digest-CRC-tests.sha256sum] = "391f0c86a6481d4851d80d88b2d3d781a7a633e626875f3d050b582637a8a4a5"
RDEPENDS:perl-Digest-CRC-tests = " \
 perl-Test-Harness \
 perl-Fcntl \
 bash \
 perl-Digest-CRC \
 perl-interpreter \
"
