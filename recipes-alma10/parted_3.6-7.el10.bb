# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "parted"
PE = "0"
PV = "3.6"
PR = "7.el10"
PACKAGES = "parted parted-devel"
PROVIDES = "rpm/parted rpm/parted-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/parted-3.6-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3917da0c69ed921c2a0b74d2ab6919bc6854982dd6fd1ae1a15c91841674ef10"

URI_parted = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/parted-3.6-7.el10.x86_64_v2.rpm;name=parted;unpack=0"
SRC_URI += "${URI_parted}"
SRC_URI[parted.sha256sum] = "bdaae6eb3cea12dc4c48b6f68031fab3bf971d939e303b1a1d0f3c388b89c43f"
RDEPENDS:parted = " \
 libuuid \
 device-mapper-libs \
 libblkid \
 readline \
 ncurses-libs \
 glibc \
"

URI_parted-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/parted-devel-3.6-7.el10.x86_64_v2.rpm;name=parted-devel;unpack=0"
SRC_URI += "${URI_parted-devel}"
SRC_URI[parted-devel.sha256sum] = "627dfabb6ec29f8688eac0029baf5509c7840eee6703ac058da7247f24f3b10e"
RDEPENDS:parted-devel = " \
 parted \
 pkgconf-pkg-config \
"
