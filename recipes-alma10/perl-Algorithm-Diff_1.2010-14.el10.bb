# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Algorithm-Diff"
PE = "0"
PV = "1.2010"
PR = "14.el10"
PACKAGES = "perl-Algorithm-Diff perl-Algorithm-Diff-tests"
PROVIDES = "rpm/perl-Algorithm-Diff rpm/perl-Algorithm-Diff-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Algorithm-Diff-1.2010-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1edd0cae95931ee58d503fbb31b7905cb4db1e78e98c2557c742c787ca2d8c85"

URI_perl-Algorithm-Diff = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Algorithm-Diff-1.2010-14.el10.noarch.rpm;name=perl-Algorithm-Diff;unpack=0"
SRC_URI += "${URI_perl-Algorithm-Diff}"
SRC_URI[perl-Algorithm-Diff.sha256sum] = "cee8d71f19e1436d8474f3b018a3f4acb73b6c68a72f9d72ae8dfe3d351f99de"
RDEPENDS:perl-Algorithm-Diff = " \
 perl-Exporter \
 perl-vars \
 perl-libs \
 perl-Carp \
"

URI_perl-Algorithm-Diff-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Algorithm-Diff-tests-1.2010-14.el10.noarch.rpm;name=perl-Algorithm-Diff-tests;unpack=0"
SRC_URI += "${URI_perl-Algorithm-Diff-tests}"
SRC_URI[perl-Algorithm-Diff-tests.sha256sum] = "5d18e4f2a629c771cd9707e1f3a9b5fed0fdaea72a6eb3b0cb9ba42076ed2a60"
RDEPENDS:perl-Algorithm-Diff-tests = " \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 perl-Algorithm-Diff \
 bash \
 perl-interpreter \
 perl-Data-Dumper \
 perl-lib \
"
