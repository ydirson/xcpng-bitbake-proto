# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libtool"
PE = "0"
PV = "2.4.7"
PR = "13.el10"
PACKAGES = "libtool libtool-ltdl libtool-ltdl-devel"
PROVIDES = "rpm/libtool rpm/libtool-ltdl rpm/libtool-ltdl-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libtool-2.4.7-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63f47b22e90bd136270f0b155a8b181c893a9d010d24c05f5d244d2ef1bb8d20"

URI_libtool = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libtool-2.4.7-13.el10.x86_64_v2.rpm;name=libtool;unpack=0"
SRC_URI += "${URI_libtool}"
SRC_URI[libtool.sha256sum] = "d85fee04e2c38f3ba2116df73eee1f472a37e9221bf5b22e645c8cd8dbfcb6bd"
RDEPENDS:libtool = " \
 autoconf \
 automake \
 tar \
 bash \
 gcc \
 sed \
 findutils \
"

URI_libtool-ltdl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libtool-ltdl-2.4.7-13.el10.x86_64_v2.rpm;name=libtool-ltdl;unpack=0"
SRC_URI += "${URI_libtool-ltdl}"
SRC_URI[libtool-ltdl.sha256sum] = "a1b3828d0be607e463eb8afe5e77e31a800133b641e7cdaffeb332a5dd47a670"
RDEPENDS:libtool-ltdl = " \
 glibc \
"

URI_libtool-ltdl-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libtool-ltdl-devel-2.4.7-13.el10.x86_64_v2.rpm;name=libtool-ltdl-devel;unpack=0"
SRC_URI += "${URI_libtool-ltdl-devel}"
SRC_URI[libtool-ltdl-devel.sha256sum] = "0b5b6f196925aa04353b82601558b4c83d29ef9b1a8e43ad26297999f3655d94"
RDEPENDS:libtool-ltdl-devel = " \
 automake \
 bash \
 libtool-ltdl \
"
