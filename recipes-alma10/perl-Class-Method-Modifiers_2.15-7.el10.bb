# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Class-Method-Modifiers"
PE = "0"
PV = "2.15"
PR = "7.el10"
PACKAGES = "perl-Class-Method-Modifiers perl-Class-Method-Modifiers-tests"
PROVIDES = "rpm/perl-Class-Method-Modifiers rpm/perl-Class-Method-Modifiers-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Class-Method-Modifiers-2.15-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35f2f24c388341f4845f4f9710e929af4ea6ca5c6177736ebfa7a619f743c0d0"

URI_perl-Class-Method-Modifiers = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Class-Method-Modifiers-2.15-7.el10.noarch.rpm;name=perl-Class-Method-Modifiers;unpack=0"
SRC_URI += "${URI_perl-Class-Method-Modifiers}"
SRC_URI[perl-Class-Method-Modifiers.sha256sum] = "b810dec1f4f2be6584ecd7ed39208c96cbadd9412eade9d15b3bc10190faad4c"
RDEPENDS:perl-Class-Method-Modifiers = " \
 perl-libs \
 perl-Carp \
 perl-B \
 perl-Exporter \
 perl-base \
"

URI_perl-Class-Method-Modifiers-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Class-Method-Modifiers-tests-2.15-7.el10.noarch.rpm;name=perl-Class-Method-Modifiers-tests;unpack=0"
SRC_URI += "${URI_perl-Class-Method-Modifiers-tests}"
SRC_URI[perl-Class-Method-Modifiers-tests.sha256sum] = "3e31481068610ba4b90e3f5227e5a2d40ae2474f55170cdfb0ed1ccfb47fb6fc"
RDEPENDS:perl-Class-Method-Modifiers-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-ExtUtils-MakeMaker \
 perl-Test-Simple \
 perl-Class-Method-Modifiers \
 perl-PathTools \
 bash \
 perl-if \
 perl-B \
 perl-interpreter \
"
