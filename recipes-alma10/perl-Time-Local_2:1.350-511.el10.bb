# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Time-Local"
PE = "2"
PV = "1.350"
PR = "511.el10"
PACKAGES = "perl-Time-Local perl-Time-Local-tests"
PROVIDES = "rpm/perl-Time-Local rpm/perl-Time-Local-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Time-Local-1.350-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "906e58ff4b53187e8fb87cc6c89da0f6d41faa1364a8840518e542b13edb6884"

URI_perl-Time-Local = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Time-Local-1.350-511.el10.noarch.rpm;name=perl-Time-Local;unpack=0"
SRC_URI += "${URI_perl-Time-Local}"
SRC_URI[perl-Time-Local.sha256sum] = "3a4cb41e150dc2f774c690fc8257b7f5064a3b5b1f4f40cb5438e1d125224347"
RDEPENDS:perl-Time-Local = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-parent \
 perl-Exporter \
"

URI_perl-Time-Local-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Time-Local-tests-1.350-511.el10.noarch.rpm;name=perl-Time-Local-tests;unpack=0"
SRC_URI += "${URI_perl-Time-Local-tests}"
SRC_URI[perl-Time-Local-tests.sha256sum] = "e9100f2411c0346e79ac65ca0d0b39c29f72022ddee4e54efe3f175127554da5"
RDEPENDS:perl-Time-Local-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-ExtUtils-MakeMaker \
 perl-Test-Simple \
 perl-PathTools \
 bash \
 perl-interpreter \
 perl-Time-Local \
"
