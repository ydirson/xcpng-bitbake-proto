# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "opentelemetry-collector"
PE = "0"
PV = "0.127.0"
PR = "3.el10_0"
PACKAGES = "opentelemetry-collector"
PROVIDES = "rpm/opentelemetry-collector"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/opentelemetry-collector-0.127.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cfc071fb4c4d21d68503c6414613c80791389d971db63589974b6c8f5f2d0955"

URI_opentelemetry-collector = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/opentelemetry-collector-0.127.0-3.el10_0.x86_64_v2.rpm;name=opentelemetry-collector;unpack=0"
SRC_URI += "${URI_opentelemetry-collector}"
SRC_URI[opentelemetry-collector.sha256sum] = "c20e669a6cbad58ccb45d55edcf96d99bdb373ab2b7527a3e4da974965f67920"
RDEPENDS:opentelemetry-collector = " \
 glibc-common \
 shadow-utils \
 util-linux \
 bash \
 glibc \
"
