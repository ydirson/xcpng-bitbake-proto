# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sysstat"
PE = "0"
PV = "12.7.6"
PR = "2.el10"
PACKAGES = "sysstat"
PROVIDES = "rpm/sysstat"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/sysstat-12.7.6-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea622d95eee42cd9d17c2bc1c6d355d813c670eadae0f2a644df09f2dcbfdf79"

URI_sysstat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sysstat-12.7.6-2.el10.x86_64_v2.rpm;name=sysstat;unpack=0"
SRC_URI += "${URI_sysstat}"
SRC_URI[sysstat.sha256sum] = "b54673ba76252eca3931017d596bef7d568c5c93bdd7759ac3d6bd2887a5fbf9"
RDEPENDS:sysstat = " \
 lm_sensors-libs \
 pcp-libs \
 bash \
 xz \
 glibc \
 findutils \
"
