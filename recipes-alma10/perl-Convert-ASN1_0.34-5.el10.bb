# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Convert-ASN1"
PE = "0"
PV = "0.34"
PR = "5.el10"
PACKAGES = "perl-Convert-ASN1 perl-Convert-ASN1-tests"
PROVIDES = "rpm/perl-Convert-ASN1 rpm/perl-Convert-ASN1-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Convert-ASN1-0.34-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b72ccfd6ceec392784f5ca41390db54e990c855e2b2a5e4f126a371193cb27b"

URI_perl-Convert-ASN1 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Convert-ASN1-0.34-5.el10.noarch.rpm;name=perl-Convert-ASN1;unpack=0"
SRC_URI += "${URI_perl-Convert-ASN1}"
SRC_URI[perl-Convert-ASN1.sha256sum] = "4656f416d412d0bcd92b9d063266a022d60ed6da40b66cc5fc85ecfd7d9e3577"
RDEPENDS:perl-Convert-ASN1 = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-Socket \
 perl-POSIX \
 perl-Encode \
 perl-Convert-ASN1 \
 perl-Exporter \
 perl-Time-Local \
"

URI_perl-Convert-ASN1-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Convert-ASN1-tests-0.34-5.el10.noarch.rpm;name=perl-Convert-ASN1-tests;unpack=0"
SRC_URI += "${URI_perl-Convert-ASN1-tests}"
SRC_URI[perl-Convert-ASN1-tests.sha256sum] = "914d34b61dddf888ab2c0cdcfded3aa893a1851786fc6fef3864fa16a934c449"
RDEPENDS:perl-Convert-ASN1-tests = " \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Math-BigInt \
 perl-IO \
 perl-POSIX \
 perl-Convert-ASN1 \
 bash \
 perl-interpreter \
 perl-Data-Dumper \
 perl-File-Temp \
"
