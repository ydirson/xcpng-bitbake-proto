# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "brotli"
PE = "0"
PV = "1.1.0"
PR = "6.el10"
PACKAGES = "libbrotli brotli brotli-devel python3-brotli"
PROVIDES = "rpm/libbrotli rpm/brotli rpm/brotli-devel rpm/python3-brotli"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/brotli-1.1.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ccea9b9dd0231357cec20bc6d0f15b6cea055eace6991302e8b1e7d0de77c785"

URI_libbrotli = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libbrotli-1.1.0-6.el10.x86_64_v2.rpm;name=libbrotli;unpack=0"
SRC_URI += "${URI_libbrotli}"
SRC_URI[libbrotli.sha256sum] = "18a9671b1a5321f55d4be9a12cc9a3d909f2d9e9ee7852283c272748d176b812"
RDEPENDS:libbrotli = " \
 glibc \
"

URI_brotli = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/brotli-1.1.0-6.el10.x86_64_v2.rpm;name=brotli;unpack=0"
SRC_URI += "${URI_brotli}"
SRC_URI[brotli.sha256sum] = "2ce067c61e5346e988ee9f337ff47f29019e85ec4ea2d07810ec253bbe0dfb19"
RDEPENDS:brotli = " \
 glibc \
 libbrotli \
"

URI_brotli-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/brotli-devel-1.1.0-6.el10.x86_64_v2.rpm;name=brotli-devel;unpack=0"
SRC_URI += "${URI_brotli-devel}"
SRC_URI[brotli-devel.sha256sum] = "9549b5f246e81c6460d4e9d77c6bce662cae092dc75e05452b76c4f4af59ae76"
RDEPENDS:brotli-devel = " \
 brotli-devel \
 brotli \
 libbrotli \
 pkgconf-pkg-config \
"

URI_python3-brotli = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-brotli-1.1.0-6.el10.x86_64_v2.rpm;name=python3-brotli;unpack=0"
SRC_URI += "${URI_python3-brotli}"
SRC_URI[python3-brotli.sha256sum] = "be0abbc7e0c4c5b1e4b7cd10d26d9d8d698d4a9c8baff6bf9548c6ce11ca9a54"
RDEPENDS:python3-brotli = " \
 glibc \
 python3 \
"
