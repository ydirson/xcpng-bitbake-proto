# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rsync"
PE = "0"
PV = "3.4.1"
PR = "2.el10"
PACKAGES = "rsync rsync-daemon rsync-rrsync"
PROVIDES = "rpm/rsync rpm/rsync-daemon rpm/rsync-rrsync"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/rsync-3.4.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cab405943a766f9490b0fc555323cbd55db26cef50ca85db3240391229a78155"

URI_rsync = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/rsync-3.4.1-2.el10.x86_64_v2.rpm;name=rsync;unpack=0"
SRC_URI += "${URI_rsync}"
SRC_URI[rsync.sha256sum] = "442035d84d6b4dee87c781ace0710c676f66903a18183f29f9e9dcb3defea5f2"
RDEPENDS:rsync = " \
 libacl \
 lz4-libs \
 openssl-libs \
 libzstd \
 bash \
 popt \
 glibc \
"

URI_rsync-daemon = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rsync-daemon-3.4.1-2.el10.noarch.rpm;name=rsync-daemon;unpack=0"
SRC_URI += "${URI_rsync-daemon}"
SRC_URI[rsync-daemon.sha256sum] = "c70129ad90ad8d013703e86fbb1e19e4c709c64b0c8bc33ce8e2581eb41aa7fb"
RDEPENDS:rsync-daemon = " \
 rsync \
 systemd \
 bash \
"

URI_rsync-rrsync = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rsync-rrsync-3.4.1-2.el10.noarch.rpm;name=rsync-rrsync;unpack=0"
SRC_URI += "${URI_rsync-rrsync}"
SRC_URI[rsync-rrsync.sha256sum] = "57e8d6fb49d61a6ad78a96628799532df853557c7b3d049d906fe09ce97c3665"
RDEPENDS:rsync-rrsync = " \
 python3 \
 rsync \
"
