# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hamcrest"
PE = "0"
PV = "2.2"
PR = "17.el10"
PACKAGES = "hamcrest hamcrest-javadoc"
PROVIDES = "rpm/hamcrest rpm/hamcrest-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hamcrest-2.2-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5c8b611e22e3a265df9e4c1873b3ca7d39e3a03481285ef5242821efaf7a68a"

URI_hamcrest = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hamcrest-2.2-17.el10.noarch.rpm;name=hamcrest;unpack=0"
SRC_URI += "${URI_hamcrest}"
SRC_URI[hamcrest.sha256sum] = "682e5349355b4eee58aecced222620e3120db8f4a3d6547bf440e6b63ba70c88"
RDEPENDS:hamcrest = " \
 javapackages-filesystem \
"

URI_hamcrest-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/hamcrest-javadoc-2.2-17.el10.noarch.rpm;name=hamcrest-javadoc;unpack=0"
SRC_URI += "${URI_hamcrest-javadoc}"
SRC_URI[hamcrest-javadoc.sha256sum] = "0d09d321d2cea90075d5c6ad415f8470aee8a78e4ff2acc4d5081bff6ce4e945"
RDEPENDS:hamcrest-javadoc = " \
 javapackages-filesystem \
"
