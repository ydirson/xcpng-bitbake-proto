# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mingw-srvany"
PE = "0"
PV = "1.1"
PR = "10.el10"
PACKAGES = "mingw-srvany-redistributable mingw32-srvany"
PROVIDES = "rpm/mingw-srvany-redistributable rpm/mingw32-srvany"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/mingw-srvany-1.1-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b0ebdd9bb8359743c81362227e56252164a75bbf31929b9669cc34d51392853"

URI_mingw-srvany-redistributable = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mingw-srvany-redistributable-1.1-10.el10.noarch.rpm;name=mingw-srvany-redistributable;unpack=0"
SRC_URI += "${URI_mingw-srvany-redistributable}"
SRC_URI[mingw-srvany-redistributable.sha256sum] = "6f05bab478528a2a47142ed1ff34e8589ab51895b1841646b1e652f3ed6563a5"
RDEPENDS:mingw-srvany-redistributable = ""

URI_mingw32-srvany = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/mingw32-srvany-1.1-10.el10.noarch.rpm;name=mingw32-srvany;unpack=0"
SRC_URI += "${URI_mingw32-srvany}"
SRC_URI[mingw32-srvany.sha256sum] = "2c2965a5e8164eb57df280739db83087ec919f2b0297d8d3067ca5bd599e4472"
RDEPENDS:mingw32-srvany = " \
 mingw32-crt \
 mingw32-filesystem \
"
