# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "liburing"
PE = "0"
PV = "2.5"
PR = "5.el10"
PACKAGES = "liburing liburing-devel"
PROVIDES = "rpm/liburing rpm/liburing-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/liburing-2.5-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5aaea52eb4900a4fbcb8222b91d40d2c0fa65ffb04d3039e8ce371e7a3dd7a84"

URI_liburing = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/liburing-2.5-5.el10.x86_64_v2.rpm;name=liburing;unpack=0"
SRC_URI += "${URI_liburing}"
SRC_URI[liburing.sha256sum] = "52fa69fd43296e9e33dc743b546397ac9c4daa5dc334495020f33c0be9acce29"
RDEPENDS:liburing = " \
 glibc \
"

URI_liburing-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/liburing-devel-2.5-5.el10.x86_64_v2.rpm;name=liburing-devel;unpack=0"
SRC_URI += "${URI_liburing-devel}"
SRC_URI[liburing-devel.sha256sum] = "7d071830adc6d4da4fa09aca215c86be87ad26a9b6cab5437993c2b814f4aeb3"
RDEPENDS:liburing-devel = " \
 pkgconf-pkg-config \
 liburing \
"
