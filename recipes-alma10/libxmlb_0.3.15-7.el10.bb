# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libxmlb"
PE = "0"
PV = "0.3.15"
PR = "7.el10"
PACKAGES = "libxmlb libxmlb-devel libxmlb-tests"
PROVIDES = "rpm/libxmlb rpm/libxmlb-devel rpm/libxmlb-tests"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libxmlb-0.3.15-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07f30dd1fad717874080f7c6d7fc9eb05b27cec81f6019f5bb9d06e57859f7b7"

URI_libxmlb = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libxmlb-0.3.15-7.el10.x86_64_v2.rpm;name=libxmlb;unpack=0"
SRC_URI += "${URI_libxmlb}"
SRC_URI[libxmlb.sha256sum] = "6a56e3472cbc7cd1faf16d60b3df1c2fd3dfe8f53e9dd3e6e696814d06742cb3"
RDEPENDS:libxmlb = " \
 shared-mime-info \
 libgcc \
 libzstd \
 glib2 \
 glibc \
 xz-libs \
"

URI_libxmlb-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libxmlb-devel-0.3.15-7.el10.x86_64_v2.rpm;name=libxmlb-devel;unpack=0"
SRC_URI += "${URI_libxmlb-devel}"
SRC_URI[libxmlb-devel.sha256sum] = "509628fa9ad9fc8f0fc786856a40956885ee600cf325f8cd81a874df2d89469a"
RDEPENDS:libxmlb-devel = " \
 xz-devel \
 glib2-devel \
 libzstd-devel \
 pkgconf-pkg-config \
 libxmlb \
"

URI_libxmlb-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libxmlb-tests-0.3.15-7.el10.x86_64_v2.rpm;name=libxmlb-tests;unpack=0"
SRC_URI += "${URI_libxmlb-tests}"
SRC_URI[libxmlb-tests.sha256sum] = "d134ee975bbd8f046d56b5f82cbde4d89cba0fb9f97c2e16acb20fa363d5bbd4"
RDEPENDS:libxmlb-tests = " \
 libgcc \
 libzstd \
 glib2 \
 glibc \
 xz-libs \
"
