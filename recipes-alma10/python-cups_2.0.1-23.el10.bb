# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-cups"
PE = "0"
PV = "2.0.1"
PR = "23.el10"
PACKAGES = "python-cups-doc python3-cups"
PROVIDES = "rpm/python-cups-doc rpm/python3-cups"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-cups-2.0.1-23.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8f968e861d06f70c4bc856f157bb1673867f706d6dae017a3a07dc1887b87fd"

URI_python-cups-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python-cups-doc-2.0.1-23.el10.x86_64_v2.rpm;name=python-cups-doc;unpack=0"
SRC_URI += "${URI_python-cups-doc}"
SRC_URI[python-cups-doc.sha256sum] = "a962b615e5adafaaa1e631071ad81e3764b9352b18bd5a4241f79f943f7a21b1"
RDEPENDS:python-cups-doc = ""

URI_python3-cups = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-cups-2.0.1-23.el10.x86_64_v2.rpm;name=python3-cups;unpack=0"
SRC_URI += "${URI_python3-cups}"
SRC_URI[python3-cups.sha256sum] = "482f228ece4e19575f040a472c51736b85af1056dcc2b632d8c56e83154f3e82"
RDEPENDS:python3-cups = " \
 glibc \
 cups-libs \
 python3 \
"
