# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "console-setup"
PE = "0"
PV = "1.224"
PR = "2.el10"
PACKAGES = "bdf2psf console-setup"
PROVIDES = "rpm/bdf2psf rpm/console-setup"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/console-setup-1.224-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40eeb0fb23e0f3b6c4d87835d507a4b1a07fef626ff9ff421d4394b9be11608b"

URI_bdf2psf = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/bdf2psf-1.224-2.el10.noarch.rpm;name=bdf2psf;unpack=0"
SRC_URI += "${URI_bdf2psf}"
SRC_URI[bdf2psf.sha256sum] = "c6b17007f96dc29822dd5460cac15af1cd2e3686c382a23d0ff0b5788a1d2549"
RDEPENDS:bdf2psf = " \
 perl-interpreter \
 perl-libs \
"

URI_console-setup = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/console-setup-1.224-2.el10.noarch.rpm;name=console-setup;unpack=0"
SRC_URI += "${URI_console-setup}"
SRC_URI[console-setup.sha256sum] = "54478d440a7fd1c41fadd2319e1fdbd115bceb6c0ff6f9d67fb8dd224b12cdda"
RDEPENDS:console-setup = " \
 perl-interpreter \
 perl-libs \
 kbd \
 bash \
"
