# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "bsf"
PE = "0"
PV = "2.4.0"
PR = "54.el10"
PACKAGES = "bsf bsf-javadoc"
PROVIDES = "rpm/bsf rpm/bsf-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/bsf-2.4.0-54.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72a2a727a1b20ac9f9a47f98b73fe3ae094dda3c0f6fea4db33d8133a24bb161"

URI_bsf = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/bsf-2.4.0-54.el10.noarch.rpm;name=bsf;unpack=0"
SRC_URI += "${URI_bsf}"
SRC_URI[bsf.sha256sum] = "f1464931d2c8ed054b3e2a494a792c348dff3e150c1171bfc4bec0671bb3c861"
RDEPENDS:bsf = " \
 javapackages-filesystem \
 apache-commons-logging \
"

URI_bsf-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/bsf-javadoc-2.4.0-54.el10.noarch.rpm;name=bsf-javadoc;unpack=0"
SRC_URI += "${URI_bsf-javadoc}"
SRC_URI[bsf-javadoc.sha256sum] = "fe272f191db4170f4e57a66ad81f572f170f682ab76ae3e842ff95c1167e341d"
RDEPENDS:bsf-javadoc = " \
 javapackages-filesystem \
"
