# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-lxml"
PE = "0"
PV = "5.2.1"
PR = "4.el10"
PACKAGES = "python3-lxml"
PROVIDES = "rpm/python3-lxml"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-lxml-5.2.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50bba3421768fec5515cc18b0b9f5e59c3cd33d390c5b86ca66929da7620ff6e"

URI_python3-lxml = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-lxml-5.2.1-4.el10.x86_64_v2.rpm;name=python3-lxml;unpack=0"
SRC_URI += "${URI_python3-lxml}"
SRC_URI[python3-lxml.sha256sum] = "d64aec49ec691f79282dab9c19f7ff54eb70d83b9b321cb92b224832fabf0177"
RDEPENDS:python3-lxml = " \
 glibc \
 python3 \
 libxslt \
 libxml2 \
"
