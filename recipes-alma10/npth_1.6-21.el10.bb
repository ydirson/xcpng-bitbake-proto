# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "npth"
PE = "0"
PV = "1.6"
PR = "21.el10"
PACKAGES = "npth npth-devel"
PROVIDES = "rpm/npth rpm/npth-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/npth-1.6-21.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0585711a20e4f84f24b4574d31316101311411350c1e69be8908f7d4806fc220"

URI_npth = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/npth-1.6-21.el10.x86_64_v2.rpm;name=npth;unpack=0"
SRC_URI += "${URI_npth}"
SRC_URI[npth.sha256sum] = "a21d4861f783e1241ba12e43492720beb4d794927909d5a23eac771e205692cb"
RDEPENDS:npth = " \
 glibc \
"

URI_npth-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/npth-devel-1.6-21.el10.x86_64_v2.rpm;name=npth-devel;unpack=0"
SRC_URI += "${URI_npth-devel}"
SRC_URI[npth-devel.sha256sum] = "d17ab70efdc8aee417acf66d38cd2107e46d5b684e47384dba088ff91c6ec6be"
RDEPENDS:npth-devel = " \
 bash \
 npth \
"
