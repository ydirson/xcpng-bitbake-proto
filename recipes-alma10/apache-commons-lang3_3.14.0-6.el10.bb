# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "apache-commons-lang3"
PE = "0"
PV = "3.14.0"
PR = "6.el10"
PACKAGES = "apache-commons-lang3 apache-commons-lang3-javadoc"
PROVIDES = "rpm/apache-commons-lang3 rpm/apache-commons-lang3-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/apache-commons-lang3-3.14.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0113cc39b39c3883f35417f156cfc1ec2841b81b1047a483884265f26ce081a"

URI_apache-commons-lang3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/apache-commons-lang3-3.14.0-6.el10.noarch.rpm;name=apache-commons-lang3;unpack=0"
SRC_URI += "${URI_apache-commons-lang3}"
SRC_URI[apache-commons-lang3.sha256sum] = "89e7bf219b86d02bf4d801f810e7f3c9099271753edacda9af50660e3429f904"
RDEPENDS:apache-commons-lang3 = " \
 javapackages-filesystem \
"

URI_apache-commons-lang3-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/apache-commons-lang3-javadoc-3.14.0-6.el10.noarch.rpm;name=apache-commons-lang3-javadoc;unpack=0"
SRC_URI += "${URI_apache-commons-lang3-javadoc}"
SRC_URI[apache-commons-lang3-javadoc.sha256sum] = "dbcefad6e340242fb7a951eb3036cd86937a839475d278a03ccac74b8e73fb23"
RDEPENDS:apache-commons-lang3-javadoc = " \
 javapackages-filesystem \
"
