# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rust-sequoia-sq"
PE = "0"
PV = "1.3.0"
PR = "2.el10_0"
PACKAGES = "sequoia-sq"
PROVIDES = "rpm/sequoia-sq"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/rust-sequoia-sq-1.3.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65d0eb8e942d1466c4eaf65c3122cab5de02484e17bc86a4c67efcb52558c25f"

URI_sequoia-sq = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sequoia-sq-1.3.0-2.el10_0.x86_64_v2.rpm;name=sequoia-sq;unpack=0"
SRC_URI += "${URI_sequoia-sq}"
SRC_URI[sequoia-sq.sha256sum] = "5669e759cfc928cf9519cc38f04d96a83ae8d3f180b912868407a498ca556093"
RDEPENDS:sequoia-sq = " \
 glibc \
 sqlite-libs \
 openssl-libs \
 libgcc \
"
