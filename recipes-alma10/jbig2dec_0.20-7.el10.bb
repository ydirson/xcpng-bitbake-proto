# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jbig2dec"
PE = "0"
PV = "0.20"
PR = "7.el10"
PACKAGES = "jbig2dec-libs jbig2dec-devel jbig2dec"
PROVIDES = "rpm/jbig2dec-libs rpm/jbig2dec-devel rpm/jbig2dec"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/jbig2dec-0.20-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a76867690f4e9aa1ed4111439bf54eddfc95f7b7892bf08693deca72254e46dc"

URI_jbig2dec-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jbig2dec-libs-0.20-7.el10.x86_64_v2.rpm;name=jbig2dec-libs;unpack=0"
SRC_URI += "${URI_jbig2dec-libs}"
SRC_URI[jbig2dec-libs.sha256sum] = "cdee49bffb7711b514de9b06f1d7c857949c0600f4c0873c3be8739505fb0258"
RDEPENDS:jbig2dec-libs = " \
 glibc \
"

URI_jbig2dec-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jbig2dec-devel-0.20-7.el10.x86_64_v2.rpm;name=jbig2dec-devel;unpack=0"
SRC_URI += "${URI_jbig2dec-devel}"
SRC_URI[jbig2dec-devel.sha256sum] = "ba08bb346dce0510e31f4989c8223bb0a55b1052d834c9fd1729724fe1c71467"
RDEPENDS:jbig2dec-devel = " \
 jbig2dec-libs \
 pkgconf-pkg-config \
"

URI_jbig2dec = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/jbig2dec-0.20-7.el10.x86_64_v2.rpm;name=jbig2dec;unpack=0"
SRC_URI += "${URI_jbig2dec}"
SRC_URI[jbig2dec.sha256sum] = "19af1a8ab13b1aa50b854e0d752acf8ae176b685811fb10a876c3bf3dcc96b60"
RDEPENDS:jbig2dec = " \
 glibc \
 jbig2dec-libs \
 libpng \
"
