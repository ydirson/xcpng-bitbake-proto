# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "nvme-cli"
PE = "0"
PV = "2.11"
PR = "6.el10_0"
PACKAGES = "nvme-cli"
PROVIDES = "rpm/nvme-cli"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/nvme-cli-2.11-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c58305b647a660b65362890508448d71dd8cf6e77ae3052bda9f5543591eb55b"

URI_nvme-cli = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/nvme-cli-2.11-6.el10_0.x86_64_v2.rpm;name=nvme-cli;unpack=0"
SRC_URI += "${URI_nvme-cli}"
SRC_URI[nvme-cli.sha256sum] = "00ecd0639fb5b34f9e347947978dff0f921726af1277607eb0355da35596fdaa"
RDEPENDS:nvme-cli = " \
 util-linux \
 libgcc \
 json-c \
 bash \
 glibc \
 libnvme \
"
