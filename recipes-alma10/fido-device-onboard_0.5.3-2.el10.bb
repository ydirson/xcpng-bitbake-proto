# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "fido-device-onboard"
PE = "0"
PV = "0.5.3"
PR = "2.el10"
PACKAGES = "fdo-admin-cli fdo-client fdo-init fdo-manufacturing-server fdo-owner-cli fdo-owner-onboarding-server fdo-rendezvous-server"
PROVIDES = "rpm/fdo-admin-cli rpm/fdo-client rpm/fdo-init rpm/fdo-manufacturing-server rpm/fdo-owner-cli rpm/fdo-owner-onboarding-server rpm/fdo-rendezvous-server"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/fido-device-onboard-0.5.3-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afb8dc3d1925dbb050388052027a6aec287940a7602ea3536b0c3fcb109fd181"

URI_fdo-admin-cli = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fdo-admin-cli-0.5.3-2.el10.x86_64_v2.rpm;name=fdo-admin-cli;unpack=0"
SRC_URI += "${URI_fdo-admin-cli}"
SRC_URI[fdo-admin-cli.sha256sum] = "1a4df67d781a6184b390d12dbcf6b5dee502e54e131e590a1e56820b7379bc08"
RDEPENDS:fdo-admin-cli = " \
 openssl-libs \
 libgcc \
 bash \
 fdo-client \
 tpm2-tss \
 glibc \
 fdo-init \
 fdo-manufacturing-server \
 fdo-owner-cli \
 fdo-owner-onboarding-server \
 fdo-rendezvous-server \
"

URI_fdo-client = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fdo-client-0.5.3-2.el10.x86_64_v2.rpm;name=fdo-client;unpack=0"
SRC_URI += "${URI_fdo-client}"
SRC_URI[fdo-client.sha256sum] = "992c15c26032cfcdf09cc0ce5c5d2f82f36f7bb209fea70af8033182442d2f6e"
RDEPENDS:fdo-client = " \
 cryptsetup \
 cryptsetup-libs \
 openssl-libs \
 libgcc \
 clevis \
 bash \
 clevis-luks \
 clevis-pin-tpm2 \
 tpm2-tss \
 glibc \
"

URI_fdo-init = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fdo-init-0.5.3-2.el10.x86_64_v2.rpm;name=fdo-init;unpack=0"
SRC_URI += "${URI_fdo-init}"
SRC_URI[fdo-init.sha256sum] = "bdcded553e576da5693c94a604a6e97a35ec47bd706d381cbeac6f38daab6221"
RDEPENDS:fdo-init = " \
 openssl-libs \
 libgcc \
 bash \
 dracut \
 tpm2-tss \
 glibc \
"

URI_fdo-manufacturing-server = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fdo-manufacturing-server-0.5.3-2.el10.x86_64_v2.rpm;name=fdo-manufacturing-server;unpack=0"
SRC_URI += "${URI_fdo-manufacturing-server}"
SRC_URI[fdo-manufacturing-server.sha256sum] = "f30bbf6340c603e663e41d4e746d461dbfc9cf5764145031da1f1c3646d72a6d"
RDEPENDS:fdo-manufacturing-server = " \
 libpq \
 openssl-libs \
 libgcc \
 sqlite-libs \
 bash \
 tpm2-tss \
 glibc \
"

URI_fdo-owner-cli = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fdo-owner-cli-0.5.3-2.el10.x86_64_v2.rpm;name=fdo-owner-cli;unpack=0"
SRC_URI += "${URI_fdo-owner-cli}"
SRC_URI[fdo-owner-cli.sha256sum] = "d300d16c6719f82ab34e356e5bd6633ea799f66c64b1efd5886848748b76cdd0"
RDEPENDS:fdo-owner-cli = " \
 libpq \
 openssl-libs \
 libgcc \
 sqlite-libs \
 tpm2-tss \
 glibc \
"

URI_fdo-owner-onboarding-server = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fdo-owner-onboarding-server-0.5.3-2.el10.x86_64_v2.rpm;name=fdo-owner-onboarding-server;unpack=0"
SRC_URI += "${URI_fdo-owner-onboarding-server}"
SRC_URI[fdo-owner-onboarding-server.sha256sum] = "85912d97a885e6c4d7e9726470686317055b307202698729fb6ed940c43d9d33"
RDEPENDS:fdo-owner-onboarding-server = " \
 libpq \
 openssl-libs \
 libgcc \
 sqlite-libs \
 bash \
 tpm2-tss \
 glibc \
"

URI_fdo-rendezvous-server = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fdo-rendezvous-server-0.5.3-2.el10.x86_64_v2.rpm;name=fdo-rendezvous-server;unpack=0"
SRC_URI += "${URI_fdo-rendezvous-server}"
SRC_URI[fdo-rendezvous-server.sha256sum] = "bc345792e0fdbb59eb30c001817701e2f9ed8903b7d723d0afd414c361934406"
RDEPENDS:fdo-rendezvous-server = " \
 libpq \
 openssl-libs \
 libgcc \
 sqlite-libs \
 bash \
 tpm2-tss \
 glibc \
"
