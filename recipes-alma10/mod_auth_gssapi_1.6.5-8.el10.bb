# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mod_auth_gssapi"
PE = "0"
PV = "1.6.5"
PR = "8.el10"
PACKAGES = "mod_auth_gssapi"
PROVIDES = "rpm/mod_auth_gssapi"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mod_auth_gssapi-1.6.5-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc2d0ff57bf9e01d8a97b95eb96c884606f282d8382925a8a405dd69e3e94768"

URI_mod_auth_gssapi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mod_auth_gssapi-1.6.5-8.el10.x86_64_v2.rpm;name=mod_auth_gssapi;unpack=0"
SRC_URI += "${URI_mod_auth_gssapi}"
SRC_URI[mod_auth_gssapi.sha256sum] = "e4daf2a326d7e50f39dc1643c491f48afaf264f8bc3024bae0782f902047fbe8"
RDEPENDS:mod_auth_gssapi = " \
 httpd-core \
 openssl-libs \
 krb5-libs \
 libcom_err \
 glibc \
"
