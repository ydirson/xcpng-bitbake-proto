# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libassuan"
PE = "0"
PV = "2.5.6"
PR = "6.el10"
PACKAGES = "libassuan libassuan-devel"
PROVIDES = "rpm/libassuan rpm/libassuan-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libassuan-2.5.6-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f327c3ca740b46d79e22b0801d2fb3e842934b567666a45a13f373fc696912ee"

URI_libassuan = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libassuan-2.5.6-6.el10.x86_64_v2.rpm;name=libassuan;unpack=0"
SRC_URI += "${URI_libassuan}"
SRC_URI[libassuan.sha256sum] = "973a9407ad42671e06b77c224f71b136a214f3e7e490e2085834226e7ff135cd"
RDEPENDS:libassuan = " \
 glibc \
 libgpg-error \
"

URI_libassuan-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libassuan-devel-2.5.6-6.el10.x86_64_v2.rpm;name=libassuan-devel;unpack=0"
SRC_URI += "${URI_libassuan-devel}"
SRC_URI[libassuan-devel.sha256sum] = "667553b11ebaab9787fabcc7ccbd033c756ae6a04e1d9ac5e8db27128fc690e3"
RDEPENDS:libassuan-devel = " \
 libgpg-error-devel \
 bash \
 pkgconf-pkg-config \
 libassuan \
"
