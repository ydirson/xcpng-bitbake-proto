# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-pam"
PE = "0"
PV = "2.0.2"
PR = "10.el10"
PACKAGES = "python3-pam"
PROVIDES = "rpm/python3-pam"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-pam-2.0.2-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19579fa550176497d81f065c1b4865953aa16bfa5710736ad8a8794243759856"

URI_python3-pam = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-pam-2.0.2-10.el10.noarch.rpm;name=python3-pam;unpack=0"
SRC_URI += "${URI_python3-pam}"
SRC_URI[python3-pam.sha256sum] = "cdbdfcfdb8ac5dbacc9b1c69c4fa785cfe9501542635dc56e837c57454f1a94b"
RDEPENDS:python3-pam = " \
 python3 \
"
