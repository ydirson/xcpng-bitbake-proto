# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "logwatch"
PE = "0"
PV = "7.11"
PR = "2.el10"
PACKAGES = "logwatch"
PROVIDES = "rpm/logwatch"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/logwatch-7.11-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "912c1e2c4568a42ce010980194a944801501e51166537e3fe00f741e61120c0a"

URI_logwatch = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/logwatch-7.11-2.el10.noarch.rpm;name=logwatch;unpack=0"
SRC_URI += "${URI_logwatch}"
SRC_URI[logwatch.sha256sum] = "0fe93d67c0b99137e2272eed09f45c323a07d7c8f91bb4d9fee97798ed0e88f9"
RDEPENDS:logwatch = " \
 crontabs \
 perl-libs \
 perl-Socket \
 perl-Getopt-Long \
 perl-HTML-Parser \
 perl-subs \
 perl-vars \
 perl-lib \
 perl-Time-Local \
 perl-Date-Manip \
 perl-URI \
 grep \
 bash \
 perl-Errno \
 perl-Exporter \
 perl-diagnostics \
 perl-POSIX \
 perl-File-Basename \
 perl-PathTools \
 perl-interpreter \
 perl-File-Temp \
"
