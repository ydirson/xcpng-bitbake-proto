# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-XML-SAX-Base"
PE = "0"
PV = "1.09"
PR = "25.el10"
PACKAGES = "perl-XML-SAX-Base perl-XML-SAX-Base-tests"
PROVIDES = "rpm/perl-XML-SAX-Base rpm/perl-XML-SAX-Base-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-XML-SAX-Base-1.09-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57aef9faa59a8f49c8ce8b6a3885129e506dc2d3e4d4fc2fde0661d72f04af53"

URI_perl-XML-SAX-Base = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-XML-SAX-Base-1.09-25.el10.noarch.rpm;name=perl-XML-SAX-Base;unpack=0"
SRC_URI += "${URI_perl-XML-SAX-Base}"
SRC_URI[perl-XML-SAX-Base.sha256sum] = "c7bf3c5bfca62c463e95b67e81cf1d29cc7a1c9d88bb8835c129eabaefb58c89"
RDEPENDS:perl-XML-SAX-Base = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-overload \
 perl-XML-SAX-Base \
"

URI_perl-XML-SAX-Base-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-XML-SAX-Base-tests-1.09-25.el10.noarch.rpm;name=perl-XML-SAX-Base-tests;unpack=0"
SRC_URI += "${URI_perl-XML-SAX-Base-tests}"
SRC_URI[perl-XML-SAX-Base-tests.sha256sum] = "fd23b0fcb7a59b0dc0682f5c8ca0fa87055a4bce5427b4882b29428c7f889fd6"
RDEPENDS:perl-XML-SAX-Base-tests = " \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 perl-vars \
 bash \
 perl-XML-SAX-Base \
 perl-interpreter \
 perl-base \
"
