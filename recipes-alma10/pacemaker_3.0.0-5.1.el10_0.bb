# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pacemaker"
PE = "0"
PV = "3.0.0"
PR = "5.1.el10_0"
PACKAGES = "pacemaker-cluster-libs pacemaker-libs pacemaker-schemas"
PROVIDES = "rpm/pacemaker-cluster-libs rpm/pacemaker-libs rpm/pacemaker-schemas"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/pacemaker-3.0.0-5.1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0630ff3db0a3b71824479f62ff563112a5b50078cebdd94d802d54f53e6cde0a"

URI_pacemaker-cluster-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pacemaker-cluster-libs-3.0.0-5.1.el10_0.x86_64_v2.rpm;name=pacemaker-cluster-libs;unpack=0"
SRC_URI += "${URI_pacemaker-cluster-libs}"
SRC_URI[pacemaker-cluster-libs.sha256sum] = "878179ee6c76f756d7dc711020c10cc5e3909b44f21197e93aa10ccb2d79714c"
RDEPENDS:pacemaker-cluster-libs = " \
 libqb \
 libuuid \
 libxslt \
 gnutls \
 bzip2-libs \
 corosynclib \
 pacemaker-libs \
 libxml2 \
 glib2 \
 glibc \
 dbus-libs \
"

URI_pacemaker-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pacemaker-libs-3.0.0-5.1.el10_0.x86_64_v2.rpm;name=pacemaker-libs;unpack=0"
SRC_URI += "${URI_pacemaker-libs}"
SRC_URI[pacemaker-libs.sha256sum] = "68a2bb135c2196c912475bc59b843530884d6b1c31e4b9a76f452f4692938a2a"
RDEPENDS:pacemaker-libs = " \
 libqb \
 libuuid \
 shadow-utils \
 libxslt \
 gnutls \
 bzip2-libs \
 pacemaker-schemas \
 libxml2 \
 bash \
 glib2 \
 glibc \
 dbus-libs \
"

URI_pacemaker-schemas = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pacemaker-schemas-3.0.0-5.1.el10_0.noarch.rpm;name=pacemaker-schemas;unpack=0"
SRC_URI += "${URI_pacemaker-schemas}"
SRC_URI[pacemaker-schemas.sha256sum] = "39b2716c64ca2c1968dc066a6ccd0a4da89244e3f0f0e92c8a185c86ac880617"
RDEPENDS:pacemaker-schemas = " \
 pkgconf-pkg-config \
"
