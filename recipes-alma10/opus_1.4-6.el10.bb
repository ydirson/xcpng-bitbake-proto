# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "opus"
PE = "0"
PV = "1.4"
PR = "6.el10"
PACKAGES = "opus opus-devel"
PROVIDES = "rpm/opus rpm/opus-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/opus-1.4-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "94ccca7cbab72630ea8f9a8322c699cbf8eabc7eae8801a7d84e9c89eb7eba61"

URI_opus = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/opus-1.4-6.el10.x86_64_v2.rpm;name=opus;unpack=0"
SRC_URI += "${URI_opus}"
SRC_URI[opus.sha256sum] = "778c518dfd8ff4cd80274dadca551fcbe21372b99161da8566f799c7114e17ac"
RDEPENDS:opus = " \
 glibc \
"

URI_opus-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/opus-devel-1.4-6.el10.x86_64_v2.rpm;name=opus-devel;unpack=0"
SRC_URI += "${URI_opus-devel}"
SRC_URI[opus-devel.sha256sum] = "bc1db8ca200797c614b2ff4ee6357b147aec6e0fc87b900a93c8f470c56ae445"
RDEPENDS:opus-devel = " \
 libogg-devel \
 opus \
 pkgconf-pkg-config \
"
