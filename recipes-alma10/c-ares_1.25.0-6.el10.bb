# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "c-ares"
PE = "0"
PV = "1.25.0"
PR = "6.el10"
PACKAGES = "c-ares c-ares-devel"
PROVIDES = "rpm/c-ares rpm/c-ares-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/c-ares-1.25.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa54666e3155ce6b83b018470ad79427dbf317ae86e929c9e5cf32b027611ab5"

URI_c-ares = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/c-ares-1.25.0-6.el10.x86_64_v2.rpm;name=c-ares;unpack=0"
SRC_URI += "${URI_c-ares}"
SRC_URI[c-ares.sha256sum] = "b2180b0a38cf6dcf73c333bfdcb0994bf9a86fb22739cab5f97a0aa4cd543c00"
RDEPENDS:c-ares = " \
 glibc \
"

URI_c-ares-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/c-ares-devel-1.25.0-6.el10.x86_64_v2.rpm;name=c-ares-devel;unpack=0"
SRC_URI += "${URI_c-ares-devel}"
SRC_URI[c-ares-devel.sha256sum] = "10a9d7c51cf213b02e22f0faf24f6d1db73919c24d652986f97333d7da7edc26"
RDEPENDS:c-ares-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 c-ares \
"
