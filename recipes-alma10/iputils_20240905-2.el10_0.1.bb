# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "iputils"
PE = "0"
PV = "20240905"
PR = "2.el10_0.1"
PACKAGES = "iputils"
PROVIDES = "rpm/iputils"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/iputils-20240905-2.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d48fd892abcf4e4aeeca311de3774700a3162c2225234f379ceb53fd419946d5"

URI_iputils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/iputils-20240905-2.el10_0.1.x86_64_v2.rpm;name=iputils;unpack=0"
SRC_URI += "${URI_iputils}"
SRC_URI[iputils.sha256sum] = "772c5149a230e1b4e1e5b916035d1bf418208bcbace9755a40e1f1354e0d11ac"
RDEPENDS:iputils = " \
 glibc \
 libidn2 \
 libcap \
"
