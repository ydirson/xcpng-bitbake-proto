# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-IPC-Run"
PE = "0"
PV = "20231003.0"
PR = "6.el10"
PACKAGES = "perl-IPC-Run perl-IPC-Run-tests"
PROVIDES = "rpm/perl-IPC-Run rpm/perl-IPC-Run-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-IPC-Run-20231003.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cfd91abffee0831740b91e65620a2d6afddc9fbe37f50b8ef948cd807272df6e"

URI_perl-IPC-Run = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-IPC-Run-20231003.0-6.el10.noarch.rpm;name=perl-IPC-Run;unpack=0"
SRC_URI += "${URI_perl-IPC-Run}"
SRC_URI[perl-IPC-Run.sha256sum] = "82a08e4777f032fe4f0a2815248279e52c21c3ca2fe5c3b916e6f4379c2d4ecc"
RDEPENDS:perl-IPC-Run = " \
 perl-IO-Tty \
 perl-constant \
 perl-IPC-Run \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-IO \
 perl-Fcntl \
 perl-File-Basename \
 perl-POSIX \
 perl-Symbol \
 perl-PathTools \
 perl-Errno \
 perl-Exporter \
 perl-Data-Dumper \
"

URI_perl-IPC-Run-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-IPC-Run-tests-20231003.0-6.el10.noarch.rpm;name=perl-IPC-Run-tests;unpack=0"
SRC_URI += "${URI_perl-IPC-Run-tests}"
SRC_URI[perl-IPC-Run-tests.sha256sum] = "263d349c7496000e51cb6cc6f540eef4d7aa3b3443c4577f947eb781f6f3d7f0"
RDEPENDS:perl-IPC-Run-tests = " \
 perl-IPC-Run \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-vars \
 perl-IO \
 perl-POSIX \
 perl-Encode \
 bash \
 perl-PathTools \
 perl-interpreter \
 perl-Data-Dumper \
 perl-Exporter \
 perl-File-Temp \
"
