# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libiptcdata"
PE = "0"
PV = "1.0.5"
PR = "20.el10"
PACKAGES = "libiptcdata libiptcdata-devel"
PROVIDES = "rpm/libiptcdata rpm/libiptcdata-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libiptcdata-1.0.5-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa38c0e25518eccf186130889c462ae219a674118b7d89f996ebd56ea95cb41d"

URI_libiptcdata = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libiptcdata-1.0.5-20.el10.x86_64_v2.rpm;name=libiptcdata;unpack=0"
SRC_URI += "${URI_libiptcdata}"
SRC_URI[libiptcdata.sha256sum] = "12acba8073513efe8c6533a348b5c041447122a9d4de481c26c94a9313e253f1"
RDEPENDS:libiptcdata = " \
 glibc \
"

URI_libiptcdata-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libiptcdata-devel-1.0.5-20.el10.x86_64_v2.rpm;name=libiptcdata-devel;unpack=0"
SRC_URI += "${URI_libiptcdata-devel}"
SRC_URI[libiptcdata-devel.sha256sum] = "0bdfb74af4b79ae3cad89ad45ceb37002efc9eb8fc71dae1b7648eb428849b0d"
RDEPENDS:libiptcdata-devel = " \
 libiptcdata \
 pkgconf-pkg-config \
"
