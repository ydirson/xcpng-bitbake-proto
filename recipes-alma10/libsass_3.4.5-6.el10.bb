# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libsass"
PE = "0"
PV = "3.4.5"
PR = "6.el10"
PACKAGES = "libsass libsass-devel"
PROVIDES = "rpm/libsass rpm/libsass-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/libsass-3.4.5-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02540dc1fd815aac77f0c00b790dc907680aff820abf4981425aa9114333eaae"

URI_libsass = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libsass-3.4.5-6.el10.x86_64_v2.rpm;name=libsass;unpack=0"
SRC_URI += "${URI_libsass}"
SRC_URI[libsass.sha256sum] = "ddb38aee7482ada4293fa8719d8ca42c4aade2517e83f88fd31ec108feec17a1"
RDEPENDS:libsass = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_libsass-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libsass-devel-3.4.5-6.el10.x86_64_v2.rpm;name=libsass-devel;unpack=0"
SRC_URI += "${URI_libsass-devel}"
SRC_URI[libsass-devel.sha256sum] = "9e424ad1ecab6602c8bf47a5aebce5f398b30b70d71d22bb0ac3473de311840e"
RDEPENDS:libsass-devel = " \
 libsass \
 pkgconf-pkg-config \
"
