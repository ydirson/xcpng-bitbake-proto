# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-da"
PE = "0"
PV = "0.20070903"
PR = "33.el10"
PACKAGES = "hyphen-da"
PROVIDES = "rpm/hyphen-da"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-da-0.20070903-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c482cd9cade3f7cae5948acc795be91ac20561c6f479a58c034d54a8aae5e3f"

URI_hyphen-da = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-da-0.20070903-33.el10.noarch.rpm;name=hyphen-da;unpack=0"
SRC_URI += "${URI_hyphen-da}"
SRC_URI[hyphen-da.sha256sum] = "385b8f7f57270d1053c1a2c03176ac4a0dc46393329bfb23116fbbfa1c305e07"
RDEPENDS:hyphen-da = " \
 hyphen \
"
