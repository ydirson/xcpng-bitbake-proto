# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "WALinuxAgent"
PE = "0"
PV = "2.9.1.1"
PR = "9.el10_0.1"
PACKAGES = "WALinuxAgent WALinuxAgent-udev"
PROVIDES = "rpm/WALinuxAgent rpm/WALinuxAgent-udev"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/WALinuxAgent-2.9.1.1-9.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f138dfd001519bdd2a138cf3e2c668c9048895c5ffb860d89dddb2694b6b119b"

URI_WALinuxAgent = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/WALinuxAgent-2.9.1.1-9.el10_0.1.noarch.rpm;name=WALinuxAgent;unpack=0"
SRC_URI += "${URI_WALinuxAgent}"
SRC_URI[WALinuxAgent.sha256sum] = "54edb682e405ded2648cfc208124e16c24debddea2a22f24a34eb970186a2651"
RDEPENDS:WALinuxAgent = " \
 python3 \
 WALinuxAgent-udev \
 systemd \
 openssh \
 openssh-server \
 python3-pyasn1 \
 openssl \
 parted \
 bash \
 iptables-nft \
"

URI_WALinuxAgent-udev = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/WALinuxAgent-udev-2.9.1.1-9.el10_0.1.noarch.rpm;name=WALinuxAgent-udev;unpack=0"
SRC_URI += "${URI_WALinuxAgent-udev}"
SRC_URI[WALinuxAgent-udev.sha256sum] = "c9ebf630b30cec85de58a49798c5b83fd01b5840fb0a698589e3ae067b80b355"
RDEPENDS:WALinuxAgent-udev = " \
 bash \
"
