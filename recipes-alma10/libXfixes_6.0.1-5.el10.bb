# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libXfixes"
PE = "0"
PV = "6.0.1"
PR = "5.el10"
PACKAGES = "libXfixes libXfixes-devel"
PROVIDES = "rpm/libXfixes rpm/libXfixes-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libXfixes-6.0.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a3b0b136c264d465f74d2d80dde2a4d466836dc4847b11803882305f5dc17de"

URI_libXfixes = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXfixes-6.0.1-5.el10.x86_64_v2.rpm;name=libXfixes;unpack=0"
SRC_URI += "${URI_libXfixes}"
SRC_URI[libXfixes.sha256sum] = "8daf697da8567e4af27b4db62f209f6da856af34972e8602c09b475d1b4fa1e3"
RDEPENDS:libXfixes = " \
 glibc \
 libX11 \
"

URI_libXfixes-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXfixes-devel-6.0.1-5.el10.x86_64_v2.rpm;name=libXfixes-devel;unpack=0"
SRC_URI += "${URI_libXfixes-devel}"
SRC_URI[libXfixes-devel.sha256sum] = "48918edbbed1fa779715122b52333225894e0fdd72fb8827d3886bf5428a43f9"
RDEPENDS:libXfixes-devel = " \
 libXfixes \
 libX11-devel \
 xorg-x11-proto-devel \
 pkgconf-pkg-config \
"
