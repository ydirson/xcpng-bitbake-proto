# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "google-noto-emoji-fonts"
PE = "0"
PV = "20231130"
PR = "3.el10"
PACKAGES = "google-noto-color-emoji-fonts google-noto-emoji-fonts"
PROVIDES = "rpm/google-noto-color-emoji-fonts rpm/google-noto-emoji-fonts"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/google-noto-emoji-fonts-20231130-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "180d55fc29ab270e2c88de844f9de575210614d149ae1400bbe459032172f9ac"

URI_google-noto-color-emoji-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-color-emoji-fonts-20231130-3.el10.noarch.rpm;name=google-noto-color-emoji-fonts;unpack=0"
SRC_URI += "${URI_google-noto-color-emoji-fonts}"
SRC_URI[google-noto-color-emoji-fonts.sha256sum] = "cebaf6dbd64f3f75455d67408ab15d5dc2563fecf3648516ab10eb9f3b663ee4"
RDEPENDS:google-noto-color-emoji-fonts = " \
 fonts-filesystem \
"

URI_google-noto-emoji-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-emoji-fonts-20231130-3.el10.noarch.rpm;name=google-noto-emoji-fonts;unpack=0"
SRC_URI += "${URI_google-noto-emoji-fonts}"
SRC_URI[google-noto-emoji-fonts.sha256sum] = "a94a1b3f4aeeaebb2af94d6b2d6fc9719cb7d03b0c6892324b867fa00523054b"
RDEPENDS:google-noto-emoji-fonts = " \
 fonts-filesystem \
"
