# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "frr"
PE = "0"
PV = "10.1"
PR = "10.el10"
PACKAGES = "frr frr-selinux"
PROVIDES = "rpm/frr rpm/frr-selinux"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/frr-10.1-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "416b1271727439410cd9b4fb06dbd1552e92e87b1b16ff27ad2859565174410a"

URI_frr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/frr-10.1-10.el10.x86_64_v2.rpm;name=frr;unpack=0"
SRC_URI += "${URI_frr}"
SRC_URI[frr.sha256sum] = "816d51fb91e4e1c82c96976d61b0fc6137dc07b26685aa6e8dc1df3d399be9da"
RDEPENDS:frr = " \
 python3 \
 systemd \
 ncurses \
 json-c \
 libcap \
 frr-selinux \
 shadow-utils \
 net-snmp \
 net-snmp-agent-libs \
 net-snmp-libs \
 libxcrypt \
 libgcc \
 openssl-libs \
 bash \
 c-ares \
 libyang \
 readline \
 hostname \
 glibc \
 protobuf-c \
 rpm-libs \
"

URI_frr-selinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/frr-selinux-10.1-10.el10.noarch.rpm;name=frr-selinux;unpack=0"
SRC_URI += "${URI_frr-selinux}"
SRC_URI[frr-selinux.sha256sum] = "6b07ae536f8e29c726097c13972afd8cd3925c6cf2b915544272fbfcad41b24a"
RDEPENDS:frr-selinux = " \
 policycoreutils-python-utils \
 policycoreutils \
 bash \
 selinux-policy \
 libselinux-utils \
 selinux-policy-targeted \
"
