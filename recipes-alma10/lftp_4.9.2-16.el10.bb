# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lftp"
PE = "0"
PV = "4.9.2"
PR = "16.el10"
PACKAGES = "lftp"
PROVIDES = "rpm/lftp"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/lftp-4.9.2-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "386ea45ec3d41050e1f8cde7ae9211d727521b58dafba6dcb5de33b66ef684e8"

URI_lftp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lftp-4.9.2-16.el10.x86_64_v2.rpm;name=lftp;unpack=0"
SRC_URI += "${URI_lftp}"
SRC_URI[lftp.sha256sum] = "bbd56c85ef2c5051e15f4c448d02aa981c12c3b67c280200717e11fed0fd2daa"
RDEPENDS:lftp = " \
 zlib-ng-compat \
 gnutls \
 libgcc \
 readline \
 libstdc++ \
 bash \
 ncurses-libs \
 glibc \
 libidn2 \
"
