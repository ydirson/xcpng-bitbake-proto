# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libnet"
PE = "0"
PV = "1.3"
PR = "7.el10"
PACKAGES = "libnet libnet-devel libnet-doc"
PROVIDES = "rpm/libnet rpm/libnet-devel rpm/libnet-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libnet-1.3-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72f719b07d783d5a669da6ad1a8abdc1d21b38f648c67bda117481b52556587e"

URI_libnet = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libnet-1.3-7.el10.x86_64_v2.rpm;name=libnet;unpack=0"
SRC_URI += "${URI_libnet}"
SRC_URI[libnet.sha256sum] = "3411f17aaf3afbe724a1018fc5efa11dbdda82a0cdd9c3355c7c3577fd834205"
RDEPENDS:libnet = " \
 glibc \
"

URI_libnet-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libnet-devel-1.3-7.el10.x86_64_v2.rpm;name=libnet-devel;unpack=0"
SRC_URI += "${URI_libnet-devel}"
SRC_URI[libnet-devel.sha256sum] = "8f7d4649ffc4cb6d8ef7d3ee29a86634b589634f0ce8b97a872076ea5077161d"
RDEPENDS:libnet-devel = " \
 bash \
 pkgconf-pkg-config \
 libnet \
"

URI_libnet-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libnet-doc-1.3-7.el10.noarch.rpm;name=libnet-doc;unpack=0"
SRC_URI += "${URI_libnet-doc}"
SRC_URI[libnet-doc.sha256sum] = "84a394f09dba2658a2f26e894234c741facb2bdc78dc97dec0807e1f3e77bc88"
RDEPENDS:libnet-doc = ""
