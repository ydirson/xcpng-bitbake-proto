# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libdisplay-info"
PE = "0"
PV = "0.2.0"
PR = "2.el10"
PACKAGES = "libdisplay-info libdisplay-info-devel libdisplay-info-tools"
PROVIDES = "rpm/libdisplay-info rpm/libdisplay-info-devel rpm/libdisplay-info-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libdisplay-info-0.2.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b55fc0645ccea6a774e0b24c291fc63c2036bac895e3c963d665e3f6da4045d5"

URI_libdisplay-info = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libdisplay-info-0.2.0-2.el10.x86_64_v2.rpm;name=libdisplay-info;unpack=0"
SRC_URI += "${URI_libdisplay-info}"
SRC_URI[libdisplay-info.sha256sum] = "48ef394039932d360cba9f5dd1a396fa3ff04ba58254434953cf3a43d2c11003"
RDEPENDS:libdisplay-info = " \
 glibc \
"

URI_libdisplay-info-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libdisplay-info-devel-0.2.0-2.el10.x86_64_v2.rpm;name=libdisplay-info-devel;unpack=0"
SRC_URI += "${URI_libdisplay-info-devel}"
SRC_URI[libdisplay-info-devel.sha256sum] = "63168dc56c5f7f5b44ec7ebbcf3faddce19129497d3e1e7a45b220c97894b76b"
RDEPENDS:libdisplay-info-devel = " \
 libdisplay-info \
 pkgconf-pkg-config \
"

URI_libdisplay-info-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libdisplay-info-tools-0.2.0-2.el10.x86_64_v2.rpm;name=libdisplay-info-tools;unpack=0"
SRC_URI += "${URI_libdisplay-info-tools}"
SRC_URI[libdisplay-info-tools.sha256sum] = "1445c54ea04ba26854f38fb03b0e0bc4b2b6ba3698eef55c6dcede19e0af558f"
RDEPENDS:libdisplay-info-tools = " \
 glibc \
 libdisplay-info \
"
