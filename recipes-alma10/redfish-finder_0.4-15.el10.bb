# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "redfish-finder"
PE = "0"
PV = "0.4"
PR = "15.el10"
PACKAGES = "redfish-finder"
PROVIDES = "rpm/redfish-finder"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/redfish-finder-0.4-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8010dc5563b36d1a90ea23fc49c23c6e7c01898b90e012d731fc6957411e1c49"

URI_redfish-finder = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/redfish-finder-0.4-15.el10.x86_64_v2.rpm;name=redfish-finder;unpack=0"
SRC_URI += "${URI_redfish-finder}"
SRC_URI[redfish-finder.sha256sum] = "75bcf82eb2f98608abc478ab9ba9452fb9edac95e89ca5b501ece20b202a86d6"
RDEPENDS:redfish-finder = " \
 python3 \
 NetworkManager \
 dmidecode \
 bash \
"
