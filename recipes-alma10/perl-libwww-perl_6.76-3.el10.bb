# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-libwww-perl"
PE = "0"
PV = "6.76"
PR = "3.el10"
PACKAGES = "perl-libwww-perl perl-libwww-perl-tests"
PROVIDES = "rpm/perl-libwww-perl rpm/perl-libwww-perl-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-libwww-perl-6.76-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "29583d98e587a971f0f917a73a8715eb657ddf5cf01f70e64c28c6612ec670e1"

URI_perl-libwww-perl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-libwww-perl-6.76-3.el10.noarch.rpm;name=perl-libwww-perl;unpack=0"
SRC_URI += "${URI_perl-libwww-perl}"
SRC_URI[perl-libwww-perl.sha256sum] = "f14d6a0a1b28f378aab5215183f314a8c0a3c298d2fdf7ad74bd66d3a4742b00"
RDEPENDS:perl-libwww-perl = " \
 perl-libnet \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-libwww-perl \
 perl-Getopt-Long \
 perl-parent \
 perl-HTML-Parser \
 perl-HTTP-Cookies \
 perl-HTTP-Date \
 perl-HTTP-Message \
 perl-HTTP-Negotiate \
 perl-File-Listing \
 perl-Carp \
 perl-IO \
 perl-LWP-MediaTypes \
 perl-Data-Dump \
 perl-MIME-Base64 \
 perl-Try-Tiny \
 perl-URI \
 perl-Digest-MD5 \
 perl-Module-Load \
 perl-WWW-RobotRules \
 perl-Encode \
 perl-Encode-Locale \
 perl-NTLM \
 perl-Exporter \
 perl-Net-HTTP \
 perl-Fcntl \
 perl-File-Copy \
 perl-PathTools \
 perl-interpreter \
"

URI_perl-libwww-perl-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-libwww-perl-tests-6.76-3.el10.noarch.rpm;name=perl-libwww-perl-tests;unpack=0"
SRC_URI += "${URI_perl-libwww-perl-tests}"
SRC_URI[perl-libwww-perl-tests.sha256sum] = "921fde8b730a0fc82c6ce545015ac6f211f6ff6b03b5e0729e349b187894d625"
RDEPENDS:perl-libwww-perl-tests = " \
 perl-libs \
 perl-libwww-perl \
 perl-FindBin \
 perl-HTTP-CookieJar \
 perl-parent \
 perl-HTTP-Cookies \
 perl-HTTP-Message \
 perl-Test-Fatal \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-IO \
 perl-URI \
 bash \
 perl-Net-HTTP \
 perl-ExtUtils-MakeMaker \
 perl-PathTools \
 coreutils \
 perl-interpreter \
 perl-HTTP-Daemon \
 perl-File-Temp \
"
