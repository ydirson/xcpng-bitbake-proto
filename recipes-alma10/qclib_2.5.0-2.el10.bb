# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qclib"
PE = "0"
PV = "2.5.0"
PR = "2.el10"
PACKAGES = ""
PROVIDES = ""


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qclib-2.5.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c95e052bb96acc87026ee4027c2f29ec4d81995d79ad34225e01109ebd91a930"
