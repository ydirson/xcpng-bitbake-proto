# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libgusb"
PE = "0"
PV = "0.4.9"
PR = "4.el10"
PACKAGES = "libgusb libgusb-devel"
PROVIDES = "rpm/libgusb rpm/libgusb-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libgusb-0.4.9-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "836cfe97740a043ed977f5dc9552eca2dcbe36a05bb85978f0403432632727ce"

URI_libgusb = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libgusb-0.4.9-4.el10.x86_64_v2.rpm;name=libgusb;unpack=0"
SRC_URI += "${URI_libgusb}"
SRC_URI[libgusb.sha256sum] = "d7de9119c062c846ffdcd4413b23a7ebe63bced9a1ab05548a9e010204c130a5"
RDEPENDS:libgusb = " \
 libgcc \
 json-glib \
 glib2 \
 glibc \
 libusb1 \
"

URI_libgusb-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libgusb-devel-0.4.9-4.el10.x86_64_v2.rpm;name=libgusb-devel;unpack=0"
SRC_URI += "${URI_libgusb-devel}"
SRC_URI[libgusb-devel.sha256sum] = "9ea03d571a784280564ee7a23fb08a11dd519252c321f0812709a32502dbbea0"
RDEPENDS:libgusb-devel = " \
 json-glib-devel \
 glib2-devel \
 libgcc \
 pkgconf-pkg-config \
 json-glib \
 libusb1-devel \
 libgusb \
 glib2 \
 glibc \
"
