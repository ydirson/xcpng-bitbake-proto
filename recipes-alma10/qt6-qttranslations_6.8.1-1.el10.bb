# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qttranslations"
PE = "0"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = "qt6-qttranslations"
PROVIDES = "rpm/qt6-qttranslations"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qttranslations-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "739852934dad59fc45fd824bd861298797283549519627c5413d51757af2e18f"

URI_qt6-qttranslations = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qttranslations-6.8.1-1.el10.noarch.rpm;name=qt6-qttranslations;unpack=0"
SRC_URI += "${URI_qt6-qttranslations}"
SRC_URI[qt6-qttranslations.sha256sum] = "3eab9d6f775f5ff66ba4b1b78962e15876ab49020d1fa5789b6d9ca36b65dded"
RDEPENDS:qt6-qttranslations = ""
