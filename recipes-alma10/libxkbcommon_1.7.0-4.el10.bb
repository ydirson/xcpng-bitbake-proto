# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libxkbcommon"
PE = "0"
PV = "1.7.0"
PR = "4.el10"
PACKAGES = "libxkbcommon libxkbcommon-devel libxkbcommon-x11 libxkbcommon-x11-devel libxkbcommon-utils libxkbcommon-x11-utils"
PROVIDES = "rpm/libxkbcommon rpm/libxkbcommon-devel rpm/libxkbcommon-x11 rpm/libxkbcommon-x11-devel rpm/libxkbcommon-utils rpm/libxkbcommon-x11-utils"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libxkbcommon-1.7.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c8bc1bc8da618b781d226b3f16666991c42c40484cd63636956c29b7ba00f60"

URI_libxkbcommon = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libxkbcommon-1.7.0-4.el10.x86_64_v2.rpm;name=libxkbcommon;unpack=0"
SRC_URI += "${URI_libxkbcommon}"
SRC_URI[libxkbcommon.sha256sum] = "cd7b47d73bb1f9b408df8eace1baa45599c9de049c08f8cd85f897c09ad8b77c"
RDEPENDS:libxkbcommon = " \
 glibc \
 xkeyboard-config \
 libxml2 \
"

URI_libxkbcommon-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libxkbcommon-devel-1.7.0-4.el10.x86_64_v2.rpm;name=libxkbcommon-devel;unpack=0"
SRC_URI += "${URI_libxkbcommon-devel}"
SRC_URI[libxkbcommon-devel.sha256sum] = "372f4f17405f70773e67d98b964956f8d06c9b9cf2cfbd8194c496aff09eb47a"
RDEPENDS:libxkbcommon-devel = " \
 libxml2-devel \
 libxkbcommon \
 pkgconf-pkg-config \
"

URI_libxkbcommon-x11 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libxkbcommon-x11-1.7.0-4.el10.x86_64_v2.rpm;name=libxkbcommon-x11;unpack=0"
SRC_URI += "${URI_libxkbcommon-x11}"
SRC_URI[libxkbcommon-x11.sha256sum] = "f98f73110a7ea79d0cfa8a7de2509261057b437b509244f0eb35b33ed6e4f1f3"
RDEPENDS:libxkbcommon-x11 = " \
 glibc \
 libxcb \
 libxkbcommon \
"

URI_libxkbcommon-x11-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libxkbcommon-x11-devel-1.7.0-4.el10.x86_64_v2.rpm;name=libxkbcommon-x11-devel;unpack=0"
SRC_URI += "${URI_libxkbcommon-x11-devel}"
SRC_URI[libxkbcommon-x11-devel.sha256sum] = "410bc37e802e1e9e208b287741258feedeec12a98be07a58b26013e2b337b732"
RDEPENDS:libxkbcommon-x11-devel = " \
 libxkbcommon-devel \
 libxkbcommon-x11 \
 pkgconf-pkg-config \
 libxcb-devel \
"

URI_libxkbcommon-utils = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libxkbcommon-utils-1.7.0-4.el10.x86_64_v2.rpm;name=libxkbcommon-utils;unpack=0"
SRC_URI += "${URI_libxkbcommon-utils}"
SRC_URI[libxkbcommon-utils.sha256sum] = "f0808d88d4210195e23bbb61dfa55637bc48f0193713258d2b3fc31d5dfbde82"
RDEPENDS:libxkbcommon-utils = " \
 glibc \
 libxkbcommon \
 libwayland-client \
"

URI_libxkbcommon-x11-utils = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libxkbcommon-x11-utils-1.7.0-4.el10.x86_64_v2.rpm;name=libxkbcommon-x11-utils;unpack=0"
SRC_URI += "${URI_libxkbcommon-x11-utils}"
SRC_URI[libxkbcommon-x11-utils.sha256sum] = "8181a3da01900728e19e193509669d442ea59f8a20aa1b8765e2764871658272"
RDEPENDS:libxkbcommon-x11-utils = " \
 libxkbcommon-utils \
 libxcb \
 glibc \
 libxkbcommon \
 libxkbcommon-x11 \
"
