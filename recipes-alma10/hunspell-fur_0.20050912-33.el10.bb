# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-fur"
PE = "0"
PV = "0.20050912"
PR = "33.el10"
PACKAGES = "hunspell-fur"
PROVIDES = "rpm/hunspell-fur"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-fur-0.20050912-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c80cccb11c62e1587f21c87c0a1cdf69bb7f71835dcf04a03988399d1fbd5124"

URI_hunspell-fur = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-fur-0.20050912-33.el10.noarch.rpm;name=hunspell-fur;unpack=0"
SRC_URI += "${URI_hunspell-fur}"
SRC_URI[hunspell-fur.sha256sum] = "609c225c395e1de8a09011b776d3d4b54a96533799cfc9d1117a5b995dcf4363"
RDEPENDS:hunspell-fur = " \
 hunspell-filesystem \
"
