# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mesa-libGLU"
PE = "0"
PV = "9.0.3"
PR = "7.el10"
PACKAGES = "mesa-libGLU mesa-libGLU-devel"
PROVIDES = "rpm/mesa-libGLU rpm/mesa-libGLU-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mesa-libGLU-9.0.3-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9359b902de2431cc9a9690976b2393a198a4b5bcdad8f7cb1b6e2a77a9f232fb"

URI_mesa-libGLU = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mesa-libGLU-9.0.3-7.el10.x86_64_v2.rpm;name=mesa-libGLU;unpack=0"
SRC_URI += "${URI_mesa-libGLU}"
SRC_URI[mesa-libGLU.sha256sum] = "4c6354a534a50aab3e939227021dcc7023ac031683aa26ca34168214a0b40b97"
RDEPENDS:mesa-libGLU = " \
 glibc \
 libglvnd-opengl \
 libgcc \
 libstdc++ \
"

URI_mesa-libGLU-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mesa-libGLU-devel-9.0.3-7.el10.x86_64_v2.rpm;name=mesa-libGLU-devel;unpack=0"
SRC_URI += "${URI_mesa-libGLU-devel}"
SRC_URI[mesa-libGLU-devel.sha256sum] = "6b199fa6d4a19f013098e67d1a0bfcefb45dbffd3fe4dd483b70ad4cd9edafa1"
RDEPENDS:mesa-libGLU-devel = " \
 mesa-libGLU \
 pkgconf-pkg-config \
 libglvnd-devel \
"
