# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "aspell"
PE = "12"
PV = "0.60.8.1"
PR = "3.el10"
PACKAGES = "aspell aspell-devel"
PROVIDES = "rpm/aspell rpm/aspell-devel"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/aspell-0.60.8.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0ead5d484d47df6147b2fd0b800ed19300883b47be39db09095cea62656b5ff"

URI_aspell = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/aspell-0.60.8.1-3.el10.x86_64_v2.rpm;name=aspell;unpack=0"
SRC_URI += "${URI_aspell}"
SRC_URI[aspell.sha256sum] = "e41c59efae912890b426f5bd6270036a9fac77d392642a7054b72636bda5b019"
RDEPENDS:aspell = " \
 glibc \
 libstdc++ \
 bash \
 ncurses-libs \
"

URI_aspell-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/aspell-devel-0.60.8.1-3.el10.x86_64_v2.rpm;name=aspell-devel;unpack=0"
SRC_URI += "${URI_aspell-devel}"
SRC_URI[aspell-devel.sha256sum] = "9b2c693d6224692860d4ae16dfd2a1346903552686062f2d0b7c3bf14872a568"
RDEPENDS:aspell-devel = " \
 aspell \
 bash \
 pkgconf-pkg-config \
"
