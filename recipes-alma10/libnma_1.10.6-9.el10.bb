# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libnma"
PE = "0"
PV = "1.10.6"
PR = "9.el10"
PACKAGES = "libnma libnma-gtk4 libnma-devel libnma-gtk4-devel"
PROVIDES = "rpm/libnma rpm/libnma-gtk4 rpm/libnma-devel rpm/libnma-gtk4-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libnma-1.10.6-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b715f29d9aff3eeae84394c09c850c19ee46cc57bd7e8aa8720b5f82fdb4bae4"

URI_libnma = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libnma-1.10.6-9.el10.x86_64_v2.rpm;name=libnma;unpack=0"
SRC_URI += "${URI_libnma}"
SRC_URI[libnma.sha256sum] = "7fb8984a155773cbf26243b1ff61c9169f993f3e10c294099b85e27ebb2e75dd"
RDEPENDS:libnma = " \
 mobile-broadband-provider-info \
 libgcc \
 cairo \
 glib2 \
 gtk3 \
 glibc \
 NetworkManager-libnm \
 gcr-libs \
"

URI_libnma-gtk4 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libnma-gtk4-1.10.6-9.el10.x86_64_v2.rpm;name=libnma-gtk4;unpack=0"
SRC_URI += "${URI_libnma-gtk4}"
SRC_URI[libnma-gtk4.sha256sum] = "6d1a23d584ddfc8b347d5140be4afb7f5c761a8dcf2f161b46e1095134057f67"
RDEPENDS:libnma-gtk4 = " \
 mobile-broadband-provider-info \
 libgcc \
 cairo \
 glib2 \
 glibc \
 gtk4 \
 NetworkManager-libnm \
 gcr-libs \
"

URI_libnma-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libnma-devel-1.10.6-9.el10.x86_64_v2.rpm;name=libnma-devel;unpack=0"
SRC_URI += "${URI_libnma-devel}"
SRC_URI[libnma-devel.sha256sum] = "a589b61be8df140fea1cdc58709b9bda2a160893243ef5a3f7756893ab087061"
RDEPENDS:libnma-devel = " \
 NetworkManager-libnm-devel \
 pkgconf-pkg-config \
 libnma \
 gtk3-devel \
"

URI_libnma-gtk4-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libnma-gtk4-devel-1.10.6-9.el10.x86_64_v2.rpm;name=libnma-gtk4-devel;unpack=0"
SRC_URI += "${URI_libnma-gtk4-devel}"
SRC_URI[libnma-gtk4-devel.sha256sum] = "500dbdf6c3cf3e83902c36f4002fadd7d14949a06f8e1da101e13ed5747183af"
RDEPENDS:libnma-gtk4-devel = " \
 gtk4-devel \
 NetworkManager-libnm-devel \
 pkgconf-pkg-config \
 libnma-gtk4 \
"
