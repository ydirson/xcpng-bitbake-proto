# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-mr"
PE = "1"
PV = "0.7.0"
PR = "27.el10"
PACKAGES = "hyphen-mr"
PROVIDES = "rpm/hyphen-mr"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-mr-0.7.0-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d89f939469f86991ffd3ccaccb494bef32c0cec556cb0a53fbeabcb54984120"

URI_hyphen-mr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-mr-0.7.0-27.el10.noarch.rpm;name=hyphen-mr;unpack=0"
SRC_URI += "${URI_hyphen-mr}"
SRC_URI[hyphen-mr.sha256sum] = "ae34c11987e8b3091adfeb17474fa45eca289a73858a3229c3c1d338be56da74"
RDEPENDS:hyphen-mr = " \
 hyphen \
"
