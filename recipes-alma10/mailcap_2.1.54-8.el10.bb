# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mailcap"
PE = "0"
PV = "2.1.54"
PR = "8.el10"
PACKAGES = "mailcap nginx-mimetypes"
PROVIDES = "rpm/mailcap rpm/nginx-mimetypes"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/mailcap-2.1.54-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a0ad9df7202ecd09219978ee3879d7fc45e4a09b343fb8c8c2ae76ca6a094db"

URI_mailcap = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/mailcap-2.1.54-8.el10.noarch.rpm;name=mailcap;unpack=0"
SRC_URI += "${URI_mailcap}"
SRC_URI[mailcap.sha256sum] = "0e6cccb4b9e61ea5384b81ed9cd4b45e862393effd979307105d84f9cd8acd26"
RDEPENDS:mailcap = ""

URI_nginx-mimetypes = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/nginx-mimetypes-2.1.54-8.el10.noarch.rpm;name=nginx-mimetypes;unpack=0"
SRC_URI += "${URI_nginx-mimetypes}"
SRC_URI[nginx-mimetypes.sha256sum] = "4086c74c8eb7b4290d9c4f6b01306cfbe0604f2b790e603046cdd852a8b272c7"
RDEPENDS:nginx-mimetypes = " \
 nginx-filesystem \
"
