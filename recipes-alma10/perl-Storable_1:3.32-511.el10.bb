# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Storable"
PE = "1"
PV = "3.32"
PR = "511.el10"
PACKAGES = "perl-Storable perl-Storable-tests"
PROVIDES = "rpm/perl-Storable rpm/perl-Storable-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Storable-3.32-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19896f2c9bbf58e1d221b8f03924229caca42bc5d086af9f3ef8c8294429d92c"

URI_perl-Storable = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Storable-3.32-511.el10.x86_64_v2.rpm;name=perl-Storable;unpack=0"
SRC_URI += "${URI_perl-Storable}"
SRC_URI[perl-Storable.sha256sum] = "5e98baa52f61c2f579008cb5ef0a767a8fee30d1f45d3a9f55d6c4c7d817c4b5"
RDEPENDS:perl-Storable = " \
 perl-libs \
 perl-Carp \
 perl-IO \
 perl-Fcntl \
 glibc \
 perl-Exporter \
"

URI_perl-Storable-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Storable-tests-3.32-511.el10.x86_64_v2.rpm;name=perl-Storable-tests;unpack=0"
SRC_URI += "${URI_perl-Storable-tests}"
SRC_URI[perl-Storable-tests.sha256sum] = "ae3086d93a4e58140fc7efc5b940e355507947bc4e41d14efda218adf5e37b2e"
RDEPENDS:perl-Storable-tests = " \
 perl-Safe \
 perl-libs \
 perl-Storable \
 perl-overload \
 perl-Symbol \
 perl-B \
 perl-Hash-Util \
 perl-threads \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Carp \
 perl-Tie \
 perl-Digest-MD5 \
 bash \
 perl-base \
 perl-constant \
 perl-PathTools \
 perl-interpreter \
 perl-File-Temp \
"
