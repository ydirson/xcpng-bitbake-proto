# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Date-Calc"
PE = "0"
PV = "6.4"
PR = "30.el10"
PACKAGES = "perl-Date-Calc perl-Date-Calc-tests"
PROVIDES = "rpm/perl-Date-Calc rpm/perl-Date-Calc-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Date-Calc-6.4-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3f50c806880ab7a9d1ba5ae7ba102188a328fa076d9c4550d19b702c6495c88"

URI_perl-Date-Calc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Date-Calc-6.4-30.el10.noarch.rpm;name=perl-Date-Calc;unpack=0"
SRC_URI += "${URI_perl-Date-Calc}"
SRC_URI[perl-Date-Calc.sha256sum] = "5bf91457c2365f6d816f00ed0e9f4065b1284eab772500bc895ca73393000b5e"
RDEPENDS:perl-Date-Calc = " \
 perl-libs \
 perl-Carp-Clan \
 perl-vars \
 perl-POSIX \
 perl-overload \
 perl-Exporter \
 perl-Bit-Vector \
 perl-Date-Calc \
"

URI_perl-Date-Calc-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Date-Calc-tests-6.4-30.el10.noarch.rpm;name=perl-Date-Calc-tests;unpack=0"
SRC_URI += "${URI_perl-Date-Calc-tests}"
SRC_URI[perl-Date-Calc-tests.sha256sum] = "b031c8f108200f1f923672de5d44f660ac7faf725063b2b36cc1d4222b7634cd"
RDEPENDS:perl-Date-Calc-tests = " \
 perl-Test-Harness \
 perl-libs \
 bash \
 perl-interpreter \
 perl-Date-Calc \
"
