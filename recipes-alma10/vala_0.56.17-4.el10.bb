# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "vala"
PE = "0"
PV = "0.56.17"
PR = "4.el10"
PACKAGES = "libvala libvala-devel vala vala-doc valadoc valadoc-devel"
PROVIDES = "rpm/libvala rpm/libvala-devel rpm/vala rpm/vala-doc rpm/valadoc rpm/valadoc-devel"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/vala-0.56.17-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3b174569893f761f30d41740617ac344e0777ae203d89eb459336058107e058"

URI_libvala = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libvala-0.56.17-4.el10.x86_64_v2.rpm;name=libvala;unpack=0"
SRC_URI += "${URI_libvala}"
SRC_URI[libvala.sha256sum] = "de5ca65d2234d88e239954ae35406dc28028506162383dd2820b70c984a00aaa"
RDEPENDS:libvala = " \
 glibc \
 libgcc \
 glib2 \
"

URI_libvala-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libvala-devel-0.56.17-4.el10.x86_64_v2.rpm;name=libvala-devel;unpack=0"
SRC_URI += "${URI_libvala-devel}"
SRC_URI[libvala-devel.sha256sum] = "a9c025e2a4cc2e3340426814d15f3021b47b48f686ad5776ecdb13187354b754"
RDEPENDS:libvala-devel = " \
 glib2-devel \
 libvala \
 pkgconf-pkg-config \
"

URI_vala = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/vala-0.56.17-4.el10.x86_64_v2.rpm;name=vala;unpack=0"
SRC_URI += "${URI_vala}"
SRC_URI[vala.sha256sum] = "0190255f7a642b4cc612f3e874e5b8cc30755fc35c142941c729ff6ec3676be8"
RDEPENDS:vala = " \
 libvala \
 pkgconf-pkg-config \
 bash \
 glib2 \
 gobject-introspection-devel \
 glibc \
"

URI_vala-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/vala-doc-0.56.17-4.el10.noarch.rpm;name=vala-doc;unpack=0"
SRC_URI += "${URI_vala-doc}"
SRC_URI[vala-doc.sha256sum] = "7b52fc5698f067e5ca0ade2d9dd64c1f108d57e0cec9a6f13cdd34a2fd845826"
RDEPENDS:vala-doc = " \
 vala \
"

URI_valadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/valadoc-0.56.17-4.el10.x86_64_v2.rpm;name=valadoc;unpack=0"
SRC_URI += "${URI_valadoc}"
SRC_URI[valadoc.sha256sum] = "f5bb14371fc91281de27da135e45ad10e75231b2e6416a6ff14d072a938c0e0f"
RDEPENDS:valadoc = " \
 vala \
 libvala \
 glib2 \
 glibc \
 graphviz \
"

URI_valadoc-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/valadoc-devel-0.56.17-4.el10.x86_64_v2.rpm;name=valadoc-devel;unpack=0"
SRC_URI += "${URI_valadoc-devel}"
SRC_URI[valadoc-devel.sha256sum] = "ad4c4a1e56af2970f2663d32bd0e9b51631d830f9cbae9bbb6b8a3f7c2c0a759"
RDEPENDS:valadoc-devel = " \
 graphviz-devel \
 glib2-devel \
 valadoc \
 pkgconf-pkg-config \
 libvala-devel \
"
