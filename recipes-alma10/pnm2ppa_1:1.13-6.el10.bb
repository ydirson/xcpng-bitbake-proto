# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pnm2ppa"
PE = "1"
PV = "1.13"
PR = "6.el10"
PACKAGES = "pnm2ppa"
PROVIDES = "rpm/pnm2ppa"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/pnm2ppa-1.13-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c05a08b1997cd8708f46ab19351f38dcbf1f0cb68be3631c0542f3d88d22d1bf"

URI_pnm2ppa = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pnm2ppa-1.13-6.el10.x86_64_v2.rpm;name=pnm2ppa;unpack=0"
SRC_URI += "${URI_pnm2ppa}"
SRC_URI[pnm2ppa.sha256sum] = "40faea3932983a9155ac372ffa1f0e138f2e2140a57d44d335aaf561f85ccb05"
RDEPENDS:pnm2ppa = " \
 glibc \
 foomatic \
 bash \
"
