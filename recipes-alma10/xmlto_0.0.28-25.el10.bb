# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xmlto"
PE = "0"
PV = "0.0.28"
PR = "25.el10"
PACKAGES = "xmlto xmlto-tex xmlto-xhtml"
PROVIDES = "rpm/xmlto rpm/xmlto-tex rpm/xmlto-xhtml"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xmlto-0.0.28-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc273dd6719bdb4ce5f0e3bec9c55fead4af504130802404dd4f0ec743da1fb1"

URI_xmlto = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xmlto-0.0.28-25.el10.x86_64_v2.rpm;name=xmlto;unpack=0"
SRC_URI += "${URI_xmlto}"
SRC_URI[xmlto.sha256sum] = "8a9c29dc38826021eeff059e7fc537047053e7e71358d80f00a5295085a0eff0"
RDEPENDS:xmlto = " \
 libxslt \
 flex \
 util-linux \
 docbook-dtds \
 docbook-style-xsl \
 bash \
 glibc \
"

URI_xmlto-tex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xmlto-tex-0.0.28-25.el10.noarch.rpm;name=xmlto-tex;unpack=0"
SRC_URI += "${URI_xmlto-tex}"
SRC_URI[xmlto-tex.sha256sum] = "8785f0c1d6ceba3806b3bb5875c4d1b0d5594d0e114797b0e109048a576c7511"
RDEPENDS:xmlto-tex = " \
 texlive-passivetex \
 xmlto \
"

URI_xmlto-xhtml = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xmlto-xhtml-0.0.28-25.el10.noarch.rpm;name=xmlto-xhtml;unpack=0"
SRC_URI += "${URI_xmlto-xhtml}"
SRC_URI[xmlto-xhtml.sha256sum] = "b496ee0e6f2db0bb8d4ac74b258f953b727352049b4447ac8e1cbc7091520272"
RDEPENDS:xmlto-xhtml = " \
 xhtml2fo-style-xsl \
 xmlto \
"
