# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sblim-cmpi-devel"
PE = "0"
PV = "2.0.3"
PR = "33.el10"
PACKAGES = "libcmpiCppImpl0 sblim-cmpi-devel"
PROVIDES = "rpm/libcmpiCppImpl0 rpm/sblim-cmpi-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/sblim-cmpi-devel-2.0.3-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd1c5cdeeaa2177ae06884063cd51b14c03e0e104da513b8160871a08e2204f6"

URI_libcmpiCppImpl0 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libcmpiCppImpl0-2.0.3-33.el10.x86_64_v2.rpm;name=libcmpiCppImpl0;unpack=0"
SRC_URI += "${URI_libcmpiCppImpl0}"
SRC_URI[libcmpiCppImpl0.sha256sum] = "19ae61a9139add24b945efe44617eb3dbf6306471419ab2b272dcea386784004"
RDEPENDS:libcmpiCppImpl0 = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_sblim-cmpi-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/sblim-cmpi-devel-2.0.3-33.el10.x86_64_v2.rpm;name=sblim-cmpi-devel;unpack=0"
SRC_URI += "${URI_sblim-cmpi-devel}"
SRC_URI[sblim-cmpi-devel.sha256sum] = "afb5a826c2f3523bb4bff4181c21fab6fe8c109414a807b5c2e0c1cad56625d9"
RDEPENDS:sblim-cmpi-devel = ""
