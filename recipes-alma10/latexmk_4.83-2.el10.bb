# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "latexmk"
PE = "0"
PV = "4.83"
PR = "2.el10"
PACKAGES = "latexmk"
PROVIDES = "rpm/latexmk"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/latexmk-4.83-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61f46244b7f45744cad84c764c3bc47c6ede7c6ced8b0df926c3ab93c529ca0a"

URI_latexmk = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/latexmk-4.83-2.el10.noarch.rpm;name=latexmk;unpack=0"
SRC_URI += "${URI_latexmk}"
SRC_URI[latexmk.sha256sum] = "06ae376a1616e7dcdff9fe3633d68977123691c45db1a2256b48401c40a4794e"
RDEPENDS:latexmk = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-File-Path \
 perl-FileHandle \
 perl-Unicode-Normalize \
 perl-Digest-MD5 \
 xdg-utils \
 perl-File-Basename \
 perl-Encode \
 texlive-latex \
 perl-File-Copy \
 perl-PathTools \
 perl-File-Find \
 perl-interpreter \
 perl-sigtrap \
 ghostscript \
 perl-Time-HiRes \
"
