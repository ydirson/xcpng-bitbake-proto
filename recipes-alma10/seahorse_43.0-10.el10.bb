# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "seahorse"
PE = "0"
PV = "43.0"
PR = "10.el10"
PACKAGES = "seahorse"
PROVIDES = "rpm/seahorse"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/seahorse-43.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e48d7af06090634f868f25b5e13c1b6c3e327cf3ae7142447035826cc5963676"

URI_seahorse = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/seahorse-43.0-10.el10.x86_64_v2.rpm;name=seahorse;unpack=0"
SRC_URI += "${URI_seahorse}"
SRC_URI[seahorse.sha256sum] = "426aa644b1a7abcf4e4b88ec2f3d16fc6e4163b49af87f1651c03ad3fe8937db"
RDEPENDS:seahorse = " \
 gcr3 \
 libhandy \
 gcr3-base \
 libsoup3 \
 libpwquality \
 libgcc \
 gpgme \
 gdk-pixbuf2 \
 pinentry-gnome3 \
 libsecret \
 glib2 \
 gtk3 \
 glibc \
 openldap \
"
