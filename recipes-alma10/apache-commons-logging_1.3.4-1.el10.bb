# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "apache-commons-logging"
PE = "0"
PV = "1.3.4"
PR = "1.el10"
PACKAGES = "apache-commons-logging apache-commons-logging-javadoc"
PROVIDES = "rpm/apache-commons-logging rpm/apache-commons-logging-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/apache-commons-logging-1.3.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8354c6461cbe815bef28d9ff999ab603fec67126106a232f70791910105f613e"

URI_apache-commons-logging = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/apache-commons-logging-1.3.4-1.el10.noarch.rpm;name=apache-commons-logging;unpack=0"
SRC_URI += "${URI_apache-commons-logging}"
SRC_URI[apache-commons-logging.sha256sum] = "d46190bcd4adf877cecc60e46f2c5e0367ea10256a03c19add17e9ed82a01811"
RDEPENDS:apache-commons-logging = " \
 javapackages-filesystem \
"

URI_apache-commons-logging-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/apache-commons-logging-javadoc-1.3.4-1.el10.noarch.rpm;name=apache-commons-logging-javadoc;unpack=0"
SRC_URI += "${URI_apache-commons-logging-javadoc}"
SRC_URI[apache-commons-logging-javadoc.sha256sum] = "537dcfb4646b0e6a7a6edb1d4d15f359d85d0ee342e24a7fc638a8ab66c96180"
RDEPENDS:apache-commons-logging-javadoc = " \
 javapackages-filesystem \
"
