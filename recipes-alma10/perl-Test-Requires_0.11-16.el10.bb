# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Test-Requires"
PE = "0"
PV = "0.11"
PR = "16.el10"
PACKAGES = "perl-Test-Requires"
PROVIDES = "rpm/perl-Test-Requires"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Test-Requires-0.11-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f2e415fb0de29e7386c6719f87da85a02bedba00ed4996a3204885153c3d04d"

URI_perl-Test-Requires = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Test-Requires-0.11-16.el10.noarch.rpm;name=perl-Test-Requires;unpack=0"
SRC_URI += "${URI_perl-Test-Requires}"
SRC_URI[perl-Test-Requires.sha256sum] = "ba88b3c910268a7c0679d41a6b1d63f1754f888df1956881fabeb6c2d26c95f8"
RDEPENDS:perl-Test-Requires = " \
 perl-libs \
 perl-base \
 perl-Test-Simple \
"
