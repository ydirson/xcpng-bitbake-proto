# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "glibmm2.68"
PE = "0"
PV = "2.78.1"
PR = "5.el10"
PACKAGES = "glibmm2.68 glibmm2.68-devel glibmm2.68-doc"
PROVIDES = "rpm/glibmm2.68 rpm/glibmm2.68-devel rpm/glibmm2.68-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/glibmm2.68-2.78.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c4843aa2dc27f52474f491922b43bf2102338da7cab068973cda6ef65317017"

URI_glibmm2.68 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/glibmm2.68-2.78.1-5.el10.x86_64_v2.rpm;name=glibmm2.68;unpack=0"
SRC_URI += "${URI_glibmm2.68}"
SRC_URI[glibmm2.68.sha256sum] = "ead7b52166b165c887ecd2acde3438932591a6e71c314e1662e4452171827ae5"
RDEPENDS:glibmm2.68 = " \
 libgcc \
 libstdc++ \
 glib2 \
 glibc \
 libsigc++30 \
"

URI_glibmm2.68-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/glibmm2.68-devel-2.78.1-5.el10.x86_64_v2.rpm;name=glibmm2.68-devel;unpack=0"
SRC_URI += "${URI_glibmm2.68-devel}"
SRC_URI[glibmm2.68-devel.sha256sum] = "b574b65d8b7f08953e69aafad4bcf1f4bab9a3ea4970c2a6cbddfd3718777bda"
RDEPENDS:glibmm2.68-devel = " \
 perl-constant \
 glib2-devel \
 perl-libs \
 libsigc++30-devel \
 perl-interpreter \
 pkgconf-pkg-config \
 perl-open \
 glibmm2.68-devel \
 perl-XML-Parser \
 glibmm2.68 \
 perl-Exporter \
"

URI_glibmm2.68-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/glibmm2.68-doc-2.78.1-5.el10.noarch.rpm;name=glibmm2.68-doc;unpack=0"
SRC_URI += "${URI_glibmm2.68-doc}"
SRC_URI[glibmm2.68-doc.sha256sum] = "3c57beec9554f2e56827b837c2a90801ca4a020c5aa443043d54551596e15c42"
RDEPENDS:glibmm2.68-doc = " \
 libsigc++30-doc \
 glibmm2.68 \
"
