# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "flexiblas"
PE = "0"
PV = "3.4.2"
PR = "3.el10"
PACKAGES = "flexiblas flexiblas-devel flexiblas-netlib flexiblas-netlib64 flexiblas-openblas-openmp flexiblas-openblas-openmp64 flexiblas-openblas-serial flexiblas-hook-profile flexiblas-hook-profile64 flexiblas-openblas-serial64 flexiblas-openblas-threads flexiblas-openblas-threads64"
PROVIDES = "rpm/flexiblas rpm/flexiblas-devel rpm/flexiblas-netlib rpm/flexiblas-netlib64 rpm/flexiblas-openblas-openmp rpm/flexiblas-openblas-openmp64 rpm/flexiblas-openblas-serial rpm/flexiblas-hook-profile rpm/flexiblas-hook-profile64 rpm/flexiblas-openblas-serial64 rpm/flexiblas-openblas-threads rpm/flexiblas-openblas-threads64"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/flexiblas-3.4.2-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "291b34531e48cad84105cced8f6b5cd4e202613b7f334ea8014419e85e84564c"

URI_flexiblas = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/flexiblas-3.4.2-3.el10.x86_64_v2.rpm;name=flexiblas;unpack=0"
SRC_URI += "${URI_flexiblas}"
SRC_URI[flexiblas.sha256sum] = "21e0c9d1222b7852772f41e00d85756cee61526b5ba3ada862297d7ab20764f6"
RDEPENDS:flexiblas = " \
 flexiblas-netlib \
"

URI_flexiblas-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/flexiblas-devel-3.4.2-3.el10.x86_64_v2.rpm;name=flexiblas-devel;unpack=0"
SRC_URI += "${URI_flexiblas-devel}"
SRC_URI[flexiblas-devel.sha256sum] = "f83d306698512bdd81c4e0f0b34773604de71be1f236f25672d2eafa4444dbb3"
RDEPENDS:flexiblas-devel = " \
 flexiblas \
 flexiblas-netlib \
 flexiblas-netlib64 \
 pkgconf-pkg-config \
 glibc \
"

URI_flexiblas-netlib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/flexiblas-netlib-3.4.2-3.el10.x86_64_v2.rpm;name=flexiblas-netlib;unpack=0"
SRC_URI += "${URI_flexiblas-netlib}"
SRC_URI[flexiblas-netlib.sha256sum] = "5502f758e4276f6b21b2f48f31cfda9d1037cb9fd12bf4c4301ac3fd4b6533cb"
RDEPENDS:flexiblas-netlib = " \
 flexiblas \
 flexiblas-openblas-openmp \
 libgcc \
 libgfortran \
 libquadmath \
 glibc \
"

URI_flexiblas-netlib64 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/flexiblas-netlib64-3.4.2-3.el10.x86_64_v2.rpm;name=flexiblas-netlib64;unpack=0"
SRC_URI += "${URI_flexiblas-netlib64}"
SRC_URI[flexiblas-netlib64.sha256sum] = "655827b453123949dc44d61075369dabeb3d7d893dbd32bbc1f90c4e23e6bc21"
RDEPENDS:flexiblas-netlib64 = " \
 flexiblas \
 libgcc \
 flexiblas-openblas-openmp64 \
 libgfortran \
 libquadmath \
 glibc \
"

URI_flexiblas-openblas-openmp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/flexiblas-openblas-openmp-3.4.2-3.el10.x86_64_v2.rpm;name=flexiblas-openblas-openmp;unpack=0"
SRC_URI += "${URI_flexiblas-openblas-openmp}"
SRC_URI[flexiblas-openblas-openmp.sha256sum] = "3ddf8e916417b0843253a095ee145681ce1c7a174b7ba463668f9f58de419b6a"
RDEPENDS:flexiblas-openblas-openmp = " \
 glibc \
 openblas-openmp \
 flexiblas-netlib \
 flexiblas \
"

URI_flexiblas-openblas-openmp64 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/flexiblas-openblas-openmp64-3.4.2-3.el10.x86_64_v2.rpm;name=flexiblas-openblas-openmp64;unpack=0"
SRC_URI += "${URI_flexiblas-openblas-openmp64}"
SRC_URI[flexiblas-openblas-openmp64.sha256sum] = "053e63a19830f9986d2ca627d2c2e73a4751e499b3acd45810e572ff97457823"
RDEPENDS:flexiblas-openblas-openmp64 = " \
 glibc \
 flexiblas-netlib64 \
 openblas-openmp64 \
 flexiblas \
"

URI_flexiblas-openblas-serial = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/flexiblas-openblas-serial-3.4.2-3.el10.x86_64_v2.rpm;name=flexiblas-openblas-serial;unpack=0"
SRC_URI += "${URI_flexiblas-openblas-serial}"
SRC_URI[flexiblas-openblas-serial.sha256sum] = "9c72b9a7c0dd6c8e50c9428be0a53c4daf4d059518a7fba430f187333fde096d"
RDEPENDS:flexiblas-openblas-serial = " \
 glibc \
 flexiblas-netlib \
 openblas-serial \
 flexiblas \
"

URI_flexiblas-hook-profile = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/flexiblas-hook-profile-3.4.2-3.el10.x86_64_v2.rpm;name=flexiblas-hook-profile;unpack=0"
SRC_URI += "${URI_flexiblas-hook-profile}"
SRC_URI[flexiblas-hook-profile.sha256sum] = "c9d415e5d39434b0fa7091b57850a14988eaea992d078d4077bd44c8d7956ceb"
RDEPENDS:flexiblas-hook-profile = " \
 flexiblas \
 flexiblas-netlib \
 libgfortran \
 libquadmath \
 glibc \
"

URI_flexiblas-hook-profile64 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/flexiblas-hook-profile64-3.4.2-3.el10.x86_64_v2.rpm;name=flexiblas-hook-profile64;unpack=0"
SRC_URI += "${URI_flexiblas-hook-profile64}"
SRC_URI[flexiblas-hook-profile64.sha256sum] = "a482b6a473a6c4cc4cb44156915b4fdf5f7543c386b1f56498148fb2a1afd0b9"
RDEPENDS:flexiblas-hook-profile64 = " \
 flexiblas \
 flexiblas-netlib64 \
 libgfortran \
 libquadmath \
 glibc \
"

URI_flexiblas-openblas-serial64 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/flexiblas-openblas-serial64-3.4.2-3.el10.x86_64_v2.rpm;name=flexiblas-openblas-serial64;unpack=0"
SRC_URI += "${URI_flexiblas-openblas-serial64}"
SRC_URI[flexiblas-openblas-serial64.sha256sum] = "72722f808a48d7888a7e23357c0275d8124f4bf8278ac693e201ac23cf62c0b8"
RDEPENDS:flexiblas-openblas-serial64 = " \
 glibc \
 flexiblas-netlib64 \
 flexiblas \
 openblas-serial64 \
"

URI_flexiblas-openblas-threads = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/flexiblas-openblas-threads-3.4.2-3.el10.x86_64_v2.rpm;name=flexiblas-openblas-threads;unpack=0"
SRC_URI += "${URI_flexiblas-openblas-threads}"
SRC_URI[flexiblas-openblas-threads.sha256sum] = "834fa70878019aa8bc19605ffc16b627a934e584135565aeb44d4e677e74a4c8"
RDEPENDS:flexiblas-openblas-threads = " \
 glibc \
 openblas-threads \
 flexiblas-netlib \
 flexiblas \
"

URI_flexiblas-openblas-threads64 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/flexiblas-openblas-threads64-3.4.2-3.el10.x86_64_v2.rpm;name=flexiblas-openblas-threads64;unpack=0"
SRC_URI += "${URI_flexiblas-openblas-threads64}"
SRC_URI[flexiblas-openblas-threads64.sha256sum] = "e3d9b20c0c5d5fea92a3a7f882918ac5c3f2623ca17609a6f4b93dec6ff9ae5c"
RDEPENDS:flexiblas-openblas-threads64 = " \
 glibc \
 flexiblas-netlib64 \
 openblas-threads64 \
 flexiblas \
"
