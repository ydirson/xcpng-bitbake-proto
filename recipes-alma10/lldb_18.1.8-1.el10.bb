# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lldb"
PE = "0"
PV = "18.1.8"
PR = "1.el10"
PACKAGES = ""
PROVIDES = ""


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/lldb-18.1.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1bb7627508b5308c6cfac6de4b70895b89d87b2c64c143dffaa4b19b5f4fb198"
