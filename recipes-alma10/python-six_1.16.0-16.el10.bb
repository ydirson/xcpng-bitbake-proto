# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-six"
PE = "0"
PV = "1.16.0"
PR = "16.el10"
PACKAGES = "python3-six"
PROVIDES = "rpm/python3-six"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/python-six-1.16.0-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8136f09ddd0e18bed3e93ed4679ad14d6e9891ba46523ddac6ccefd5040ff10a"

URI_python3-six = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-six-1.16.0-16.el10.noarch.rpm;name=python3-six;unpack=0"
SRC_URI += "${URI_python3-six}"
SRC_URI[python3-six.sha256sum] = "c3f50a6cf8baae82a41a9da61aab88616e44d0e4cae7a86521539199a885c106"
RDEPENDS:python3-six = " \
 python3 \
"
