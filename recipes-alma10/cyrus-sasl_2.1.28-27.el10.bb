# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cyrus-sasl"
PE = "0"
PV = "2.1.28"
PR = "27.el10"
PACKAGES = "cyrus-sasl cyrus-sasl-gssapi cyrus-sasl-lib cyrus-sasl-plain cyrus-sasl-scram cyrus-sasl-devel cyrus-sasl-gs2 cyrus-sasl-ldap cyrus-sasl-md5 cyrus-sasl-sql"
PROVIDES = "rpm/cyrus-sasl rpm/cyrus-sasl-gssapi rpm/cyrus-sasl-lib rpm/cyrus-sasl-plain rpm/cyrus-sasl-scram rpm/cyrus-sasl-devel rpm/cyrus-sasl-gs2 rpm/cyrus-sasl-ldap rpm/cyrus-sasl-md5 rpm/cyrus-sasl-sql"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/cyrus-sasl-2.1.28-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e32c62010fd86ecb45d1fb1d4c1d6891b45820216d643ad79be9a88e1e2274d"

URI_cyrus-sasl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cyrus-sasl-2.1.28-27.el10.x86_64_v2.rpm;name=cyrus-sasl;unpack=0"
SRC_URI += "${URI_cyrus-sasl}"
SRC_URI[cyrus-sasl.sha256sum] = "585ef230ca5b8a618e9310a82e3e0de79f7fb8cc607a1a613ff52b4882652973"
RDEPENDS:cyrus-sasl = " \
 shadow-utils \
 util-linux \
 libxcrypt \
 openssl-libs \
 gdbm-libs \
 pam-libs \
 krb5-libs \
 cyrus-sasl-lib \
 bash \
 glibc \
 openldap \
"

URI_cyrus-sasl-gssapi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cyrus-sasl-gssapi-2.1.28-27.el10.x86_64_v2.rpm;name=cyrus-sasl-gssapi;unpack=0"
SRC_URI += "${URI_cyrus-sasl-gssapi}"
SRC_URI[cyrus-sasl-gssapi.sha256sum] = "2fc570d3f57f609287076e255fc542d66606886db9408ab814162a80641fb86e"
RDEPENDS:cyrus-sasl-gssapi = " \
 libxcrypt \
 krb5-libs \
 cyrus-sasl-lib \
 libcom_err \
 glibc \
"

URI_cyrus-sasl-lib = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cyrus-sasl-lib-2.1.28-27.el10.x86_64_v2.rpm;name=cyrus-sasl-lib;unpack=0"
SRC_URI += "${URI_cyrus-sasl-lib}"
SRC_URI[cyrus-sasl-lib.sha256sum] = "55975f7bd6bb9500ff6084b137101e7b7764ab69e51c3400b2adc7d811a36263"
RDEPENDS:cyrus-sasl-lib = " \
 glibc \
 libxcrypt \
 gdbm-libs \
"

URI_cyrus-sasl-plain = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cyrus-sasl-plain-2.1.28-27.el10.x86_64_v2.rpm;name=cyrus-sasl-plain;unpack=0"
SRC_URI += "${URI_cyrus-sasl-plain}"
SRC_URI[cyrus-sasl-plain.sha256sum] = "a09da4da004564648f860dbb6360b9d22e668dd3412f7f70203ca7d5baeb8d62"
RDEPENDS:cyrus-sasl-plain = " \
 glibc \
 libxcrypt \
 cyrus-sasl-lib \
"

URI_cyrus-sasl-scram = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cyrus-sasl-scram-2.1.28-27.el10.x86_64_v2.rpm;name=cyrus-sasl-scram;unpack=0"
SRC_URI += "${URI_cyrus-sasl-scram}"
SRC_URI[cyrus-sasl-scram.sha256sum] = "92a5ffa8d800c7df7c36abf9a4d6f74aa4855e1729d69eabcf97655bf9ffefaf"
RDEPENDS:cyrus-sasl-scram = " \
 glibc \
 libxcrypt \
 cyrus-sasl-lib \
 openssl-libs \
"

URI_cyrus-sasl-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cyrus-sasl-devel-2.1.28-27.el10.x86_64_v2.rpm;name=cyrus-sasl-devel;unpack=0"
SRC_URI += "${URI_cyrus-sasl-devel}"
SRC_URI[cyrus-sasl-devel.sha256sum] = "431c1ab898a514b7c5106ff18780480f6c962dd8828eef276ab48bae1011af5d"
RDEPENDS:cyrus-sasl-devel = " \
 pkgconf-pkg-config \
 cyrus-sasl \
 krb5-libs \
 cyrus-sasl-lib \
 glibc \
"

URI_cyrus-sasl-gs2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cyrus-sasl-gs2-2.1.28-27.el10.x86_64_v2.rpm;name=cyrus-sasl-gs2;unpack=0"
SRC_URI += "${URI_cyrus-sasl-gs2}"
SRC_URI[cyrus-sasl-gs2.sha256sum] = "c397dd9dc890d64343ae8a080f8e075f17b6ad719618528a690e06b8e349a586"
RDEPENDS:cyrus-sasl-gs2 = " \
 libxcrypt \
 cyrus-sasl-lib \
 krb5-libs \
 libcom_err \
 glibc \
"

URI_cyrus-sasl-ldap = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cyrus-sasl-ldap-2.1.28-27.el10.x86_64_v2.rpm;name=cyrus-sasl-ldap;unpack=0"
SRC_URI += "${URI_cyrus-sasl-ldap}"
SRC_URI[cyrus-sasl-ldap.sha256sum] = "976abc6d194bb9399bc54d5dfa3c6b5f60091713c17de6f563900c9d400cb0f3"
RDEPENDS:cyrus-sasl-ldap = " \
 glibc \
 libxcrypt \
 cyrus-sasl-lib \
 openldap \
"

URI_cyrus-sasl-md5 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cyrus-sasl-md5-2.1.28-27.el10.x86_64_v2.rpm;name=cyrus-sasl-md5;unpack=0"
SRC_URI += "${URI_cyrus-sasl-md5}"
SRC_URI[cyrus-sasl-md5.sha256sum] = "3390df29d0f4b85eea439d9d4af29843fc2a661136a25a38e7d1022d54769d8c"
RDEPENDS:cyrus-sasl-md5 = " \
 glibc \
 libxcrypt \
 cyrus-sasl-lib \
 openssl-libs \
"

URI_cyrus-sasl-sql = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cyrus-sasl-sql-2.1.28-27.el10.x86_64_v2.rpm;name=cyrus-sasl-sql;unpack=0"
SRC_URI += "${URI_cyrus-sasl-sql}"
SRC_URI[cyrus-sasl-sql.sha256sum] = "3cbff549c698307a5c7f37ad5137b29d4a30ae3af218f0179406e2c97bcb399b"
RDEPENDS:cyrus-sasl-sql = " \
 libpq \
 libxcrypt \
 cyrus-sasl-lib \
 mariadb-connector-c \
 glibc \
"
