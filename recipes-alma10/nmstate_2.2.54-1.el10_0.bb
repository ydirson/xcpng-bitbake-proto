# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "nmstate"
PE = "0"
PV = "2.2.54"
PR = "1.el10_0"
PACKAGES = "nmstate nmstate-libs python3-libnmstate nmstate-devel nmstate-static"
PROVIDES = "rpm/nmstate rpm/nmstate-libs rpm/python3-libnmstate rpm/nmstate-devel rpm/nmstate-static"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/nmstate-2.2.54-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9499717c1f1015eb742c47f35bb9a0c34692052d58945f1dff806364c3769aba"

URI_nmstate = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nmstate-2.2.54-1.el10_0.x86_64_v2.rpm;name=nmstate;unpack=0"
SRC_URI += "${URI_nmstate}"
SRC_URI[nmstate.sha256sum] = "c19ac7ccad5b3a7711c34a026ce751ba50553bcf2dc6cf31efa9077289ecd2d1"
RDEPENDS:nmstate = " \
 glibc \
 nmstate-libs \
 libgcc \
"

URI_nmstate-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nmstate-libs-2.2.54-1.el10_0.x86_64_v2.rpm;name=nmstate-libs;unpack=0"
SRC_URI += "${URI_nmstate-libs}"
SRC_URI[nmstate-libs.sha256sum] = "5461e05ef4de51e7b17d4fa2136378bede82109b54713485f355ec0c8cfb8622"
RDEPENDS:nmstate-libs = " \
 glibc \
 libgcc \
"

URI_python3-libnmstate = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-libnmstate-2.2.54-1.el10_0.x86_64_v2.rpm;name=python3-libnmstate;unpack=0"
SRC_URI += "${URI_python3-libnmstate}"
SRC_URI[python3-libnmstate.sha256sum] = "b68e16982d3528232aaa0b2bb43bb31288e356c682d30c408e8d41acc69f97a1"
RDEPENDS:python3-libnmstate = " \
 python3 \
 python3-pyyaml \
 nmstate-libs \
"

URI_nmstate-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/nmstate-devel-2.2.54-1.el10_0.x86_64_v2.rpm;name=nmstate-devel;unpack=0"
SRC_URI += "${URI_nmstate-devel}"
SRC_URI[nmstate-devel.sha256sum] = "c552ec44431674f54a42384a24bdf3b6d151d62630f6da6a234c1aebb25c6d99"
RDEPENDS:nmstate-devel = " \
 nmstate-libs \
 pkgconf-pkg-config \
"

URI_nmstate-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/nmstate-static-2.2.54-1.el10_0.x86_64_v2.rpm;name=nmstate-static;unpack=0"
SRC_URI += "${URI_nmstate-static}"
SRC_URI[nmstate-static.sha256sum] = "1a21c0fbf18da2dff4d7dcb8518cf4c0bec7d9b2055421937b832083b54f1375"
RDEPENDS:nmstate-static = " \
 nmstate-devel \
"
