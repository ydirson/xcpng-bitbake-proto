# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-sq"
PE = "0"
PV = "1.6.4"
PR = "30.el10"
PACKAGES = "hunspell-sq"
PROVIDES = "rpm/hunspell-sq"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-sq-1.6.4-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c6b6935875725a0c84cfa135765affc96d59a7f2a52155801980e3e4d7379ad"

URI_hunspell-sq = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-sq-1.6.4-30.el10.noarch.rpm;name=hunspell-sq;unpack=0"
SRC_URI += "${URI_hunspell-sq}"
SRC_URI[hunspell-sq.sha256sum] = "75cacc1fe48206eb8fe5c54c16d01fc6d29988233b24cf49c1334d702fff4eac"
RDEPENDS:hunspell-sq = " \
 hunspell \
"
