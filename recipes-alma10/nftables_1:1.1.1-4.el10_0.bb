# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "nftables"
PE = "1"
PV = "1.1.1"
PR = "4.el10_0"
PACKAGES = "nftables python3-nftables nftables-devel"
PROVIDES = "rpm/nftables rpm/python3-nftables rpm/nftables-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/nftables-1.1.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5557665a3447bf6833b089ecfa59d28c0ea9e59e4cec0f9c94307b9e23ab8b59"

URI_nftables = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/nftables-1.1.1-4.el10_0.x86_64_v2.rpm;name=nftables;unpack=0"
SRC_URI += "${URI_nftables}"
SRC_URI[nftables.sha256sum] = "ecdbdfb488a04b3bb88159b99ee298ac1de833dea5f73ee8d045f2cc9a4b3509"
RDEPENDS:nftables = " \
 gmp \
 jansson \
 libmnl \
 readline \
 iptables-libs \
 bash \
 libnftnl \
 glibc \
"

URI_python3-nftables = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-nftables-1.1.1-4.el10_0.x86_64_v2.rpm;name=python3-nftables;unpack=0"
SRC_URI += "${URI_python3-nftables}"
SRC_URI[python3-nftables.sha256sum] = "c5e96971cb817c862da2680a018cbab4c602326df6f1fbbfc85531a032906e73"
RDEPENDS:python3-nftables = " \
 python3 \
 nftables \
"

URI_nftables-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/nftables-devel-1.1.1-4.el10_0.x86_64_v2.rpm;name=nftables-devel;unpack=0"
SRC_URI += "${URI_nftables-devel}"
SRC_URI[nftables-devel.sha256sum] = "cbd7abdfd92444c059ef5be1fcd200f033848f171d5dd830ebe022a60819a4ec"
RDEPENDS:nftables-devel = " \
 nftables \
 pkgconf-pkg-config \
"
