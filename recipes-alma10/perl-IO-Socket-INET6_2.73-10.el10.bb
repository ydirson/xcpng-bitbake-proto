# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-IO-Socket-INET6"
PE = "0"
PV = "2.73"
PR = "10.el10"
PACKAGES = "perl-IO-Socket-INET6"
PROVIDES = "rpm/perl-IO-Socket-INET6"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-IO-Socket-INET6-2.73-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb69eb2f124305cb7dcc97ecd91401397dde597dd0017165027a66dcda5b15bf"

URI_perl-IO-Socket-INET6 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-IO-Socket-INET6-2.73-10.el10.noarch.rpm;name=perl-IO-Socket-INET6;unpack=0"
SRC_URI += "${URI_perl-IO-Socket-INET6}"
SRC_URI[perl-IO-Socket-INET6.sha256sum] = "420a4122960474424f85a7c5413cc7d3cc7e6fb4622d1cf3e8889abcaae7536e"
RDEPENDS:perl-IO-Socket-INET6 = " \
 perl-libs \
 perl-Carp \
 perl-IO \
 perl-Socket \
 perl-Socket6 \
 perl-Errno \
"
