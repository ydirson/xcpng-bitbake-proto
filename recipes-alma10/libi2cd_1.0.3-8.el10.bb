# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libi2cd"
PE = "0"
PV = "1.0.3"
PR = "8.el10"
PACKAGES = "libi2cd libi2cd-devel"
PROVIDES = "rpm/libi2cd rpm/libi2cd-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libi2cd-1.0.3-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f113efc938aee39c35c3f856c7f0024734a3b14c003ac7d25e3d87c35ae2d666"

URI_libi2cd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libi2cd-1.0.3-8.el10.x86_64_v2.rpm;name=libi2cd;unpack=0"
SRC_URI += "${URI_libi2cd}"
SRC_URI[libi2cd.sha256sum] = "1e8f63984facfd35a9eaa21bbc7133f3fd0ac0d5d3a805ec0219e1eeda019732"
RDEPENDS:libi2cd = " \
 glibc \
"

URI_libi2cd-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libi2cd-devel-1.0.3-8.el10.x86_64_v2.rpm;name=libi2cd-devel;unpack=0"
SRC_URI += "${URI_libi2cd-devel}"
SRC_URI[libi2cd-devel.sha256sum] = "1d1204deac47d0b60ab93762e067c96907f320a09b48498a6b3d862e60c95f67"
RDEPENDS:libi2cd-devel = " \
 pkgconf-pkg-config \
 libi2cd \
"
