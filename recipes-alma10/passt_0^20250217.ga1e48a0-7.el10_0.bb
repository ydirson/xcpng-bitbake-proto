# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "passt"
PE = "0"
PV = "0^20250217.ga1e48a0"
PR = "7.el10_0"
PACKAGES = "passt passt-selinux"
PROVIDES = "rpm/passt rpm/passt-selinux"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/passt-0^20250217.ga1e48a0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3af69d27cc05ca3ea352cc2adf5a679580d90c9cadeb13421d59b5c0c38072a"

URI_passt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/passt-0^20250217.ga1e48a0-7.el10_0.x86_64_v2.rpm;name=passt;unpack=0"
SRC_URI += "${URI_passt}"
SRC_URI[passt.sha256sum] = "150e55f7f6d635e559cfaea0113cf43724a994a53adb05cc6f885dea5c897a40"
RDEPENDS:passt = " \
 glibc \
 passt-selinux \
"

URI_passt-selinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/passt-selinux-0^20250217.ga1e48a0-7.el10_0.noarch.rpm;name=passt-selinux;unpack=0"
SRC_URI += "${URI_passt-selinux}"
SRC_URI[passt-selinux.sha256sum] = "1b172f1156f5eb1189e1d6b16fbb0545247696beab600a8f59740b2dc546abdd"
RDEPENDS:passt-selinux = " \
 selinux-policy \
 bash \
 passt \
 policycoreutils \
"
