# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-justbases"
PE = "0"
PV = "0.15.2"
PR = "9.el10"
PACKAGES = "python3-justbases"
PROVIDES = "rpm/python3-justbases"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-justbases-0.15.2-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9bb6d442ac80659ce743ca29075476b51bcdaeebea61be1e37c3b4c9d2babb24"

URI_python3-justbases = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-justbases-0.15.2-9.el10.noarch.rpm;name=python3-justbases;unpack=0"
SRC_URI += "${URI_python3-justbases}"
SRC_URI[python3-justbases.sha256sum] = "f8d8192f4dbda52c4dedc21a1b49b36b5e1138a38d29d085fda81316f6f2e8d1"
RDEPENDS:python3-justbases = " \
 python3 \
"
