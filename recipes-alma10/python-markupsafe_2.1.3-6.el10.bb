# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-markupsafe"
PE = "0"
PV = "2.1.3"
PR = "6.el10"
PACKAGES = "python3-markupsafe"
PROVIDES = "rpm/python3-markupsafe"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-markupsafe-2.1.3-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e8ef149f912bff952a88880cb1dd9073efa66506a3d3469975b9c7a86b12ebe"

URI_python3-markupsafe = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-markupsafe-2.1.3-6.el10.x86_64_v2.rpm;name=python3-markupsafe;unpack=0"
SRC_URI += "${URI_python3-markupsafe}"
SRC_URI[python3-markupsafe.sha256sum] = "6178f98d1c88888f9d9ac9f125c3a80b2f8f9997ef4c56a6560f5ed35e93d54e"
RDEPENDS:python3-markupsafe = " \
 glibc \
 python3 \
"
