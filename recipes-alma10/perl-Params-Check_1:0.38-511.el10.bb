# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Params-Check"
PE = "1"
PV = "0.38"
PR = "511.el10"
PACKAGES = "perl-Params-Check perl-Params-Check-tests"
PROVIDES = "rpm/perl-Params-Check rpm/perl-Params-Check-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Params-Check-0.38-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a21239ed26da7b0c00be5f03167e9eab7d70693e39f608f08db084920dfae47"

URI_perl-Params-Check = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Params-Check-0.38-511.el10.noarch.rpm;name=perl-Params-Check;unpack=0"
SRC_URI += "${URI_perl-Params-Check}"
SRC_URI[perl-Params-Check.sha256sum] = "a1ed4bda809da65e7217926249ba1699f45ca68e1a8a1acbe235d0e22c74731e"
RDEPENDS:perl-Params-Check = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-Exporter \
 perl-Locale-Maketext-Simple \
"

URI_perl-Params-Check-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Params-Check-tests-0.38-511.el10.noarch.rpm;name=perl-Params-Check-tests;unpack=0"
SRC_URI += "${URI_perl-Params-Check-tests}"
SRC_URI[perl-Params-Check-tests.sha256sum] = "54103a0770f22792bcdadef8f992d9f3390ad8ca887df34289a44608fb7dae89"
RDEPENDS:perl-Params-Check-tests = " \
 perl-constant \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Params-Check \
 bash \
 perl-interpreter \
"
