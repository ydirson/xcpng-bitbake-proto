# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-cop"
PE = "0"
PV = "0.3"
PR = "30.el10"
PACKAGES = "hunspell-cop"
PROVIDES = "rpm/hunspell-cop"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-cop-0.3-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69b181a6eb685ef164e51035414fe02babc72fb83f7c4deeb9b2779c2770ee06"

URI_hunspell-cop = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-cop-0.3-30.el10.noarch.rpm;name=hunspell-cop;unpack=0"
SRC_URI += "${URI_hunspell-cop}"
SRC_URI[hunspell-cop.sha256sum] = "78a87fcca71d2e124ea8d4c2bbeec0cfaee5e39397265cb6c022aebaf902bbfa"
RDEPENDS:hunspell-cop = " \
 hunspell-filesystem \
"
