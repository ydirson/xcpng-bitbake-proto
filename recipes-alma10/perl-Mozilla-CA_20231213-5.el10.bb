# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Mozilla-CA"
PE = "0"
PV = "20231213"
PR = "5.el10"
PACKAGES = "perl-Mozilla-CA perl-Mozilla-CA-tests"
PROVIDES = "rpm/perl-Mozilla-CA rpm/perl-Mozilla-CA-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Mozilla-CA-20231213-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07ef942c15d237fe92c449c54b58e1094becb0d4e896c99f15989dd788881da9"

URI_perl-Mozilla-CA = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Mozilla-CA-20231213-5.el10.noarch.rpm;name=perl-Mozilla-CA;unpack=0"
SRC_URI += "${URI_perl-Mozilla-CA}"
SRC_URI[perl-Mozilla-CA.sha256sum] = "4eaa9fd20bb34e0f137061322ff6b023abe7db9276da1dd9a6687eefe0d98e57"
RDEPENDS:perl-Mozilla-CA = " \
 ca-certificates \
 perl-PathTools \
 perl-libs \
"

URI_perl-Mozilla-CA-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Mozilla-CA-tests-20231213-5.el10.noarch.rpm;name=perl-Mozilla-CA-tests;unpack=0"
SRC_URI += "${URI_perl-Mozilla-CA-tests}"
SRC_URI[perl-Mozilla-CA-tests.sha256sum] = "dde9bd4da10a7b201d5b6028ecc604694e0c9dad0b746264eb6214aec563078b"
RDEPENDS:perl-Mozilla-CA-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Mozilla-CA \
 bash \
 perl-interpreter \
"
