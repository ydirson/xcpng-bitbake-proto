# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-ru"
PE = "0"
PV = "0.20200325"
PR = "13.el10"
PACKAGES = "hyphen-ru"
PROVIDES = "rpm/hyphen-ru"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-ru-0.20200325-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62ca5155e25b74d97671cfb7d49eb86e6207e5fe81e8a300c640bcc8c39e84c1"

URI_hyphen-ru = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-ru-0.20200325-13.el10.noarch.rpm;name=hyphen-ru;unpack=0"
SRC_URI += "${URI_hyphen-ru}"
SRC_URI[hyphen-ru.sha256sum] = "784fb72ec4481a41d9a2636f5fde92cd79d2c53311fc200e684ec869e811ea2d"
RDEPENDS:hyphen-ru = " \
 hyphen \
"
