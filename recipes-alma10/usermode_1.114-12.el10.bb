# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "usermode"
PE = "0"
PV = "1.114"
PR = "12.el10"
PACKAGES = "usermode"
PROVIDES = "rpm/usermode"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/usermode-1.114-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d768b636bf852d61e2de98966abf68a80f2d3ccbade37318a0daaec3dcb73db"

URI_usermode = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/usermode-1.114-12.el10.x86_64_v2.rpm;name=usermode;unpack=0"
SRC_URI += "${URI_usermode}"
SRC_URI[usermode.sha256sum] = "7ed48a9080a48cccfc0bc20d0d1c60a2a4c73060f10dd68fb5e2a4929e0b8629"
RDEPENDS:usermode = " \
 libuser \
 shadow-utils \
 util-linux \
 pam \
 pam-libs \
 glib2 \
 glibc \
 libselinux \
"
