# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "osinfo-db"
PE = "0"
PV = "20250124"
PR = "2.el10_0"
PACKAGES = "osinfo-db"
PROVIDES = "rpm/osinfo-db"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/osinfo-db-20250124-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7612bff7005ffa21a1bf586e22121a4f8a199b37d8fce394bd439c532ce0ba8"

URI_osinfo-db = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/osinfo-db-20250124-2.el10_0.noarch.rpm;name=osinfo-db;unpack=0"
SRC_URI += "${URI_osinfo-db}"
SRC_URI[osinfo-db.sha256sum] = "0035b076e4022aa791fb83538d84b28736901ae6b5e750b275b2a02518d2802c"
RDEPENDS:osinfo-db = " \
 hwdata \
"
