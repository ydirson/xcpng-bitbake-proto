# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "scl-utils"
PE = "1"
PV = "2.0.3"
PR = "5.el10"
PACKAGES = "scl-utils scl-utils-build"
PROVIDES = "rpm/scl-utils rpm/scl-utils-build"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/scl-utils-2.0.3-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9269080b4ed62c815f2c1d7eeda0ba57b93da492de3932f4a24c8457448f3119"

URI_scl-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/scl-utils-2.0.3-5.el10.x86_64_v2.rpm;name=scl-utils;unpack=0"
SRC_URI += "${URI_scl-utils}"
SRC_URI[scl-utils.sha256sum] = "1dc4e70be124c7e7087b86fcc622b3ed0c7e302c95d8f4676cb060c53103c62a"
RDEPENDS:scl-utils = " \
 glibc \
 environment-modules \
 bash \
 rpm-libs \
"

URI_scl-utils-build = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/scl-utils-build-2.0.3-5.el10.x86_64_v2.rpm;name=scl-utils-build;unpack=0"
SRC_URI += "${URI_scl-utils-build}"
SRC_URI[scl-utils-build.sha256sum] = "36759722bcafb16d0037c2fccd4a3e38859b8485c982f8bfb6e02dac8b1f3bdc"
RDEPENDS:scl-utils-build = " \
 redhat-rpm-config \
 bash \
 iso-codes \
"
