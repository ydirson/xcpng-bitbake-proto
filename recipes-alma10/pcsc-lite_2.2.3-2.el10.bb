# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pcsc-lite"
PE = "0"
PV = "2.2.3"
PR = "2.el10"
PACKAGES = "pcsc-lite pcsc-lite-libs pcsc-lite-devel pcsc-lite-doc"
PROVIDES = "rpm/pcsc-lite rpm/pcsc-lite-libs rpm/pcsc-lite-devel rpm/pcsc-lite-doc"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/pcsc-lite-2.2.3-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6abec551968b13371ca15aa7deeff150504348f32b58d0b6edf984842abf3e4"

URI_pcsc-lite = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/pcsc-lite-2.2.3-2.el10.x86_64_v2.rpm;name=pcsc-lite;unpack=0"
SRC_URI += "${URI_pcsc-lite}"
SRC_URI[pcsc-lite.sha256sum] = "8d77fee332b223fe7fc43093104fd14023697083a2741e237c95ead7e2b8ced2"
RDEPENDS:pcsc-lite = " \
 python3 \
 systemd \
 systemd-libs \
 polkit \
 polkit-libs \
 bash \
 glib2 \
 pcsc-lite-libs \
 pcsc-lite-ccid \
 glibc \
"

URI_pcsc-lite-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/pcsc-lite-libs-2.2.3-2.el10.x86_64_v2.rpm;name=pcsc-lite-libs;unpack=0"
SRC_URI += "${URI_pcsc-lite-libs}"
SRC_URI[pcsc-lite-libs.sha256sum] = "8543123b85bae86bf1d3a811edfbbf26a23bd63714a2c4013c99eef0e0cd68e3"
RDEPENDS:pcsc-lite-libs = " \
 glibc \
"

URI_pcsc-lite-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcsc-lite-devel-2.2.3-2.el10.x86_64_v2.rpm;name=pcsc-lite-devel;unpack=0"
SRC_URI += "${URI_pcsc-lite-devel}"
SRC_URI[pcsc-lite-devel.sha256sum] = "ca997f50f4c5008af0939b2911485e1ee02d83e617b7329695fd02f2284f6f1f"
RDEPENDS:pcsc-lite-devel = " \
 glibc \
 pcsc-lite-libs \
 pkgconf-pkg-config \
 python3 \
"

URI_pcsc-lite-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/pcsc-lite-doc-2.2.3-2.el10.noarch.rpm;name=pcsc-lite-doc;unpack=0"
SRC_URI += "${URI_pcsc-lite-doc}"
SRC_URI[pcsc-lite-doc.sha256sum] = "9639792bf59d5b59c8564be58e3f4eefe07d09cc98d1ca8605ee3162ea035a0f"
RDEPENDS:pcsc-lite-doc = " \
 pcsc-lite-libs \
"
