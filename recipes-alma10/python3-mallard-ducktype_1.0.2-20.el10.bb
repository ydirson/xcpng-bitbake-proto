# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python3-mallard-ducktype"
PE = "0"
PV = "1.0.2"
PR = "20.el10"
PACKAGES = "python3-mallard-ducktype"
PROVIDES = "rpm/python3-mallard-ducktype"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/python3-mallard-ducktype-1.0.2-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83cb0fa578fd79b8911392a8d0cf9c57909e04e4484a9190733ec70c9d39f4fb"

URI_python3-mallard-ducktype = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-mallard-ducktype-1.0.2-20.el10.noarch.rpm;name=python3-mallard-ducktype;unpack=0"
SRC_URI += "${URI_python3-mallard-ducktype}"
SRC_URI[python3-mallard-ducktype.sha256sum] = "5590e066bbd95738b435bce7202bd7773a4eeb14a05240e1f0abcb9fb920fa66"
RDEPENDS:python3-mallard-ducktype = " \
 python3 \
"
