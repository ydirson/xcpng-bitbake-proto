# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "copy-jdk-configs"
PE = "0"
PV = "4.1"
PR = "7.el10"
PACKAGES = "copy-jdk-configs"
PROVIDES = "rpm/copy-jdk-configs"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/copy-jdk-configs-4.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eccaa12f1ca0142aedf6b12b4229275caab1588fe8ac7a8729aeaee5ab6ae7ab"

URI_copy-jdk-configs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/copy-jdk-configs-4.1-7.el10.noarch.rpm;name=copy-jdk-configs;unpack=0"
SRC_URI += "${URI_copy-jdk-configs}"
SRC_URI[copy-jdk-configs.sha256sum] = "09d734879e102a3b3fafacdc4c9137b7bfe81f89335ca35239ca45f70d635c8f"
RDEPENDS:copy-jdk-configs = " \
 lua \
 lua-posix \
 bash \
 findutils \
"
