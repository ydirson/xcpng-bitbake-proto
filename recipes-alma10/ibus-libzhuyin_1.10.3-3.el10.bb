# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ibus-libzhuyin"
PE = "0"
PV = "1.10.3"
PR = "3.el10"
PACKAGES = "ibus-libzhuyin"
PROVIDES = "rpm/ibus-libzhuyin"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ibus-libzhuyin-1.10.3-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7bd44b4ebb3feda7e8700beda76eae6b22cfed9b2773ad36c7f455e0ce770a8"

URI_ibus-libzhuyin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ibus-libzhuyin-1.10.3-3.el10.x86_64_v2.rpm;name=ibus-libzhuyin;unpack=0"
SRC_URI += "${URI_ibus-libzhuyin}"
SRC_URI[ibus-libzhuyin.sha256sum] = "6724db3b581b30418038cb4d4d135af05c9cb9ee56642877905aea4afb572c7b"
RDEPENDS:ibus-libzhuyin = " \
 libzhuyin \
 libgcc \
 ibus \
 libstdc++ \
 bash \
 glib2 \
 ibus-libs \
 glibc \
"
