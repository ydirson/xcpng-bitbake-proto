# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Text-Template"
PE = "0"
PV = "1.61"
PR = "8.el10"
PACKAGES = "perl-Text-Template perl-Text-Template-tests"
PROVIDES = "rpm/perl-Text-Template rpm/perl-Text-Template-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Text-Template-1.61-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e9e19fd20ac16f2615ebdb88420cad8b872071b1d853db3ce19760a77be9154"

URI_perl-Text-Template = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Text-Template-1.61-8.el10.noarch.rpm;name=perl-Text-Template;unpack=0"
SRC_URI += "${URI_perl-Text-Template}"
SRC_URI[perl-Text-Template.sha256sum] = "6c777da05ff3a242770e64e19d09508de4eb157e33cd58f9f98c5c9ca6ecaa71"
RDEPENDS:perl-Text-Template = " \
 perl-libs \
 perl-Carp \
 perl-Text-Template \
 perl-Exporter \
 perl-base \
"

URI_perl-Text-Template-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Text-Template-tests-1.61-8.el10.noarch.rpm;name=perl-Text-Template-tests;unpack=0"
SRC_URI += "${URI_perl-Text-Template-tests}"
SRC_URI[perl-Text-Template-tests.sha256sum] = "a31a6b8d68db828125a2ff34e8f2bbcaed20ebee6ef5dc40a390428d31cee75b"
RDEPENDS:perl-Text-Template-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-vars \
 perl-Text-Template \
 perl-Encode \
 perl-File-Temp \
 bash \
 perl-interpreter \
 perl-lib \
"
