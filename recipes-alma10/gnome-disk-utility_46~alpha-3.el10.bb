# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-disk-utility"
PE = "0"
PV = "46~alpha"
PR = "3.el10"
PACKAGES = "gnome-disk-utility"
PROVIDES = "rpm/gnome-disk-utility"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-disk-utility-46~alpha-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc682703ce403d448f49b6a9c81a5391f1e9c33abaf1d86cbd6c94ead9af291d"

URI_gnome-disk-utility = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-disk-utility-46~alpha-3.el10.x86_64_v2.rpm;name=gnome-disk-utility;unpack=0"
SRC_URI += "${URI_gnome-disk-utility}"
SRC_URI[gnome-disk-utility.sha256sum] = "25ab9ad6733cb1ac8303b784ca667c317629d91d45c4afef3e06dd40dc6f5b96"
RDEPENDS:gnome-disk-utility = " \
 libdvdread \
 atk \
 libhandy \
 systemd-libs \
 libpwquality \
 libgcc \
 pango \
 gdk-pixbuf2 \
 libudisks2 \
 libsecret \
 libcanberra-gtk3 \
 cairo \
 glib2 \
 gtk3 \
 glibc \
 udisks2 \
 xz-libs \
 libnotify \
"
