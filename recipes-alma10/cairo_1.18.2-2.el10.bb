# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cairo"
PE = "0"
PV = "1.18.2"
PR = "2.el10"
PACKAGES = "cairo cairo-devel cairo-gobject cairo-gobject-devel cairo-tools"
PROVIDES = "rpm/cairo rpm/cairo-devel rpm/cairo-gobject rpm/cairo-gobject-devel rpm/cairo-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/cairo-1.18.2-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b074e211524b885a6a671ac14789be66064f044940479dc7bc4409770fa81fa"

URI_cairo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cairo-1.18.2-2.el10.x86_64_v2.rpm;name=cairo;unpack=0"
SRC_URI += "${URI_cairo}"
SRC_URI[cairo.sha256sum] = "3a0d0d632876f6e74548c7e30aec6ab9ef380cf08c7b8f4c1b2af86a246e7b7f"
RDEPENDS:cairo = " \
 zlib-ng-compat \
 freetype \
 libpng \
 fontconfig \
 libX11 \
 libxcb \
 libXrender \
 glibc \
 pixman \
 libXext \
"

URI_cairo-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cairo-devel-1.18.2-2.el10.x86_64_v2.rpm;name=cairo-devel;unpack=0"
SRC_URI += "${URI_cairo-devel}"
SRC_URI[cairo-devel.sha256sum] = "6bd361df86f0ff7f46eb4ce609961ac4aaea127aee67a29bf627b86353ffddc1"
RDEPENDS:cairo-devel = " \
 libXext-devel \
 zlib-ng-compat-devel \
 freetype-devel \
 pkgconf-pkg-config \
 fontconfig-devel \
 libXrender-devel \
 libX11-devel \
 libxcb-devel \
 cairo \
 cairo-devel \
 libpng-devel \
 pixman-devel \
"

URI_cairo-gobject = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cairo-gobject-1.18.2-2.el10.x86_64_v2.rpm;name=cairo-gobject;unpack=0"
SRC_URI += "${URI_cairo-gobject}"
SRC_URI[cairo-gobject.sha256sum] = "90709735093f0be0e723fe35ac1fa5b4be98a7882918fbe4fb741a386ae17be4"
RDEPENDS:cairo-gobject = " \
 glibc \
 cairo \
 glib2 \
"

URI_cairo-gobject-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cairo-gobject-devel-1.18.2-2.el10.x86_64_v2.rpm;name=cairo-gobject-devel;unpack=0"
SRC_URI += "${URI_cairo-gobject-devel}"
SRC_URI[cairo-gobject-devel.sha256sum] = "a2567eb6004619dc38359c2af6aa5988b0ef1fa9348a4c6b1e6f0fe6c6166448"
RDEPENDS:cairo-gobject-devel = " \
 libXext-devel \
 glib2-devel \
 zlib-ng-compat-devel \
 freetype-devel \
 pkgconf-pkg-config \
 fontconfig-devel \
 libpng-devel \
 libX11-devel \
 libxcb-devel \
 libXrender-devel \
 cairo-devel \
 cairo-gobject \
 pixman-devel \
"

URI_cairo-tools = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/cairo-tools-1.18.2-2.el10.x86_64_v2.rpm;name=cairo-tools;unpack=0"
SRC_URI += "${URI_cairo-tools}"
SRC_URI[cairo-tools.sha256sum] = "65af87cc858ac325e8ff589807129ecddf9b3453da62ffedaea0b9d19b1f988b"
RDEPENDS:cairo-tools = " \
 glibc \
 zlib-ng-compat \
 bash \
 cairo \
"
