# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-gl"
PE = "0"
PV = "0.99"
PR = "32.el10"
PACKAGES = "hyphen-gl"
PROVIDES = "rpm/hyphen-gl"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-gl-0.99-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82536993d194eab5f10dc609da862175f28ba67881a34bfe9162adfd9db96579"

URI_hyphen-gl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-gl-0.99-32.el10.noarch.rpm;name=hyphen-gl;unpack=0"
SRC_URI += "${URI_hyphen-gl}"
SRC_URI[hyphen-gl.sha256sum] = "f4b253d1b154656779865728e498e2d8a117120ceb5fb6cb050d1afb208b78d1"
RDEPENDS:hyphen-gl = " \
 hyphen \
"
