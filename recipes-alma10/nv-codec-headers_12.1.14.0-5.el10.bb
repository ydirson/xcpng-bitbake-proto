# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "nv-codec-headers"
PE = "0"
PV = "12.1.14.0"
PR = "5.el10"
PACKAGES = "nv-codec-headers"
PROVIDES = "rpm/nv-codec-headers"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/nv-codec-headers-12.1.14.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ae42dab7b3dcba409f00863bd3e77f6234c285009d69f78bbdad672b36b79fb"

URI_nv-codec-headers = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/nv-codec-headers-12.1.14.0-5.el10.noarch.rpm;name=nv-codec-headers;unpack=0"
SRC_URI += "${URI_nv-codec-headers}"
SRC_URI[nv-codec-headers.sha256sum] = "04ae014515a9571459780ae3361577899dcb59da7e78cfc53e5304e8b9c91ab6"
RDEPENDS:nv-codec-headers = " \
 pkgconf-pkg-config \
"
