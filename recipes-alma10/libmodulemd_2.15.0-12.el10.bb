# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libmodulemd"
PE = "0"
PV = "2.15.0"
PR = "12.el10"
PACKAGES = "libmodulemd python3-libmodulemd libmodulemd-devel"
PROVIDES = "rpm/libmodulemd rpm/python3-libmodulemd rpm/libmodulemd-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libmodulemd-2.15.0-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6224c6986c63f30e51a3385eff748f1758e422915d37d924e0dd0b61f2ede595"

URI_libmodulemd = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libmodulemd-2.15.0-12.el10.x86_64_v2.rpm;name=libmodulemd;unpack=0"
SRC_URI += "${URI_libmodulemd}"
SRC_URI[libmodulemd.sha256sum] = "b456e569d04cf4352bf04cd32e5fb51b33f879a540b2dd312d61bc6c73a00f41"
RDEPENDS:libmodulemd = " \
 libgcc \
 libyaml \
 glib2 \
 glibc \
 rpm-libs \
"

URI_python3-libmodulemd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-libmodulemd-2.15.0-12.el10.x86_64_v2.rpm;name=python3-libmodulemd;unpack=0"
SRC_URI += "${URI_python3-libmodulemd}"
SRC_URI[python3-libmodulemd.sha256sum] = "21d10476473070cd50c0fc64f0b91813e9c440e248ab5371708a5ae0cfb7217e"
RDEPENDS:python3-libmodulemd = " \
 python3 \
 python3-six \
 libmodulemd \
 python3-gobject-base \
"

URI_libmodulemd-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libmodulemd-devel-2.15.0-12.el10.x86_64_v2.rpm;name=libmodulemd-devel;unpack=0"
SRC_URI += "${URI_libmodulemd-devel}"
SRC_URI[libmodulemd-devel.sha256sum] = "6bb07e15095906dc7a0f462cbbff3d61f9666f4c85deeeabd00864f4f06aa3c0"
RDEPENDS:libmodulemd-devel = " \
 glib2-devel \
 libmodulemd \
 pkgconf-pkg-config \
 libyaml-devel \
 rpm-devel \
"
