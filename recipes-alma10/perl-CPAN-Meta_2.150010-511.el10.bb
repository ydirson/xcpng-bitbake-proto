# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-CPAN-Meta"
PE = "0"
PV = "2.150010"
PR = "511.el10"
PACKAGES = "perl-CPAN-Meta perl-CPAN-Meta-tests"
PROVIDES = "rpm/perl-CPAN-Meta rpm/perl-CPAN-Meta-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-CPAN-Meta-2.150010-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b9705e76276cccf3d6a24367519d18261f1a17edfeabfae1e0cb0b6793496ec"

URI_perl-CPAN-Meta = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-CPAN-Meta-2.150010-511.el10.noarch.rpm;name=perl-CPAN-Meta;unpack=0"
SRC_URI += "${URI_perl-CPAN-Meta}"
SRC_URI[perl-CPAN-Meta.sha256sum] = "c42daa47e93bbc7b6ca5c636178949ae4331ce3050d981c017ea27b4cbdb079c"
RDEPENDS:perl-CPAN-Meta = " \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Requirements \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-CPAN-Meta-YAML \
 perl-version \
 perl-Encode \
 perl-JSON-PP \
 perl-Exporter \
"

URI_perl-CPAN-Meta-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-CPAN-Meta-tests-2.150010-511.el10.noarch.rpm;name=perl-CPAN-Meta-tests;unpack=0"
SRC_URI += "${URI_perl-CPAN-Meta-tests}"
SRC_URI[perl-CPAN-Meta-tests.sha256sum] = "eaca32073723bc319edc1badb0b42de398a29ccd1341be16c332faa413247089"
RDEPENDS:perl-CPAN-Meta-tests = " \
 perl-CPAN-Meta \
 perl-Test-Harness \
 perl-libs \
 perl-ExtUtils-MakeMaker \
 perl-vars \
 perl-Scalar-List-Utils \
 perl-IO \
 perl-Test-Simple \
 perl-Storable \
 perl-File-Basename \
 perl-overload \
 perl-File-Temp \
 perl-PathTools \
 bash \
 perl-interpreter \
 perl-Data-Dumper \
 perl-lib \
"
