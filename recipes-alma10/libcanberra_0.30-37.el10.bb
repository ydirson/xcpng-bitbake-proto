# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libcanberra"
PE = "0"
PV = "0.30"
PR = "37.el10"
PACKAGES = "libcanberra libcanberra-devel libcanberra-gtk3"
PROVIDES = "rpm/libcanberra rpm/libcanberra-devel rpm/libcanberra-gtk3"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libcanberra-0.30-37.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e8bb6af5d935d89cf300e5015277d58dc41f9841bb03dc285b4cfaf666e339e"

URI_libcanberra = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libcanberra-0.30-37.el10.x86_64_v2.rpm;name=libcanberra;unpack=0"
SRC_URI += "${URI_libcanberra}"
SRC_URI[libcanberra.sha256sum] = "5df0395d1075cf89478bcf313b7bd5d85edab22f64578f3f4811295e4f2e3db6"
RDEPENDS:libcanberra = " \
 alsa-lib \
 libvorbis \
 sound-theme-freedesktop \
 libtool-ltdl \
 systemd-libs \
 gstreamer1 \
 pulseaudio-libs \
 bash \
 glib2 \
 libtdb \
 glibc \
"

URI_libcanberra-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libcanberra-devel-0.30-37.el10.x86_64_v2.rpm;name=libcanberra-devel;unpack=0"
SRC_URI += "${URI_libcanberra-devel}"
SRC_URI[libcanberra-devel.sha256sum] = "a0310cf737cd88b14396999888c609dd1ca9f835d6eb35cea5e3d4550e99cc81"
RDEPENDS:libcanberra-devel = " \
 pkgconf-pkg-config \
 libcanberra \
 libcanberra-devel \
 libcanberra-gtk3 \
 gtk3-devel \
"

URI_libcanberra-gtk3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libcanberra-gtk3-0.30-37.el10.x86_64_v2.rpm;name=libcanberra-gtk3;unpack=0"
SRC_URI += "${URI_libcanberra-gtk3}"
SRC_URI[libcanberra-gtk3.sha256sum] = "1f904d9b6742ab72f571f84d4c3a4371b2b43da3d80c3a354d05c014d9b5d8ab"
RDEPENDS:libcanberra-gtk3 = " \
 libvorbis \
 atk \
 libtool-ltdl \
 cairo-gobject \
 libtdb \
 harfbuzz \
 pango \
 gdk-pixbuf2 \
 libX11 \
 libcanberra \
 bash \
 cairo \
 glib2 \
 gtk3 \
 glibc \
"
