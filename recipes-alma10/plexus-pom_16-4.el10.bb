# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "plexus-pom"
PE = "0"
PV = "16"
PR = "4.el10"
PACKAGES = "plexus-pom"
PROVIDES = "rpm/plexus-pom"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/plexus-pom-16-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c82ef1096615ef2e04c5ff81d63b768c31ec7f2aa1b00a26ff0369112680901"

URI_plexus-pom = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-pom-16-4.el10.noarch.rpm;name=plexus-pom;unpack=0"
SRC_URI += "${URI_plexus-pom}"
SRC_URI[plexus-pom.sha256sum] = "2314b8ac951ff706c22e42990c3f59b55ddec520423658e22eedf57caaac25e8"
RDEPENDS:plexus-pom = " \
 javapackages-filesystem \
"
