# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "radvd"
PE = "0"
PV = "2.19"
PR = "16.el10"
PACKAGES = "radvd"
PROVIDES = "rpm/radvd"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/radvd-2.19-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9fc0dd7600587d861966d689fb54c39d349e9536d49eae8d996a095eff00c16"

URI_radvd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/radvd-2.19-16.el10.x86_64_v2.rpm;name=radvd;unpack=0"
SRC_URI += "${URI_radvd}"
SRC_URI[radvd.sha256sum] = "7d43671eba0fd9e181ba291c9dfec7722cc024c64b86253fd7fc0104bc886cd0"
RDEPENDS:radvd = " \
 glibc \
 shadow-utils \
 systemd \
 bash \
"
