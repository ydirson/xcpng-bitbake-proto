# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "stratisd"
PE = "0"
PV = "3.7.3"
PR = "2.el10"
PACKAGES = "stratisd stratisd-dracut stratisd-tools"
PROVIDES = "rpm/stratisd rpm/stratisd-dracut rpm/stratisd-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/stratisd-3.7.3-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6605eb6ae39b8456ce1065ce5b7d07b221163e0f1fc9e944d623cc27a8bb194c"

URI_stratisd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/stratisd-3.7.3-2.el10.x86_64_v2.rpm;name=stratisd;unpack=0"
SRC_URI += "${URI_stratisd}"
SRC_URI[stratisd.sha256sum] = "d238a1fddf37a43c998a45b621b745e034ffd0e3b9a75df02f453ae3919b2ed9"
RDEPENDS:stratisd = " \
 python3 \
 systemd-libs \
 cryptsetup-libs \
 device-mapper-persistent-data \
 libgcc \
 libblkid \
 bash \
 glibc \
 xfsprogs \
 dbus-libs \
"

URI_stratisd-dracut = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/stratisd-dracut-3.7.3-2.el10.x86_64_v2.rpm;name=stratisd-dracut;unpack=0"
SRC_URI += "${URI_stratisd-dracut}"
SRC_URI[stratisd-dracut.sha256sum] = "4c34e844ae4b27c9e8b7691dffdafd8ef6cac1e9d8528927366fcf8146ae5210"
RDEPENDS:stratisd-dracut = " \
 systemd \
 systemd-libs \
 cryptsetup-libs \
 libgcc \
 libblkid \
 stratisd \
 bash \
 dracut \
 glibc \
"

URI_stratisd-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/stratisd-tools-3.7.3-2.el10.x86_64_v2.rpm;name=stratisd-tools;unpack=0"
SRC_URI += "${URI_stratisd-tools}"
SRC_URI[stratisd-tools.sha256sum] = "b0b57327530ce4b25ac771dd072e9e55e5a5324e5b792daf13fcb6fc86299ed4"
RDEPENDS:stratisd-tools = " \
 systemd-libs \
 cryptsetup-libs \
 libblkid \
 libgcc \
 stratisd \
 glibc \
"
