# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "opensm"
PE = "0"
PV = "3.3.24"
PR = "12.el10"
PACKAGES = "opensm opensm-libs opensm-devel opensm-static"
PROVIDES = "rpm/opensm rpm/opensm-libs rpm/opensm-devel rpm/opensm-static"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/opensm-3.3.24-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54e54c9ccdb3b1c6c444a214ac62f2fafecab87d6dca5a6a1a73f039f71e7e5a"

URI_opensm = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/opensm-3.3.24-12.el10.x86_64_v2.rpm;name=opensm;unpack=0"
SRC_URI += "${URI_opensm}"
SRC_URI[opensm.sha256sum] = "4a33036bd464dcb5666f37d458311b9fdcdc7006d3ec627cb18f77beaaa0dbcf"
RDEPENDS:opensm = " \
 logrotate \
 systemd \
 opensm-libs \
 rdma-core \
 bash \
 glibc \
"

URI_opensm-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/opensm-libs-3.3.24-12.el10.x86_64_v2.rpm;name=opensm-libs;unpack=0"
SRC_URI += "${URI_opensm-libs}"
SRC_URI[opensm-libs.sha256sum] = "0296ed5ee8d61c41fbc0c5285b43aab986bde591dd645bc360de1bdd90bbe957"
RDEPENDS:opensm-libs = " \
 glibc \
 libibumad \
 libgcc \
"

URI_opensm-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/opensm-devel-3.3.24-12.el10.x86_64_v2.rpm;name=opensm-devel;unpack=0"
SRC_URI += "${URI_opensm-devel}"
SRC_URI[opensm-devel.sha256sum] = "a9f21fd299677a5556a27c8127d6b3121c9f3ccfc89e16899ad5e72751049f16"
RDEPENDS:opensm-devel = " \
 opensm-libs \
"

URI_opensm-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/opensm-static-3.3.24-12.el10.x86_64_v2.rpm;name=opensm-static;unpack=0"
SRC_URI += "${URI_opensm-static}"
SRC_URI[opensm-static.sha256sum] = "cad334d73f29afde27aa96d46314249f16fe1af23349dbd05384001cc4912585"
RDEPENDS:opensm-static = " \
 opensm-devel \
"
