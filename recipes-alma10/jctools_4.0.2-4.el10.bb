# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jctools"
PE = "0"
PV = "4.0.2"
PR = "4.el10"
PACKAGES = "jctools jctools-javadoc"
PROVIDES = "rpm/jctools rpm/jctools-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/jctools-4.0.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68f3bae318266e367f998c546de2eb8fc582798e5a0b4a063c4eb7bcf7c29c92"

URI_jctools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jctools-4.0.2-4.el10.noarch.rpm;name=jctools;unpack=0"
SRC_URI += "${URI_jctools}"
SRC_URI[jctools.sha256sum] = "3f715de7cd5af1e01fbd894f64c6f5530d16222fb049695984ea58590f94dfe2"
RDEPENDS:jctools = " \
 javapackages-filesystem \
"

URI_jctools-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/jctools-javadoc-4.0.2-4.el10.noarch.rpm;name=jctools-javadoc;unpack=0"
SRC_URI += "${URI_jctools-javadoc}"
SRC_URI[jctools-javadoc.sha256sum] = "ad392796bfbc6c08fc015d9b0e6d918e337f3707f513267847aea1cecce6661f"
RDEPENDS:jctools-javadoc = " \
 javapackages-filesystem \
"
