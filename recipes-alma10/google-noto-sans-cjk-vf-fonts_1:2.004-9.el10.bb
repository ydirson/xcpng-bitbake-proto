# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "google-noto-sans-cjk-vf-fonts"
PE = "1"
PV = "2.004"
PR = "9.el10"
PACKAGES = "google-noto-sans-cjk-vf-fonts google-noto-sans-mono-cjk-vf-fonts"
PROVIDES = "rpm/google-noto-sans-cjk-vf-fonts rpm/google-noto-sans-mono-cjk-vf-fonts"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/google-noto-sans-cjk-vf-fonts-2.004-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90fe1ba8725be673caedda87120acbf721ac80f8343ff0e240b03e7e05083b3f"

URI_google-noto-sans-cjk-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-cjk-vf-fonts-2.004-9.el10.noarch.rpm;name=google-noto-sans-cjk-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-cjk-vf-fonts}"
SRC_URI[google-noto-sans-cjk-vf-fonts.sha256sum] = "cd7bfa59806126fa6a4bede5c7eb2e19d6494dcbf4164cd64a2a9698c825b6f9"
RDEPENDS:google-noto-sans-cjk-vf-fonts = " \
 fonts-filesystem \
"

URI_google-noto-sans-mono-cjk-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/google-noto-sans-mono-cjk-vf-fonts-2.004-9.el10.noarch.rpm;name=google-noto-sans-mono-cjk-vf-fonts;unpack=0"
SRC_URI += "${URI_google-noto-sans-mono-cjk-vf-fonts}"
SRC_URI[google-noto-sans-mono-cjk-vf-fonts.sha256sum] = "18b319d454963085f25e92528738a66d2c5ba0c291cb9b4e035f5f8dcfb07aa0"
RDEPENDS:google-noto-sans-mono-cjk-vf-fonts = " \
 fonts-filesystem \
"
