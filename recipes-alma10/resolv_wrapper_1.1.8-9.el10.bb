# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "resolv_wrapper"
PE = "0"
PV = "1.1.8"
PR = "9.el10"
PACKAGES = "resolv_wrapper"
PROVIDES = "rpm/resolv_wrapper"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/resolv_wrapper-1.1.8-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df9bbb85abb38c745aa8901c7f5a9a8dd653696bdeacf5cdaa26affd6e611c2a"

URI_resolv_wrapper = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/resolv_wrapper-1.1.8-9.el10.x86_64_v2.rpm;name=resolv_wrapper;unpack=0"
SRC_URI += "${URI_resolv_wrapper}"
SRC_URI[resolv_wrapper.sha256sum] = "e97a696092ed68a91664c6f7309399f90af4d5b77069a2983001159833ac0aad"
RDEPENDS:resolv_wrapper = " \
 glibc \
 cmake-filesystem \
 pkgconf-pkg-config \
"
