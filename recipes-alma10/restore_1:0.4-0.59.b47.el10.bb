# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "restore"
PE = "1"
PV = "0.4"
PR = "0.59.b47.el10"
PACKAGES = "restore"
PROVIDES = "rpm/restore"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/restore-0.4-0.59.b47.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8935948209e9883395a7af6a2be6a7e66a8e8e9be1899cae2dad72e163772b50"

URI_restore = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/restore-0.4-0.59.b47.el10.x86_64_v2.rpm;name=restore;unpack=0"
SRC_URI += "${URI_restore}"
SRC_URI[restore.sha256sum] = "28b629339b8ba6d9511a1fc9105bc9c74f3ed771db97f34654b90b31e25f739a"
RDEPENDS:restore = " \
 setup \
 e2fsprogs-libs \
 zlib-ng-compat \
 bzip2-libs \
 lzo \
 readline \
 rmt \
 glibc \
 libselinux \
"
