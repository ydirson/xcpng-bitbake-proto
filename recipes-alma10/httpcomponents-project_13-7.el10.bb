# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "httpcomponents-project"
PE = "0"
PV = "13"
PR = "7.el10"
PACKAGES = "httpcomponents-project"
PROVIDES = "rpm/httpcomponents-project"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/httpcomponents-project-13-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6926cd3966eca6fbcd23c8057a9f11762d06286100338e716e9488393c8eaa51"

URI_httpcomponents-project = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/httpcomponents-project-13-7.el10.noarch.rpm;name=httpcomponents-project;unpack=0"
SRC_URI += "${URI_httpcomponents-project}"
SRC_URI[httpcomponents-project.sha256sum] = "cb4c7079f36f6a24fe18c5414b6185e938224588a11ab19d4f706199618e2e5d"
RDEPENDS:httpcomponents-project = " \
 maven-jar-plugin \
 javapackages-filesystem \
 apache-parent \
"
