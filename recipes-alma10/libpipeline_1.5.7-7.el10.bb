# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libpipeline"
PE = "0"
PV = "1.5.7"
PR = "7.el10"
PACKAGES = "libpipeline libpipeline-devel"
PROVIDES = "rpm/libpipeline rpm/libpipeline-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libpipeline-1.5.7-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d7829c21fddd8efd8f445614a8da1da16dec0fc45f70dab493674e7e9177300"

URI_libpipeline = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libpipeline-1.5.7-7.el10.x86_64_v2.rpm;name=libpipeline;unpack=0"
SRC_URI += "${URI_libpipeline}"
SRC_URI[libpipeline.sha256sum] = "43f492d5cfa82e4dab85b381e3a94612bcd014afd455393c99b0d50f5042eeaa"
RDEPENDS:libpipeline = " \
 glibc \
"

URI_libpipeline-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libpipeline-devel-1.5.7-7.el10.x86_64_v2.rpm;name=libpipeline-devel;unpack=0"
SRC_URI += "${URI_libpipeline-devel}"
SRC_URI[libpipeline-devel.sha256sum] = "97fea0dfb77e0f11348301a8e40892639340cef0dd4c601e90bae10f01332ed9"
RDEPENDS:libpipeline-devel = " \
 libpipeline \
 pkgconf-pkg-config \
"
