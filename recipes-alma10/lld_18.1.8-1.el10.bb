# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lld"
PE = "0"
PV = "18.1.8"
PR = "1.el10"
PACKAGES = ""
PROVIDES = ""


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/lld-18.1.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd3e63b9ab1f87522047def16e45fed320623bec1205f48ef402cb32ed3488a2"
