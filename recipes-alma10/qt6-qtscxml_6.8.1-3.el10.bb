# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtscxml"
PE = "0"
PV = "6.8.1"
PR = "3.el10"
PACKAGES = "qt6-qtscxml qt6-qtscxml-devel qt6-qtscxml-examples qt6-qtscxml-tests"
PROVIDES = "rpm/qt6-qtscxml rpm/qt6-qtscxml-devel rpm/qt6-qtscxml-examples rpm/qt6-qtscxml-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtscxml-6.8.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43467d3cc13acce44be231bbab057d0a4dd5764b75277a0360ff984ebad7890e"

URI_qt6-qtscxml = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtscxml-6.8.1-3.el10.x86_64_v2.rpm;name=qt6-qtscxml;unpack=0"
SRC_URI += "${URI_qt6-qtscxml}"
SRC_URI[qt6-qtscxml.sha256sum] = "1eb62be07118507e841f915a7dfc62e8ecdf0ae9126216bbcc4608f239250559"
RDEPENDS:qt6-qtscxml = " \
 qt6-qtdeclarative \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qtscxml-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtscxml-devel-6.8.1-3.el10.x86_64_v2.rpm;name=qt6-qtscxml-devel;unpack=0"
SRC_URI += "${URI_qt6-qtscxml-devel}"
SRC_URI[qt6-qtscxml-devel.sha256sum] = "d243dc1463a12870d7f03d629fe776fa72b79f26d5b8a1d6b6357b11d638d2e8"
RDEPENDS:qt6-qtscxml-devel = " \
 qt6-qtdeclarative-devel \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtscxml \
 qt6-qtscxml-devel \
"

URI_qt6-qtscxml-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtscxml-examples-6.8.1-3.el10.x86_64_v2.rpm;name=qt6-qtscxml-examples;unpack=0"
SRC_URI += "${URI_qt6-qtscxml-examples}"
SRC_URI[qt6-qtscxml-examples.sha256sum] = "11182010c5de878052565c456621dba2fd12d304adc03ecace73f71496443e28"
RDEPENDS:qt6-qtscxml-examples = " \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 qt6-qtscxml \
 glibc \
"

URI_qt6-qtscxml-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtscxml-tests-6.8.1-3.el10.x86_64_v2.rpm;name=qt6-qtscxml-tests;unpack=0"
SRC_URI += "${URI_qt6-qtscxml-tests}"
SRC_URI[qt6-qtscxml-tests.sha256sum] = "c60725fd76cd39af75a326b825f64bf5f3c53b16f14d10ff78c263eb9a60c979"
RDEPENDS:qt6-qtscxml-tests = " \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 qt6-qtscxml \
 glibc \
"
