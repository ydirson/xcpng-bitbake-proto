# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "baobab"
PE = "0"
PV = "46.0"
PR = "4.el10"
PACKAGES = "baobab"
PROVIDES = "rpm/baobab"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/baobab-46.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8357c8a0bf04d216be28fd154c19094e12ee48bc4adfd2075f02f3886763a0c"

URI_baobab = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/baobab-46.0-4.el10.x86_64_v2.rpm;name=baobab;unpack=0"
SRC_URI += "${URI_baobab}"
SRC_URI[baobab.sha256sum] = "b86fca69ed16704bf90ecaa2f04c27215920522bf7da5c6a9bbd4bfe0a307b65"
RDEPENDS:baobab = " \
 pango \
 cairo \
 glib2 \
 glibc \
 gtk4 \
 libadwaita \
"
