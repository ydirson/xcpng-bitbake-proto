# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ibus-m17n"
PE = "0"
PV = "1.4.29"
PR = "6.el10"
PACKAGES = "ibus-m17n"
PROVIDES = "rpm/ibus-m17n"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ibus-m17n-1.4.29-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ef65d2f551dba49e126f2d445e6ecbf4ac9e9515bad41c14f44373c8e12c624"

URI_ibus-m17n = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ibus-m17n-1.4.29-6.el10.x86_64_v2.rpm;name=ibus-m17n;unpack=0"
SRC_URI += "${URI_ibus-m17n}"
SRC_URI[ibus-m17n.sha256sum] = "388ba262b66f4f0d9c319b24da01a32fc6e68ea4b3b9e0503306b43f13f09dee"
RDEPENDS:ibus-m17n = " \
 ibus \
 glib2 \
 gtk3 \
 ibus-libs \
 glibc \
 m17n-lib \
"
