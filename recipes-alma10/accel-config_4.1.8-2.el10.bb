# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "accel-config"
PE = "0"
PV = "4.1.8"
PR = "2.el10"
PACKAGES = "accel-config accel-config-libs accel-config-devel accel-config-test"
PROVIDES = "rpm/accel-config rpm/accel-config-libs rpm/accel-config-devel rpm/accel-config-test"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/accel-config-4.1.8-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "745c4158503d2d08e304e7f501fd5506151eab8100cc034a7ffb40ad7dfa892b"

URI_accel-config = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/accel-config-4.1.8-2.el10.x86_64_v2.rpm;name=accel-config;unpack=0"
SRC_URI += "${URI_accel-config}"
SRC_URI[accel-config.sha256sum] = "5dc64d4e0e91a26e6313328a1e6a686e58abb9727099fc32615453e969b2d7d1"
RDEPENDS:accel-config = " \
 glibc \
 json-c \
 accel-config-libs \
"

URI_accel-config-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/accel-config-libs-4.1.8-2.el10.x86_64_v2.rpm;name=accel-config-libs;unpack=0"
SRC_URI += "${URI_accel-config-libs}"
SRC_URI[accel-config-libs.sha256sum] = "6e1fed5da3d63c8bdfb235146c8954e569866aa8f623ab4db542bc6378c17f24"
RDEPENDS:accel-config-libs = " \
 glibc \
 libuuid \
 accel-config \
"

URI_accel-config-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/accel-config-devel-4.1.8-2.el10.x86_64_v2.rpm;name=accel-config-devel;unpack=0"
SRC_URI += "${URI_accel-config-devel}"
SRC_URI[accel-config-devel.sha256sum] = "c1ad48cf4aab9468234161e493d5c701d5210fb4c9e15307a38a5745f3d136af"
RDEPENDS:accel-config-devel = " \
 accel-config-libs \
 pkgconf-pkg-config \
"

URI_accel-config-test = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/accel-config-test-4.1.8-2.el10.x86_64_v2.rpm;name=accel-config-test;unpack=0"
SRC_URI += "${URI_accel-config-test}"
SRC_URI[accel-config-test.sha256sum] = "babb41e91b6aa9d2f8dd4071d3bb4cf9c2da6790e3f6b975d4cc6ccf09ad35e8"
RDEPENDS:accel-config-test = " \
 zlib-ng-compat \
 openssl-libs \
 accel-config-libs \
 bash \
 glibc \
"
