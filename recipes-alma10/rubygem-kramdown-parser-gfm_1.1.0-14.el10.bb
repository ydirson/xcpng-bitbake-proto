# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rubygem-kramdown-parser-gfm"
PE = "0"
PV = "1.1.0"
PR = "14.el10"
PACKAGES = "rubygem-kramdown-parser-gfm rubygem-kramdown-parser-gfm-doc"
PROVIDES = "rpm/rubygem-kramdown-parser-gfm rpm/rubygem-kramdown-parser-gfm-doc"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/rubygem-kramdown-parser-gfm-1.1.0-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "29fc0c5d3ad93e52d86a4a7867d518857953e3ccb8c1d05506ed7f36cee4a7c6"

URI_rubygem-kramdown-parser-gfm = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-kramdown-parser-gfm-1.1.0-14.el10.noarch.rpm;name=rubygem-kramdown-parser-gfm;unpack=0"
SRC_URI += "${URI_rubygem-kramdown-parser-gfm}"
SRC_URI[rubygem-kramdown-parser-gfm.sha256sum] = "d92d7166f8fa05c9e4f26b5b7665d4363275ef364e29fccd43dd304fca0207e1"
RDEPENDS:rubygem-kramdown-parser-gfm = " \
 rubygems \
 rubygem-kramdown \
"

URI_rubygem-kramdown-parser-gfm-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-kramdown-parser-gfm-doc-1.1.0-14.el10.noarch.rpm;name=rubygem-kramdown-parser-gfm-doc;unpack=0"
SRC_URI += "${URI_rubygem-kramdown-parser-gfm-doc}"
SRC_URI[rubygem-kramdown-parser-gfm-doc.sha256sum] = "badf10f479e8abd96da9dad34f33d1777fab6ee35433590a6d11762ee80d3fe2"
RDEPENDS:rubygem-kramdown-parser-gfm-doc = " \
 rubygem-kramdown-parser-gfm \
"
