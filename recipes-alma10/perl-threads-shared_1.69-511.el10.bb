# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-threads-shared"
PE = "0"
PV = "1.69"
PR = "511.el10"
PACKAGES = "perl-threads-shared perl-threads-shared-tests"
PROVIDES = "rpm/perl-threads-shared rpm/perl-threads-shared-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-threads-shared-1.69-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4e87b45d67096a5bca822fc7571e625c08c5b72247ea82c6ace38925eb886bd"

URI_perl-threads-shared = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-threads-shared-1.69-511.el10.x86_64_v2.rpm;name=perl-threads-shared;unpack=0"
SRC_URI += "${URI_perl-threads-shared}"
SRC_URI[perl-threads-shared.sha256sum] = "bd632da68ce2a80728c6ac2d8c307198bb98191157712670be9a8857cabb1712"
RDEPENDS:perl-threads-shared = " \
 perl-threads \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 glibc \
"

URI_perl-threads-shared-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-threads-shared-tests-1.69-511.el10.x86_64_v2.rpm;name=perl-threads-shared-tests;unpack=0"
SRC_URI += "${URI_perl-threads-shared-tests}"
SRC_URI[perl-threads-shared-tests.sha256sum] = "acbb209366ff9bc8898f99cf9e8b2326b1d74ea6acc4d210cd3ba6ba49bbf707"
RDEPENDS:perl-threads-shared-tests = " \
 perl-threads \
 perl-threads-shared \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Scalar-List-Utils \
 perl-ExtUtils-MakeMaker \
 perl-POSIX \
 bash \
 perl-interpreter \
 perl-Time-HiRes \
"
