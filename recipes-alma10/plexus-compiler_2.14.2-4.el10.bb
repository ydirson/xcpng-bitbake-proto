# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "plexus-compiler"
PE = "0"
PV = "2.14.2"
PR = "4.el10"
PACKAGES = "plexus-compiler plexus-compiler-extras plexus-compiler-javadoc plexus-compiler-pom"
PROVIDES = "rpm/plexus-compiler rpm/plexus-compiler-extras rpm/plexus-compiler-javadoc rpm/plexus-compiler-pom"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/plexus-compiler-2.14.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7389f87c39ac1a6e6ccd5d29ccfc36c6ddfb8175543f34b01c7cac709f029e4c"

URI_plexus-compiler = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-compiler-2.14.2-4.el10.noarch.rpm;name=plexus-compiler;unpack=0"
SRC_URI += "${URI_plexus-compiler}"
SRC_URI[plexus-compiler.sha256sum] = "b47afc9aa4da6aa577063dcf872dfdc9b85d4594a2de1b4fb6e32d2fc4ea8587"
RDEPENDS:plexus-compiler = " \
 plexus-utils \
 atinject \
 javapackages-filesystem \
 slf4j \
"

URI_plexus-compiler-extras = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-compiler-extras-2.14.2-4.el10.noarch.rpm;name=plexus-compiler-extras;unpack=0"
SRC_URI += "${URI_plexus-compiler-extras}"
SRC_URI[plexus-compiler-extras.sha256sum] = "098d8a32c816a040087643043c55c16d34fb5036599e0bb88ad2697e61f8e997"
RDEPENDS:plexus-compiler-extras = " \
 plexus-utils \
 atinject \
 javapackages-filesystem \
 plexus-compiler \
"

URI_plexus-compiler-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-compiler-javadoc-2.14.2-4.el10.noarch.rpm;name=plexus-compiler-javadoc;unpack=0"
SRC_URI += "${URI_plexus-compiler-javadoc}"
SRC_URI[plexus-compiler-javadoc.sha256sum] = "7515a6f49b81a217c87b75de0704f884e1e5c16dc9c2522a175b38bd0a70910f"
RDEPENDS:plexus-compiler-javadoc = " \
 javapackages-filesystem \
"

URI_plexus-compiler-pom = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-compiler-pom-2.14.2-4.el10.noarch.rpm;name=plexus-compiler-pom;unpack=0"
SRC_URI += "${URI_plexus-compiler-pom}"
SRC_URI[plexus-compiler-pom.sha256sum] = "b0fd4fb2077b72301208ef2ea5c68285ff43cbbea9a9dd394ca3cab9ff9b49a5"
RDEPENDS:plexus-compiler-pom = " \
 plexus-pom \
 sisu-mojos \
 javapackages-filesystem \
 plexus-compiler \
"
