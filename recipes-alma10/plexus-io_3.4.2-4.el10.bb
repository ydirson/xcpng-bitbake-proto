# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "plexus-io"
PE = "0"
PV = "3.4.2"
PR = "4.el10"
PACKAGES = "plexus-io plexus-io-javadoc"
PROVIDES = "rpm/plexus-io rpm/plexus-io-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/plexus-io-3.4.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc18f2e23a4f8419c46076fb50d66c78f9e29a4936f5d0e4e616795999eea87f"

URI_plexus-io = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-io-3.4.2-4.el10.noarch.rpm;name=plexus-io;unpack=0"
SRC_URI += "${URI_plexus-io}"
SRC_URI[plexus-io.sha256sum] = "e0a59a14708715aa62c4e8a1556671c9ca177069d8e8497fbc0db5d0a856fe13"
RDEPENDS:plexus-io = " \
 plexus-utils \
 apache-commons-io \
 javapackages-filesystem \
 atinject \
"

URI_plexus-io-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/plexus-io-javadoc-3.4.2-4.el10.noarch.rpm;name=plexus-io-javadoc;unpack=0"
SRC_URI += "${URI_plexus-io-javadoc}"
SRC_URI[plexus-io-javadoc.sha256sum] = "6bdb55aac6e8ce62fa3947bce36621251fa2caeae17065d642fd964c45b583bc"
RDEPENDS:plexus-io-javadoc = " \
 javapackages-filesystem \
"
