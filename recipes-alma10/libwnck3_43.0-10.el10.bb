# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libwnck3"
PE = "0"
PV = "43.0"
PR = "10.el10"
PACKAGES = "libwnck3 libwnck3-devel"
PROVIDES = "rpm/libwnck3 rpm/libwnck3-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libwnck3-43.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee23a1fda484aa5956b39c11c7d035b93ed743deee969720230b26fea5847b76"

URI_libwnck3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libwnck3-43.0-10.el10.x86_64_v2.rpm;name=libwnck3;unpack=0"
SRC_URI += "${URI_libwnck3}"
SRC_URI[libwnck3.sha256sum] = "b5c0de36ed6ab9c2f14dfded2edcfad6fd9f74e4a98f1f77efc84972e810c0db"
RDEPENDS:libwnck3 = " \
 atk \
 startup-notification \
 pango \
 gdk-pixbuf2 \
 libX11 \
 libXrender \
 libXres \
 cairo \
 glib2 \
 gtk3 \
 glibc \
"

URI_libwnck3-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libwnck3-devel-43.0-10.el10.x86_64_v2.rpm;name=libwnck3-devel;unpack=0"
SRC_URI += "${URI_libwnck3-devel}"
SRC_URI[libwnck3-devel.sha256sum] = "90112c4ecb33fcf117b77af57e2433b44391797285504756e0883a6ae431698f"
RDEPENDS:libwnck3-devel = " \
 glib2-devel \
 startup-notification-devel \
 pkgconf-pkg-config \
 pango-devel \
 libX11 \
 libXres-devel \
 libX11-devel \
 libwnck3 \
 glib2 \
 cairo-devel \
 gtk3-devel \
 glibc \
 gtk3 \
"
