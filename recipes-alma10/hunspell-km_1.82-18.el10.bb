# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-km"
PE = "0"
PV = "1.82"
PR = "18.el10"
PACKAGES = "hunspell-km"
PROVIDES = "rpm/hunspell-km"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-km-1.82-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aaf8a83607181acb00df56fc184b1ef6330ee35325c8433c8c376d372a70c7f1"

URI_hunspell-km = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-km-1.82-18.el10.noarch.rpm;name=hunspell-km;unpack=0"
SRC_URI += "${URI_hunspell-km}"
SRC_URI[hunspell-km.sha256sum] = "6bdfe6c89a55fb1260a0f11dc6e0ce65dff70a7e6864420e2a8f19372de55ac7"
RDEPENDS:hunspell-km = " \
 hunspell-filesystem \
"
