# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-ny"
PE = "1"
PV = "0.01"
PR = "31.el10"
PACKAGES = "hunspell-ny"
PROVIDES = "rpm/hunspell-ny"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-ny-0.01-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3b2204bcdfb0685feb601c7f3f0a2e2e9d5ef3e76a5318df0d9ede11867f41f"

URI_hunspell-ny = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-ny-0.01-31.el10.noarch.rpm;name=hunspell-ny;unpack=0"
SRC_URI += "${URI_hunspell-ny}"
SRC_URI[hunspell-ny.sha256sum] = "a361ec4534cf18f6df4bb6c478a7674b2e3537679c08a9eac99f91b8940e6042"
RDEPENDS:hunspell-ny = " \
 hunspell \
"
