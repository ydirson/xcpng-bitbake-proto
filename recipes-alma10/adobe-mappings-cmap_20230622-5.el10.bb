# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "adobe-mappings-cmap"
PE = "0"
PV = "20230622"
PR = "5.el10"
PACKAGES = "adobe-mappings-cmap adobe-mappings-cmap-deprecated adobe-mappings-cmap-devel"
PROVIDES = "rpm/adobe-mappings-cmap rpm/adobe-mappings-cmap-deprecated rpm/adobe-mappings-cmap-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/adobe-mappings-cmap-20230622-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e517979569c71e3305ec00d43c1376fa5015d5ce19f826579ffb02befdfbdfa6"

URI_adobe-mappings-cmap = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/adobe-mappings-cmap-20230622-5.el10.noarch.rpm;name=adobe-mappings-cmap;unpack=0"
SRC_URI += "${URI_adobe-mappings-cmap}"
SRC_URI[adobe-mappings-cmap.sha256sum] = "efb0594b06750f5e85693f8074f785671cf1c54689017d24b09bd1392f04201c"
RDEPENDS:adobe-mappings-cmap = ""

URI_adobe-mappings-cmap-deprecated = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/adobe-mappings-cmap-deprecated-20230622-5.el10.noarch.rpm;name=adobe-mappings-cmap-deprecated;unpack=0"
SRC_URI += "${URI_adobe-mappings-cmap-deprecated}"
SRC_URI[adobe-mappings-cmap-deprecated.sha256sum] = "079ac0cfa475b1a1269d19172d486847e50e517ea6f20882947d8be7164aac4d"
RDEPENDS:adobe-mappings-cmap-deprecated = " \
 adobe-mappings-cmap \
"

URI_adobe-mappings-cmap-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/adobe-mappings-cmap-devel-20230622-5.el10.noarch.rpm;name=adobe-mappings-cmap-devel;unpack=0"
SRC_URI += "${URI_adobe-mappings-cmap-devel}"
SRC_URI[adobe-mappings-cmap-devel.sha256sum] = "edde37280f24b16154a1e5bf1bd36e84f3dc23c455206e7123f5b421cd0635d8"
RDEPENDS:adobe-mappings-cmap-devel = " \
 adobe-mappings-cmap \
 adobe-mappings-cmap-deprecated \
"
