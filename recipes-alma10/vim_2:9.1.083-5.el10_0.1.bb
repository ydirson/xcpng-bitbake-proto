# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "vim"
PE = "2"
PV = "9.1.083"
PR = "5.el10_0.1"
PACKAGES = "vim-data vim-filesystem vim-minimal vim-X11 vim-common vim-enhanced xxd"
PROVIDES = "rpm/vim-data rpm/vim-filesystem rpm/vim-minimal rpm/vim-X11 rpm/vim-common rpm/vim-enhanced rpm/xxd"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/vim-9.1.083-5.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4fd4dd1561f9fc79983333d035254aa32f9aaff90312eaf011aefc13f4001a85"

URI_vim-data = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/vim-data-9.1.083-5.el10_0.1.noarch.rpm;name=vim-data;unpack=0"
SRC_URI += "${URI_vim-data}"
SRC_URI[vim-data.sha256sum] = "54e1243815069deac11366953092dd2a4d1bc40f0e1419020f1900ee207efad6"
RDEPENDS:vim-data = ""

URI_vim-filesystem = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/vim-filesystem-9.1.083-5.el10_0.1.noarch.rpm;name=vim-filesystem;unpack=0"
SRC_URI += "${URI_vim-filesystem}"
SRC_URI[vim-filesystem.sha256sum] = "f5a7e74ae9822a40769fc46ad09243f375b9921e705a6211d7dd7cf35907852a"
RDEPENDS:vim-filesystem = ""

URI_vim-minimal = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/vim-minimal-9.1.083-5.el10_0.1.x86_64_v2.rpm;name=vim-minimal;unpack=0"
SRC_URI += "${URI_vim-minimal}"
SRC_URI[vim-minimal.sha256sum] = "de6be66dc6a2cadb783db29c1cda8e5fcf8bcfb9ec38a89d11b5c52b96a59995"
RDEPENDS:vim-minimal = " \
 libacl \
 vim-data \
 bash \
 ncurses-libs \
 glibc \
 libselinux \
"

URI_vim-X11 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/vim-X11-9.1.083-5.el10_0.1.x86_64_v2.rpm;name=vim-X11;unpack=0"
SRC_URI += "${URI_vim-X11}"
SRC_URI[vim-X11.sha256sum] = "daa912f0df1f4939909e0c3121ddc58af948ebf11c5250bfb9ed85734e693d3f"
RDEPENDS:vim-X11 = " \
 libacl \
 vim-common \
 libattr \
 libICE \
 pango \
 gdk-pixbuf2 \
 libX11 \
 libSM \
 libcanberra \
 libXt \
 bash \
 cairo \
 glib2 \
 gtk3 \
 glibc \
 libselinux \
 ncurses-libs \
 hicolor-icon-theme \
"

URI_vim-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/vim-common-9.1.083-5.el10_0.1.x86_64_v2.rpm;name=vim-common;unpack=0"
SRC_URI += "${URI_vim-common}"
SRC_URI[vim-common.sha256sum] = "3921138d60e76763c259f2fd74d410b51028f1b9568f657a1e5bbaccda8552c9"
RDEPENDS:vim-common = " \
 vim-filesystem \
 bash \
 vim-data \
 xxd \
"

URI_vim-enhanced = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/vim-enhanced-9.1.083-5.el10_0.1.x86_64_v2.rpm;name=vim-enhanced;unpack=0"
SRC_URI += "${URI_vim-enhanced}"
SRC_URI[vim-enhanced.sha256sum] = "5565f36a9595fe35291cb5d8b3b40ad254e9d7afa3c9a79711a997b161eb17fa"
RDEPENDS:vim-enhanced = " \
 libacl \
 vim-common \
 bash \
 ncurses-libs \
 which \
 glibc \
 libselinux \
"

URI_xxd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xxd-9.1.083-5.el10_0.1.x86_64_v2.rpm;name=xxd;unpack=0"
SRC_URI += "${URI_xxd}"
SRC_URI[xxd.sha256sum] = "bf58292177b954263c3ebf71019d56877bf67b69a1d8eb57c20b799f6ebfd8ec"
RDEPENDS:xxd = " \
 glibc \
"
