# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ipa"
PE = "0"
PV = "4.12.2"
PR = "15.el10_0.1"
PACKAGES = "ipa-client ipa-client-common ipa-client-encrypted-dns ipa-client-epn ipa-client-samba ipa-common ipa-selinux ipa-selinux-luna ipa-selinux-nfast ipa-server ipa-server-common ipa-server-dns ipa-server-encrypted-dns ipa-server-trust-ad python3-ipaclient python3-ipalib python3-ipaserver python3-ipatests ipa-python-compat"
PROVIDES = "rpm/ipa-client rpm/ipa-client-common rpm/ipa-client-encrypted-dns rpm/ipa-client-epn rpm/ipa-client-samba rpm/ipa-common rpm/ipa-selinux rpm/ipa-selinux-luna rpm/ipa-selinux-nfast rpm/ipa-server rpm/ipa-server-common rpm/ipa-server-dns rpm/ipa-server-encrypted-dns rpm/ipa-server-trust-ad rpm/python3-ipaclient rpm/python3-ipalib rpm/python3-ipaserver rpm/python3-ipatests rpm/ipa-python-compat"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ipa-4.12.2-15.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2af755c67f4f3fdb45c7c6f22ca2cf5b0d61f8d7c6281577e615c0da24a87bcf"

URI_ipa-client = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ipa-client-4.12.2-15.el10_0.1.x86_64_v2.rpm;name=ipa-client;unpack=0"
SRC_URI += "${URI_ipa-client}"
SRC_URI[ipa-client.sha256sum] = "58ccfa9a438e5417d9dab4d207472d06ac6dc9c89bea094806233319374923b0"
RDEPENDS:ipa-client = " \
 python3 \
 python3-gssapi \
 python3-ipaclient \
 curl \
 cyrus-sasl-gssapi \
 krb5-libs \
 nss-tools \
 krb5-pkinit \
 krb5-workstation \
 python3-ldap \
 nfs-utils \
 oddjob-mkhomedir \
 jansson \
 libsss_autofs \
 libsss_sudo \
 libcom_err \
 libcurl \
 openldap \
 certmonger \
 openssl-libs \
 authselect \
 autofs \
 ipa-client-common \
 bash \
 ipa-common \
 python3-sssdconfig \
 libini_config \
 sssd-ipa \
 sssd-idp \
 sssd-krb5 \
 bind-utils \
 chrony \
 hostname \
 policycoreutils \
 sssd-tools \
 popt \
 libnfsidmap \
 glibc \
"

URI_ipa-client-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ipa-client-common-4.12.2-15.el10_0.1.noarch.rpm;name=ipa-client-common;unpack=0"
SRC_URI += "${URI_ipa-client-common}"
SRC_URI[ipa-client-common.sha256sum] = "8fc3a971c000d420f59c1e178d9ec1ed49fe813fa261a62664131a7700eb708f"
RDEPENDS:ipa-client-common = ""

URI_ipa-client-encrypted-dns = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ipa-client-encrypted-dns-4.12.2-15.el10_0.1.x86_64_v2.rpm;name=ipa-client-encrypted-dns;unpack=0"
SRC_URI += "${URI_ipa-client-encrypted-dns}"
SRC_URI[ipa-client-encrypted-dns.sha256sum] = "7dc195468c79ee16ef748303d1b52274443778394105cf8e4f16dfa65d9fd5dc"
RDEPENDS:ipa-client-encrypted-dns = " \
 unbound \
"

URI_ipa-client-epn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ipa-client-epn-4.12.2-15.el10_0.1.x86_64_v2.rpm;name=ipa-client-epn;unpack=0"
SRC_URI += "${URI_ipa-client-epn}"
SRC_URI[ipa-client-epn.sha256sum] = "300edb1b6009e7f36cefd215917f8665fcdfc393b51e3f24e80f6b3b068df762"
RDEPENDS:ipa-client-epn = " \
 python3 \
 systemd \
 bash \
 ipa-client \
"

URI_ipa-client-samba = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ipa-client-samba-4.12.2-15.el10_0.1.x86_64_v2.rpm;name=ipa-client-samba;unpack=0"
SRC_URI += "${URI_ipa-client-samba}"
SRC_URI[ipa-client-samba.sha256sum] = "78a437d9aa133591bbd34e5bca34a691fc9832e54ce5f4b93971fceb1765fd9d"
RDEPENDS:ipa-client-samba = " \
 python3 \
 samba-client \
 samba \
 python3-samba \
 cifs-utils \
 tdb-tools \
 ipa-client \
 samba-winbind \
 sssd-winbind-idmap \
 samba-common-tools \
"

URI_ipa-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ipa-common-4.12.2-15.el10_0.1.noarch.rpm;name=ipa-common;unpack=0"
SRC_URI += "${URI_ipa-common}"
SRC_URI[ipa-common.sha256sum] = "22f8c6bef8a065f1f5760933dda34f9edf851f0660a926e16f26f828396ce510"
RDEPENDS:ipa-common = " \
 ipa-selinux \
"

URI_ipa-selinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ipa-selinux-4.12.2-15.el10_0.1.noarch.rpm;name=ipa-selinux;unpack=0"
SRC_URI += "${URI_ipa-selinux}"
SRC_URI[ipa-selinux.sha256sum] = "1d920b6eb90547a26ceb2e93717ff49565acb2cd59195f5ab383f78da02f317c"
RDEPENDS:ipa-selinux = " \
 policycoreutils-python-utils \
 policycoreutils \
 bash \
 selinux-policy \
 libselinux-utils \
 selinux-policy-targeted \
"

URI_ipa-selinux-luna = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ipa-selinux-luna-4.12.2-15.el10_0.1.noarch.rpm;name=ipa-selinux-luna;unpack=0"
SRC_URI += "${URI_ipa-selinux-luna}"
SRC_URI[ipa-selinux-luna.sha256sum] = "9ceefd1921ad06cefb32677e58b59d0df6b608cf85e168919b1875a8113a18a8"
RDEPENDS:ipa-selinux-luna = " \
 policycoreutils-python-utils \
 policycoreutils \
 bash \
 selinux-policy \
 libselinux-utils \
 selinux-policy-targeted \
"

URI_ipa-selinux-nfast = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ipa-selinux-nfast-4.12.2-15.el10_0.1.noarch.rpm;name=ipa-selinux-nfast;unpack=0"
SRC_URI += "${URI_ipa-selinux-nfast}"
SRC_URI[ipa-selinux-nfast.sha256sum] = "dd04bbf38ef0a3f2ae8b5b72ac6bc90265d58c54792c0533cbc550afc392a9f0"
RDEPENDS:ipa-selinux-nfast = " \
 policycoreutils-python-utils \
 policycoreutils \
 bash \
 selinux-policy \
 libselinux-utils \
 selinux-policy-targeted \
"

URI_ipa-server = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ipa-server-4.12.2-15.el10_0.1.x86_64_v2.rpm;name=ipa-server;unpack=0"
SRC_URI += "${URI_ipa-server}"
SRC_URI[ipa-server.sha256sum] = "b577601ad9a9d5634f76a47fab506d8075fec5a47e02edb14282443f93b1c5f3"
RDEPENDS:ipa-server = " \
 python3 \
 systemd \
 python3-gssapi \
 libpwquality \
 samba-client-libs \
 tar \
 fontawesome4-fonts \
 cyrus-sasl-gssapi \
 krb5-libs \
 nss-tools \
 python3-ipaserver \
 krb5-server \
 python3-ldap \
 oddjob \
 httpd \
 jansson \
 open-sans-fonts \
 libsss_certmap \
 acl \
 libsss_nss_idmap \
 idm-pki-acme \
 libcom_err \
 idm-pki-ca \
 libtalloc \
 idm-pki-kra \
 slapi-nis \
 libtevent \
 selinux-policy \
 python3-mod_wsgi \
 openldap \
 libunistring \
 openldap-clients \
 softhsm \
 certmonger \
 shadow-utils \
 libuuid \
 libverto \
 openssl \
 libgcc \
 openssl-libs \
 p11-kit \
 ipa-client \
 bash \
 ipa-common \
 python3-systemd \
 sssd-dbus \
 ipa-server-common \
 mod_auth_gssapi \
 gssproxy \
 gzip \
 chrony \
 mod_lookup_identity \
 policycoreutils \
 389-ds-base \
 popt \
 mod_session \
 glibc \
 mod_ssl \
 cracklib-dicts \
"

URI_ipa-server-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ipa-server-common-4.12.2-15.el10_0.1.noarch.rpm;name=ipa-server-common;unpack=0"
SRC_URI += "${URI_ipa-server-common}"
SRC_URI[ipa-server-common.sha256sum] = "bae4fbd69e26956c5d5969abae1a567c7249bbaf23694523ae9057f309b70824"
RDEPENDS:ipa-server-common = " \
 systemd \
 httpd \
 ipa-client-common \
 bash \
 almalinux-logos-ipa \
"

URI_ipa-server-dns = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ipa-server-dns-4.12.2-15.el10_0.1.noarch.rpm;name=ipa-server-dns;unpack=0"
SRC_URI += "${URI_ipa-server-dns}"
SRC_URI[ipa-server-dns.sha256sum] = "d68011bee38b709e41d48a107623fda8be01268f56aa750112f6ef811113cf08"
RDEPENDS:ipa-server-dns = " \
 python3 \
 softhsm \
 ipa-server \
 systemd \
 bind-dnssec-utils \
 bind-dyndb-ldap \
 opendnssec \
 pkcs11-provider \
 bind-utils \
 bash \
 bind \
"

URI_ipa-server-encrypted-dns = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ipa-server-encrypted-dns-4.12.2-15.el10_0.1.x86_64_v2.rpm;name=ipa-server-encrypted-dns;unpack=0"
SRC_URI += "${URI_ipa-server-encrypted-dns}"
SRC_URI[ipa-server-encrypted-dns.sha256sum] = "e687bd5861dbb0db290e5016b023d02a48ff47262cb36082bb8f0df7bc7d10da"
RDEPENDS:ipa-server-encrypted-dns = " \
 ipa-client-encrypted-dns \
"

URI_ipa-server-trust-ad = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ipa-server-trust-ad-4.12.2-15.el10_0.1.x86_64_v2.rpm;name=ipa-server-trust-ad;unpack=0"
SRC_URI += "${URI_ipa-server-trust-ad}"
SRC_URI[ipa-server-trust-ad.sha256sum] = "85c88a18ce449cec2282d0d6b49a01757ba15031667b84bfc65c089b70a9dc60"
RDEPENDS:ipa-server-trust-ad = " \
 python3 \
 samba \
 libpwquality \
 samba-client-libs \
 krb5-libs \
 libsss_idmap \
 python3-libsss_nss_idmap \
 libcom_err \
 samba-winbind \
 libtalloc \
 libtevent \
 alternatives \
 openldap \
 python3-samba \
 openssl-libs \
 bash \
 python3-sss \
 ipa-common \
 ipa-server \
 sssd-winbind-idmap \
 glibc \
"

URI_python3-ipaclient = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-ipaclient-4.12.2-15.el10_0.1.noarch.rpm;name=python3-ipaclient;unpack=0"
SRC_URI += "${URI_python3-ipaclient}"
SRC_URI[python3-ipaclient.sha256sum] = "dd8a1f50c402fa33d0822345a594508b293266bd1862e875877daabdbf6fc20a"
RDEPENDS:python3-ipaclient = " \
 python3 \
 augeas-libs \
 python3-cryptography \
 python3-ipalib \
 ipa-client-common \
 python3-six \
 python3-jinja2 \
 python3-dns \
 python3-qrcode \
 ipa-common \
 python3-augeas \
"

URI_python3-ipalib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-ipalib-4.12.2-15.el10_0.1.noarch.rpm;name=python3-ipalib;unpack=0"
SRC_URI += "${URI_python3-ipalib}"
SRC_URI[python3-ipalib.sha256sum] = "dc8fc068fb753fb8238745c8a3ff902a51d96c5729162efd78b12f850e5be474"
RDEPENDS:python3-ipalib = " \
 python3 \
 python3-cffi \
 python3-gssapi \
 keyutils \
 python3-cryptography \
 python3-dateutil \
 python3-dbus \
 python3-ifaddr \
 python3-dns \
 python3-jwcrypto \
 python3-yubico \
 python3-ldap \
 python3-libipa_hbac \
 python3-netaddr \
 gnupg2 \
 python3-requests \
 python3-setuptools \
 python3-six \
 python3-sss-murmur \
 ipa-common \
 python3-argcomplete \
 python3-systemd \
 python3-urllib3 \
 python3-pyasn1 \
 python3-pyasn1-modules \
 python3-pyusb \
 python3-qrcode \
"

URI_python3-ipaserver = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-ipaserver-4.12.2-15.el10_0.1.noarch.rpm;name=python3-ipaserver;unpack=0"
SRC_URI += "${URI_python3-ipaserver}"
SRC_URI[python3-ipaserver.sha256sum] = "a4388950feacfdcd8576e3013104063df956260b000a58820007651ec47be40e"
RDEPENDS:python3-ipaserver = " \
 python3 \
 python3-gssapi \
 python3-idm-pki \
 python3-cryptography \
 python3-dbus \
 python3-ipaclient \
 python3-ipalib \
 python3-dns \
 python3-jwcrypto \
 python3-kdcproxy \
 python3-ldap \
 python3-lxml \
 python3-netaddr \
 python3-requests \
 augeas-libs \
 python3-six \
 python3-sssdconfig \
 ipa-common \
 python3-augeas \
 python3-urllib3 \
 ipa-server-common \
 python3-psutil \
 python3-pyasn1 \
 rpm-libs \
"

URI_python3-ipatests = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-ipatests-4.12.2-15.el10_0.1.noarch.rpm;name=python3-ipatests;unpack=0"
SRC_URI += "${URI_python3-ipatests}"
SRC_URI[python3-ipatests.sha256sum] = "b7323e19b3f2ed06345cdd723a2207ded4a0ce6665a7a456597c962fc5c5661b"
RDEPENDS:python3-ipatests = " \
 openssh-clients \
 python3-cryptography \
 tar \
 python3-ipaclient \
 python3-ipaserver \
 iptables-nft \
 python3-sssdconfig \
 xz \
"

URI_ipa-python-compat = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ipa-python-compat-4.12.2-15.el10_0.1.noarch.rpm;name=ipa-python-compat;unpack=0"
SRC_URI += "${URI_ipa-python-compat}"
SRC_URI[ipa-python-compat.sha256sum] = "143ec1c1b5539fd6c6073efaf7cff64e4867bfb807d5cc8002e9d41087aca158"
RDEPENDS:ipa-python-compat = " \
 ipa-common \
 python3-ipalib \
"
