# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "urlview"
PE = "0"
PV = "0.9"
PR = "39.20131022git08767a.el10"
PACKAGES = "urlview"
PROVIDES = "rpm/urlview"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/urlview-0.9-39.20131022git08767a.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09b852068dbd76c59fa3d050dc50e807622a854825152e40d3bccdaa65b762d0"

URI_urlview = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/urlview-0.9-39.20131022git08767a.el10.x86_64_v2.rpm;name=urlview;unpack=0"
SRC_URI += "${URI_urlview}"
SRC_URI[urlview.sha256sum] = "39cec6a43a8c9bbecb5c0acbf049c24692d775324f25209144a1a1a4879218a7"
RDEPENDS:urlview = " \
 glibc \
 bash \
 ncurses-libs \
"
