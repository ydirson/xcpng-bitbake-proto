# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "at"
PE = "0"
PV = "3.2.5"
PR = "13.el10_0"
PACKAGES = "at"
PROVIDES = "rpm/at"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/at-3.2.5-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8245cc3462825c956e5a91d63c797f1b3c63e7ba05899559a15678f4bec79416"

URI_at = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/at-3.2.5-13.el10_0.x86_64_v2.rpm;name=at;unpack=0"
SRC_URI += "${URI_at}"
SRC_URI[at.sha256sum] = "08e212800dd0d2f16a27455538e0bd5688d3dba60df1fd9f090f2dbaa1e6030a"
RDEPENDS:at = " \
 glibc \
 libselinux \
 systemd \
 bash \
"
