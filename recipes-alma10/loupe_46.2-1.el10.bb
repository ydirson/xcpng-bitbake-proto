# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "loupe"
PE = "0"
PV = "46.2"
PR = "1.el10"
PACKAGES = "loupe"
PROVIDES = "rpm/loupe"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/loupe-46.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1dc36401bcfa942e6fdfae73e7f56ec4de5dd206451838e1ee08605d3e46e62c"

URI_loupe = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/loupe-46.2-1.el10.x86_64_v2.rpm;name=loupe;unpack=0"
SRC_URI += "${URI_loupe}"
SRC_URI[loupe.sha256sum] = "271bbfedbf7757b4b90ad769f63a90e851e1108ef55f87d9914f8b67db5c0860"
RDEPENDS:loupe = " \
 lcms2 \
 libseccomp \
 libgcc \
 glycin-loaders \
 cairo \
 glib2 \
 dbus \
 glibc \
 graphene \
 gtk4 \
 hicolor-icon-theme \
 libadwaita \
 libgweather \
"
