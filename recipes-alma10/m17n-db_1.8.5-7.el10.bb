# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "m17n-db"
PE = "0"
PV = "1.8.5"
PR = "7.el10"
PACKAGES = "m17n-db m17n-db-devel m17n-db-extras"
PROVIDES = "rpm/m17n-db rpm/m17n-db-devel rpm/m17n-db-extras"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/m17n-db-1.8.5-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "937b4b077f9f1eeafee50330cc2c129e11933710f63f34429c7c8fba808a8653"

URI_m17n-db = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/m17n-db-1.8.5-7.el10.noarch.rpm;name=m17n-db;unpack=0"
SRC_URI += "${URI_m17n-db}"
SRC_URI[m17n-db.sha256sum] = "3b256ebaece406fe4aa0342cbd085843e137c94cf7bfaef8f422cae5b46c9227"
RDEPENDS:m17n-db = " \
 gawk \
"

URI_m17n-db-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/m17n-db-devel-1.8.5-7.el10.noarch.rpm;name=m17n-db-devel;unpack=0"
SRC_URI += "${URI_m17n-db-devel}"
SRC_URI[m17n-db-devel.sha256sum] = "1bacaaa81993571b151147b0e76eaa95786ca0c60ad37752b1c5e47f4b20dd6a"
RDEPENDS:m17n-db-devel = " \
 bash \
 pkgconf-pkg-config \
 m17n-db \
"

URI_m17n-db-extras = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/m17n-db-extras-1.8.5-7.el10.noarch.rpm;name=m17n-db-extras;unpack=0"
SRC_URI += "${URI_m17n-db-extras}"
SRC_URI[m17n-db-extras.sha256sum] = "ae1fb8e60d44cd8d2beee7469bb55a44d5ba369c1c874d4a66099d3104a54e48"
RDEPENDS:m17n-db-extras = " \
 m17n-db \
"
