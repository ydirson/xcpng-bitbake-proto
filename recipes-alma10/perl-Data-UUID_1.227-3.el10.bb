# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Data-UUID"
PE = "0"
PV = "1.227"
PR = "3.el10"
PACKAGES = "perl-Data-UUID perl-Data-UUID-tests"
PROVIDES = "rpm/perl-Data-UUID rpm/perl-Data-UUID-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Data-UUID-1.227-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2af2c93703206c1ea6d8a064cd3c43430cf8aca3566e7561f921d8e069faadc8"

URI_perl-Data-UUID = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Data-UUID-1.227-3.el10.x86_64_v2.rpm;name=perl-Data-UUID;unpack=0"
SRC_URI += "${URI_perl-Data-UUID}"
SRC_URI[perl-Data-UUID.sha256sum] = "cf1d7a2632b5db1c90d877b9c092dbddf5f5f1a29da38bb47f515029647e6c5f"
RDEPENDS:perl-Data-UUID = " \
 perl-libs \
 perl-Carp \
 perl-Digest-MD5 \
 perl-DynaLoader \
 glibc \
 perl-Exporter \
"

URI_perl-Data-UUID-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Data-UUID-tests-1.227-3.el10.x86_64_v2.rpm;name=perl-Data-UUID-tests;unpack=0"
SRC_URI += "${URI_perl-Data-UUID-tests}"
SRC_URI[perl-Data-UUID-tests.sha256sum] = "67bb942949cacf162f2c1fff56498417479dac0ff1e14a2496aa0e090681f9e8"
RDEPENDS:perl-Data-UUID-tests = " \
 perl-threads \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Data-UUID \
 bash \
 perl-interpreter \
"
