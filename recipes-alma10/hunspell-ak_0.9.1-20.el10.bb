# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-ak"
PE = "0"
PV = "0.9.1"
PR = "20.el10"
PACKAGES = "hunspell-ak"
PROVIDES = "rpm/hunspell-ak"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-ak-0.9.1-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4657bd37ae54283440d89e44db78f44c358d887a42468fdf0982ed908e29afb"

URI_hunspell-ak = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-ak-0.9.1-20.el10.noarch.rpm;name=hunspell-ak;unpack=0"
SRC_URI += "${URI_hunspell-ak}"
SRC_URI[hunspell-ak.sha256sum] = "d570412e0d29230cbc3e7bc6a434c0a7f7613595ae464a6123da8d1587da6752"
RDEPENDS:hunspell-ak = " \
 hunspell-filesystem \
"
