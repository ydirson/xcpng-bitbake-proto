# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rust-afterburn"
PE = "0"
PV = "5.7.0"
PR = "1.el10"
PACKAGES = "afterburn afterburn-dracut"
PROVIDES = "rpm/afterburn rpm/afterburn-dracut"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/rust-afterburn-5.7.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21f674bbbc70c02c5c0ab06feadd00a3948a39d49efa07a7267818c5e3cdf792"

URI_afterburn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/afterburn-5.7.0-1.el10.x86_64_v2.rpm;name=afterburn;unpack=0"
SRC_URI += "${URI_afterburn}"
SRC_URI[afterburn.sha256sum] = "30fc8c9ffcc851dc1fe6cc325e3857e1cc64ef5956dc05896d2422af731397e5"
RDEPENDS:afterburn = " \
 systemd \
 libgcc \
 openssl-libs \
 bash \
 glibc \
"

URI_afterburn-dracut = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/afterburn-dracut-5.7.0-1.el10.x86_64_v2.rpm;name=afterburn-dracut;unpack=0"
SRC_URI += "${URI_afterburn-dracut}"
SRC_URI[afterburn-dracut.sha256sum] = "33a50c12c94eb9580a60887d638d88d9ca4cd5ba7e4ff6336d8e86ad917a950e"
RDEPENDS:afterburn-dracut = " \
 dracut-network \
 bash \
 dracut \
 afterburn \
"
