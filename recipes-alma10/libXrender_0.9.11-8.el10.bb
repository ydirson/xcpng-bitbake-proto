# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libXrender"
PE = "0"
PV = "0.9.11"
PR = "8.el10"
PACKAGES = "libXrender libXrender-devel"
PROVIDES = "rpm/libXrender rpm/libXrender-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libXrender-0.9.11-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e10278d14e3fb7f09122bb4e13063fd54d34a57945ed51c0ee5adef0a36008c6"

URI_libXrender = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXrender-0.9.11-8.el10.x86_64_v2.rpm;name=libXrender;unpack=0"
SRC_URI += "${URI_libXrender}"
SRC_URI[libXrender.sha256sum] = "a817b33f2055f76ab174c1392a2b465ed456a8e709e70f2019a5c69c36b08dfc"
RDEPENDS:libXrender = " \
 glibc \
 libX11 \
"

URI_libXrender-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXrender-devel-0.9.11-8.el10.x86_64_v2.rpm;name=libXrender-devel;unpack=0"
SRC_URI += "${URI_libXrender-devel}"
SRC_URI[libXrender-devel.sha256sum] = "3abf52f8fe75eb01a38989c0bb859a2a5291e96e96410bf129c6e7d61ef89de5"
RDEPENDS:libXrender-devel = " \
 libXrender \
 libX11-devel \
 xorg-x11-proto-devel \
 pkgconf-pkg-config \
"
