# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ninja-build"
PE = "0"
PV = "1.11.1"
PR = "9.el10"
PACKAGES = "ninja-build"
PROVIDES = "rpm/ninja-build"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/ninja-build-1.11.1-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7ecc820bba3af655cf484f57f06da6b4f7b379bcf93503cc366074548671167"

URI_ninja-build = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ninja-build-1.11.1-9.el10.x86_64_v2.rpm;name=ninja-build;unpack=0"
SRC_URI += "${URI_ninja-build}"
SRC_URI[ninja-build.sha256sum] = "3da3d855bc6cba68b05bb048cb23fc04cf8ef7525c132489e02b0f6f02103940"
RDEPENDS:ninja-build = " \
 python3 \
 emacs-filesystem \
 libgcc \
 vim-filesystem \
 libstdc++ \
 glibc \
"
