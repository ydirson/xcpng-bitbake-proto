# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "createrepo_c"
PE = "0"
PV = "1.1.2"
PR = "4.el10"
PACKAGES = "createrepo_c createrepo_c-libs python3-createrepo_c createrepo_c-devel"
PROVIDES = "rpm/createrepo_c rpm/createrepo_c-libs rpm/python3-createrepo_c rpm/createrepo_c-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/createrepo_c-1.1.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5d9c587eeb6baf22b93c9ecb8ee91b263a2e7136f215b6082ef15df0fff539b"

URI_createrepo_c = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/createrepo_c-1.1.2-4.el10.x86_64_v2.rpm;name=createrepo_c;unpack=0"
SRC_URI += "${URI_createrepo_c}"
SRC_URI[createrepo_c.sha256sum] = "6f69f732bd30d3cd2753af7baaaaf4ff36a16d36197cb4bac7a1a980f2e83f9b"
RDEPENDS:createrepo_c = " \
 libgcc \
 libmodulemd \
 createrepo_c-libs \
 glib2 \
 glibc \
 rpm \
"

URI_createrepo_c-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/createrepo_c-libs-1.1.2-4.el10.x86_64_v2.rpm;name=createrepo_c-libs;unpack=0"
SRC_URI += "${URI_createrepo_c-libs}"
SRC_URI[createrepo_c-libs.sha256sum] = "3c5451bb61e1156e2b719bfe7f7f85d8117d4c379cdb962879e55b9dcaae0dd5"
RDEPENDS:createrepo_c-libs = " \
 zlib-ng-compat \
 bzip2-libs \
 openssl-libs \
 libgcc \
 libxml2 \
 libmodulemd \
 libzstd \
 sqlite-libs \
 glib2 \
 libcurl \
 glibc \
 rpm-libs \
 xz-libs \
"

URI_python3-createrepo_c = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-createrepo_c-1.1.2-4.el10.x86_64_v2.rpm;name=python3-createrepo_c;unpack=0"
SRC_URI += "${URI_python3-createrepo_c}"
SRC_URI[python3-createrepo_c.sha256sum] = "f204a5e3c202b8fb8c6f1f860c17d670c27155732da552173cc3978311850a96"
RDEPENDS:python3-createrepo_c = " \
 python3 \
 createrepo_c-libs \
 python3-libs \
 glib2 \
 glibc \
"

URI_createrepo_c-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/createrepo_c-devel-1.1.2-4.el10.x86_64_v2.rpm;name=createrepo_c-devel;unpack=0"
SRC_URI += "${URI_createrepo_c-devel}"
SRC_URI[createrepo_c-devel.sha256sum] = "54a503b83c07a3c54dcdd50cb6eee1bf697fef7c747f007a0876ca20be7f46d0"
RDEPENDS:createrepo_c-devel = " \
 libxml2-devel \
 glib2-devel \
 zlib-ng-compat-devel \
 pkgconf-pkg-config \
 createrepo_c-libs \
 rpm-devel \
 libcurl-devel \
 sqlite-devel \
"
