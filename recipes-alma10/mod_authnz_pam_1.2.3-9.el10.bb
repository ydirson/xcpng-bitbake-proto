# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mod_authnz_pam"
PE = "0"
PV = "1.2.3"
PR = "9.el10"
PACKAGES = "mod_authnz_pam"
PROVIDES = "rpm/mod_authnz_pam"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mod_authnz_pam-1.2.3-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e4f6e911d664cf5beff46c1ce83ac28f2b52f0872ad272c118aa4ae7efbca81"

URI_mod_authnz_pam = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mod_authnz_pam-1.2.3-9.el10.x86_64_v2.rpm;name=mod_authnz_pam;unpack=0"
SRC_URI += "${URI_mod_authnz_pam}"
SRC_URI[mod_authnz_pam.sha256sum] = "bc9a5ca210a3b9bf38ef84e66bb69d53a3ca93b73090095a2cc5abc91f32decb"
RDEPENDS:mod_authnz_pam = " \
 glibc \
 pam-libs \
 httpd-core \
 pam \
"
