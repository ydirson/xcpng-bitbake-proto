# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-YAML"
PE = "0"
PV = "1.31"
PR = "7.el10"
PACKAGES = "perl-YAML perl-YAML-tests"
PROVIDES = "rpm/perl-YAML rpm/perl-YAML-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-YAML-1.31-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b9ec266effe3fe792088d720bc95cb46d08640760339bf85766ea0160d6776a"

URI_perl-YAML = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-YAML-1.31-7.el10.noarch.rpm;name=perl-YAML;unpack=0"
SRC_URI += "${URI_perl-YAML}"
SRC_URI[perl-YAML.sha256sum] = "653e94b68098c2c8b07ff4b6cac1c8f3f7aaad76deeb20fccd626f1522b78b5f"
RDEPENDS:perl-YAML = " \
 perl-constant \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-overload \
 perl-B \
 perl-Exporter \
"

URI_perl-YAML-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-YAML-tests-1.31-7.el10.noarch.rpm;name=perl-YAML-tests;unpack=0"
SRC_URI += "${URI_perl-YAML-tests}"
SRC_URI[perl-YAML-tests.sha256sum] = "4b86a7e1f631224a77e9efda157f958855f61d37774bfa7ec4fc7f0a604dc07a"
RDEPENDS:perl-YAML-tests = " \
 perl-constant \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-Test-Deep \
 bash \
 perl-B \
 perl-interpreter \
 perl-YAML \
"
