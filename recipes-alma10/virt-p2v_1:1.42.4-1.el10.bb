# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "virt-p2v"
PE = "1"
PV = "1.42.4"
PR = "1.el10"
PACKAGES = "virt-p2v"
PROVIDES = "rpm/virt-p2v"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/virt-p2v-1.42.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d69378c4741bc8f97ecd7f9fb1c6048f016bbd1b4a4d9fcd2fc33b124a79ecb"

URI_virt-p2v = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/virt-p2v-1.42.4-1.el10.x86_64_v2.rpm;name=virt-p2v;unpack=0"
SRC_URI += "${URI_virt-p2v}"
SRC_URI[virt-p2v.sha256sum] = "5a2e1aef9d155a4f688709f5b1a48640a1535d029bcd28d6c484f545e538e282"
RDEPENDS:virt-p2v = " \
 gzip \
 gawk \
 bash \
 binutils \
 guestfs-tools \
"
