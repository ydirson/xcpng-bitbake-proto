# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tpm2-tools"
PE = "0"
PV = "5.7"
PR = "4.el10"
PACKAGES = "tpm2-tools"
PROVIDES = "rpm/tpm2-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tpm2-tools-5.7-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "08e50969f1d93ad16e9477af21bd9ac7e609bd439a068e8f34303c8aa540eb45"

URI_tpm2-tools = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/tpm2-tools-5.7-4.el10.x86_64_v2.rpm;name=tpm2-tools;unpack=0"
SRC_URI += "${URI_tpm2-tools}"
SRC_URI[tpm2-tools.sha256sum] = "93dd9001db32ac081d037ad869aa80a287ff0045dd7c05a959e571e8245a9b7a"
RDEPENDS:tpm2-tools = " \
 libcurl \
 openssl-libs \
 tpm2-tss \
 glibc \
 tpm2-tss-fapi \
"
