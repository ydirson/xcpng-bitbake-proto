# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "usbguard"
PE = "0"
PV = "1.1.3"
PR = "6.el10"
PACKAGES = "usbguard usbguard-dbus usbguard-notifier usbguard-selinux usbguard-tools usbguard-devel"
PROVIDES = "rpm/usbguard rpm/usbguard-dbus rpm/usbguard-notifier rpm/usbguard-selinux rpm/usbguard-tools rpm/usbguard-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/usbguard-1.1.3-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a58a0a866384272ae4b77aad0b6eb7abcf0d576d2fadd1ba98ec9ca5df05840"

URI_usbguard = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/usbguard-1.1.3-6.el10.x86_64_v2.rpm;name=usbguard;unpack=0"
SRC_URI += "${URI_usbguard}"
SRC_URI[usbguard.sha256sum] = "4af9248abe8769064cdc3953bb8b58026ecea76bd6634064c2ac930f01596197"
RDEPENDS:usbguard = " \
 libqb \
 protobuf \
 systemd \
 audit-libs \
 libgcc \
 openssl-libs \
 libcap-ng \
 libstdc++ \
 bash \
 glibc \
"

URI_usbguard-dbus = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/usbguard-dbus-1.1.3-6.el10.x86_64_v2.rpm;name=usbguard-dbus;unpack=0"
SRC_URI += "${URI_usbguard-dbus}"
SRC_URI[usbguard-dbus.sha256sum] = "64f4fd555cd8d46f29ed9ec2f4d13600055e81b6d9f3c184d6ac5354b125648e"
RDEPENDS:usbguard-dbus = " \
 usbguard \
 libgcc \
 polkit \
 libstdc++ \
 bash \
 glib2 \
 polkit-libs \
 dbus \
 glibc \
"

URI_usbguard-notifier = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/usbguard-notifier-1.1.3-6.el10.x86_64_v2.rpm;name=usbguard-notifier;unpack=0"
SRC_URI += "${URI_usbguard-notifier}"
SRC_URI[usbguard-notifier.sha256sum] = "652aaa62dafc187184533830f4f28682fdac8fb0280771f2865ac85648eae689"
RDEPENDS:usbguard-notifier = " \
 systemd \
 usbguard \
 librsvg2 \
 libgcc \
 libstdc++ \
 bash \
 glib2 \
 glibc \
 libnotify \
"

URI_usbguard-selinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/usbguard-selinux-1.1.3-6.el10.noarch.rpm;name=usbguard-selinux;unpack=0"
SRC_URI += "${URI_usbguard-selinux}"
SRC_URI[usbguard-selinux.sha256sum] = "bd7f1a5e03effc28d6da7ef1232bf04fad2bdaadaf68c6f63346a2915544ec73"
RDEPENDS:usbguard-selinux = " \
 policycoreutils-python-utils \
 policycoreutils \
 bash \
 selinux-policy \
 libselinux-utils \
 selinux-policy-targeted \
"

URI_usbguard-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/usbguard-tools-1.1.3-6.el10.x86_64_v2.rpm;name=usbguard-tools;unpack=0"
SRC_URI += "${URI_usbguard-tools}"
SRC_URI[usbguard-tools.sha256sum] = "558fb2fe2d5ece97c2cf2b325cb0d8c873286ea9e0d4774170b087f35b1c8443"
RDEPENDS:usbguard-tools = " \
 glibc \
 libgcc \
 libstdc++ \
 usbguard \
"

URI_usbguard-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/usbguard-devel-1.1.3-6.el10.x86_64_v2.rpm;name=usbguard-devel;unpack=0"
SRC_URI += "${URI_usbguard-devel}"
SRC_URI[usbguard-devel.sha256sum] = "a331c849dbd58c736c50fe8ccb7924e4a4d1a4a48a88045b29c733a69701fac5"
RDEPENDS:usbguard-devel = " \
 usbguard \
 pkgconf-pkg-config \
 libstdc++-devel \
"
