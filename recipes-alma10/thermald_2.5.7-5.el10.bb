# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "thermald"
PE = "0"
PV = "2.5.7"
PR = "5.el10"
PACKAGES = "thermald"
PROVIDES = "rpm/thermald"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/thermald-2.5.7-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2bd99373fc27f44a3c1ddf555c35e4dea0b5662c33bc1d4acc1cacff65756cf"

URI_thermald = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/thermald-2.5.7-5.el10.x86_64_v2.rpm;name=thermald;unpack=0"
SRC_URI += "${URI_thermald}"
SRC_URI[thermald.sha256sum] = "239a62201c024da75c5d498eca504db4731c126c7248ae14da968535dee8a1b7"
RDEPENDS:thermald = " \
 glibc-common \
 shadow-utils \
 systemd \
 libgcc \
 libxml2 \
 libstdc++ \
 bash \
 glib2 \
 libevdev \
 upower-libs \
 glibc \
 dbus \
"
