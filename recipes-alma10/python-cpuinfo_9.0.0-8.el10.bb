# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-cpuinfo"
PE = "0"
PV = "9.0.0"
PR = "8.el10"
PACKAGES = "python3-cpuinfo"
PROVIDES = "rpm/python3-cpuinfo"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/python-cpuinfo-9.0.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d71ab9c504b8c684c7ee9208bc6d3a85e62bb19706a990558a2388c48269cc6"

URI_python3-cpuinfo = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-cpuinfo-9.0.0-8.el10.noarch.rpm;name=python3-cpuinfo;unpack=0"
SRC_URI += "${URI_python3-cpuinfo}"
SRC_URI[python3-cpuinfo.sha256sum] = "b00cf5df56bf81cb9d4c9230bc3886d3949c6d1d18bbb200691f826c2704cc21"
RDEPENDS:python3-cpuinfo = " \
 python3 \
"
