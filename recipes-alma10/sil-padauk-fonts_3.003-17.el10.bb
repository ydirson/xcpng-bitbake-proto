# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sil-padauk-fonts"
PE = "0"
PV = "3.003"
PR = "17.el10"
PACKAGES = "sil-padauk-fonts sil-padauk-book-fonts"
PROVIDES = "rpm/sil-padauk-fonts rpm/sil-padauk-book-fonts"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/sil-padauk-fonts-3.003-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "530e8c18d787824beb569f0ebea0188485064312d95f2111defce2d7dd38cef3"

URI_sil-padauk-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sil-padauk-fonts-3.003-17.el10.noarch.rpm;name=sil-padauk-fonts;unpack=0"
SRC_URI += "${URI_sil-padauk-fonts}"
SRC_URI[sil-padauk-fonts.sha256sum] = "9bd28600a29d68871ec21976d41e3e9c0fe5fd9ba237579a12d50d4d74e23936"
RDEPENDS:sil-padauk-fonts = " \
 fonts-filesystem \
"

URI_sil-padauk-book-fonts = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sil-padauk-book-fonts-3.003-17.el10.noarch.rpm;name=sil-padauk-book-fonts;unpack=0"
SRC_URI += "${URI_sil-padauk-book-fonts}"
SRC_URI[sil-padauk-book-fonts.sha256sum] = "ee83cd4d69ea4e2656c9bb23a6095f6189d225873be1c3cf2db2201a4bff8c95"
RDEPENDS:sil-padauk-book-fonts = " \
 fonts-filesystem \
"
