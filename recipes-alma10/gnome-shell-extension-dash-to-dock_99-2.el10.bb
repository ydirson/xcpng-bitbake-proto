# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-shell-extension-dash-to-dock"
PE = "0"
PV = "99"
PR = "2.el10"
PACKAGES = "gnome-shell-extension-dash-to-dock"
PROVIDES = "rpm/gnome-shell-extension-dash-to-dock"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-shell-extension-dash-to-dock-99-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "433e4efc58f195bd353c52e695ae1a24c56bd65a5a2bb2cf94c56d7bbded013a"

URI_gnome-shell-extension-dash-to-dock = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-dash-to-dock-99-2.el10.noarch.rpm;name=gnome-shell-extension-dash-to-dock;unpack=0"
SRC_URI += "${URI_gnome-shell-extension-dash-to-dock}"
SRC_URI[gnome-shell-extension-dash-to-dock.sha256sum] = "a8dc8f31c7dc8f1f1135c62b084c8ef96fec58434463186e6f3c0283eab671b2"
RDEPENDS:gnome-shell-extension-dash-to-dock = " \
 gnome-shell-extension-common \
"
