# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jose"
PE = "0"
PV = "14"
PR = "102.el10"
PACKAGES = "jose libjose libjose-devel"
PROVIDES = "rpm/jose rpm/libjose rpm/libjose-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/jose-14-102.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3907042f4d5937a564226e1408ff04be22cee7d7201b084e682921a15edd4f3b"

URI_jose = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/jose-14-102.el10.x86_64_v2.rpm;name=jose;unpack=0"
SRC_URI += "${URI_jose}"
SRC_URI[jose.sha256sum] = "ca722fad8600ed9096442658089a49cc551e22400a237eb1156782a61fb52dbd"
RDEPENDS:jose = " \
 glibc \
 libgcc \
 libjose \
 jansson \
"

URI_libjose = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libjose-14-102.el10.x86_64_v2.rpm;name=libjose;unpack=0"
SRC_URI += "${URI_libjose}"
SRC_URI[libjose.sha256sum] = "39e7e9ae150e66bc9933c128f119cc822a994eb32aff18e6ca6dc5fd65bf0971"
RDEPENDS:libjose = " \
 zlib-ng-compat \
 jansson \
 openssl-libs \
 libgcc \
 glibc \
"

URI_libjose-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libjose-devel-14-102.el10.x86_64_v2.rpm;name=libjose-devel;unpack=0"
SRC_URI += "${URI_libjose-devel}"
SRC_URI[libjose-devel.sha256sum] = "f9b8c00e0c74f7b8e0272cfee724cd76e52981970d6df84c487f62d11a6fc511"
RDEPENDS:libjose-devel = " \
 zlib-ng-compat-devel \
 pkgconf-pkg-config \
 openssl-devel \
 jansson-devel \
 libjose \
"
