# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xcb-util-wm"
PE = "0"
PV = "0.4.2"
PR = "7.el10"
PACKAGES = "xcb-util-wm xcb-util-wm-devel"
PROVIDES = "rpm/xcb-util-wm rpm/xcb-util-wm-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xcb-util-wm-0.4.2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "efeb0bce05790af7bdbb6496fb4366b737358c3a6e1599908923af04b1888b46"

URI_xcb-util-wm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xcb-util-wm-0.4.2-7.el10.x86_64_v2.rpm;name=xcb-util-wm;unpack=0"
SRC_URI += "${URI_xcb-util-wm}"
SRC_URI[xcb-util-wm.sha256sum] = "d034877b48d8803f804285cc09a43f4b1866f7460680e812cb87255c87a8fe2c"
RDEPENDS:xcb-util-wm = " \
 glibc \
 libxcb \
"

URI_xcb-util-wm-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/xcb-util-wm-devel-0.4.2-7.el10.x86_64_v2.rpm;name=xcb-util-wm-devel;unpack=0"
SRC_URI += "${URI_xcb-util-wm-devel}"
SRC_URI[xcb-util-wm-devel.sha256sum] = "23bb59bf07b8fbfdc4693ccbd50a922a9b0ffc9526cdb8bcb8364ec8923203c2"
RDEPENDS:xcb-util-wm-devel = " \
 xcb-util-wm \
 libxcb-devel \
 pkgconf-pkg-config \
"
