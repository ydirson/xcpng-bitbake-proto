# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-hy"
PE = "0"
PV = "0.20.0"
PR = "30.el10"
PACKAGES = "hunspell-hy"
PROVIDES = "rpm/hunspell-hy"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-hy-0.20.0-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "709b4f3de42aeca3b61db3c35d52579f2599dd6e36454df76a3c4109d6bfc558"

URI_hunspell-hy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-hy-0.20.0-30.el10.noarch.rpm;name=hunspell-hy;unpack=0"
SRC_URI += "${URI_hunspell-hy}"
SRC_URI[hunspell-hy.sha256sum] = "8f18f4be04a2e36492a26961fd5a335a682dca4dbd4ef4c4c8d26718ab4b727b"
RDEPENDS:hunspell-hy = " \
 hunspell-filesystem \
"
