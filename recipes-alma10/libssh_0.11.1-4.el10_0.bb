# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libssh"
PE = "0"
PV = "0.11.1"
PR = "4.el10_0"
PACKAGES = "libssh libssh-config libssh-devel"
PROVIDES = "rpm/libssh rpm/libssh-config rpm/libssh-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libssh-0.11.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8bec2151ca3674a5ded7b159a0582b3586bb80d7489f494935879bbe7a7ab120"

URI_libssh = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libssh-0.11.1-4.el10_0.x86_64_v2.rpm;name=libssh;unpack=0"
SRC_URI += "${URI_libssh}"
SRC_URI[libssh.sha256sum] = "d2f3a8949eee22bb49cb43e9136d54bf680f9ea4ad72a2b2b678b517234a9014"
RDEPENDS:libssh = " \
 zlib-ng-compat \
 libssh-config \
 openssl-libs \
 krb5-libs \
 glibc \
"

URI_libssh-config = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libssh-config-0.11.1-4.el10_0.noarch.rpm;name=libssh-config;unpack=0"
SRC_URI += "${URI_libssh-config}"
SRC_URI[libssh-config.sha256sum] = "158aff84c7b644acf712580e0a52436c02cadb8efba212801e2ca5582b162eb6"
RDEPENDS:libssh-config = ""

URI_libssh-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libssh-devel-0.11.1-4.el10_0.x86_64_v2.rpm;name=libssh-devel;unpack=0"
SRC_URI += "${URI_libssh-devel}"
SRC_URI[libssh-devel.sha256sum] = "47a2295c873fb1f928a756647a39a5c04ce183fbe58b6a775321cf168802e01f"
RDEPENDS:libssh-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 libssh \
"
