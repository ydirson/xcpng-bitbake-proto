# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Carp-Clan"
PE = "0"
PV = "6.08"
PR = "20.el10"
PACKAGES = "perl-Carp-Clan perl-Carp-Clan-tests"
PROVIDES = "rpm/perl-Carp-Clan rpm/perl-Carp-Clan-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Carp-Clan-6.08-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de1bf74815bbb4bd6090f4158a54b06d2d03047afbc2909dd45f4356d545e2c2"

URI_perl-Carp-Clan = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Carp-Clan-6.08-20.el10.noarch.rpm;name=perl-Carp-Clan;unpack=0"
SRC_URI += "${URI_perl-Carp-Clan}"
SRC_URI[perl-Carp-Clan.sha256sum] = "116bc6e3e7ac11d5df7110ae7f66a67a2c43dd1cb0b94344e6d7882f8d79b48b"
RDEPENDS:perl-Carp-Clan = " \
 perl-overload \
 perl-libs \
"

URI_perl-Carp-Clan-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Carp-Clan-tests-6.08-20.el10.noarch.rpm;name=perl-Carp-Clan-tests;unpack=0"
SRC_URI += "${URI_perl-Carp-Clan-tests}"
SRC_URI[perl-Carp-Clan-tests.sha256sum] = "a5399a5af33d51a8fb3b16e7857cffaa800217301e74e512f81617e04e785010"
RDEPENDS:perl-Carp-Clan-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-ExtUtils-MakeMaker \
 perl-Carp-Clan \
 perl-overload \
 bash \
 perl-PathTools \
 perl-Object-Deadly \
 perl-interpreter \
"
