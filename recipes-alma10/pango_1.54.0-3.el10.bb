# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pango"
PE = "0"
PV = "1.54.0"
PR = "3.el10"
PACKAGES = "pango pango-devel pango-doc"
PROVIDES = "rpm/pango rpm/pango-devel rpm/pango-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/pango-1.54.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09b1e77c52f1be17a9df36edb00480efda73f4d899142a1001f16a447be7e250"

URI_pango = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pango-1.54.0-3.el10.x86_64_v2.rpm;name=pango;unpack=0"
SRC_URI += "${URI_pango}"
SRC_URI[pango.sha256sum] = "c21e43b86ec1f24c973cbb06d96024c40b0d6537a5c1760e8aa39687fa000c14"
RDEPENDS:pango = " \
 freetype \
 libXft \
 harfbuzz \
 fribidi \
 fontconfig \
 libX11 \
 libXrender \
 cairo \
 glib2 \
 glibc \
 libthai \
"

URI_pango-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pango-devel-1.54.0-3.el10.x86_64_v2.rpm;name=pango-devel;unpack=0"
SRC_URI += "${URI_pango-devel}"
SRC_URI[pango-devel.sha256sum] = "2c95309f8af3ec966d9bce1bdfcc087896b1e2ed9839b5e649211aa664ed6ca3"
RDEPENDS:pango-devel = " \
 glib2-devel \
 libXft-devel \
 freetype-devel \
 fribidi-devel \
 pkgconf-pkg-config \
 pango \
 pango-devel \
 fontconfig-devel \
 libXrender-devel \
 cairo-devel \
 harfbuzz-devel \
 libthai-devel \
"

URI_pango-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/pango-doc-1.54.0-3.el10.x86_64_v2.rpm;name=pango-doc;unpack=0"
SRC_URI += "${URI_pango-doc}"
SRC_URI[pango-doc.sha256sum] = "bcd434ca67175648157128c614076322f9310ae1054395a0ef3bcde18cd566dc"
RDEPENDS:pango-doc = " \
 pango \
"
