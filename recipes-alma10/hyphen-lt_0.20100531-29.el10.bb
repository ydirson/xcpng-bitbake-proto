# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-lt"
PE = "0"
PV = "0.20100531"
PR = "29.el10"
PACKAGES = "hyphen-lt"
PROVIDES = "rpm/hyphen-lt"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-lt-0.20100531-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3dc46ee6f14dca0c08cdb2aa50e2d11b888b91069bc584729463ffcb58546d09"

URI_hyphen-lt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-lt-0.20100531-29.el10.noarch.rpm;name=hyphen-lt;unpack=0"
SRC_URI += "${URI_hyphen-lt}"
SRC_URI[hyphen-lt.sha256sum] = "80458b962f0c9a5bfcb961a205ce03c20bfb68c3d361928ae9fadbe117748f84"
RDEPENDS:hyphen-lt = " \
 hyphen \
"
