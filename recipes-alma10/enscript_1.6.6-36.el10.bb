# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "enscript"
PE = "0"
PV = "1.6.6"
PR = "36.el10"
PACKAGES = "enscript"
PROVIDES = "rpm/enscript"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/enscript-1.6.6-36.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06bda76369c2ecc7d6635ef18239a85a8a904254ab691767f1369703f40cff0d"

URI_enscript = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/enscript-1.6.6-36.el10.x86_64_v2.rpm;name=enscript;unpack=0"
SRC_URI += "${URI_enscript}"
SRC_URI[enscript.sha256sum] = "cb2b14931c85410058a64f0da3fd14ce8687b3e288f5b26c8813b4f941d9bfbb"
RDEPENDS:enscript = " \
 glibc \
 perl-interpreter \
 bash \
"
