# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "swtpm"
PE = "0"
PV = "0.9.0"
PR = "5.el10"
PACKAGES = "swtpm swtpm-libs swtpm-selinux swtpm-tools swtpm-devel swtpm-tools-pkcs11"
PROVIDES = "rpm/swtpm rpm/swtpm-libs rpm/swtpm-selinux rpm/swtpm-tools rpm/swtpm-devel rpm/swtpm-tools-pkcs11"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/swtpm-0.9.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90cf488bfa79d0d70cc92458e6983bdfac7c4f666b08bca1d1deab7462bd9c2c"

URI_swtpm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/swtpm-0.9.0-5.el10.x86_64_v2.rpm;name=swtpm;unpack=0"
SRC_URI += "${URI_swtpm}"
SRC_URI[swtpm.sha256sum] = "4d84604ad8e0e2b616ec98036612d370c1b50e986b3f5ef726b2e87bb4f25d9a"
RDEPENDS:swtpm = " \
 glibc \
 swtpm-libs \
 swtpm-selinux \
 libtpms \
"

URI_swtpm-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/swtpm-libs-0.9.0-5.el10.x86_64_v2.rpm;name=swtpm-libs;unpack=0"
SRC_URI += "${URI_swtpm-libs}"
SRC_URI[swtpm-libs.sha256sum] = "9c1988541581949ec55b4bca293c2064c97cf6af98ec3c8282fe10f276b1d892"
RDEPENDS:swtpm-libs = " \
 libtpms \
 openssl-libs \
 glib2 \
 libseccomp \
 glibc \
"

URI_swtpm-selinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/swtpm-selinux-0.9.0-5.el10.noarch.rpm;name=swtpm-selinux;unpack=0"
SRC_URI += "${URI_swtpm-selinux}"
SRC_URI[swtpm-selinux.sha256sum] = "18a3762c4d4cf1192c640060b542314f159558ac4b11815af75928e47f3a658d"
RDEPENDS:swtpm-selinux = " \
 policycoreutils-python-utils \
 policycoreutils \
 bash \
 selinux-policy \
 libselinux-utils \
 swtpm \
"

URI_swtpm-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/swtpm-tools-0.9.0-5.el10.x86_64_v2.rpm;name=swtpm-tools;unpack=0"
SRC_URI += "${URI_swtpm-tools}"
SRC_URI[swtpm-tools.sha256sum] = "0ef3c87070c1e2084164bbc8e34208bc46ebf9a433f2c9259dcff19f6d5e5c36"
RDEPENDS:swtpm-tools = " \
 gmp \
 gnutls \
 openssl-libs \
 libgcc \
 json-glib \
 gnutls-utils \
 bash \
 glib2 \
 libtasn1 \
 tpm2-tss \
 glibc \
 swtpm \
"

URI_swtpm-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/swtpm-devel-0.9.0-5.el10.x86_64_v2.rpm;name=swtpm-devel;unpack=0"
SRC_URI += "${URI_swtpm-devel}"
SRC_URI[swtpm-devel.sha256sum] = "7013a97ec0a763eb41b7bb1a99561ebccf792862971c4804a84582b370c326b8"
RDEPENDS:swtpm-devel = " \
 swtpm-libs \
"

URI_swtpm-tools-pkcs11 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/swtpm-tools-pkcs11-0.9.0-5.el10.x86_64_v2.rpm;name=swtpm-tools-pkcs11;unpack=0"
SRC_URI += "${URI_swtpm-tools-pkcs11}"
SRC_URI[swtpm-tools-pkcs11.sha256sum] = "24e339d8f6f1c1d04ce97275ec0af067aebc440b3b01587d9bafb19fda057fe5"
RDEPENDS:swtpm-tools-pkcs11 = " \
 swtpm-tools \
 gnutls-utils \
 expect \
 bash \
 tpm2-tools \
 tpm2-abrmd \
 tpm2-pkcs11 \
 tpm2-pkcs11-tools \
"
