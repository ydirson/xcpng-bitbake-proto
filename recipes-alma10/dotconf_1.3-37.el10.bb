# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dotconf"
PE = "0"
PV = "1.3"
PR = "37.el10"
PACKAGES = "dotconf dotconf-devel"
PROVIDES = "rpm/dotconf rpm/dotconf-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/dotconf-1.3-37.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4e09819f4824f13f2cd190558e89ec0dde0ad2b80fa5afa448bc6fcd68ddbc6"

URI_dotconf = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/dotconf-1.3-37.el10.x86_64_v2.rpm;name=dotconf;unpack=0"
SRC_URI += "${URI_dotconf}"
SRC_URI[dotconf.sha256sum] = "cff07c4c36a0275aebfdebd0d47512f978fc6b29e2bf87d04ea47f50ee372d9f"
RDEPENDS:dotconf = " \
 glibc \
"

URI_dotconf-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/dotconf-devel-1.3-37.el10.x86_64_v2.rpm;name=dotconf-devel;unpack=0"
SRC_URI += "${URI_dotconf-devel}"
SRC_URI[dotconf-devel.sha256sum] = "20da79294f1fe080a71dd793099b52f2b6a388d7683523dc9f5efc3f29783cc2"
RDEPENDS:dotconf-devel = " \
 dotconf \
 pkgconf-pkg-config \
"
