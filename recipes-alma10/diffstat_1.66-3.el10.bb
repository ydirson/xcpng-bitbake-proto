# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "diffstat"
PE = "0"
PV = "1.66"
PR = "3.el10"
PACKAGES = "diffstat"
PROVIDES = "rpm/diffstat"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/diffstat-1.66-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5e223ffdfc3de4742f7f2fc472b429e06c25a5b6bc50da45b9a7f9ae28bd3e0"

URI_diffstat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/diffstat-1.66-3.el10.x86_64_v2.rpm;name=diffstat;unpack=0"
SRC_URI += "${URI_diffstat}"
SRC_URI[diffstat.sha256sum] = "fa5b669929a1b0bb3cb0397842a8396fb739363ba87e5a29fb7a9ac11e761fe2"
RDEPENDS:diffstat = " \
 glibc \
"
