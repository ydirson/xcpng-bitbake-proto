# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "selinux-policy"
PE = "0"
PV = "40.13.26"
PR = "1.el10"
PACKAGES = "selinux-policy selinux-policy-doc selinux-policy-mls selinux-policy-sandbox selinux-policy-targeted selinux-policy-devel selinux-policy-minimum"
PROVIDES = "rpm/selinux-policy rpm/selinux-policy-doc rpm/selinux-policy-mls rpm/selinux-policy-sandbox rpm/selinux-policy-targeted rpm/selinux-policy-devel rpm/selinux-policy-minimum"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/selinux-policy-40.13.26-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2cf687d0bf3bc4380bdd798a893946d716fa3d8c81a26bc3fece8877c40a27f4"

URI_selinux-policy = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/selinux-policy-40.13.26-1.el10.noarch.rpm;name=selinux-policy;unpack=0"
SRC_URI += "${URI_selinux-policy}"
SRC_URI[selinux-policy.sha256sum] = "8ebfbbd8b7cde1d7e10444fcec1620d77fef77653c3f599865ef4bbcd0b4793b"
RDEPENDS:selinux-policy = " \
 gawk \
 policycoreutils \
 bash \
 selinux-policy-minimum \
 coreutils \
 rpm-plugin-selinux \
"

URI_selinux-policy-doc = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/selinux-policy-doc-40.13.26-1.el10.noarch.rpm;name=selinux-policy-doc;unpack=0"
SRC_URI += "${URI_selinux-policy-doc}"
SRC_URI[selinux-policy-doc.sha256sum] = "c00d3e587e25a3303fbce9374ce7f6f3889af2f8140e1a763b9a8e5981c6c2f4"
RDEPENDS:selinux-policy-doc = " \
 selinux-policy \
"

URI_selinux-policy-mls = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/selinux-policy-mls-40.13.26-1.el10.noarch.rpm;name=selinux-policy-mls;unpack=0"
SRC_URI += "${URI_selinux-policy-mls}"
SRC_URI[selinux-policy-mls.sha256sum] = "506b160121581fabe63049407cf645e5ae48fdb334cf151a755b5561f2246f38"
RDEPENDS:selinux-policy-mls = " \
 policycoreutils \
 policycoreutils-newrole \
 bash \
 mcstrans \
 coreutils \
 selinux-policy \
"

URI_selinux-policy-sandbox = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/selinux-policy-sandbox-40.13.26-1.el10.noarch.rpm;name=selinux-policy-sandbox;unpack=0"
SRC_URI += "${URI_selinux-policy-sandbox}"
SRC_URI[selinux-policy-sandbox.sha256sum] = "c0c5232a6a82594e46ef3f4a90347b8cc63bb69e22f78026b7e904d47bc5baa1"
RDEPENDS:selinux-policy-sandbox = " \
 selinux-policy \
 bash \
 selinux-policy-targeted \
"

URI_selinux-policy-targeted = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/selinux-policy-targeted-40.13.26-1.el10.noarch.rpm;name=selinux-policy-targeted;unpack=0"
SRC_URI += "${URI_selinux-policy-targeted}"
SRC_URI[selinux-policy-targeted.sha256sum] = "b3e61225d525c2c6372929cfb2b1c56134c19580617764f624b64f2806c253ec"
RDEPENDS:selinux-policy-targeted = " \
 coreutils \
 bash \
 policycoreutils \
 selinux-policy \
"

URI_selinux-policy-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/selinux-policy-devel-40.13.26-1.el10.noarch.rpm;name=selinux-policy-devel;unpack=0"
SRC_URI += "${URI_selinux-policy-devel}"
SRC_URI[selinux-policy-devel.sha256sum] = "adfaf0b76bec2cc8c62b567f80f76b158498899b2c83ad8a5c7c46b03eadea64"
RDEPENDS:selinux-policy-devel = " \
 m4 \
 checkpolicy \
 policycoreutils-devel \
 make \
 bash \
 selinux-policy \
"

URI_selinux-policy-minimum = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/selinux-policy-minimum-40.13.26-1.el10.noarch.rpm;name=selinux-policy-minimum;unpack=0"
SRC_URI += "${URI_selinux-policy-minimum}"
SRC_URI[selinux-policy-minimum.sha256sum] = "7d47ad0a8d0dcb49f2063aee86b1d5315e0210f859c618fd2d1806f051fe9251"
RDEPENDS:selinux-policy-minimum = " \
 coreutils \
 policycoreutils-python-utils \
 bash \
 selinux-policy \
"
