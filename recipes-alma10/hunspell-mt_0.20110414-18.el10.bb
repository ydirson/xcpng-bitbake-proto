# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-mt"
PE = "0"
PV = "0.20110414"
PR = "18.el10"
PACKAGES = "hunspell-mt"
PROVIDES = "rpm/hunspell-mt"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-mt-0.20110414-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46c086d990b6b3cb63148c340de378be251a5c44b113738fdc94df91406cfb0c"

URI_hunspell-mt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-mt-0.20110414-18.el10.noarch.rpm;name=hunspell-mt;unpack=0"
SRC_URI += "${URI_hunspell-mt}"
SRC_URI[hunspell-mt.sha256sum] = "7e15a26eea60ea83c876a5950f88a21bb19f1323ee9099c1a60df9098a4def8f"
RDEPENDS:hunspell-mt = " \
 hunspell-filesystem \
"
