# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libmnl"
PE = "0"
PV = "1.0.5"
PR = "7.el10"
PACKAGES = "libmnl libmnl-devel libmnl-static"
PROVIDES = "rpm/libmnl rpm/libmnl-devel rpm/libmnl-static"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libmnl-1.0.5-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0adfe737ee998116dacf99551dedda831cfee689cc33c9c15325439b982f38ca"

URI_libmnl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libmnl-1.0.5-7.el10.x86_64_v2.rpm;name=libmnl;unpack=0"
SRC_URI += "${URI_libmnl}"
SRC_URI[libmnl.sha256sum] = "972ffae5b746addc46f61f79700ef1a716d257ecc226ec8e77bb9bbdee3671e4"
RDEPENDS:libmnl = " \
 glibc \
"

URI_libmnl-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libmnl-devel-1.0.5-7.el10.x86_64_v2.rpm;name=libmnl-devel;unpack=0"
SRC_URI += "${URI_libmnl-devel}"
SRC_URI[libmnl-devel.sha256sum] = "82c6169d3ac4fa162143118a11959257fb3c9b08f2efb0eadeda2ce210b94413"
RDEPENDS:libmnl-devel = " \
 libmnl \
 pkgconf-pkg-config \
"

URI_libmnl-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libmnl-static-1.0.5-7.el10.x86_64_v2.rpm;name=libmnl-static;unpack=0"
SRC_URI += "${URI_libmnl-static}"
SRC_URI[libmnl-static.sha256sum] = "f46f2a689c6a8189a38e00b71cbe14166ce973f04035fae3c6f2738d2e88813c"
RDEPENDS:libmnl-static = " \
 libmnl-devel \
"
