# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qpdf"
PE = "0"
PV = "11.8.0"
PR = "5.el10"
PACKAGES = "qpdf-libs qpdf qpdf-devel qpdf-doc"
PROVIDES = "rpm/qpdf-libs rpm/qpdf rpm/qpdf-devel rpm/qpdf-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qpdf-11.8.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a494d9b4e5dc236bacbd015ecb525e09468d4636b78acf20020e5b16db316652"

URI_qpdf-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qpdf-libs-11.8.0-5.el10.x86_64_v2.rpm;name=qpdf-libs;unpack=0"
SRC_URI += "${URI_qpdf-libs}"
SRC_URI[qpdf-libs.sha256sum] = "7fd5e04cc71c47329a604f0d4adfd972cd163673be76e895191b4e403282653d"
RDEPENDS:qpdf-libs = " \
 zlib-ng-compat \
 gnutls \
 libgcc \
 libstdc++ \
 glibc \
 libjpeg-turbo \
"

URI_qpdf = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qpdf-11.8.0-5.el10.x86_64_v2.rpm;name=qpdf;unpack=0"
SRC_URI += "${URI_qpdf}"
SRC_URI[qpdf.sha256sum] = "1de67263ba3c868cad5c260e6a4d5fb491dd0ce6ca096f65c4474e393334bb0b"
RDEPENDS:qpdf = " \
 glibc \
 qpdf-libs \
 libgcc \
 libstdc++ \
"

URI_qpdf-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qpdf-devel-11.8.0-5.el10.x86_64_v2.rpm;name=qpdf-devel;unpack=0"
SRC_URI += "${URI_qpdf-devel}"
SRC_URI[qpdf-devel.sha256sum] = "1911cfd02ed158ce5d74aeea568608db6b993c1cf085e3899a2240e0db5bae74"
RDEPENDS:qpdf-devel = " \
 qpdf-libs \
 gnutls-devel \
 zlib-ng-compat-devel \
 pkgconf-pkg-config \
 libjpeg-turbo-devel \
"

URI_qpdf-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qpdf-doc-11.8.0-5.el10.noarch.rpm;name=qpdf-doc;unpack=0"
SRC_URI += "${URI_qpdf-doc}"
SRC_URI[qpdf-doc.sha256sum] = "3fd3538826712ed902fc24943b7044ea983d358abf7e22c4625c6d1f179c6054"
RDEPENDS:qpdf-doc = " \
 qpdf-libs \
"
