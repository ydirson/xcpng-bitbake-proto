# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gstreamer1"
PE = "0"
PV = "1.24.11"
PR = "1.el10"
PACKAGES = "gstreamer1 gstreamer1-devel"
PROVIDES = "rpm/gstreamer1 rpm/gstreamer1-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gstreamer1-1.24.11-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90d9b14969aa3855f9389b9772a42627f9e7a281bcc414eb25ff600647738160"

URI_gstreamer1 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gstreamer1-1.24.11-1.el10.x86_64_v2.rpm;name=gstreamer1;unpack=0"
SRC_URI += "${URI_gstreamer1}"
SRC_URI[gstreamer1.sha256sum] = "9ed1b20f33de1e0b426c83362dabc70f609ae6f086d804fafcff7b3b99d25c3e"
RDEPENDS:gstreamer1 = " \
 python3 \
 libgcc \
 libcap \
 bash \
 glib2 \
 glibc \
"

URI_gstreamer1-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gstreamer1-devel-1.24.11-1.el10.x86_64_v2.rpm;name=gstreamer1-devel;unpack=0"
SRC_URI += "${URI_gstreamer1-devel}"
SRC_URI[gstreamer1-devel.sha256sum] = "86b74009cb77030c43c3b4deff537e94c9d57651226b057196c847b5e8677b71"
RDEPENDS:gstreamer1-devel = " \
 libxml2-devel \
 glib2-devel \
 check-devel \
 gstreamer1 \
 gstreamer1-devel \
 pkgconf-pkg-config \
"
