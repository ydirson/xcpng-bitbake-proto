# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "device-mapper-persistent-data"
PE = "0"
PV = "1.1.0"
PR = "2.el10"
PACKAGES = "device-mapper-persistent-data"
PROVIDES = "rpm/device-mapper-persistent-data"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/device-mapper-persistent-data-1.1.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45ca7781874793f18e51560905c73e7e020b6e90d648af8d5b531c0bc92f7a92"

URI_device-mapper-persistent-data = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/device-mapper-persistent-data-1.1.0-2.el10.x86_64_v2.rpm;name=device-mapper-persistent-data;unpack=0"
SRC_URI += "${URI_device-mapper-persistent-data}"
SRC_URI[device-mapper-persistent-data.sha256sum] = "805e01c4021097990a6f5151636c138b2833c973832e85276adf2d71bab00403"
RDEPENDS:device-mapper-persistent-data = " \
 glibc \
 libgcc \
 systemd-libs \
"
