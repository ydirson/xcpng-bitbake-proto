# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libldb"
PE = "0"
PV = "2.9.1"
PR = "1.el10"
PACKAGES = "libldb libldb-devel python-ldb-devel-common python3-ldb python3-ldb-devel"
PROVIDES = "rpm/libldb rpm/libldb-devel rpm/python-ldb-devel-common rpm/python3-ldb rpm/python3-ldb-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/libldb-2.9.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3aab6f105c0c53374291c6975feab2ecfb98f8f314ea547a829dc620bab950b"

URI_libldb = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libldb-2.9.1-1.el10.x86_64_v2.rpm;name=libldb;unpack=0"
SRC_URI += "${URI_libldb}"
SRC_URI[libldb.sha256sum] = "a89db71905a1d957fd14cafbf931a397ec555f74d819363adbbb258367bc505e"
RDEPENDS:libldb = " \
 lmdb-libs \
 libtevent \
 libtalloc \
 libtdb \
 glibc \
 openldap \
"

URI_libldb-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libldb-devel-2.9.1-1.el10.x86_64_v2.rpm;name=libldb-devel;unpack=0"
SRC_URI += "${URI_libldb-devel}"
SRC_URI[libldb-devel.sha256sum] = "4a023f886bbcd739fe95430854d28b7d5e54a0555fa50942edcfd1e7ae78976d"
RDEPENDS:libldb-devel = " \
 libldb \
 libldb \
 pkgconf-pkg-config \
 libtalloc-devel \
 libtdb-devel \
 libtevent-devel \
"

URI_python-ldb-devel-common = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python-ldb-devel-common-2.9.1-1.el10.x86_64_v2.rpm;name=python-ldb-devel-common;unpack=0"
SRC_URI += "${URI_python-ldb-devel-common}"
SRC_URI[python-ldb-devel-common.sha256sum] = "a6cacdbd97bf26057fdbec1feaae9ca359cd2d1da74d62aa029c917dd081e7a8"
RDEPENDS:python-ldb-devel-common = ""

URI_python3-ldb = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-ldb-2.9.1-1.el10.x86_64_v2.rpm;name=python3-ldb;unpack=0"
SRC_URI += "${URI_python3-ldb}"
SRC_URI[python3-ldb.sha256sum] = "9f3bccfc3b5ef86b8fbd3777f1ecc5645a6b7df5bef93f45d34aab96518ee2f5"
RDEPENDS:python3-ldb = " \
 python3 \
 libldb \
 libldb \
 python3-libs \
 libtevent \
 libtalloc \
 libtdb \
 glibc \
 python3-tdb \
"

URI_python3-ldb-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-ldb-devel-2.9.1-1.el10.x86_64_v2.rpm;name=python3-ldb-devel;unpack=0"
SRC_URI += "${URI_python3-ldb-devel}"
SRC_URI[python3-ldb-devel.sha256sum] = "bbfb37f99699f6e6be59ce81feee803389ab0cc03b1589b2ef3a71cf66ae8a3e"
RDEPENDS:python3-ldb-devel = " \
 libldb-devel \
 python3-ldb \
 pkgconf-pkg-config \
 python-ldb-devel-common \
"
