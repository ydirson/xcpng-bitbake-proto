# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libvorbis"
PE = "1"
PV = "1.3.7"
PR = "12.el10"
PACKAGES = "libvorbis libvorbis-devel libvorbis-devel-docs"
PROVIDES = "rpm/libvorbis rpm/libvorbis-devel rpm/libvorbis-devel-docs"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libvorbis-1.3.7-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bfdd6322fe6ddee3faf166f470a8db911e32b5852dcc507d238103425e119839"

URI_libvorbis = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvorbis-1.3.7-12.el10.x86_64_v2.rpm;name=libvorbis;unpack=0"
SRC_URI += "${URI_libvorbis}"
SRC_URI[libvorbis.sha256sum] = "aaa2db5cf4d583a0ae45d17fd0f7b39514791be63898c81cd3dc74ceba422da5"
RDEPENDS:libvorbis = " \
 glibc \
 libogg \
"

URI_libvorbis-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libvorbis-devel-1.3.7-12.el10.x86_64_v2.rpm;name=libvorbis-devel;unpack=0"
SRC_URI += "${URI_libvorbis-devel}"
SRC_URI[libvorbis-devel.sha256sum] = "607b78c4960717f83429895e7c2c16ae378c406b29b832fd32909e981c8cc4fd"
RDEPENDS:libvorbis-devel = " \
 libvorbis \
 libvorbis-devel \
 libogg-devel \
 pkgconf-pkg-config \
"

URI_libvorbis-devel-docs = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libvorbis-devel-docs-1.3.7-12.el10.noarch.rpm;name=libvorbis-devel-docs;unpack=0"
SRC_URI += "${URI_libvorbis-devel-docs}"
SRC_URI[libvorbis-devel-docs.sha256sum] = "bb009b03104df3a906f3fa2ad21f3a79e0536c6fb2308edd07b35d229d09ef89"
RDEPENDS:libvorbis-devel-docs = " \
 libvorbis-devel \
"
