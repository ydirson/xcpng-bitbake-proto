# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-flit-core"
PE = "0"
PV = "3.9.0"
PR = "8.el10"
PACKAGES = "python3-flit-core"
PROVIDES = "rpm/python3-flit-core"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/python-flit-core-3.9.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc040988eeb313ad7164fbf77a7fb4dcbcc7de1bb92fc1b63f7fa588cc7e5ac7"

URI_python3-flit-core = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-flit-core-3.9.0-8.el10.noarch.rpm;name=python3-flit-core;unpack=0"
SRC_URI += "${URI_python3-flit-core}"
SRC_URI[python3-flit-core.sha256sum] = "8ba38fc1cc4203543556888e51595abd1cb8dd78b0a9c69ec258e29259bd1e56"
RDEPENDS:python3-flit-core = " \
 python3 \
"
