# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "net-tools"
PE = "0"
PV = "2.0"
PR = "0.73.20160912git.el10"
PACKAGES = "net-tools"
PROVIDES = "rpm/net-tools"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/net-tools-2.0-0.73.20160912git.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91da6eb23ffc2ca2d10d6b9b31fa825883cefc5c6c3cd51bbb63ed7fa777d038"

URI_net-tools = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/net-tools-2.0-0.73.20160912git.el10.x86_64_v2.rpm;name=net-tools;unpack=0"
SRC_URI += "${URI_net-tools}"
SRC_URI[net-tools.sha256sum] = "253dfde89d6977ca1e5ebfb7169270aff1d2bd573165d2462589916fe1a6184d"
RDEPENDS:net-tools = " \
 glibc \
 libselinux \
 systemd \
 bash \
"
