# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "munge"
PE = "0"
PV = "0.5.15"
PR = "10.el10"
PACKAGES = "munge munge-libs munge-devel"
PROVIDES = "rpm/munge rpm/munge-libs rpm/munge-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/munge-0.5.15-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c4a57de4903c71d9b6986e5b4a47e1da52e3e3cef83b98b75bd492aea17a7c6"

URI_munge = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/munge-0.5.15-10.el10.x86_64_v2.rpm;name=munge;unpack=0"
SRC_URI += "${URI_munge}"
SRC_URI[munge.sha256sum] = "3a30adfb3ff23a734df2b5bc42e9f6a6e7e3c5ff810bc357cabf9da57dda47a3"
RDEPENDS:munge = " \
 logrotate \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 bzip2-libs \
 libgcc \
 openssl-libs \
 munge-libs \
 bash \
 glibc \
"

URI_munge-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/munge-libs-0.5.15-10.el10.x86_64_v2.rpm;name=munge-libs;unpack=0"
SRC_URI += "${URI_munge-libs}"
SRC_URI[munge-libs.sha256sum] = "6edddcdbede341035cd52a604b2ef910afe02ac139f166a4d90dd7516b2bcb1d"
RDEPENDS:munge-libs = " \
 glibc \
"

URI_munge-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/munge-devel-0.5.15-10.el10.x86_64_v2.rpm;name=munge-devel;unpack=0"
SRC_URI += "${URI_munge-devel}"
SRC_URI[munge-devel.sha256sum] = "e79ca9e97df97824b5d5f34dfc8cb559ffbe2cb07027ccd33bb7e87807e036d7"
RDEPENDS:munge-devel = " \
 munge-libs \
 pkgconf-pkg-config \
"
