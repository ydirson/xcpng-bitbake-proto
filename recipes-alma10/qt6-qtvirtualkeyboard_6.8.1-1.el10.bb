# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtvirtualkeyboard"
PE = "0"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = "qt6-qtvirtualkeyboard qt6-qtvirtualkeyboard-devel qt6-qtvirtualkeyboard-examples qt6-qtvirtualkeyboard-tests"
PROVIDES = "rpm/qt6-qtvirtualkeyboard rpm/qt6-qtvirtualkeyboard-devel rpm/qt6-qtvirtualkeyboard-examples rpm/qt6-qtvirtualkeyboard-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtvirtualkeyboard-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5dd06a7694efb5c85750b739447806141963d48a2c7bc3a6f663234e352e689"

URI_qt6-qtvirtualkeyboard = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtvirtualkeyboard-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtvirtualkeyboard;unpack=0"
SRC_URI += "${URI_qt6-qtvirtualkeyboard}"
SRC_URI[qt6-qtvirtualkeyboard.sha256sum] = "974d3526600f2e1647eaf0f2790fa3da4201a77171bf93e461c02a36ada878e2"
RDEPENDS:qt6-qtvirtualkeyboard = " \
 qt6-qtdeclarative \
 qt6-qtsvg \
 qt6-qtbase \
 hunspell \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qtvirtualkeyboard-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtvirtualkeyboard-devel-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtvirtualkeyboard-devel;unpack=0"
SRC_URI += "${URI_qt6-qtvirtualkeyboard-devel}"
SRC_URI[qt6-qtvirtualkeyboard-devel.sha256sum] = "aa81da5876f3f5c8cd398117298dced1a8647218efcde3f23aa911bf0cd0dd04"
RDEPENDS:qt6-qtvirtualkeyboard-devel = " \
 qt6-qtdeclarative-devel \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtvirtualkeyboard \
 qt6-qtvirtualkeyboard-devel \
 qt6-qtbase-devel \
"

URI_qt6-qtvirtualkeyboard-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtvirtualkeyboard-examples-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtvirtualkeyboard-examples;unpack=0"
SRC_URI += "${URI_qt6-qtvirtualkeyboard-examples}"
SRC_URI[qt6-qtvirtualkeyboard-examples.sha256sum] = "00e2d567d971d3fa9a4e38917d6f9cb941d142c612f9a7f1b3b6a4029fc6d6b6"
RDEPENDS:qt6-qtvirtualkeyboard-examples = " \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtbase \
 qt6-qtvirtualkeyboard \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qtvirtualkeyboard-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtvirtualkeyboard-tests-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtvirtualkeyboard-tests;unpack=0"
SRC_URI += "${URI_qt6-qtvirtualkeyboard-tests}"
SRC_URI[qt6-qtvirtualkeyboard-tests.sha256sum] = "296e53776376714e1ed73a7fa60a93d7f0893b8bd3813f3886656d5741ef2e80"
RDEPENDS:qt6-qtvirtualkeyboard-tests = " \
 python3 \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtbase \
 qt6-qtvirtualkeyboard \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"
