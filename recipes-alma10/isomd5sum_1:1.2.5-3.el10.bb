# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "isomd5sum"
PE = "1"
PV = "1.2.5"
PR = "3.el10"
PACKAGES = "isomd5sum isomd5sum-devel python3-isomd5sum"
PROVIDES = "rpm/isomd5sum rpm/isomd5sum-devel rpm/python3-isomd5sum"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/isomd5sum-1.2.5-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17f0481fa302f5f70b2d32ae9ece90bb5e9863f516efb6e9ed3cdb4adc70960d"

URI_isomd5sum = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/isomd5sum-1.2.5-3.el10.x86_64_v2.rpm;name=isomd5sum;unpack=0"
SRC_URI += "${URI_isomd5sum}"
SRC_URI[isomd5sum.sha256sum] = "a4535e3114e22014eb08a582a9033f6c4a73743cf7e1480a14a69ed39d5fb217"
RDEPENDS:isomd5sum = " \
 glibc \
 popt \
"

URI_isomd5sum-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/isomd5sum-devel-1.2.5-3.el10.x86_64_v2.rpm;name=isomd5sum-devel;unpack=0"
SRC_URI += "${URI_isomd5sum-devel}"
SRC_URI[isomd5sum-devel.sha256sum] = "4610d011aa721feb032ac1d9ae77f445b869b83b79b681d8c90513f11e281c55"
RDEPENDS:isomd5sum-devel = " \
 isomd5sum \
 pkgconf-pkg-config \
"

URI_python3-isomd5sum = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-isomd5sum-1.2.5-3.el10.x86_64_v2.rpm;name=python3-isomd5sum;unpack=0"
SRC_URI += "${URI_python3-isomd5sum}"
SRC_URI[python3-isomd5sum.sha256sum] = "47268fed47f6a58559d81c19496db510ab92ff1c3d90b9f8e2578f379a1ee4d7"
RDEPENDS:python3-isomd5sum = " \
 glibc \
 python3 \
"
