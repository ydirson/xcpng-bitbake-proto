# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-parent"
PE = "1"
PV = "0.241"
PR = "512.el10"
PACKAGES = "perl-parent perl-parent-tests"
PROVIDES = "rpm/perl-parent rpm/perl-parent-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-parent-0.241-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "965a06dd78ed10a3f67581b6df0fe5114f13225757157f7ba797c56b098ea247"

URI_perl-parent = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-parent-0.241-512.el10.noarch.rpm;name=perl-parent;unpack=0"
SRC_URI += "${URI_perl-parent}"
SRC_URI[perl-parent.sha256sum] = "48d35217133b3b82b86419803e6e0f4b62e5f7eedc987e3c52ade2c541c6b8a9"
RDEPENDS:perl-parent = " \
 perl-libs \
"

URI_perl-parent-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-parent-tests-0.241-512.el10.noarch.rpm;name=perl-parent-tests;unpack=0"
SRC_URI += "${URI_perl-parent-tests}"
SRC_URI[perl-parent-tests.sha256sum] = "3c0f08ac1b93bdab97b955fafa59beaab9f2ff613704f828bbdee0670f326ed1"
RDEPENDS:perl-parent-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 bash \
 perl-parent \
 perl-interpreter \
 perl-lib \
"
