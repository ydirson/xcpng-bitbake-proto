# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "kdump-utils"
PE = "0"
PV = "1.0.51"
PR = "11.el10_0"
PACKAGES = "kdump-utils"
PROVIDES = "rpm/kdump-utils"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/kdump-utils-1.0.51-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "140947d49e1babc847308449a578727a7d937db3efc2844c1ef09b00c7fe4c0d"

URI_kdump-utils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kdump-utils-1.0.51-11.el10_0.x86_64_v2.rpm;name=kdump-utils;unpack=0"
SRC_URI += "${URI_kdump-utils}"
SRC_URI[kdump-utils.sha256sum] = "bd97289824e00a10d4a19016d1d8bfc16b03680d9487117521d0ceac908e92f2"
RDEPENDS:kdump-utils = " \
 dracut-squash \
 kexec-tools \
 util-linux \
 systemd-udev \
 makedumpfile \
 bash \
 ethtool \
 dracut \
 sed \
 coreutils \
 dracut-network \
"
