# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sdl12-compat"
PE = "0"
PV = "1.2.68"
PR = "4.el10"
PACKAGES = "sdl12-compat sdl12-compat-devel"
PROVIDES = "rpm/sdl12-compat rpm/sdl12-compat-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/sdl12-compat-1.2.68-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec91b3a65ff4f49a10ae9f2ccf39223f547d918cba25adfcf7c21a802efbefb2"

URI_sdl12-compat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sdl12-compat-1.2.68-4.el10.x86_64_v2.rpm;name=sdl12-compat;unpack=0"
SRC_URI += "${URI_sdl12-compat}"
SRC_URI[sdl12-compat.sha256sum] = "5cfa434312572bf2eb78a3dd0eed5b2790f46dfc76772cd7964ed196bad3cc50"
RDEPENDS:sdl12-compat = " \
 glibc \
 SDL2 \
"

URI_sdl12-compat-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/sdl12-compat-devel-1.2.68-4.el10.x86_64_v2.rpm;name=sdl12-compat-devel;unpack=0"
SRC_URI += "${URI_sdl12-compat-devel}"
SRC_URI[sdl12-compat-devel.sha256sum] = "096e8c1a890c6ee43b21563a7bf8fc85c9899cd0d16c928380281f31704061cb"
RDEPENDS:sdl12-compat-devel = " \
 libglvnd-devel \
 pkgconf-pkg-config \
 libX11-devel \
 xorg-x11-proto-devel \
 bash \
 mesa-libGLU-devel \
 sdl12-compat \
"
