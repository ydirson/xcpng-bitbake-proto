# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "librhsm"
PE = "0"
PV = "0.0.3"
PR = "16.el10"
PACKAGES = "librhsm librhsm-devel"
PROVIDES = "rpm/librhsm rpm/librhsm-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/librhsm-0.0.3-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1487faec3a006f4425b0b8e16d6984ed2b64c97ac2d7569dffd1613ebb387f0f"

URI_librhsm = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/librhsm-0.0.3-16.el10.x86_64_v2.rpm;name=librhsm;unpack=0"
SRC_URI += "${URI_librhsm}"
SRC_URI[librhsm.sha256sum] = "53fe0ede43d7e84fe427e0fcac36aa50f6b4a9030e26e1b9798a1e193f99df61"
RDEPENDS:librhsm = " \
 openssl-libs \
 libgcc \
 json-glib \
 glib2 \
 glibc \
"

URI_librhsm-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/librhsm-devel-0.0.3-16.el10.x86_64_v2.rpm;name=librhsm-devel;unpack=0"
SRC_URI += "${URI_librhsm-devel}"
SRC_URI[librhsm-devel.sha256sum] = "90d840a28222fda3802f6f9b12da70b8bcd1d5b32939560e98eced2fd9cd782f"
RDEPENDS:librhsm-devel = " \
 json-glib-devel \
 glib2-devel \
 pkgconf-pkg-config \
 openssl-devel \
 librhsm \
"
