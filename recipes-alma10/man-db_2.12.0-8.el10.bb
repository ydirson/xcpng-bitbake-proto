# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "man-db"
PE = "0"
PV = "2.12.0"
PR = "8.el10"
PACKAGES = "man-db man-db-cron"
PROVIDES = "rpm/man-db rpm/man-db-cron"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/man-db-2.12.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4b90697bb0b285cdae73a7541af47d23c36fb15f932db84598bb54cf3bfed99"

URI_man-db = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/man-db-2.12.0-8.el10.x86_64_v2.rpm;name=man-db;unpack=0"
SRC_URI += "${URI_man-db}"
SRC_URI[man-db.sha256sum] = "1300fa1a528db8c41f9105ec4e00a569f7d49a0dcd9af3075756ec790f3780a4"
RDEPENDS:man-db = " \
 coreutils \
 less \
 zlib-ng-compat \
 libpipeline \
 gzip \
 grep \
 gdbm-libs \
 groff-base \
 bash \
 glibc \
 alternatives \
"

URI_man-db-cron = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/man-db-cron-2.12.0-8.el10.noarch.rpm;name=man-db-cron;unpack=0"
SRC_URI += "${URI_man-db-cron}"
SRC_URI[man-db-cron.sha256sum] = "2c27cf85287584f099983539c484445349b32a06c1dcc568f9370f594de71dff"
RDEPENDS:man-db-cron = " \
 crontabs \
 bash \
 man-db \
"
