# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Tk"
PE = "0"
PV = "804.036"
PR = "17.el10"
PACKAGES = "perl-Tk perl-Tk-devel perl-Tk-tests"
PROVIDES = "rpm/perl-Tk rpm/perl-Tk-devel rpm/perl-Tk-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Tk-804.036-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f569a1bce6b2564a54bb2972e76ca3b20f3046176990eb95910be995e766839b"

URI_perl-Tk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Tk-804.036-17.el10.x86_64_v2.rpm;name=perl-Tk;unpack=0"
SRC_URI += "${URI_perl-Tk}"
SRC_URI[perl-Tk.sha256sum] = "0aa54b45d4ee31cc6777f9455dac82cab65ae36c6f65efa8efc777fb2e24ba1f"
RDEPENDS:perl-Tk = " \
 perl-libs \
 libpng \
 perl-locale \
 perl-Socket \
 perl-Getopt-Long \
 fontconfig \
 libX11 \
 perl-Getopt-Std \
 perl-overload \
 perl-Symbol \
 perl-AutoLoader \
 perl-open \
 perl-subs \
 perl-Carp \
 libXft \
 perl-vars \
 perl-IO \
 perl-Text-Tabs+Wrap \
 perl-Tk \
 perl-DirHandle \
 perl-DynaLoader \
 perl-Encode \
 perl-Exporter \
 perl-base \
 perl-File-Basename \
 perl-PathTools \
 perl-if \
 glibc \
 perl-interpreter \
 libjpeg-turbo \
"

URI_perl-Tk-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Tk-devel-804.036-17.el10.x86_64_v2.rpm;name=perl-Tk-devel;unpack=0"
SRC_URI += "${URI_perl-Tk-devel}"
SRC_URI[perl-Tk-devel.sha256sum] = "e1fbd2cf60ea68912985655d88348b117e76c67739f5ca113833de975a2fd99a"
RDEPENDS:perl-Tk-devel = " \
 perl-Tk \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-ExtUtils-MakeMaker \
 perl-Tk-devel \
 perl-File-Basename \
 perl-PathTools \
 perl-Exporter \
 perl-base \
"

URI_perl-Tk-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Tk-tests-804.036-17.el10.x86_64_v2.rpm;name=perl-Tk-tests;unpack=0"
SRC_URI += "${URI_perl-Tk-tests}"
SRC_URI[perl-Tk-tests.sha256sum] = "5f08012bc070ce58bb64ff80e34bc5675dbb7b3c5bdf96955ee8f4a7ccf3a952"
RDEPENDS:perl-Tk-tests = " \
 perl-libs \
 perl-FindBin \
 perl-Getopt-Long \
 mutter \
 default-fonts-core-sans \
 perl-subs \
 perl-Test \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Carp \
 perl-vars \
 perl-IO \
 liberation-sans-fonts \
 perl-lib \
 perl-Data-Dumper \
 xwayland-run \
 perl-Devel-Peek \
 perl-Tk \
 mesa-dri-drivers \
 perl-Encode \
 bash \
 google-noto-sans-fonts \
 perl-Exporter \
 perl-base \
 perl-constant \
 perl-POSIX \
 perl-File-Copy \
 perl-PathTools \
 perl-interpreter \
 perl-File-Temp \
"
