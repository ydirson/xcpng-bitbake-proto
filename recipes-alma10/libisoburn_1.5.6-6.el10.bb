# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libisoburn"
PE = "0"
PV = "1.5.6"
PR = "6.el10"
PACKAGES = "libisoburn libisoburn-doc xorriso libisoburn-devel"
PROVIDES = "rpm/libisoburn rpm/libisoburn-doc rpm/xorriso rpm/libisoburn-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libisoburn-1.5.6-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44930516024b61ad2f3c7bd855006343099a395e149a55019ba23e180698ce69"

URI_libisoburn = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libisoburn-1.5.6-6.el10.x86_64_v2.rpm;name=libisoburn;unpack=0"
SRC_URI += "${URI_libisoburn}"
SRC_URI[libisoburn.sha256sum] = "b25c00d7e25e158badda5626726e6756bba6ee660c7de73b20c0c99ae06ff7e5"
RDEPENDS:libisoburn = " \
 libburn \
 libacl \
 zlib-ng-compat \
 readline \
 libisofs \
 glibc \
"

URI_libisoburn-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libisoburn-doc-1.5.6-6.el10.noarch.rpm;name=libisoburn-doc;unpack=0"
SRC_URI += "${URI_libisoburn-doc}"
SRC_URI[libisoburn-doc.sha256sum] = "763c9eed912872e9a9df4ddc100d9afece9643eb8268c1e2d03f6c75474166e4"
RDEPENDS:libisoburn-doc = ""

URI_xorriso = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xorriso-1.5.6-6.el10.x86_64_v2.rpm;name=xorriso;unpack=0"
SRC_URI += "${URI_xorriso}"
SRC_URI[xorriso.sha256sum] = "8c6007c4612d4816d64db7ae9a8080fba65a4a0de4162181e9212e22fea110bf"
RDEPENDS:xorriso = " \
 bash \
 libisoburn \
 glibc \
 coreutils \
 alternatives \
"

URI_libisoburn-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libisoburn-devel-1.5.6-6.el10.x86_64_v2.rpm;name=libisoburn-devel;unpack=0"
SRC_URI += "${URI_libisoburn-devel}"
SRC_URI[libisoburn-devel.sha256sum] = "b600fe8b14328128b5f6dece1fe02d85cf453a6bccfc821a93f56ea689c5dabf"
RDEPENDS:libisoburn-devel = " \
 pkgconf-pkg-config \
 libisoburn \
"
