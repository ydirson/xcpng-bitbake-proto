# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "setserial"
PE = "0"
PV = "2.17"
PR = "63.el10"
PACKAGES = "setserial"
PROVIDES = "rpm/setserial"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/setserial-2.17-63.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96b46ac8294173652ab95f33d07708937b7e49b0a1c60519dc9332ff65b71b20"

URI_setserial = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/setserial-2.17-63.el10.x86_64_v2.rpm;name=setserial;unpack=0"
SRC_URI += "${URI_setserial}"
SRC_URI[setserial.sha256sum] = "d4fd312d432f1ce55d142f0e242fb0f996a963d4b5e75f0f4d0becc7f8d9d3fe"
RDEPENDS:setserial = " \
 glibc \
"
