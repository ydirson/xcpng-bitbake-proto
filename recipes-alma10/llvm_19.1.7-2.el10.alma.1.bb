# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "llvm"
PE = "0"
PV = "19.1.7"
PR = "2.el10.alma.1"
PACKAGES = "clang clang-analyzer clang-devel clang-libs clang-resource-filesystem clang-tools-extra compiler-rt git-clang-format libomp libomp-devel lld lld-devel lld-libs lldb lldb-devel llvm llvm-devel llvm-doc llvm-googletest llvm-libs llvm-static llvm-test llvm-toolset python3-lldb clang-tools-extra-devel llvm-cmake-utils python3-clang python3-lit"
PROVIDES = "rpm/clang rpm/clang-analyzer rpm/clang-devel rpm/clang-libs rpm/clang-resource-filesystem rpm/clang-tools-extra rpm/compiler-rt rpm/git-clang-format rpm/libomp rpm/libomp-devel rpm/lld rpm/lld-devel rpm/lld-libs rpm/lldb rpm/lldb-devel rpm/llvm rpm/llvm-devel rpm/llvm-doc rpm/llvm-googletest rpm/llvm-libs rpm/llvm-static rpm/llvm-test rpm/llvm-toolset rpm/python3-lldb rpm/clang-tools-extra-devel rpm/llvm-cmake-utils rpm/python3-clang rpm/python3-lit"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/llvm-19.1.7-2.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d6ea03321222aeaea318b0704e0a0fbea9f3bb8e3946f68688dd70986482115"

URI_clang = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/clang-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=clang;unpack=0"
SRC_URI += "${URI_clang}"
SRC_URI[clang.sha256sum] = "15293a5efcf559fc17e0ec2e6bd75a390588852eee6bf3100d98c5e3560214af"
RDEPENDS:clang = " \
 libgcc \
 clang-libs \
 libstdc++-devel \
 libstdc++ \
 glibc \
 llvm-libs \
 gcc-c++ \
"

URI_clang-analyzer = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/clang-analyzer-19.1.7-2.el10.alma.1.noarch.rpm;name=clang-analyzer;unpack=0"
SRC_URI += "${URI_clang-analyzer}"
SRC_URI[clang-analyzer.sha256sum] = "db59f46d86d96c37803700beed64addbdb97b7b96f09eb53feaec7ba6108c70c"
RDEPENDS:clang-analyzer = " \
 python3 \
 perl-libs \
 perl-FindBin \
 perl-Text-ParseWords \
 clang \
 perl-File-Basename \
 perl-File-Temp \
 perl-File-Copy \
 perl-PathTools \
 perl-Sys-Hostname \
 perl-Term-ANSIColor \
 perl-File-Find \
 perl-interpreter \
 perl-File-Path \
 perl-Hash-Util \
 perl-lib \
"

URI_clang-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/clang-devel-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=clang-devel;unpack=0"
SRC_URI += "${URI_clang-devel}"
SRC_URI[clang-devel.sha256sum] = "da131a0b4c9e042c7d2e404c8504f13b3fa1e084d62bf785b187f1e5dfbcb0f4"
RDEPENDS:clang-devel = " \
 cmake-filesystem \
 clang \
 libgcc \
 clang-libs \
 clang-tools-extra \
 libstdc++ \
 glibc \
"

URI_clang-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/clang-libs-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=clang-libs;unpack=0"
SRC_URI += "${URI_clang-libs}"
SRC_URI[clang-libs.sha256sum] = "fe1cbb7668291d0c9cb61dbb5d804a4d22350e8c5713da5a5e1dff73e97fe22a"
RDEPENDS:clang-libs = " \
 libgcc \
 clang-resource-filesystem \
 libstdc++ \
 glibc \
 llvm-libs \
"

URI_clang-resource-filesystem = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/clang-resource-filesystem-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=clang-resource-filesystem;unpack=0"
SRC_URI += "${URI_clang-resource-filesystem}"
SRC_URI[clang-resource-filesystem.sha256sum] = "06747f007168cd5f5a1a10c4b8865ae7c7752b3cab299ace748e75813aa2ef88"
RDEPENDS:clang-resource-filesystem = ""

URI_clang-tools-extra = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/clang-tools-extra-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=clang-tools-extra;unpack=0"
SRC_URI += "${URI_clang-tools-extra}"
SRC_URI[clang-tools-extra.sha256sum] = "add16a337f27b9934cc9c24a35a50cb37358aa7b03980f080073f4d4b99d97dc"
RDEPENDS:clang-tools-extra = " \
 python3 \
 emacs-filesystem \
 libgcc \
 libxml2 \
 clang-libs \
 libstdc++ \
 glibc \
 llvm-libs \
"

URI_compiler-rt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/compiler-rt-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=compiler-rt;unpack=0"
SRC_URI += "${URI_compiler-rt}"
SRC_URI[compiler-rt.sha256sum] = "56847248fc530d5ecdbd2ec6d53e54a767973741cc5cfda2d98cb1e5bddc90d7"
RDEPENDS:compiler-rt = " \
 python3 \
 libgcc \
 clang-resource-filesystem \
 libstdc++ \
 glibc \
"

URI_git-clang-format = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/git-clang-format-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=git-clang-format;unpack=0"
SRC_URI += "${URI_git-clang-format}"
SRC_URI[git-clang-format.sha256sum] = "09127ab4eb2e76ba8a2767bba186a449081662e9e6ebcf8ae46115028f7e8fbf"
RDEPENDS:git-clang-format = " \
 python3 \
 git \
 clang-tools-extra \
"

URI_libomp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libomp-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=libomp;unpack=0"
SRC_URI += "${URI_libomp}"
SRC_URI[libomp.sha256sum] = "b7b61d2b6af86dd24163603c36a3ced8ce09c7b98bc3c153bde6b6790ac21c98"
RDEPENDS:libomp = " \
 libffi \
 libgcc \
 elfutils-libelf \
 libstdc++ \
 glibc \
 llvm-libs \
"

URI_libomp-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libomp-devel-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=libomp-devel;unpack=0"
SRC_URI += "${URI_libomp-devel}"
SRC_URI[libomp-devel.sha256sum] = "441762f342e33cfa8f5f66b68b793fdb830666d0b38bb4eda84bb3ceb390dfff"
RDEPENDS:libomp-devel = " \
 libomp \
 clang-resource-filesystem \
"

URI_lld = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lld-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=lld;unpack=0"
SRC_URI += "${URI_lld}"
SRC_URI[lld.sha256sum] = "023bbe60d31930ae3df47ff5ea2cdd4cff62ca7a60a315bcfcf00fb5c1f8eda6"
RDEPENDS:lld = " \
 libgcc \
 lld-libs \
 libstdc++ \
 bash \
 glibc \
 alternatives \
 llvm-libs \
"

URI_lld-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lld-devel-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=lld-devel;unpack=0"
SRC_URI += "${URI_lld-devel}"
SRC_URI[lld-devel.sha256sum] = "49f90d0f405bf828a0eff1ffc41031064b08b789f256ec5de1691cf81c694262"
RDEPENDS:lld-devel = " \
 lld \
 lld-libs \
 cmake-filesystem \
"

URI_lld-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lld-libs-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=lld-libs;unpack=0"
SRC_URI += "${URI_lld-libs}"
SRC_URI[lld-libs.sha256sum] = "180f7d092e110b961baf11c9845f95cdc9f06da9171ab6cb1e1cd1e6703d5f18"
RDEPENDS:lld-libs = " \
 zlib-ng-compat \
 libgcc \
 libzstd \
 libstdc++ \
 glibc \
 llvm-libs \
"

URI_lldb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lldb-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=lldb;unpack=0"
SRC_URI += "${URI_lldb}"
SRC_URI[lldb.sha256sum] = "a99ff863a937a5fa88d07549498ab32933bd149d264e6acab2ea4dce3891ede1"
RDEPENDS:lldb = " \
 zlib-ng-compat \
 libgcc \
 libxml2 \
 python3-libs \
 clang-libs \
 libstdc++ \
 ncurses-libs \
 python3-lldb \
 glibc \
 llvm-libs \
 xz-libs \
 libedit \
"

URI_lldb-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lldb-devel-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=lldb-devel;unpack=0"
SRC_URI += "${URI_lldb-devel}"
SRC_URI[lldb-devel.sha256sum] = "4dee82a7222c147c39e0ad0644b9d73d626ec38e9fb8cd12177fe484c87ef170"
RDEPENDS:lldb-devel = " \
 lldb \
"

URI_llvm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/llvm-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=llvm;unpack=0"
SRC_URI += "${URI_llvm}"
SRC_URI[llvm.sha256sum] = "198bedfb659bd8b2a922372eb60ff19fc54a6ecc5551755e3592f3c1937bda9a"
RDEPENDS:llvm = " \
 python3 \
 zlib-ng-compat \
 libgcc \
 libzstd \
 libstdc++ \
 glibc \
 llvm-libs \
"

URI_llvm-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/llvm-devel-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=llvm-devel;unpack=0"
SRC_URI += "${URI_llvm-devel}"
SRC_URI[llvm-devel.sha256sum] = "46a63b84e1be1f8e05eb281352c9c9a68b7bf41f3255d52d15f29e22eb6b5dbb"
RDEPENDS:llvm-devel = " \
 cmake-filesystem \
 libedit-devel \
 libgcc \
 libzstd-devel \
 llvm \
 libstdc++ \
 bash \
 glibc \
 alternatives \
 llvm-googletest \
 llvm-libs \
 llvm-static \
 llvm-test \
"

URI_llvm-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/llvm-doc-19.1.7-2.el10.alma.1.noarch.rpm;name=llvm-doc;unpack=0"
SRC_URI += "${URI_llvm-doc}"
SRC_URI[llvm-doc.sha256sum] = "91618b2d2711b45c5fe0540101a11bfa4b33d8f9f1ddad18e676f37664dc5ce2"
RDEPENDS:llvm-doc = " \
 llvm \
"

URI_llvm-googletest = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/llvm-googletest-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=llvm-googletest;unpack=0"
SRC_URI += "${URI_llvm-googletest}"
SRC_URI[llvm-googletest.sha256sum] = "ce28f4dd78eb3fca3cbb341548c491a9c964b97057af529e8731e37f033b107b"
RDEPENDS:llvm-googletest = ""

URI_llvm-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/llvm-libs-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=llvm-libs;unpack=0"
SRC_URI += "${URI_llvm-libs}"
SRC_URI[llvm-libs.sha256sum] = "8848810a7563a7eaee148775e0b8ef7a55624c7a04c26a8080579cac80934231"
RDEPENDS:llvm-libs = " \
 zlib-ng-compat \
 libffi \
 libgcc \
 libxml2 \
 libzstd \
 libstdc++ \
 glibc \
 libedit \
"

URI_llvm-static = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/llvm-static-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=llvm-static;unpack=0"
SRC_URI += "${URI_llvm-static}"
SRC_URI[llvm-static.sha256sum] = "cba096b521c97abd73456bfa8ee18c558c829745f0ef2392c27b90aaf9f0c005"
RDEPENDS:llvm-static = ""

URI_llvm-test = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/llvm-test-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=llvm-test;unpack=0"
SRC_URI += "${URI_llvm-test}"
SRC_URI[llvm-test.sha256sum] = "1553ea91d5a0cf1b1008ba5a445c80e5d067d4514f36dc852eb6d9c29be80bd8"
RDEPENDS:llvm-test = " \
 libgcc \
 llvm-libs \
 libstdc++ \
 glibc \
 llvm \
"

URI_llvm-toolset = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/llvm-toolset-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=llvm-toolset;unpack=0"
SRC_URI += "${URI_llvm-toolset}"
SRC_URI[llvm-toolset.sha256sum] = "d767896ced3aa9f553b04556b7d7c7c4f2cf0ab31e6868fd2186e6047e1b6ce8"
RDEPENDS:llvm-toolset = " \
 llvm \
 clang \
 lld \
"

URI_python3-lldb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-lldb-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=python3-lldb;unpack=0"
SRC_URI += "${URI_python3-lldb}"
SRC_URI[python3-lldb.sha256sum] = "4b345617a85e33af3e4eec7ad465fd2ed6d41a50ee32fa8ebea7239bc224d770"
RDEPENDS:python3-lldb = " \
 python3 \
 lldb \
"

URI_clang-tools-extra-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/clang-tools-extra-devel-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=clang-tools-extra-devel;unpack=0"
SRC_URI += "${URI_clang-tools-extra-devel}"
SRC_URI[clang-tools-extra-devel.sha256sum] = "4e3b4403939c6cdd6c84af915818494992f5fa13544e0b10e9bc61c05d6f99ee"
RDEPENDS:clang-tools-extra-devel = " \
 clang-tools-extra \
"

URI_llvm-cmake-utils = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/llvm-cmake-utils-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=llvm-cmake-utils;unpack=0"
SRC_URI += "${URI_llvm-cmake-utils}"
SRC_URI[llvm-cmake-utils.sha256sum] = "63e011da73c0c17c590a140143bdaca8cc1c0d41730a232535c9ba30cb6e7cb7"
RDEPENDS:llvm-cmake-utils = ""

URI_python3-clang = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-clang-19.1.7-2.el10.alma.1.x86_64_v2.rpm;name=python3-clang;unpack=0"
SRC_URI += "${URI_python3-clang}"
SRC_URI[python3-clang.sha256sum] = "84eee6b277a83580e7fc6e8050b6ef4ab034ae99cef0723c4a7ba74407616459"
RDEPENDS:python3-clang = " \
 python3 \
 clang-devel \
"

URI_python3-lit = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-lit-19.1.7-2.el10.alma.1.noarch.rpm;name=python3-lit;unpack=0"
SRC_URI += "${URI_python3-lit}"
SRC_URI[python3-lit.sha256sum] = "737451bf511d12cfb254731ff7832e536608a534748c85ec14f4046b20ccd6b3"
RDEPENDS:python3-lit = " \
 python3 \
 python3-setuptools \
"
