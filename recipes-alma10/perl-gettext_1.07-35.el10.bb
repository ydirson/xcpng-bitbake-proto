# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-gettext"
PE = "0"
PV = "1.07"
PR = "35.el10"
PACKAGES = "perl-Locale-gettext perl-Locale-gettext-tests"
PROVIDES = "rpm/perl-Locale-gettext rpm/perl-Locale-gettext-tests"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-gettext-1.07-35.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02d00be695ef59ca3a935470765bf7017f502961338201e576c4657934f450bc"

URI_perl-Locale-gettext = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Locale-gettext-1.07-35.el10.x86_64_v2.rpm;name=perl-Locale-gettext;unpack=0"
SRC_URI += "${URI_perl-Locale-gettext}"
SRC_URI[perl-Locale-gettext.sha256sum] = "9373404b785d011ded230d1c0207520b0c617affd7c884d18968b3540f66b84a"
RDEPENDS:perl-Locale-gettext = " \
 perl-libs \
 perl-Carp \
 perl-POSIX \
 perl-DynaLoader \
 glibc \
 perl-Exporter \
"

URI_perl-Locale-gettext-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Locale-gettext-tests-1.07-35.el10.x86_64_v2.rpm;name=perl-Locale-gettext-tests;unpack=0"
SRC_URI += "${URI_perl-Locale-gettext-tests}"
SRC_URI[perl-Locale-gettext-tests.sha256sum] = "f3eab927462726c9fb122da2a0d029c93f907350b7460eb71522f7ed47dc253d"
RDEPENDS:perl-Locale-gettext-tests = " \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 perl-Locale-gettext \
 bash \
 perl-interpreter \
"
