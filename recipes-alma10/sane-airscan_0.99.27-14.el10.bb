# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sane-airscan"
PE = "0"
PV = "0.99.27"
PR = "14.el10"
PACKAGES = "libsane-airscan sane-airscan"
PROVIDES = "rpm/libsane-airscan rpm/sane-airscan"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/sane-airscan-0.99.27-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "302a5892faa117f64e81ff230e68548e90227e790f281e3089587b630e31429d"

URI_libsane-airscan = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libsane-airscan-0.99.27-14.el10.x86_64_v2.rpm;name=libsane-airscan;unpack=0"
SRC_URI += "${URI_libsane-airscan}"
SRC_URI[libsane-airscan.sha256sum] = "32af6e7bfe4e58924415a7abcbe3e5b387da0afda003f3ce6be3a1f1df08154e"
RDEPENDS:libsane-airscan = " \
 gnutls \
 libpng \
 libxml2 \
 avahi-libs \
 glibc \
 libjpeg-turbo \
"

URI_sane-airscan = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/sane-airscan-0.99.27-14.el10.x86_64_v2.rpm;name=sane-airscan;unpack=0"
SRC_URI += "${URI_sane-airscan}"
SRC_URI[sane-airscan.sha256sum] = "ec21f50f209eedc1d01d73ed96729d6b09cbbe7a1f19be4687d91dbf1802e7b5"
RDEPENDS:sane-airscan = " \
 gnutls \
 libsane-airscan \
 libxml2 \
 avahi-libs \
 glibc \
"
