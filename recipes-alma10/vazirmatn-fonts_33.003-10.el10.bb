# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "vazirmatn-fonts"
PE = "0"
PV = "33.003"
PR = "10.el10"
PACKAGES = "vazirmatn-vf-fonts vazirmatn-fonts vazirmatn-fonts-all vazirmatn-nl-fonts vazirmatn-nl-vf-fonts vazirmatn-rd-fonts vazirmatn-rd-nl-fonts vazirmatn-rd-nl-vf-fonts vazirmatn-rd-ui-fonts vazirmatn-rd-ui-nl-fonts vazirmatn-rd-vf-fonts vazirmatn-ui-fonts vazirmatn-ui-nl-fonts"
PROVIDES = "rpm/vazirmatn-vf-fonts rpm/vazirmatn-fonts rpm/vazirmatn-fonts-all rpm/vazirmatn-nl-fonts rpm/vazirmatn-nl-vf-fonts rpm/vazirmatn-rd-fonts rpm/vazirmatn-rd-nl-fonts rpm/vazirmatn-rd-nl-vf-fonts rpm/vazirmatn-rd-ui-fonts rpm/vazirmatn-rd-ui-nl-fonts rpm/vazirmatn-rd-vf-fonts rpm/vazirmatn-ui-fonts rpm/vazirmatn-ui-nl-fonts"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/vazirmatn-fonts-33.003-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d590a64e07ede8db3e7d50aca14c28aeee1107abfaa6d448612a945c39982e70"

URI_vazirmatn-vf-fonts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/vazirmatn-vf-fonts-33.003-10.el10.noarch.rpm;name=vazirmatn-vf-fonts;unpack=0"
SRC_URI += "${URI_vazirmatn-vf-fonts}"
SRC_URI[vazirmatn-vf-fonts.sha256sum] = "18a7d504917056f506f7d8d70710c9989c53d72bcc638e029d722da522460021"
RDEPENDS:vazirmatn-vf-fonts = " \
 fonts-filesystem \
"

URI_vazirmatn-fonts = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/vazirmatn-fonts-33.003-10.el10.noarch.rpm;name=vazirmatn-fonts;unpack=0"
SRC_URI += "${URI_vazirmatn-fonts}"
SRC_URI[vazirmatn-fonts.sha256sum] = "63774f0117d318c158a2ef3bd7f52ec71ad0018577002f4726cb65c6393e884a"
RDEPENDS:vazirmatn-fonts = " \
 fonts-filesystem \
"

URI_vazirmatn-fonts-all = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/vazirmatn-fonts-all-33.003-10.el10.noarch.rpm;name=vazirmatn-fonts-all;unpack=0"
SRC_URI += "${URI_vazirmatn-fonts-all}"
SRC_URI[vazirmatn-fonts-all.sha256sum] = "468ee6c96c19b3f87e2fb163655a96fa9ef62cf77f5b6961707201e208be5de4"
RDEPENDS:vazirmatn-fonts-all = " \
 vazirmatn-vf-fonts \
 vazirmatn-fonts \
 vazirmatn-nl-fonts \
 vazirmatn-nl-vf-fonts \
 vazirmatn-rd-fonts \
 vazirmatn-rd-nl-fonts \
 vazirmatn-rd-nl-vf-fonts \
 vazirmatn-rd-ui-fonts \
 vazirmatn-rd-ui-nl-fonts \
 vazirmatn-rd-vf-fonts \
 vazirmatn-ui-fonts \
 vazirmatn-ui-nl-fonts \
"

URI_vazirmatn-nl-fonts = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/vazirmatn-nl-fonts-33.003-10.el10.noarch.rpm;name=vazirmatn-nl-fonts;unpack=0"
SRC_URI += "${URI_vazirmatn-nl-fonts}"
SRC_URI[vazirmatn-nl-fonts.sha256sum] = "ce24ee75d887ce09893a8f0be5c9e0b01169bd23a65d2d5b3d8686a1acbce318"
RDEPENDS:vazirmatn-nl-fonts = " \
 fonts-filesystem \
"

URI_vazirmatn-nl-vf-fonts = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/vazirmatn-nl-vf-fonts-33.003-10.el10.noarch.rpm;name=vazirmatn-nl-vf-fonts;unpack=0"
SRC_URI += "${URI_vazirmatn-nl-vf-fonts}"
SRC_URI[vazirmatn-nl-vf-fonts.sha256sum] = "e85052442bcbb051e9b3225afbd99b29ce396f6d7db1069ebff1a763ecf0a75a"
RDEPENDS:vazirmatn-nl-vf-fonts = " \
 fonts-filesystem \
"

URI_vazirmatn-rd-fonts = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/vazirmatn-rd-fonts-33.003-10.el10.noarch.rpm;name=vazirmatn-rd-fonts;unpack=0"
SRC_URI += "${URI_vazirmatn-rd-fonts}"
SRC_URI[vazirmatn-rd-fonts.sha256sum] = "d5c51948f9ccaebd6f6af8b12b3ca22c984cef485ab2f0868860432e1516e204"
RDEPENDS:vazirmatn-rd-fonts = " \
 fonts-filesystem \
"

URI_vazirmatn-rd-nl-fonts = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/vazirmatn-rd-nl-fonts-33.003-10.el10.noarch.rpm;name=vazirmatn-rd-nl-fonts;unpack=0"
SRC_URI += "${URI_vazirmatn-rd-nl-fonts}"
SRC_URI[vazirmatn-rd-nl-fonts.sha256sum] = "9b881d762e1000e77627a184f9d6fdd948b6897fa19259fc6fb456b08bb6dcbd"
RDEPENDS:vazirmatn-rd-nl-fonts = " \
 fonts-filesystem \
"

URI_vazirmatn-rd-nl-vf-fonts = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/vazirmatn-rd-nl-vf-fonts-33.003-10.el10.noarch.rpm;name=vazirmatn-rd-nl-vf-fonts;unpack=0"
SRC_URI += "${URI_vazirmatn-rd-nl-vf-fonts}"
SRC_URI[vazirmatn-rd-nl-vf-fonts.sha256sum] = "30bc9f440f6064b50d2ff3f700a5b226f6f141c90d84fcad9ac98d53b1e626fc"
RDEPENDS:vazirmatn-rd-nl-vf-fonts = " \
 fonts-filesystem \
"

URI_vazirmatn-rd-ui-fonts = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/vazirmatn-rd-ui-fonts-33.003-10.el10.noarch.rpm;name=vazirmatn-rd-ui-fonts;unpack=0"
SRC_URI += "${URI_vazirmatn-rd-ui-fonts}"
SRC_URI[vazirmatn-rd-ui-fonts.sha256sum] = "3011f448481df64c984542a5031dbe64afb62db3c44ca1c50a13ccb8364f05d0"
RDEPENDS:vazirmatn-rd-ui-fonts = " \
 fonts-filesystem \
"

URI_vazirmatn-rd-ui-nl-fonts = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/vazirmatn-rd-ui-nl-fonts-33.003-10.el10.noarch.rpm;name=vazirmatn-rd-ui-nl-fonts;unpack=0"
SRC_URI += "${URI_vazirmatn-rd-ui-nl-fonts}"
SRC_URI[vazirmatn-rd-ui-nl-fonts.sha256sum] = "63df4096b77c3b76aa330945205e66dea13c4e41dfe941c7a30399f03a058053"
RDEPENDS:vazirmatn-rd-ui-nl-fonts = " \
 fonts-filesystem \
"

URI_vazirmatn-rd-vf-fonts = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/vazirmatn-rd-vf-fonts-33.003-10.el10.noarch.rpm;name=vazirmatn-rd-vf-fonts;unpack=0"
SRC_URI += "${URI_vazirmatn-rd-vf-fonts}"
SRC_URI[vazirmatn-rd-vf-fonts.sha256sum] = "5f3931a60e610248e4ac2581ff1eca7b5563213aa60c3e7422d656fb4d48e07a"
RDEPENDS:vazirmatn-rd-vf-fonts = " \
 fonts-filesystem \
"

URI_vazirmatn-ui-fonts = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/vazirmatn-ui-fonts-33.003-10.el10.noarch.rpm;name=vazirmatn-ui-fonts;unpack=0"
SRC_URI += "${URI_vazirmatn-ui-fonts}"
SRC_URI[vazirmatn-ui-fonts.sha256sum] = "6930a75754818f4b953ccd7a67908247c6673198778d419c2911bf6e930d14b5"
RDEPENDS:vazirmatn-ui-fonts = " \
 fonts-filesystem \
"

URI_vazirmatn-ui-nl-fonts = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/vazirmatn-ui-nl-fonts-33.003-10.el10.noarch.rpm;name=vazirmatn-ui-nl-fonts;unpack=0"
SRC_URI += "${URI_vazirmatn-ui-nl-fonts}"
SRC_URI[vazirmatn-ui-nl-fonts.sha256sum] = "652d8a0e21a90395ca1b26c437eff3460d7035b3434c96bbdfbe8dd533bd5d2a"
RDEPENDS:vazirmatn-ui-nl-fonts = " \
 fonts-filesystem \
"
