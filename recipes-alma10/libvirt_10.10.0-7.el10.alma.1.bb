# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libvirt"
PE = "0"
PV = "10.10.0"
PR = "7.el10.alma.1"
PACKAGES = "libvirt libvirt-client libvirt-client-qemu libvirt-daemon libvirt-daemon-common libvirt-daemon-config-network libvirt-daemon-config-nwfilter libvirt-daemon-driver-interface libvirt-daemon-driver-network libvirt-daemon-driver-nodedev libvirt-daemon-driver-nwfilter libvirt-daemon-driver-qemu libvirt-daemon-driver-secret libvirt-daemon-driver-storage libvirt-daemon-driver-storage-core libvirt-daemon-driver-storage-disk libvirt-daemon-driver-storage-iscsi libvirt-daemon-driver-storage-logical libvirt-daemon-driver-storage-mpath libvirt-daemon-driver-storage-rbd libvirt-daemon-driver-storage-scsi libvirt-daemon-kvm libvirt-daemon-lock libvirt-daemon-log libvirt-daemon-plugin-lockd libvirt-daemon-proxy libvirt-libs libvirt-nss libvirt-ssh-proxy libvirt-daemon-plugin-sanlock libvirt-devel libvirt-docs libvirt-wireshark"
PROVIDES = "rpm/libvirt rpm/libvirt-client rpm/libvirt-client-qemu rpm/libvirt-daemon rpm/libvirt-daemon-common rpm/libvirt-daemon-config-network rpm/libvirt-daemon-config-nwfilter rpm/libvirt-daemon-driver-interface rpm/libvirt-daemon-driver-network rpm/libvirt-daemon-driver-nodedev rpm/libvirt-daemon-driver-nwfilter rpm/libvirt-daemon-driver-qemu rpm/libvirt-daemon-driver-secret rpm/libvirt-daemon-driver-storage rpm/libvirt-daemon-driver-storage-core rpm/libvirt-daemon-driver-storage-disk rpm/libvirt-daemon-driver-storage-iscsi rpm/libvirt-daemon-driver-storage-logical rpm/libvirt-daemon-driver-storage-mpath rpm/libvirt-daemon-driver-storage-rbd rpm/libvirt-daemon-driver-storage-scsi rpm/libvirt-daemon-kvm rpm/libvirt-daemon-lock rpm/libvirt-daemon-log rpm/libvirt-daemon-plugin-lockd rpm/libvirt-daemon-proxy rpm/libvirt-libs rpm/libvirt-nss rpm/libvirt-ssh-proxy rpm/libvirt-daemon-plugin-sanlock rpm/libvirt-devel rpm/libvirt-docs rpm/libvirt-wireshark"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libvirt-10.10.0-7.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cee8d2ae14dd48bdcb84710ac520aac889c14874bca72ccccdc4837a208c8c86"

URI_libvirt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt;unpack=0"
SRC_URI += "${URI_libvirt}"
SRC_URI[libvirt.sha256sum] = "e6b04baecbec668a88c13b0b09f5ebf7106a3fda113ec731e6122b288a692f8a"
RDEPENDS:libvirt = " \
 libvirt-client-qemu \
 libvirt-daemon \
 libvirt-daemon-config-network \
 libvirt-daemon-config-nwfilter \
 libvirt-daemon-driver-interface \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-nwfilter \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage \
 libvirt-libs \
 libvirt-client \
"

URI_libvirt-client = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-client-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-client;unpack=0"
SRC_URI += "${URI_libvirt-client}"
SRC_URI[libvirt-client.sha256sum] = "9c8dc4a0178b107c41464aa6887a3b754b48d77b14f24c0786e4da5873f7da45"
RDEPENDS:libvirt-client = " \
 gnutls \
 libgcc \
 readline \
 libxml2 \
 bash \
 glib2 \
 glibc \
 libvirt-libs \
"

URI_libvirt-client-qemu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-client-qemu-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-client-qemu;unpack=0"
SRC_URI += "${URI_libvirt-client-qemu}"
SRC_URI[libvirt-client-qemu.sha256sum] = "bf54e2a8bceb83bf803b4850f1dd533dba861cce3a8c3053eb3d221847fc80ac"
RDEPENDS:libvirt-client-qemu = " \
 python3 \
 python3-cryptography \
 python3-libvirt \
 python3-lxml \
 libvirt-libs \
"

URI_libvirt-daemon = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-daemon-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon;unpack=0"
SRC_URI += "${URI_libvirt-daemon}"
SRC_URI[libvirt-daemon.sha256sum] = "29b29148bf550456632afb43d3627d314d18f497e6c5dfbd9203343e59990f3d"
RDEPENDS:libvirt-daemon = " \
 libvirt-daemon-common \
 libgcc \
 bash \
 glib2 \
 libvirt-daemon-lock \
 libvirt-daemon-log \
 glibc \
 libtirpc \
 libvirt-libs \
 libvirt-daemon-plugin-lockd \
 libvirt-daemon-proxy \
"

URI_libvirt-daemon-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-daemon-common-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon-common;unpack=0"
SRC_URI += "${URI_libvirt-daemon-common}"
SRC_URI[libvirt-daemon-common.sha256sum] = "ddb856a1ba11a2dac61f0f63933041e0e1c8aad1b368d81bf277f3b0b5917d31"
RDEPENDS:libvirt-daemon-common = " \
 libacl \
 shadow-utils \
 systemd \
 iproute \
 iproute-tc \
 libgcc \
 readline \
 dmidecode \
 gettext \
 polkit \
 bash \
 glib2 \
 dbus \
 glibc \
 libvirt-libs \
"

URI_libvirt-daemon-config-network = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-daemon-config-network-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon-config-network;unpack=0"
SRC_URI += "${URI_libvirt-daemon-config-network}"
SRC_URI[libvirt-daemon-config-network.sha256sum] = "21d3bc08c4e871070a4d18589e4d15d863e71766100f978753e066a898e5f996"
RDEPENDS:libvirt-daemon-config-network = " \
 bash \
 libvirt-daemon-driver-network \
"

URI_libvirt-daemon-config-nwfilter = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-daemon-config-nwfilter-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon-config-nwfilter;unpack=0"
SRC_URI += "${URI_libvirt-daemon-config-nwfilter}"
SRC_URI[libvirt-daemon-config-nwfilter.sha256sum] = "6070d4ba5796a9e1b11d04b2981a1e7637caaee3b9fdd184d143babb04967572"
RDEPENDS:libvirt-daemon-config-nwfilter = " \
 libvirt-daemon-driver-nwfilter \
 bash \
"

URI_libvirt-daemon-driver-interface = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-interface-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon-driver-interface;unpack=0"
SRC_URI += "${URI_libvirt-daemon-driver-interface}"
SRC_URI[libvirt-daemon-driver-interface.sha256sum] = "e0a82d2d181acd49fc8e8307e8d0fbe064f6672e0735b5a3b0a6b4f6b1ee9101"
RDEPENDS:libvirt-daemon-driver-interface = " \
 libvirt-daemon-common \
 systemd-libs \
 libgcc \
 bash \
 glib2 \
 glibc \
 libtirpc \
 libvirt-libs \
"

URI_libvirt-daemon-driver-network = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-network-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon-driver-network;unpack=0"
SRC_URI += "${URI_libvirt-daemon-driver-network}"
SRC_URI[libvirt-daemon-driver-network.sha256sum] = "2d7c58979a5a14dbf70d3d576b9f2c9aabca84e25cd0124755b4d8f7794d0828"
RDEPENDS:libvirt-daemon-driver-network = " \
 libvirt-daemon-common \
 nftables \
 libgcc \
 dnsmasq \
 bash \
 glib2 \
 glibc \
 libtirpc \
 libvirt-libs \
"

URI_libvirt-daemon-driver-nodedev = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-nodedev-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon-driver-nodedev;unpack=0"
SRC_URI += "${URI_libvirt-daemon-driver-nodedev}"
SRC_URI[libvirt-daemon-driver-nodedev.sha256sum] = "6586087446776324d73c15e1c534a3d7a911f6317cd8e1860135f9011ebe9ba1"
RDEPENDS:libvirt-daemon-driver-nodedev = " \
 libpciaccess \
 libvirt-daemon-common \
 systemd \
 systemd-libs \
 kmod \
 libgcc \
 bash \
 glib2 \
 glibc \
 libtirpc \
 libvirt-libs \
 mdevctl \
"

URI_libvirt-daemon-driver-nwfilter = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-nwfilter-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon-driver-nwfilter;unpack=0"
SRC_URI += "${URI_libvirt-daemon-driver-nwfilter}"
SRC_URI[libvirt-daemon-driver-nwfilter.sha256sum] = "d3d755a566bf14abfbd75daed7049942ab1889af70033242d85494e6168eab2d"
RDEPENDS:libvirt-daemon-driver-nwfilter = " \
 libpcap \
 libvirt-daemon-common \
 libgcc \
 bash \
 glib2 \
 iptables-nft \
 glibc \
 libtirpc \
 libvirt-libs \
"

URI_libvirt-daemon-driver-qemu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-qemu-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon-driver-qemu;unpack=0"
SRC_URI += "${URI_libvirt-daemon-driver-qemu}"
SRC_URI[libvirt-daemon-driver-qemu.sha256sum] = "ac55cc1e3e4e0458e138058c15dd519c4ecf4cb78bde5f06558e97e6bb8a167b"
RDEPENDS:libvirt-daemon-driver-qemu = " \
 systemd-container \
 libnbd \
 libselinux \
 libvirt-daemon-common \
 numad \
 qemu-img \
 libvirt-daemon-log \
 libtirpc \
 libvirt-libs \
 xz \
 gnutls \
 zstd \
 libgcc \
 libxml2 \
 bash \
 bzip2 \
 gzip \
 lzop \
 glib2 \
 glibc \
 swtpm-tools \
"

URI_libvirt-daemon-driver-secret = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-secret-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon-driver-secret;unpack=0"
SRC_URI += "${URI_libvirt-daemon-driver-secret}"
SRC_URI[libvirt-daemon-driver-secret.sha256sum] = "a10211def190687f6d250244516dc0f59bd2dafb12f16acd401601cf6f223243"
RDEPENDS:libvirt-daemon-driver-secret = " \
 libvirt-daemon-common \
 libgcc \
 bash \
 glib2 \
 glibc \
 libtirpc \
 libvirt-libs \
"

URI_libvirt-daemon-driver-storage = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon-driver-storage;unpack=0"
SRC_URI += "${URI_libvirt-daemon-driver-storage}"
SRC_URI[libvirt-daemon-driver-storage.sha256sum] = "5b2571639d09e7f8be68fb87899b6cad668b0718266a25515b526091fe959e4b"
RDEPENDS:libvirt-daemon-driver-storage = " \
 libvirt-daemon-driver-storage-core \
 libvirt-daemon-driver-storage-disk \
 libvirt-daemon-driver-storage-iscsi \
 libvirt-daemon-driver-storage-logical \
 libvirt-daemon-driver-storage-mpath \
 libvirt-daemon-driver-storage-rbd \
 libvirt-daemon-driver-storage-scsi \
"

URI_libvirt-daemon-driver-storage-core = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-core-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon-driver-storage-core;unpack=0"
SRC_URI += "${URI_libvirt-daemon-driver-storage-core}"
SRC_URI[libvirt-daemon-driver-storage-core.sha256sum] = "1f037d12ca2bba51d398e1581420dddd08dd6256c5b8770792eb3334a2549884"
RDEPENDS:libvirt-daemon-driver-storage-core = " \
 libvirt-daemon-common \
 util-linux \
 scrub \
 libgcc \
 libblkid \
 libxml2 \
 qemu-img \
 parted \
 libtirpc \
 bash \
 glib2 \
 glibc \
 libselinux \
 libvirt-libs \
"

URI_libvirt-daemon-driver-storage-disk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-disk-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon-driver-storage-disk;unpack=0"
SRC_URI += "${URI_libvirt-daemon-driver-storage-disk}"
SRC_URI[libvirt-daemon-driver-storage-disk.sha256sum] = "a95cb0f27f269f60b96145042e7793d480ff28ee71d2b82ae5ec8fba12024590"
RDEPENDS:libvirt-daemon-driver-storage-disk = " \
 device-mapper \
 libgcc \
 libvirt-daemon-driver-storage-core \
 parted \
 glib2 \
 glibc \
 libvirt-libs \
"

URI_libvirt-daemon-driver-storage-iscsi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-iscsi-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon-driver-storage-iscsi;unpack=0"
SRC_URI += "${URI_libvirt-daemon-driver-storage-iscsi}"
SRC_URI[libvirt-daemon-driver-storage-iscsi.sha256sum] = "edc222abd2fd76e1e4d393d2e84e4c41e62a4499797cb50fded95ae73f90c9e9"
RDEPENDS:libvirt-daemon-driver-storage-iscsi = " \
 libgcc \
 libvirt-daemon-driver-storage-core \
 iscsi-initiator-utils \
 glib2 \
 glibc \
 libvirt-libs \
"

URI_libvirt-daemon-driver-storage-logical = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-logical-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon-driver-storage-logical;unpack=0"
SRC_URI += "${URI_libvirt-daemon-driver-storage-logical}"
SRC_URI[libvirt-daemon-driver-storage-logical.sha256sum] = "5e0359801342bdde566b30f51ef9c07ed52c828e1a7fad71bab045b735575c55"
RDEPENDS:libvirt-daemon-driver-storage-logical = " \
 lvm2 \
 libgcc \
 libvirt-daemon-driver-storage-core \
 glib2 \
 glibc \
 libvirt-libs \
"

URI_libvirt-daemon-driver-storage-mpath = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-mpath-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon-driver-storage-mpath;unpack=0"
SRC_URI += "${URI_libvirt-daemon-driver-storage-mpath}"
SRC_URI[libvirt-daemon-driver-storage-mpath.sha256sum] = "a86e0cdf24b49399a498d3bb3b2e83b9bf0ec6c93e9a0f81756aebaf80569ab9"
RDEPENDS:libvirt-daemon-driver-storage-mpath = " \
 device-mapper \
 device-mapper-libs \
 libgcc \
 libvirt-daemon-driver-storage-core \
 glib2 \
 glibc \
 libvirt-libs \
"

URI_libvirt-daemon-driver-storage-rbd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-rbd-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon-driver-storage-rbd;unpack=0"
SRC_URI += "${URI_libvirt-daemon-driver-storage-rbd}"
SRC_URI[libvirt-daemon-driver-storage-rbd.sha256sum] = "bde6b37be90d4cbc5a44f8f6d4032a747ea9de026840208fdd958122d9492151"
RDEPENDS:libvirt-daemon-driver-storage-rbd = " \
 librados2 \
 librbd1 \
 libgcc \
 libvirt-daemon-driver-storage-core \
 glib2 \
 glibc \
 libvirt-libs \
"

URI_libvirt-daemon-driver-storage-scsi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-scsi-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon-driver-storage-scsi;unpack=0"
SRC_URI += "${URI_libvirt-daemon-driver-storage-scsi}"
SRC_URI[libvirt-daemon-driver-storage-scsi.sha256sum] = "3c03f921ea91ec1bc6c6592c38b4443617c70805cd664e168b087a51597f9297"
RDEPENDS:libvirt-daemon-driver-storage-scsi = " \
 libgcc \
 libvirt-daemon-driver-storage-core \
 glib2 \
 glibc \
 libvirt-libs \
"

URI_libvirt-daemon-kvm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-daemon-kvm-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon-kvm;unpack=0"
SRC_URI += "${URI_libvirt-daemon-kvm}"
SRC_URI[libvirt-daemon-kvm.sha256sum] = "fb499575b36a458427f3427e27b9d7407a9d50191108fc613f8d78e56f9bc930"
RDEPENDS:libvirt-daemon-kvm = " \
 libvirt-daemon-common \
 libvirt-daemon-driver-interface \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-nwfilter \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage \
 qemu-kvm \
 libvirt-daemon-lock \
 libvirt-daemon-log \
 libvirt-daemon-plugin-lockd \
 libvirt-daemon-proxy \
 libvirt-ssh-proxy \
"

URI_libvirt-daemon-lock = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-daemon-lock-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon-lock;unpack=0"
SRC_URI += "${URI_libvirt-daemon-lock}"
SRC_URI[libvirt-daemon-lock.sha256sum] = "4be375408c8b4cc37edb947f5e16b86965c07a3f82ee158ce2c03f0bbe4b6419"
RDEPENDS:libvirt-daemon-lock = " \
 libgcc \
 bash \
 glib2 \
 glibc \
 libtirpc \
 libvirt-libs \
"

URI_libvirt-daemon-log = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-daemon-log-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon-log;unpack=0"
SRC_URI += "${URI_libvirt-daemon-log}"
SRC_URI[libvirt-daemon-log.sha256sum] = "c583883a96127945b9e5dc2df450594f53bd1654083cdf2c19f662797da4458e"
RDEPENDS:libvirt-daemon-log = " \
 libgcc \
 bash \
 glib2 \
 glibc \
 libtirpc \
 libvirt-libs \
"

URI_libvirt-daemon-plugin-lockd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-daemon-plugin-lockd-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon-plugin-lockd;unpack=0"
SRC_URI += "${URI_libvirt-daemon-plugin-lockd}"
SRC_URI[libvirt-daemon-plugin-lockd.sha256sum] = "7a4350b3f9e1d89c091145c2d330d88e42563face465ed2354e5781b08abdbad"
RDEPENDS:libvirt-daemon-plugin-lockd = " \
 libgcc \
 libvirt-daemon-lock \
 glib2 \
 glibc \
 libtirpc \
 libvirt-libs \
"

URI_libvirt-daemon-proxy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-daemon-proxy-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon-proxy;unpack=0"
SRC_URI += "${URI_libvirt-daemon-proxy}"
SRC_URI[libvirt-daemon-proxy.sha256sum] = "5528098ab6b126f6f89ffcc4ad2354ad6592466bd392b6d1d4ded1cb1957d01b"
RDEPENDS:libvirt-daemon-proxy = " \
 libgcc \
 bash \
 glib2 \
 glibc \
 libtirpc \
 libvirt-libs \
"

URI_libvirt-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-libs-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-libs;unpack=0"
SRC_URI += "${URI_libvirt-libs}"
SRC_URI[libvirt-libs.sha256sum] = "08233a7a1035d786ad6baec9c8543d35ba912a96344b84d6df0a9d89adee5512"
RDEPENDS:libvirt-libs = " \
 libacl \
 gnutls \
 numactl-libs \
 libssh \
 audit-libs \
 libgcc \
 json-c \
 libxml2 \
 libnl3 \
 libcap-ng \
 cyrus-sasl-gssapi \
 cyrus-sasl-lib \
 libtirpc \
 glib2 \
 libcurl \
 glibc \
 libselinux \
"

URI_libvirt-nss = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-nss-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-nss;unpack=0"
SRC_URI += "${URI_libvirt-nss}"
SRC_URI[libvirt-nss.sha256sum] = "9bdc116b1e573535cc2b90ddca434eba8159c7b5a4338e890348267b1afc11b4"
RDEPENDS:libvirt-nss = " \
 glibc \
 json-c \
 libvirt-daemon-driver-network \
"

URI_libvirt-ssh-proxy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-ssh-proxy-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-ssh-proxy;unpack=0"
SRC_URI += "${URI_libvirt-ssh-proxy}"
SRC_URI[libvirt-ssh-proxy.sha256sum] = "fba039e0f5abee51f2414e9e9520108555cb199f584a3de2a9a5e2cd45790ba7"
RDEPENDS:libvirt-ssh-proxy = " \
 libgcc \
 libxml2 \
 glib2 \
 glibc \
 libvirt-libs \
"

URI_libvirt-daemon-plugin-sanlock = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libvirt-daemon-plugin-sanlock-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-daemon-plugin-sanlock;unpack=0"
SRC_URI += "${URI_libvirt-daemon-plugin-sanlock}"
SRC_URI[libvirt-daemon-plugin-sanlock.sha256sum] = "289972619594c71bf96cf6af981be9a15d654bd8757fc335b0d8d0b5ce639118"
RDEPENDS:libvirt-daemon-plugin-sanlock = " \
 augeas \
 sanlock-lib \
 sanlock \
 libgcc \
 bash \
 glib2 \
 glibc \
 libvirt-libs \
"

URI_libvirt-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libvirt-devel-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-devel;unpack=0"
SRC_URI += "${URI_libvirt-devel}"
SRC_URI[libvirt-devel.sha256sum] = "9bb45cf120e0de459eb748a5a373ea1d3e206c13952208f5408df728a0027573"
RDEPENDS:libvirt-devel = " \
 libvirt-devel \
 libvirt-libs \
 pkgconf-pkg-config \
"

URI_libvirt-docs = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libvirt-docs-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-docs;unpack=0"
SRC_URI += "${URI_libvirt-docs}"
SRC_URI[libvirt-docs.sha256sum] = "9899fdf47da55f7dc9d8f86fcf8dd32e050070140a1176b3488b44d0292da644"
RDEPENDS:libvirt-docs = ""

URI_libvirt-wireshark = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libvirt-wireshark-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=libvirt-wireshark;unpack=0"
SRC_URI += "${URI_libvirt-wireshark}"
SRC_URI[libvirt-wireshark.sha256sum] = "45d8abc47ab4f7f82238a318a5785f0de82b5a83f9ee3d7f52e4feeb901b30b6"
RDEPENDS:libvirt-wireshark = " \
 wireshark \
 wireshark-cli \
 glib2 \
 glibc \
 libtirpc \
 libvirt-libs \
"
