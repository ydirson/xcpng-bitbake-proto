# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "m17n-lib"
PE = "0"
PV = "1.8.4"
PR = "7.el10"
PACKAGES = "m17n-lib m17n-lib-devel m17n-lib-tools"
PROVIDES = "rpm/m17n-lib rpm/m17n-lib-devel rpm/m17n-lib-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/m17n-lib-1.8.4-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21ba4d9e07ec883c9081b2e8fcf47d3092cc78b6e603b417b6fdb4a32f3f0c19"

URI_m17n-lib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/m17n-lib-1.8.4-7.el10.x86_64_v2.rpm;name=m17n-lib;unpack=0"
SRC_URI += "${URI_m17n-lib}"
SRC_URI[m17n-lib.sha256sum] = "f2ad468edcb77315a7a0ed8f04c694af09c19fa4c65260432528cdad396c76a1"
RDEPENDS:m17n-lib = " \
 zlib-ng-compat \
 libxml2 \
 glibc \
 m17n-db \
 libthai \
 xz-libs \
"

URI_m17n-lib-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/m17n-lib-devel-1.8.4-7.el10.x86_64_v2.rpm;name=m17n-lib-devel;unpack=0"
SRC_URI += "${URI_m17n-lib-devel}"
SRC_URI[m17n-lib-devel.sha256sum] = "622786c501559183e04097ff57186ad9ae7be25b434c959a35d53d74e6d29637"
RDEPENDS:m17n-lib-devel = " \
 m17n-lib-tools \
 pkgconf-pkg-config \
 m17n-lib \
"

URI_m17n-lib-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/m17n-lib-tools-1.8.4-7.el10.x86_64_v2.rpm;name=m17n-lib-tools;unpack=0"
SRC_URI += "${URI_m17n-lib-tools}"
SRC_URI[m17n-lib-tools.sha256sum] = "552ad200100d8fa1cc6ef4669f5e740124c763a738791fdd96e4a6efa4ea3b89"
RDEPENDS:m17n-lib-tools = " \
 gd \
 zlib-ng-compat \
 freetype \
 libXft \
 libotf \
 fribidi \
 libICE \
 libxml2 \
 fontconfig \
 libSM \
 libX11 \
 libXt \
 libXaw \
 glibc \
 m17n-db-extras \
 libthai \
 xz-libs \
 m17n-lib \
"
