# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libmbim"
PE = "0"
PV = "1.30.0"
PR = "6.el10"
PACKAGES = "libmbim libmbim-utils libmbim-devel"
PROVIDES = "rpm/libmbim rpm/libmbim-utils rpm/libmbim-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libmbim-1.30.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9ae7c1eff34af2abfea0f5045b8834c7e70e6cd62508f3f4b73c4c2743cf5d3"

URI_libmbim = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libmbim-1.30.0-6.el10.x86_64_v2.rpm;name=libmbim;unpack=0"
SRC_URI += "${URI_libmbim}"
SRC_URI[libmbim.sha256sum] = "74f3aa55aeb6c95a7baadbab8f8151471cced4d3dd617c07cbd40a1dac7cb378"
RDEPENDS:libmbim = " \
 glibc \
 libgcc \
 glib2 \
"

URI_libmbim-utils = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libmbim-utils-1.30.0-6.el10.x86_64_v2.rpm;name=libmbim-utils;unpack=0"
SRC_URI += "${URI_libmbim-utils}"
SRC_URI[libmbim-utils.sha256sum] = "54ffe958296ded564fbb9effd55c27fdf55b6f280d73afcbc74b18c03894b98a"
RDEPENDS:libmbim-utils = " \
 libmbim \
 libgcc \
 bash \
 glib2 \
 glibc \
"

URI_libmbim-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libmbim-devel-1.30.0-6.el10.x86_64_v2.rpm;name=libmbim-devel;unpack=0"
SRC_URI += "${URI_libmbim-devel}"
SRC_URI[libmbim-devel.sha256sum] = "ac5894cea6bb2591e4d0cd9a382a84c62dcc61b2bf377f75ada6dc4287d213d4"
RDEPENDS:libmbim-devel = " \
 libmbim \
 glib2-devel \
 pkgconf-pkg-config \
"
