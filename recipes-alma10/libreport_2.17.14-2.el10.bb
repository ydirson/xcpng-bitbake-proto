# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libreport"
PE = "0"
PV = "2.17.14"
PR = "2.el10"
PACKAGES = "libreport libreport-anaconda libreport-centos libreport-cli libreport-devel libreport-filesystem libreport-gtk libreport-gtk-devel libreport-newt libreport-plugin-bugzilla libreport-plugin-kerneloops libreport-plugin-logger libreport-plugin-mailx libreport-plugin-mantisbt libreport-plugin-reportuploader libreport-plugin-systemd-journal libreport-plugin-ureport libreport-web libreport-web-devel python3-libreport"
PROVIDES = "rpm/libreport rpm/libreport-anaconda rpm/libreport-centos rpm/libreport-cli rpm/libreport-devel rpm/libreport-filesystem rpm/libreport-gtk rpm/libreport-gtk-devel rpm/libreport-newt rpm/libreport-plugin-bugzilla rpm/libreport-plugin-kerneloops rpm/libreport-plugin-logger rpm/libreport-plugin-mailx rpm/libreport-plugin-mantisbt rpm/libreport-plugin-reportuploader rpm/libreport-plugin-systemd-journal rpm/libreport-plugin-ureport rpm/libreport-web rpm/libreport-web-devel rpm/python3-libreport"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/libreport-2.17.14-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03e6e6e6c1c616859c383f0566541f9531c65b75f11439f83788c5ac8a4f5f8b"

URI_libreport = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libreport-2.17.14-2.el10.x86_64_v2.rpm;name=libreport;unpack=0"
SRC_URI += "${URI_libreport}"
SRC_URI[libreport.sha256sum] = "53be758263091e3e6a2621347d8621d1439d570a469f0ebf895cea76d316d82d"
RDEPENDS:libreport = " \
 systemd-libs \
 libarchive \
 augeas-libs \
 satyr \
 libgcc \
 json-c \
 glib2 \
 glibc \
 libreport-filesystem \
"

URI_libreport-anaconda = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libreport-anaconda-2.17.14-2.el10.x86_64_v2.rpm;name=libreport-anaconda;unpack=0"
SRC_URI += "${URI_libreport-anaconda}"
SRC_URI[libreport-anaconda.sha256sum] = "f06af05b133c20441e439fd4da7f5a3618162e83dec1e39b39d5f14e4bf69e7d"
RDEPENDS:libreport-anaconda = " \
 libreport \
 libreport-plugin-reportuploader \
"

URI_libreport-centos = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libreport-centos-2.17.14-2.el10.x86_64_v2.rpm;name=libreport-centos;unpack=0"
SRC_URI += "${URI_libreport-centos}"
SRC_URI[libreport-centos.sha256sum] = "c58ec58e922f8fe9faebaefc9124b5f204fc5935dacf41b75024d6fdfdbd5869"
RDEPENDS:libreport-centos = " \
 libreport \
 libreport-web \
 libreport-plugin-mantisbt \
"

URI_libreport-cli = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libreport-cli-2.17.14-2.el10.x86_64_v2.rpm;name=libreport-cli;unpack=0"
SRC_URI += "${URI_libreport-cli}"
SRC_URI[libreport-cli.sha256sum] = "444838c54d08063834baae369b7e6cf40fdbc91fd42e1b8d640cf16b1bea9c1b"
RDEPENDS:libreport-cli = " \
 glibc \
 libreport \
 libgcc \
 glib2 \
"

URI_libreport-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libreport-devel-2.17.14-2.el10.x86_64_v2.rpm;name=libreport-devel;unpack=0"
SRC_URI += "${URI_libreport-devel}"
SRC_URI[libreport-devel.sha256sum] = "63c50b8bdda3193d54e0ea3ca49f2ef739f5c92e25564cdb587e39b98e21a76f"
RDEPENDS:libreport-devel = " \
 libreport \
 glib2-devel \
 pkgconf-pkg-config \
"

URI_libreport-filesystem = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libreport-filesystem-2.17.14-2.el10.noarch.rpm;name=libreport-filesystem;unpack=0"
SRC_URI += "${URI_libreport-filesystem}"
SRC_URI[libreport-filesystem.sha256sum] = "8e72f93132a8f0789aa9b1b74babbbc701a1436c154937ccf006f7c04df95176"
RDEPENDS:libreport-filesystem = ""

URI_libreport-gtk = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libreport-gtk-2.17.14-2.el10.x86_64_v2.rpm;name=libreport-gtk;unpack=0"
SRC_URI += "${URI_libreport-gtk}"
SRC_URI[libreport-gtk.sha256sum] = "4c63cda0c07472b17f1977059d6c9f9e83304a5b405b389b43404efad666bcd5"
RDEPENDS:libreport-gtk = " \
 atk \
 systemd-libs \
 libarchive \
 cairo-gobject \
 augeas-libs \
 satyr \
 libreport-plugin-reportuploader \
 libgcc \
 json-c \
 harfbuzz \
 pango \
 gdk-pixbuf2 \
 cairo \
 glib2 \
 gtk3 \
 glibc \
 libreport \
"

URI_libreport-gtk-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libreport-gtk-devel-2.17.14-2.el10.x86_64_v2.rpm;name=libreport-gtk-devel;unpack=0"
SRC_URI += "${URI_libreport-gtk-devel}"
SRC_URI[libreport-gtk-devel.sha256sum] = "089685b5be96e840eebcb9b7ea605606edfe3f2c578620550c78000316e034f2"
RDEPENDS:libreport-gtk-devel = " \
 libreport-devel \
 pkgconf-pkg-config \
 libreport-gtk \
"

URI_libreport-newt = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libreport-newt-2.17.14-2.el10.x86_64_v2.rpm;name=libreport-newt;unpack=0"
SRC_URI += "${URI_libreport-newt}"
SRC_URI[libreport-newt.sha256sum] = "92909065aef83e4696a9465e57ca5aa199d21134dc5715ebeb708051e8240465"
RDEPENDS:libreport-newt = " \
 newt \
 libgcc \
 glib2 \
 glibc \
 libreport \
"

URI_libreport-plugin-bugzilla = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libreport-plugin-bugzilla-2.17.14-2.el10.x86_64_v2.rpm;name=libreport-plugin-bugzilla;unpack=0"
SRC_URI += "${URI_libreport-plugin-bugzilla}"
SRC_URI[libreport-plugin-bugzilla.sha256sum] = "1e3896f8f93538fbdd4452101cc9563fe87018e5d689d949e0055a63b7faae16"
RDEPENDS:libreport-plugin-bugzilla = " \
 python3 \
 xmlrpc-c \
 xmlrpc-c-client \
 libreport-web \
 libgcc \
 python3-libreport \
 glib2 \
 glibc \
 libreport \
"

URI_libreport-plugin-kerneloops = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libreport-plugin-kerneloops-2.17.14-2.el10.x86_64_v2.rpm;name=libreport-plugin-kerneloops;unpack=0"
SRC_URI += "${URI_libreport-plugin-kerneloops}"
SRC_URI[libreport-plugin-kerneloops.sha256sum] = "5dce5e1cc6663f9bbd16b44c60e3bfff9dc6cef362cd2964b9627a5b822381d6"
RDEPENDS:libreport-plugin-kerneloops = " \
 libreport-web \
 libgcc \
 curl \
 glib2 \
 libcurl \
 glibc \
 libreport \
"

URI_libreport-plugin-logger = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libreport-plugin-logger-2.17.14-2.el10.x86_64_v2.rpm;name=libreport-plugin-logger;unpack=0"
SRC_URI += "${URI_libreport-plugin-logger}"
SRC_URI[libreport-plugin-logger.sha256sum] = "c8ffbf2a0a1c10bbf5e6e07771a0a9e7891f285634970b6e510de6ad9424abb3"
RDEPENDS:libreport-plugin-logger = " \
 glibc \
 libreport \
 libgcc \
 glib2 \
"

URI_libreport-plugin-mailx = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libreport-plugin-mailx-2.17.14-2.el10.x86_64_v2.rpm;name=libreport-plugin-mailx;unpack=0"
SRC_URI += "${URI_libreport-plugin-mailx}"
SRC_URI[libreport-plugin-mailx.sha256sum] = "493139fd748d1c06901c0cb87f7e6912966257be625f0468f66721404e04d205"
RDEPENDS:libreport-plugin-mailx = " \
 libgcc \
 glib2 \
 glibc \
 libreport \
 s-nail \
"

URI_libreport-plugin-mantisbt = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libreport-plugin-mantisbt-2.17.14-2.el10.x86_64_v2.rpm;name=libreport-plugin-mantisbt;unpack=0"
SRC_URI += "${URI_libreport-plugin-mantisbt}"
SRC_URI[libreport-plugin-mantisbt.sha256sum] = "188bd06d4b38bac07c2891663d5b074849a76ddcc2cf877c9261ff7f21d697f9"
RDEPENDS:libreport-plugin-mantisbt = " \
 libreport-web \
 libgcc \
 libxml2 \
 glib2 \
 glibc \
 libreport \
"

URI_libreport-plugin-reportuploader = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libreport-plugin-reportuploader-2.17.14-2.el10.x86_64_v2.rpm;name=libreport-plugin-reportuploader;unpack=0"
SRC_URI += "${URI_libreport-plugin-reportuploader}"
SRC_URI[libreport-plugin-reportuploader.sha256sum] = "56cdd180ba467dd63e70901f8556ae246687d9ca589e65f251330a9df6518713"
RDEPENDS:libreport-plugin-reportuploader = " \
 libreport-web \
 libgcc \
 glib2 \
 glibc \
 libreport \
"

URI_libreport-plugin-systemd-journal = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libreport-plugin-systemd-journal-2.17.14-2.el10.x86_64_v2.rpm;name=libreport-plugin-systemd-journal;unpack=0"
SRC_URI += "${URI_libreport-plugin-systemd-journal}"
SRC_URI[libreport-plugin-systemd-journal.sha256sum] = "891443f20a4e657464d6e5bad3e596cf83950b6586d2956129c53af1e4a5ffac"
RDEPENDS:libreport-plugin-systemd-journal = " \
 systemd-libs \
 libgcc \
 glib2 \
 glibc \
 libreport \
"

URI_libreport-plugin-ureport = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libreport-plugin-ureport-2.17.14-2.el10.x86_64_v2.rpm;name=libreport-plugin-ureport;unpack=0"
SRC_URI += "${URI_libreport-plugin-ureport}"
SRC_URI[libreport-plugin-ureport.sha256sum] = "f0582671bf78288eb329553e2adc07146d6e655a3621953e647773b0218a438c"
RDEPENDS:libreport-plugin-ureport = " \
 libreport-web \
 libgcc \
 glib2 \
 glibc \
 libreport \
"

URI_libreport-web = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libreport-web-2.17.14-2.el10.x86_64_v2.rpm;name=libreport-web;unpack=0"
SRC_URI += "${URI_libreport-web}"
SRC_URI[libreport-web.sha256sum] = "0a82a7543889bcc2cd7a967cffdf83c925c214e8ddf603e73fb90e87457c96b7"
RDEPENDS:libreport-web = " \
 xmlrpc-c \
 systemd-libs \
 libarchive \
 xmlrpc-c-client \
 augeas-libs \
 satyr \
 libgcc \
 json-c \
 libxml2 \
 glib2 \
 libcurl \
 glibc \
 libreport \
"

URI_libreport-web-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libreport-web-devel-2.17.14-2.el10.x86_64_v2.rpm;name=libreport-web-devel;unpack=0"
SRC_URI += "${URI_libreport-web-devel}"
SRC_URI[libreport-web-devel.sha256sum] = "d04976c42fe9b83e34d65ad854c9a9b632897fed3859e7d23f2e346884677a6b"
RDEPENDS:libreport-web-devel = " \
 libxml2-devel \
 glib2-devel \
 xmlrpc-c-devel \
 libreport-web \
 satyr-devel \
 pkgconf-pkg-config \
 libcurl-devel \
 libreport-devel \
 json-c-devel \
"

URI_python3-libreport = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-libreport-2.17.14-2.el10.x86_64_v2.rpm;name=python3-libreport;unpack=0"
SRC_URI += "${URI_python3-libreport}"
SRC_URI[python3-libreport.sha256sum] = "2841391e1cdb7ac1bd472479f7c6e0b950f0524dce9e2bd563781a0a3eba605b"
RDEPENDS:python3-libreport = " \
 python3-urllib3 \
 python3 \
 python3-requests \
 systemd-libs \
 libarchive \
 augeas-libs \
 satyr \
 libgcc \
 json-c \
 python3-dnf \
 glib2 \
 glibc \
 libreport \
"
