# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Object-Deadly"
PE = "0"
PV = "0.09"
PR = "48.el10"
PACKAGES = "perl-Object-Deadly perl-Object-Deadly-tests"
PROVIDES = "rpm/perl-Object-Deadly rpm/perl-Object-Deadly-tests"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-Object-Deadly-0.09-48.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3564c067c47ea97169a291a0724f8108a76d036955f9149ade7a3ceb889699f"

URI_perl-Object-Deadly = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Object-Deadly-0.09-48.el10.noarch.rpm;name=perl-Object-Deadly;unpack=0"
SRC_URI += "${URI_perl-Object-Deadly}"
SRC_URI[perl-Object-Deadly.sha256sum] = "599e3c6ed7f564f6b65edbd716bebbb4dcebd3e07b10a2cf98b3b32e1f97a344"
RDEPENDS:perl-Object-Deadly = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp-Clan \
 perl-vars \
 perl-Object-Deadly \
 perl-overload \
 perl-English \
 perl-Devel-StackTrace \
 perl-Devel-Symdump \
 perl-B \
"

URI_perl-Object-Deadly-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Object-Deadly-tests-0.09-48.el10.noarch.rpm;name=perl-Object-Deadly-tests;unpack=0"
SRC_URI += "${URI_perl-Object-Deadly-tests}"
SRC_URI[perl-Object-Deadly-tests.sha256sum] = "d00787ccea158ad5b46941b4e3f3686fb6ee7db0c3d90cc0aa2352699f019232"
RDEPENDS:perl-Object-Deadly-tests = " \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Scalar-List-Utils \
 perl-overload \
 perl-Symbol \
 bash \
 perl-Object-Deadly \
 perl-interpreter \
 perl-Test-Exception \
"
