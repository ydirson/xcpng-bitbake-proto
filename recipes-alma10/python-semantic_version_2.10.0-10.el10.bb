# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-semantic_version"
PE = "0"
PV = "2.10.0"
PR = "10.el10"
PACKAGES = "python3-semantic_version python-semantic_version-doc"
PROVIDES = "rpm/python3-semantic_version rpm/python-semantic_version-doc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/python-semantic_version-2.10.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b5cb3d671ed08c6026713e47025438d1847f78c20c4517de1ae16cf64aed3fa"

URI_python3-semantic_version = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/python3-semantic_version-2.10.0-10.el10.noarch.rpm;name=python3-semantic_version;unpack=0"
SRC_URI += "${URI_python3-semantic_version}"
SRC_URI[python3-semantic_version.sha256sum] = "cb0cd3e85a21caf599d46c4bb7d9f4e6149f10075f0106a189bc228b004f043b"
RDEPENDS:python3-semantic_version = " \
 python3 \
"

URI_python-semantic_version-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python-semantic_version-doc-2.10.0-10.el10.noarch.rpm;name=python-semantic_version-doc;unpack=0"
SRC_URI += "${URI_python-semantic_version-doc}"
SRC_URI[python-semantic_version-doc.sha256sum] = "c9b6ab46785fbfa2c58bee4f7bef9be715674c4b33189608777309ed9ec5c3d2"
RDEPENDS:python-semantic_version-doc = ""
