# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "glib2"
PE = "0"
PV = "2.80.4"
PR = "4.el10_0.7"
PACKAGES = "glib2 glib2-devel glib2-tests glib2-doc glib2-static"
PROVIDES = "rpm/glib2 rpm/glib2-devel rpm/glib2-tests rpm/glib2-doc rpm/glib2-static"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/glib2-2.80.4-4.el10_0.7.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3273efe113eac1d1a00483da796ce56a8fe487213eede258d62e45c79222520"

URI_glib2 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glib2-2.80.4-4.el10_0.7.x86_64_v2.rpm;name=glib2;unpack=0"
SRC_URI += "${URI_glib2}"
SRC_URI[glib2.sha256sum] = "4457f0dad1fb7970f725d059653f97d3b0116ab39b7f79b1360bb019277a6fc0"
RDEPENDS:glib2 = " \
 zlib-ng-compat \
 gnutls \
 libffi \
 libmount \
 bash \
 pcre2 \
 glibc \
 libselinux \
"

URI_glib2-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/glib2-devel-2.80.4-4.el10_0.7.x86_64_v2.rpm;name=glib2-devel;unpack=0"
SRC_URI += "${URI_glib2-devel}"
SRC_URI[glib2-devel.sha256sum] = "d1505585c85fad3f19e2736201db6d9884c9c390656d6279c56110b0961ffb6e"
RDEPENDS:glib2-devel = " \
 python3 \
 sysprof-capture-devel \
 glib2-devel \
 libffi \
 zlib-ng-compat-devel \
 pkgconf-pkg-config \
 elfutils-libelf \
 libmount-devel \
 pcre2-devel \
 bash \
 glib2 \
 libselinux-devel \
 glibc \
 python3-packaging \
 libffi-devel \
"

URI_glib2-tests = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/glib2-tests-2.80.4-4.el10_0.7.x86_64_v2.rpm;name=glib2-tests;unpack=0"
SRC_URI += "${URI_glib2-tests}"
SRC_URI[glib2-tests.sha256sum] = "f609c548c3a38b0d9bb08d77e4a349f5a4dbca15e0d7e87f08b8992763d40621"
RDEPENDS:glib2-tests = " \
 python3 \
 libgcc \
 bash \
 glib2 \
 pcre2 \
 glibc \
"

URI_glib2-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/glib2-doc-2.80.4-4.el10_0.7.x86_64_v2.rpm;name=glib2-doc;unpack=0"
SRC_URI += "${URI_glib2-doc}"
SRC_URI[glib2-doc.sha256sum] = "072314903415fb2902f8a2986e371b01b8389d6398754f97418a53d17f1fabdf"
RDEPENDS:glib2-doc = " \
 glib2 \
"

URI_glib2-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/glib2-static-2.80.4-4.el10_0.7.x86_64_v2.rpm;name=glib2-static;unpack=0"
SRC_URI += "${URI_glib2-static}"
SRC_URI[glib2-static.sha256sum] = "2c7df95ea30f45846d798f173dfcc94c3790cc3dbbe0a4ad4cb4bb2fa6111de3"
RDEPENDS:glib2-static = " \
 glib2-devel \
 sysprof-capture-devel \
 pcre2-static \
"
