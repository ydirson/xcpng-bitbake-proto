# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-tour"
PE = "0"
PV = "46.0"
PR = "4.el10.alma.1"
PACKAGES = "gnome-tour"
PROVIDES = "rpm/gnome-tour"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-tour-46.0-4.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7e173848fd4ba52411a7c8dc9d2aec25b6b412370cf76f998b6cae5ffc8836d"

URI_gnome-tour = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-tour-46.0-4.el10.alma.1.x86_64_v2.rpm;name=gnome-tour;unpack=0"
SRC_URI += "${URI_gnome-tour}"
SRC_URI[gnome-tour.sha256sum] = "e883bf58ac64e04e2faa7e23cb6691f0a21fd7c9f83b1d70eb2a7d5968af56af"
RDEPENDS:gnome-tour = " \
 libgcc \
 pango \
 gdk-pixbuf2 \
 cairo \
 glib2 \
 glibc \
 gtk4 \
 libadwaita \
"
