# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rshim"
PE = "0"
PV = "2.0.17"
PR = "6.el10"
PACKAGES = "rshim"
PROVIDES = "rpm/rshim"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/rshim-2.0.17-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71df78929ef5cfc0f82fb80cf55f195b75ee949d4d8f4e6b03be60e28151a724"

URI_rshim = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rshim-2.0.17-6.el10.x86_64_v2.rpm;name=rshim;unpack=0"
SRC_URI += "${URI_rshim}"
SRC_URI[rshim.sha256sum] = "376375e8138e15b622d1ca9d1effe7afb49834028813b31c5a0d6d2447fd990e"
RDEPENDS:rshim = " \
 fuse-libs \
 kernel-modules-extra \
 pciutils-libs \
 bash \
 glibc \
 libusb1 \
"
