# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "alsa-firmware"
PE = "0"
PV = "1.2.4"
PR = "17.el10"
PACKAGES = "alsa-firmware"
PROVIDES = "rpm/alsa-firmware"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/alsa-firmware-1.2.4-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ae1413204dad815555b615bcbd07a8d8dd4cc9afde675e9e3454d894b97289d"

URI_alsa-firmware = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/alsa-firmware-1.2.4-17.el10.noarch.rpm;name=alsa-firmware;unpack=0"
SRC_URI += "${URI_alsa-firmware}"
SRC_URI[alsa-firmware.sha256sum] = "f14924ab61ece7fbb75af81e86707430eea7dbd2ba37d62bb50e0ef3370ecfbd"
RDEPENDS:alsa-firmware = " \
 systemd \
 alsa-tools-firmware \
"
