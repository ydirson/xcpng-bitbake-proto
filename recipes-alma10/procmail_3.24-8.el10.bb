# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "procmail"
PE = "0"
PV = "3.24"
PR = "8.el10"
PACKAGES = "procmail"
PROVIDES = "rpm/procmail"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/procmail-3.24-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7538c3dbddfa938eb5eb031edd023a14eb6e0fcd07849e11e4665e0b8b581fd"

URI_procmail = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/procmail-3.24-8.el10.x86_64_v2.rpm;name=procmail;unpack=0"
SRC_URI += "${URI_procmail}"
SRC_URI[procmail.sha256sum] = "d77eb28eea74da38e6ff51f0bc3704075124528b43082c2cbd13481c70237690"
RDEPENDS:procmail = " \
 glibc \
 bash \
"
