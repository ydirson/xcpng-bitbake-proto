# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Net-HTTP"
PE = "0"
PV = "6.23"
PR = "6.el10"
PACKAGES = "perl-Net-HTTP perl-Net-HTTP-tests"
PROVIDES = "rpm/perl-Net-HTTP rpm/perl-Net-HTTP-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Net-HTTP-6.23-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3f3e714202e9fb0ddcb8b50f931afddb1b1a9cbfbe89775127717e604305ce3"

URI_perl-Net-HTTP = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Net-HTTP-6.23-6.el10.noarch.rpm;name=perl-Net-HTTP;unpack=0"
SRC_URI += "${URI_perl-Net-HTTP}"
SRC_URI[perl-Net-HTTP.sha256sum] = "d55220ae7778d1d0fe34dfb0001d86de2d96cab9d2e43163d584d16f8a09beb1"
RDEPENDS:perl-Net-HTTP = " \
 perl-libs \
 perl-URI \
 perl-Carp \
 perl-IO-Compress \
 perl-Compress-Raw-Zlib \
 perl-IO-Socket-IP \
 perl-IO-Socket-SSL \
 perl-Symbol \
 perl-Net-HTTP \
 perl-base \
"

URI_perl-Net-HTTP-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Net-HTTP-tests-6.23-6.el10.noarch.rpm;name=perl-Net-HTTP-tests;unpack=0"
SRC_URI += "${URI_perl-Net-HTTP-tests}"
SRC_URI[perl-Net-HTTP-tests.sha256sum] = "4b984fb0c3a88b3dc20fb49dab9cc1b5cb83eed7a34bc6afa7f75ead35bd30e0"
RDEPENDS:perl-Net-HTTP-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-ExtUtils-MakeMaker \
 perl-IO \
 perl-Socket \
 bash \
 perl-PathTools \
 perl-interpreter \
 perl-Net-HTTP \
 perl-Data-Dumper \
 perl-base \
"
