# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cppunit"
PE = "0"
PV = "1.15.1"
PR = "23.el10"
PACKAGES = "cppunit cppunit-devel cppunit-doc"
PROVIDES = "rpm/cppunit rpm/cppunit-devel rpm/cppunit-doc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/cppunit-1.15.1-23.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8e856e8d6857c658c0fca259da00d0201d5c842df19129e74ec38cf40659542"

URI_cppunit = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/cppunit-1.15.1-23.el10.x86_64_v2.rpm;name=cppunit;unpack=0"
SRC_URI += "${URI_cppunit}"
SRC_URI[cppunit.sha256sum] = "328ad349c6dd3dde09a7574008d3b084dcb6fc536ceb7c77e9867a0429a267d2"
RDEPENDS:cppunit = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_cppunit-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/cppunit-devel-1.15.1-23.el10.x86_64_v2.rpm;name=cppunit-devel;unpack=0"
SRC_URI += "${URI_cppunit-devel}"
SRC_URI[cppunit-devel.sha256sum] = "830d4db3889438030d94260b8d77c506a27e18d27cad6fdddd1ea647763b1d4f"
RDEPENDS:cppunit-devel = " \
 cppunit \
 pkgconf-pkg-config \
"

URI_cppunit-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/cppunit-doc-1.15.1-23.el10.x86_64_v2.rpm;name=cppunit-doc;unpack=0"
SRC_URI += "${URI_cppunit-doc}"
SRC_URI[cppunit-doc.sha256sum] = "97892c399bddfbe9d8ef1933c85ec43a681b9c92e8fb5e153c8b97cd5e64754f"
RDEPENDS:cppunit-doc = ""
