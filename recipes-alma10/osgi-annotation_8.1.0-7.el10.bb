# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "osgi-annotation"
PE = "0"
PV = "8.1.0"
PR = "7.el10"
PACKAGES = "osgi-annotation osgi-annotation-javadoc"
PROVIDES = "rpm/osgi-annotation rpm/osgi-annotation-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/osgi-annotation-8.1.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b367f73b2b3f281a6279ac8eb222bfd1741b312a102c059e64f4e1780827e68"

URI_osgi-annotation = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/osgi-annotation-8.1.0-7.el10.noarch.rpm;name=osgi-annotation;unpack=0"
SRC_URI += "${URI_osgi-annotation}"
SRC_URI[osgi-annotation.sha256sum] = "b668b2921de2140bc744ea6570bb5f9a04b0be7d9bf4c4090963ea737184b34b"
RDEPENDS:osgi-annotation = " \
 javapackages-filesystem \
"

URI_osgi-annotation-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/osgi-annotation-javadoc-8.1.0-7.el10.noarch.rpm;name=osgi-annotation-javadoc;unpack=0"
SRC_URI += "${URI_osgi-annotation-javadoc}"
SRC_URI[osgi-annotation-javadoc.sha256sum] = "ce307901ccb672ba0741e711d01c9d8617d3a16762e26985ed59850f346bbac8"
RDEPENDS:osgi-annotation-javadoc = " \
 javapackages-filesystem \
"
