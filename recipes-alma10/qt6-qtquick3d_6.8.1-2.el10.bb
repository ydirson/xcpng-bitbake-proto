# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtquick3d"
PE = "0"
PV = "6.8.1"
PR = "2.el10"
PACKAGES = "qt6-qtquick3d qt6-qtquick3d-devel qt6-qtquick3d-examples qt6-qtquick3d-tests"
PROVIDES = "rpm/qt6-qtquick3d rpm/qt6-qtquick3d-devel rpm/qt6-qtquick3d-examples rpm/qt6-qtquick3d-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtquick3d-6.8.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6192118fedde3e8ab7056f674a39677427ec228eac5ff3ba4e40f0396b5bfb38"

URI_qt6-qtquick3d = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtquick3d-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtquick3d;unpack=0"
SRC_URI += "${URI_qt6-qtquick3d}"
SRC_URI[qt6-qtquick3d.sha256sum] = "0603762fe5c6a37cf521c0208c5cfc4699c8f8e3c96a67fba1439aa7861728be"
RDEPENDS:qt6-qtquick3d = " \
 qt6-qtdeclarative \
 zlib-ng-compat \
 libgcc \
 qt6-qtbase \
 qt6-qtquicktimeline \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
 qt6-qtshadertools \
"

URI_qt6-qtquick3d-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtquick3d-devel-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtquick3d-devel;unpack=0"
SRC_URI += "${URI_qt6-qtquick3d-devel}"
SRC_URI[qt6-qtquick3d-devel.sha256sum] = "6b5624804f23d73e2c35bb17fb972d315d133f9eb3be3e80106cc94f455f2508"
RDEPENDS:qt6-qtquick3d-devel = " \
 qt6-qtdeclarative \
 qt6-qtdeclarative-devel \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtquick3d \
 qt6-qtquick3d-devel \
 qt6-qtbase-devel \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
 qt6-qtshadertools \
 qt6-qtshadertools-devel \
"

URI_qt6-qtquick3d-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtquick3d-examples-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtquick3d-examples;unpack=0"
SRC_URI += "${URI_qt6-qtquick3d-examples}"
SRC_URI[qt6-qtquick3d-examples.sha256sum] = "e33d349049264b63a75f813f9bfa7eaef77d194c05532c751ecd1a73f9e8a009"
RDEPENDS:qt6-qtquick3d-examples = " \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtbase \
 libgomp \
 qt6-qtquick3d \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qtquick3d-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtquick3d-tests-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtquick3d-tests;unpack=0"
SRC_URI += "${URI_qt6-qtquick3d-tests}"
SRC_URI[qt6-qtquick3d-tests.sha256sum] = "f7543f4de55269d5772b780743e54ab50493a19722d0fa582e0ebe919bde764d"
RDEPENDS:qt6-qtquick3d-tests = " \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtbase \
 qt6-qtquick3d \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
 qt6-qtshadertools \
"
