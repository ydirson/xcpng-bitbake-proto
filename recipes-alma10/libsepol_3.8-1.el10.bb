# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libsepol"
PE = "0"
PV = "3.8"
PR = "1.el10"
PACKAGES = "libsepol libsepol-devel libsepol-utils libsepol-static"
PROVIDES = "rpm/libsepol rpm/libsepol-devel rpm/libsepol-utils rpm/libsepol-static"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libsepol-3.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c9e81b420eb5455d6cbfba3fc6dd822e6dc393af3f276d353c3acb1e85974cb3"

URI_libsepol = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libsepol-3.8-1.el10.x86_64_v2.rpm;name=libsepol;unpack=0"
SRC_URI += "${URI_libsepol}"
SRC_URI[libsepol.sha256sum] = "fd50fedd5e8a66b03f99c608aa9eb08ba0b5e642bd0492b72f3cc212e762ba7c"
RDEPENDS:libsepol = " \
 glibc \
"

URI_libsepol-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libsepol-devel-3.8-1.el10.x86_64_v2.rpm;name=libsepol-devel;unpack=0"
SRC_URI += "${URI_libsepol-devel}"
SRC_URI[libsepol-devel.sha256sum] = "a4dc3bec478ab9c84440a6805b7779d74f55f2cec6cc13d254e1ef6a3c9f163c"
RDEPENDS:libsepol-devel = " \
 pkgconf-pkg-config \
 libsepol \
"

URI_libsepol-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libsepol-utils-3.8-1.el10.x86_64_v2.rpm;name=libsepol-utils;unpack=0"
SRC_URI += "${URI_libsepol-utils}"
SRC_URI[libsepol-utils.sha256sum] = "b2293a10b0147ea923fd9d70babb4f422f2ca30564168b8fbf688d7dd4918ad7"
RDEPENDS:libsepol-utils = " \
 glibc \
 libsepol \
"

URI_libsepol-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libsepol-static-3.8-1.el10.x86_64_v2.rpm;name=libsepol-static;unpack=0"
SRC_URI += "${URI_libsepol-static}"
SRC_URI[libsepol-static.sha256sum] = "0ed1d4ba6b65d210c55362469e3f6ff83fd76cd6ec51137347a65b364c3a60bb"
RDEPENDS:libsepol-static = " \
 libsepol-devel \
"
