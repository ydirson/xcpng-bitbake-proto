# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tbb"
PE = "0"
PV = "2021.11.0"
PR = "7.el10"
PACKAGES = "python3-tbb tbb tbb-bind tbb-devel tbb-doc"
PROVIDES = "rpm/python3-tbb rpm/tbb rpm/tbb-bind rpm/tbb-devel rpm/tbb-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tbb-2021.11.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4c721e8a46c13f9e88df040082be21636142eac3c42798ca8d7cdce5c3e0df2"

URI_python3-tbb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-tbb-2021.11.0-7.el10.x86_64_v2.rpm;name=python3-tbb;unpack=0"
SRC_URI += "${URI_python3-tbb}"
SRC_URI[python3-tbb.sha256sum] = "384a0ef98e5987aa68dad3951e7985b974c56b7b66449b290db6bc652bd85ffb"
RDEPENDS:python3-tbb = " \
 python3 \
 libgcc \
 libstdc++ \
 glibc \
 tbb \
"

URI_tbb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tbb-2021.11.0-7.el10.x86_64_v2.rpm;name=tbb;unpack=0"
SRC_URI += "${URI_tbb}"
SRC_URI[tbb.sha256sum] = "bcdb0c2002f1ad3bde3c90104413c6a9c2e2ba3a929fe455e0a41ff0e2c838d9"
RDEPENDS:tbb = " \
 glibc \
 libgcc \
 libstdc++ \
"

URI_tbb-bind = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tbb-bind-2021.11.0-7.el10.x86_64_v2.rpm;name=tbb-bind;unpack=0"
SRC_URI += "${URI_tbb-bind}"
SRC_URI[tbb-bind.sha256sum] = "e098e0827361a830675b4c491e4c1526551da8545e87eb1935c3fc5fac92c162"
RDEPENDS:tbb-bind = " \
 libgcc \
 hwloc-libs \
 libstdc++ \
 glibc \
 tbb \
"

URI_tbb-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tbb-devel-2021.11.0-7.el10.x86_64_v2.rpm;name=tbb-devel;unpack=0"
SRC_URI += "${URI_tbb-devel}"
SRC_URI[tbb-devel.sha256sum] = "08c5642706e2ceaf5b565afecee3800cc5eabd1593a3fd9b39adf563d287fdea"
RDEPENDS:tbb-devel = " \
 tbb \
 cmake-filesystem \
 pkgconf-pkg-config \
 tbb-bind \
"

URI_tbb-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tbb-doc-2021.11.0-7.el10.x86_64_v2.rpm;name=tbb-doc;unpack=0"
SRC_URI += "${URI_tbb-doc}"
SRC_URI[tbb-doc.sha256sum] = "46617d49fbf655fb49ffd519924a332e11ca4f05d20df708fa7c654a7c45e7f5"
RDEPENDS:tbb-doc = ""
