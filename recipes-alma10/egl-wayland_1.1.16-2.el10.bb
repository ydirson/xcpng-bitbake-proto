# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "egl-wayland"
PE = "0"
PV = "1.1.16"
PR = "2.el10"
PACKAGES = "egl-wayland egl-wayland-devel"
PROVIDES = "rpm/egl-wayland rpm/egl-wayland-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/egl-wayland-1.1.16-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "34d35e538af7f5e5b47082daa9c24543258e9cac3e6e158e87c8f009cb1058ba"

URI_egl-wayland = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/egl-wayland-1.1.16-2.el10.x86_64_v2.rpm;name=egl-wayland;unpack=0"
SRC_URI += "${URI_egl-wayland}"
SRC_URI[egl-wayland.sha256sum] = "11e460247ef7a8f25ec7c4029897aca53d8e2d40cb43bf650b5abefc81c368b0"
RDEPENDS:egl-wayland = " \
 libglvnd-egl \
 libwayland-client \
 libwayland-server \
 glibc \
 libdrm \
"

URI_egl-wayland-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/egl-wayland-devel-1.1.16-2.el10.x86_64_v2.rpm;name=egl-wayland-devel;unpack=0"
SRC_URI += "${URI_egl-wayland-devel}"
SRC_URI[egl-wayland-devel.sha256sum] = "4f80040a282c20abc420b86e2bc1e8798f036d32c0c28f8c2c835ba593ef364f"
RDEPENDS:egl-wayland-devel = " \
 egl-wayland \
 eglexternalplatform-devel \
 pkgconf-pkg-config \
"
