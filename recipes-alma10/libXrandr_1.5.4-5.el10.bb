# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libXrandr"
PE = "0"
PV = "1.5.4"
PR = "5.el10"
PACKAGES = "libXrandr libXrandr-devel"
PROVIDES = "rpm/libXrandr rpm/libXrandr-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libXrandr-1.5.4-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8abc0a257075f00e19c6a5ad499c585ae4297bf8abf754f2a6648bdef9001d7"

URI_libXrandr = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXrandr-1.5.4-5.el10.x86_64_v2.rpm;name=libXrandr;unpack=0"
SRC_URI += "${URI_libXrandr}"
SRC_URI[libXrandr.sha256sum] = "7753b7d50fec767f3cc9b34cf80a3dbb15ff4a11970707e407780baedca32ec1"
RDEPENDS:libXrandr = " \
 glibc \
 libX11 \
 libXrender \
 libXext \
"

URI_libXrandr-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libXrandr-devel-1.5.4-5.el10.x86_64_v2.rpm;name=libXrandr-devel;unpack=0"
SRC_URI += "${URI_libXrandr-devel}"
SRC_URI[libXrandr-devel.sha256sum] = "0c906178f77e69474faa658ee2b847b11ff38cd05f8802c0002319184d42884c"
RDEPENDS:libXrandr-devel = " \
 libXext-devel \
 pkgconf-pkg-config \
 libXrandr \
 libXrender-devel \
 libX11-devel \
 xorg-x11-proto-devel \
"
