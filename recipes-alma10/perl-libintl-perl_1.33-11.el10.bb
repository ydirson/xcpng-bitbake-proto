# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-libintl-perl"
PE = "0"
PV = "1.33"
PR = "11.el10"
PACKAGES = "perl-libintl-perl perl-libintl-perl-tests"
PROVIDES = "rpm/perl-libintl-perl rpm/perl-libintl-perl-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-libintl-perl-1.33-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b41d7eac83c13b5bf9a2da15f030eb1e8e00e726d2870ca49e5636c6658b4052"

URI_perl-libintl-perl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-libintl-perl-1.33-11.el10.x86_64_v2.rpm;name=perl-libintl-perl;unpack=0"
SRC_URI += "${URI_perl-libintl-perl}"
SRC_URI[perl-libintl-perl.sha256sum] = "23124e815921546becd5d50ef2a0fdee2ab4acc598ca32df6c4cae08c9390556"
RDEPENDS:perl-libintl-perl = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-IO \
 perl-locale \
 perl-POSIX \
 perl-DynaLoader \
 perl-Encode \
 perl-PathTools \
 glibc \
 perl-Exporter \
 perl-base \
 perl-libintl-perl \
"

URI_perl-libintl-perl-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-libintl-perl-tests-1.33-11.el10.x86_64_v2.rpm;name=perl-libintl-perl-tests;unpack=0"
SRC_URI += "${URI_perl-libintl-perl-tests}"
SRC_URI[perl-libintl-perl-tests.sha256sum] = "75dcaa66429acf826ff10efee52b89381f86b32ed043daf5f632e2aba5d52687"
RDEPENDS:perl-libintl-perl-tests = " \
 perl-constant \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 perl-File-Basename \
 perl-POSIX \
 perl-PathTools \
 bash \
 perl-interpreter \
 perl-libintl-perl \
"
