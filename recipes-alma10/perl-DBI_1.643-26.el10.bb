# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-DBI"
PE = "0"
PV = "1.643"
PR = "26.el10"
PACKAGES = "perl-DBI perl-DBI-tests"
PROVIDES = "rpm/perl-DBI rpm/perl-DBI-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-DBI-1.643-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d33875671c16b31ff39f81998fb66a36a2a6a0807779aadfcbabd517997c43d"

URI_perl-DBI = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-DBI-1.643-26.el10.x86_64_v2.rpm;name=perl-DBI;unpack=0"
SRC_URI += "${URI_perl-DBI}"
SRC_URI[perl-DBI.sha256sum] = "a4588de36cbbe4f6b1f3296d318884f29d96c21c94117c8fbbd3190710c2b396"
RDEPENDS:perl-DBI = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-FileHandle \
 perl-Storable \
 perl-Getopt-Long \
 perl-Symbol \
 perl-Carp \
 perl-vars \
 perl-IO \
 perl-IPC-Open3 \
 perl-DBI \
 perl-Data-Dumper \
 perl-Math-BigInt \
 perl-DynaLoader \
 perl-Errno \
 perl-Exporter \
 perl-base \
 perl-constant \
 perl-Fcntl \
 perl-File-Basename \
 perl-PathTools \
 glibc \
 perl-interpreter \
"

URI_perl-DBI-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-DBI-tests-1.643-26.el10.x86_64_v2.rpm;name=perl-DBI-tests;unpack=0"
SRC_URI += "${URI_perl-DBI-tests}"
SRC_URI[perl-DBI-tests.sha256sum] = "02cc2616d020592b86761de0594d556125c6040d14ff806c6216585609942d3c"
RDEPENDS:perl-DBI-tests = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Storable \
 perl-Getopt-Long \
 perl-overload \
 perl-Symbol \
 perl-B \
 perl-Benchmark \
 perl-threads \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-vars \
 perl-DBI \
 perl-Data-Dumper \
 bash \
 perl-base \
 perl-constant \
 perl-File-Basename \
 perl-File-Copy \
 perl-PathTools \
 perl-interpreter \
 perl-File-Path \
"
