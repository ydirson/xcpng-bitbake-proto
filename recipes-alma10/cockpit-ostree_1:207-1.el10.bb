# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cockpit-ostree"
PE = "1"
PV = "207"
PR = "1.el10"
PACKAGES = "cockpit-ostree"
PROVIDES = "rpm/cockpit-ostree"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/cockpit-ostree-207-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5da0d0271a622c9f01e15b160ba14c4ecda00ee16d2fff5e18e5504819971c7"

URI_cockpit-ostree = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cockpit-ostree-207-1.el10.noarch.rpm;name=cockpit-ostree;unpack=0"
SRC_URI += "${URI_cockpit-ostree}"
SRC_URI[cockpit-ostree.sha256sum] = "72963f1140c253210ed9e5857490e2fea00a5d8a93bb02c159d451d92702310e"
RDEPENDS:cockpit-ostree = " \
 cockpit-bridge \
 rpm-ostree \
 cockpit-system \
"
