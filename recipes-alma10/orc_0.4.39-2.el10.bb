# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "orc"
PE = "0"
PV = "0.4.39"
PR = "2.el10"
PACKAGES = "orc orc-compiler orc-devel orc-doc"
PROVIDES = "rpm/orc rpm/orc-compiler rpm/orc-devel rpm/orc-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/orc-0.4.39-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d5038117842c1b8595ae2c3cea9f8f72dde65580d7a80c96a396c44c2968644"

URI_orc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/orc-0.4.39-2.el10.x86_64_v2.rpm;name=orc;unpack=0"
SRC_URI += "${URI_orc}"
SRC_URI[orc.sha256sum] = "a6b3f5f669e2c6b95a31f97455fb49c56f18ecbf2a7d357738846136b9c59f69"
RDEPENDS:orc = " \
 glibc \
"

URI_orc-compiler = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/orc-compiler-0.4.39-2.el10.x86_64_v2.rpm;name=orc-compiler;unpack=0"
SRC_URI += "${URI_orc-compiler}"
SRC_URI[orc-compiler.sha256sum] = "f776546e1fb830cf3d31ae1269e88b35183f19704a307a19ffc1005be8265354"
RDEPENDS:orc-compiler = " \
 glibc \
 pkgconf-pkg-config \
 orc \
"

URI_orc-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/orc-devel-0.4.39-2.el10.x86_64_v2.rpm;name=orc-devel;unpack=0"
SRC_URI += "${URI_orc-devel}"
SRC_URI[orc-devel.sha256sum] = "9c2fd60c11ae520991ededfce674ec47e671df8f95a4e2df9f8feab364f9d51b"
RDEPENDS:orc-devel = " \
 orc-compiler \
 pkgconf-pkg-config \
 orc \
"

URI_orc-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/orc-doc-0.4.39-2.el10.noarch.rpm;name=orc-doc;unpack=0"
SRC_URI += "${URI_orc-doc}"
SRC_URI[orc-doc.sha256sum] = "af6a468b481b248bcb50ecd5f1b70c005f6948e748e73d792a9605206bbb5116"
RDEPENDS:orc-doc = " \
 orc \
"
