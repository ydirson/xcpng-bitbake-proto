# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pam"
PE = "0"
PV = "1.6.1"
PR = "7.el10"
PACKAGES = "pam pam-libs pam-devel pam-doc"
PROVIDES = "rpm/pam rpm/pam-libs rpm/pam-devel rpm/pam-doc"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/pam-1.6.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "093bd136970434ea05642a58761ec0c144c72e13780dd0cfd2a697478626c321"

URI_pam = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/pam-1.6.1-7.el10.x86_64_v2.rpm;name=pam;unpack=0"
SRC_URI += "${URI_pam}"
SRC_URI[pam.sha256sum] = "332e5ef7ff3314621ccab948143b4915ddd48dd101da3353cf7230177d7b340a"
RDEPENDS:pam = " \
 setup \
 libxcrypt \
 audit-libs \
 openssl-libs \
 gdbm \
 gdbm-libs \
 libpwquality \
 authselect \
 pam-libs \
 bash \
 glibc \
 libselinux \
 libeconf \
"

URI_pam-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/pam-libs-1.6.1-7.el10.x86_64_v2.rpm;name=pam-libs;unpack=0"
SRC_URI += "${URI_pam-libs}"
SRC_URI[pam-libs.sha256sum] = "d76438e3add23e41a80599bb0de479fe9c20c0f6c9d5d061dcbfe15f210ea16a"
RDEPENDS:pam-libs = " \
 glibc \
 audit-libs \
 libeconf \
"

URI_pam-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pam-devel-1.6.1-7.el10.x86_64_v2.rpm;name=pam-devel;unpack=0"
SRC_URI += "${URI_pam-devel}"
SRC_URI[pam-devel.sha256sum] = "09d9ed8cf90e3ab8d7f5638f5c1287292fb281fec8f187f137fae9a2a2f6e692"
RDEPENDS:pam-devel = " \
 pam-libs \
 pkgconf-pkg-config \
"

URI_pam-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/pam-doc-1.6.1-7.el10.noarch.rpm;name=pam-doc;unpack=0"
SRC_URI += "${URI_pam-doc}"
SRC_URI[pam-doc.sha256sum] = "71660d6522f1402927b81195e6e8af1de8f07f13ad408376b32cbd9bf5ecbf19"
RDEPENDS:pam-doc = " \
 pam \
"
