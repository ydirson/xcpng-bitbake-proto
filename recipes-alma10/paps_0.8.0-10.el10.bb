# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "paps"
PE = "0"
PV = "0.8.0"
PR = "10.el10"
PACKAGES = "paps texttopaps"
PROVIDES = "rpm/paps rpm/texttopaps"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/paps-0.8.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75049e1983d76052e15752aa30f46bf2403e57375ba7e2297708c0911dcaa692"

URI_paps = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/paps-0.8.0-10.el10.x86_64_v2.rpm;name=paps;unpack=0"
SRC_URI += "${URI_paps}"
SRC_URI[paps.sha256sum] = "89ef93ff41a5d5ff7505a3cf1d0c28521ef695431781822e1b2aeaf74e31f28c"
RDEPENDS:paps = " \
 python3 \
 libgcc \
 pango \
 libstdc++ \
 glib2 \
 cairo \
 glibc \
"

URI_texttopaps = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/texttopaps-0.8.0-10.el10.x86_64_v2.rpm;name=texttopaps;unpack=0"
SRC_URI += "${URI_texttopaps}"
SRC_URI[texttopaps.sha256sum] = "6d2b30cb012dfb18ae33d1d9b2ffc7c16654bbd4e65aa37a93208038c1495ed4"
RDEPENDS:texttopaps = " \
 fonts-filesystem \
 freetype \
 cups-filesystem \
 harfbuzz \
 cups-libs \
 pango \
 fontconfig \
 glib2 \
 glibc \
"
