# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "glib-networking"
PE = "0"
PV = "2.80.0"
PR = "3.el10"
PACKAGES = "glib-networking glib-networking-tests"
PROVIDES = "rpm/glib-networking rpm/glib-networking-tests"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/glib-networking-2.80.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ca8135a4763d41cf0ca80fd60cbe85817474de3bef5b232a748bb663425b4a5"

URI_glib-networking = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/glib-networking-2.80.0-3.el10.x86_64_v2.rpm;name=glib-networking;unpack=0"
SRC_URI += "${URI_glib-networking}"
SRC_URI[glib-networking.sha256sum] = "ef155884f1c28dbc02d2f9ccd39f614d6702220e64a1f744a143048943f4cf3a"
RDEPENDS:glib-networking = " \
 gnutls \
 libproxy \
 ca-certificates \
 gsettings-desktop-schemas \
 glib2 \
 glibc \
"

URI_glib-networking-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/glib-networking-tests-2.80.0-3.el10.x86_64_v2.rpm;name=glib-networking-tests;unpack=0"
SRC_URI += "${URI_glib-networking-tests}"
SRC_URI[glib-networking-tests.sha256sum] = "46c0f3fdbbdf92d58be8ea4ead7b18d1d01189d88339765a7031c5891f5fd372"
RDEPENDS:glib-networking-tests = " \
 python3 \
 gnutls \
 glib-networking \
 bash \
 glib2 \
 glibc \
"
