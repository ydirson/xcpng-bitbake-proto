# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "composefs"
PE = "0"
PV = "1.0.8"
PR = "1.el10"
PACKAGES = "composefs composefs-libs composefs-devel"
PROVIDES = "rpm/composefs rpm/composefs-libs rpm/composefs-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/composefs-1.0.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8187de35d9a036e621f7b35f0f93add26814ed0feb52c0d91ac25eca743e4a2"

URI_composefs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/composefs-1.0.8-1.el10.x86_64_v2.rpm;name=composefs;unpack=0"
SRC_URI += "${URI_composefs}"
SRC_URI[composefs.sha256sum] = "f36592b3ebe12d4e308cc624c39eda936458970a63665735bbcb827ef3b1407d"
RDEPENDS:composefs = " \
 glibc \
 composefs-libs \
 libgcc \
"

URI_composefs-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/composefs-libs-1.0.8-1.el10.x86_64_v2.rpm;name=composefs-libs;unpack=0"
SRC_URI += "${URI_composefs-libs}"
SRC_URI[composefs-libs.sha256sum] = "d79e1069bd56c63aacf9229d4b0cd0110bc72205707379b76a2904cb61c308a4"
RDEPENDS:composefs-libs = " \
 glibc \
 openssl-libs \
 libgcc \
"

URI_composefs-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/composefs-devel-1.0.8-1.el10.x86_64_v2.rpm;name=composefs-devel;unpack=0"
SRC_URI += "${URI_composefs-devel}"
SRC_URI[composefs-devel.sha256sum] = "20ac2bf817046df58b7c4df8b50cd06eec63eb9584a0e1dc462a20f9e5993fca"
RDEPENDS:composefs-devel = " \
 composefs \
 composefs-libs \
 openssl-devel \
 pkgconf-pkg-config \
"
