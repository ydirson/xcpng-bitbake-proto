# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rubygem-mustache"
PE = "0"
PV = "1.1.1"
PR = "10.el10"
PACKAGES = "rubygem-mustache rubygem-mustache-doc"
PROVIDES = "rpm/rubygem-mustache rpm/rubygem-mustache-doc"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/rubygem-mustache-1.1.1-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b172ef5aad38545af046badd0b053e0204b92b9db8fcbd22d9b8ed04f53d4dd"

URI_rubygem-mustache = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-mustache-1.1.1-10.el10.noarch.rpm;name=rubygem-mustache;unpack=0"
SRC_URI += "${URI_rubygem-mustache}"
SRC_URI[rubygem-mustache.sha256sum] = "7ae5d3a5cb62bcfb0e5036e418bcc06be46cb0a347da5ecd635b4f900d238ded"
RDEPENDS:rubygem-mustache = " \
 rubygems \
 ruby \
"

URI_rubygem-mustache-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-mustache-doc-1.1.1-10.el10.noarch.rpm;name=rubygem-mustache-doc;unpack=0"
SRC_URI += "${URI_rubygem-mustache-doc}"
SRC_URI[rubygem-mustache-doc.sha256sum] = "1937d39feb632709f80161995b7dac7fe680ad0da01c3ebfffab3c704f7cc44f"
RDEPENDS:rubygem-mustache-doc = " \
 rubygem-mustache \
"
