# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lrzsz"
PE = "0"
PV = "0.12.20"
PR = "66.el10"
PACKAGES = "lrzsz"
PROVIDES = "rpm/lrzsz"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/lrzsz-0.12.20-66.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f477b49427cd7309663ca057c2bb69ad85f535b65efb105c2f9910a22be9ba78"

URI_lrzsz = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/lrzsz-0.12.20-66.el10.x86_64_v2.rpm;name=lrzsz;unpack=0"
SRC_URI += "${URI_lrzsz}"
SRC_URI[lrzsz.sha256sum] = "278ef0474e697ef6fdf61e99cf714266dfdc35bc1716b324d51a360600a94fdf"
RDEPENDS:lrzsz = " \
 glibc \
"
