# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "curl"
PE = "0"
PV = "8.9.1"
PR = "5.el10"
PACKAGES = "curl libcurl libcurl-minimal libcurl-devel"
PROVIDES = "rpm/curl rpm/libcurl rpm/libcurl-minimal rpm/libcurl-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/curl-8.9.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d9a28a59d3a56b8e693f2266b8804952e5f2ca8f7d6135dccd7036bc6865a05"

URI_curl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/curl-8.9.1-5.el10.x86_64_v2.rpm;name=curl;unpack=0"
SRC_URI += "${URI_curl}"
SRC_URI[curl.sha256sum] = "65001d56c0a370fc1f869dd2c090a9a974fe233a5fad79fdb42cf517e0471a01"
RDEPENDS:curl = " \
 glibc \
 libcurl \
"

URI_libcurl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libcurl-8.9.1-5.el10.x86_64_v2.rpm;name=libcurl;unpack=0"
SRC_URI += "${URI_libcurl}"
SRC_URI[libcurl.sha256sum] = "4de03600c9f4ec32c900f6928f334a4f1e7dce968f848dbfb599c3e14ff13ea4"
RDEPENDS:libcurl = " \
 zlib-ng-compat \
 libssh \
 libpsl \
 openssl-libs \
 libbrotli \
 krb5-libs \
 libnghttp2 \
 glibc \
 libidn2 \
 openldap \
"

URI_libcurl-minimal = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libcurl-minimal-8.9.1-5.el10.x86_64_v2.rpm;name=libcurl-minimal;unpack=0"
SRC_URI += "${URI_libcurl-minimal}"
SRC_URI[libcurl-minimal.sha256sum] = "5a87882ca63640d2f20eba459109d97f2b930a5767225b7b1af97c3d5875e1f8"
RDEPENDS:libcurl-minimal = " \
 zlib-ng-compat \
 openssl-libs \
 krb5-libs \
 libnghttp2 \
 glibc \
 libidn2 \
"

URI_libcurl-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libcurl-devel-8.9.1-5.el10.x86_64_v2.rpm;name=libcurl-devel;unpack=0"
SRC_URI += "${URI_libcurl-devel}"
SRC_URI[libcurl-devel.sha256sum] = "665add4d0b3bc1958e659ba99557d63c1ffad29596ab6e69ab82f23d39ec6fc8"
RDEPENDS:libcurl-devel = " \
 brotli-devel \
 zlib-ng-compat-devel \
 libidn2-devel \
 pkgconf-pkg-config \
 libssh-devel \
 openssl-devel \
 bash \
 libcurl \
 libnghttp2-devel \
 libpsl-devel \
"
