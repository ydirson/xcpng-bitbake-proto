# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mingw-glib2"
PE = "0"
PV = "2.82.2"
PR = "1.el10"
PACKAGES = "mingw32-glib2 mingw32-glib2-static mingw64-glib2 mingw64-glib2-static"
PROVIDES = "rpm/mingw32-glib2 rpm/mingw32-glib2-static rpm/mingw64-glib2 rpm/mingw64-glib2-static"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/mingw-glib2-2.82.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7fcf8531a6fb0fd272b08387c6dc0c60fafbce722ddb7cc5dce484ffca89754"

URI_mingw32-glib2 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw32-glib2-2.82.2-1.el10.noarch.rpm;name=mingw32-glib2;unpack=0"
SRC_URI += "${URI_mingw32-glib2}"
SRC_URI[mingw32-glib2.sha256sum] = "df93d9b6c0a74dc400e041e54e384f73e65ff1f03be4ab03e334ffb3eb39d2c7"
RDEPENDS:mingw32-glib2 = " \
 python3 \
 mingw32-pcre2 \
 mingw32-zlib \
 bash \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-gettext \
 mingw32-libffi \
 mingw32-libgcc \
"

URI_mingw32-glib2-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw32-glib2-static-2.82.2-1.el10.noarch.rpm;name=mingw32-glib2-static;unpack=0"
SRC_URI += "${URI_mingw32-glib2-static}"
SRC_URI[mingw32-glib2-static.sha256sum] = "1a6ffa29a15bd09fc6d6210310babf23ceb649df996fcc8202dd1c88ce0cdf57"
RDEPENDS:mingw32-glib2-static = " \
 mingw32-gettext-static \
 mingw32-glib2 \
"

URI_mingw64-glib2 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw64-glib2-2.82.2-1.el10.noarch.rpm;name=mingw64-glib2;unpack=0"
SRC_URI += "${URI_mingw64-glib2}"
SRC_URI[mingw64-glib2.sha256sum] = "e35635582f13ded7e9c3c1379b80600749adf8a8bf7aa950e0320180f78d8e9e"
RDEPENDS:mingw64-glib2 = " \
 python3 \
 mingw64-zlib \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-gettext \
 bash \
 mingw64-libffi \
 mingw64-libgcc \
 mingw64-pcre2 \
"

URI_mingw64-glib2-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw64-glib2-static-2.82.2-1.el10.noarch.rpm;name=mingw64-glib2-static;unpack=0"
SRC_URI += "${URI_mingw64-glib2-static}"
SRC_URI[mingw64-glib2-static.sha256sum] = "599ce50c3a23030702f511b368699aa0b78ff7d2f48edce20d468d1d9e5cd57f"
RDEPENDS:mingw64-glib2-static = " \
 mingw64-gettext-static \
 mingw64-glib2 \
"
