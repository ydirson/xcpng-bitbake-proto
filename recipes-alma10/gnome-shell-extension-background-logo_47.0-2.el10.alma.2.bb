# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-shell-extension-background-logo"
PE = "0"
PV = "47.0"
PR = "2.el10.alma.2"
PACKAGES = "gnome-shell-extension-background-logo"
PROVIDES = "rpm/gnome-shell-extension-background-logo"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-shell-extension-background-logo-47.0-2.el10.alma.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74cf34ee585a1cdf914ebc126af835250a8d6ba20730ecf10ade0f620c73221c"

URI_gnome-shell-extension-background-logo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-background-logo-47.0-2.el10.alma.2.noarch.rpm;name=gnome-shell-extension-background-logo;unpack=0"
SRC_URI += "${URI_gnome-shell-extension-background-logo}"
SRC_URI[gnome-shell-extension-background-logo.sha256sum] = "4e37dc80f5794359704ac730c7a802f400157ff6e4a6a4357d65420d2cec0da7"
RDEPENDS:gnome-shell-extension-background-logo = " \
 almalinux-logos \
 gnome-shell \
"
