# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "satyr"
PE = "0"
PV = "0.43"
PR = "3.el10"
PACKAGES = "python3-satyr satyr satyr-devel"
PROVIDES = "rpm/python3-satyr rpm/satyr rpm/satyr-devel"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/satyr-0.43-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edb02e9f2e9918267fb260bad697e3681270ab31e98b16b13e787d7dd9e15aac"

URI_python3-satyr = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-satyr-0.43-3.el10.x86_64_v2.rpm;name=python3-satyr;unpack=0"
SRC_URI += "${URI_python3-satyr}"
SRC_URI[python3-satyr.sha256sum] = "336eb2d0e46d91f23cc0bbbcda3fd53bbcbcfe31ea51988b7c97c9149c635bc0"
RDEPENDS:python3-satyr = " \
 python3 \
 zlib-ng-compat \
 satyr \
 json-c \
 elfutils-libelf \
 elfutils-libs \
 libstdc++ \
 glib2 \
 popt \
 glibc \
 rpm-libs \
"

URI_satyr = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/satyr-0.43-3.el10.x86_64_v2.rpm;name=satyr;unpack=0"
SRC_URI += "${URI_satyr}"
SRC_URI[satyr.sha256sum] = "7c4ed0f600569bb14bcb953ee8408d11e9abaf5b74f33791f09c30cc3cdc7692"
RDEPENDS:satyr = " \
 zlib-ng-compat \
 libgcc \
 json-c \
 elfutils-libelf \
 elfutils-libs \
 libstdc++ \
 glib2 \
 popt \
 glibc \
 rpm-libs \
"

URI_satyr-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/satyr-devel-0.43-3.el10.x86_64_v2.rpm;name=satyr-devel;unpack=0"
SRC_URI += "${URI_satyr-devel}"
SRC_URI[satyr-devel.sha256sum] = "ec31352f41a1d14831af6cc119d9c366bb6f5de59bd8ee1d5605ba36b3f768b6"
RDEPENDS:satyr-devel = " \
 satyr \
 pkgconf-pkg-config \
 json-c-devel \
"
