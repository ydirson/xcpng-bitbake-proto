# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "readline"
PE = "0"
PV = "8.2"
PR = "11.el10"
PACKAGES = "readline readline-devel readline-static"
PROVIDES = "rpm/readline rpm/readline-devel rpm/readline-static"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/readline-8.2-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5f45f935633181b1f42be16e2381622ae4298d1fbe9524bc4ce93ad13238692"

URI_readline = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/readline-8.2-11.el10.x86_64_v2.rpm;name=readline;unpack=0"
SRC_URI += "${URI_readline}"
SRC_URI[readline.sha256sum] = "2f1613b41d576a6177696c3909a193a833fddb70d374ff21d6cf95d3c4ef9c5e"
RDEPENDS:readline = " \
 glibc \
 ncurses-libs \
"

URI_readline-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/readline-devel-8.2-11.el10.x86_64_v2.rpm;name=readline-devel;unpack=0"
SRC_URI += "${URI_readline-devel}"
SRC_URI[readline-devel.sha256sum] = "708af3720e998c0ff01dceecfd742770e8825cc3b13e13710830f06937e56537"
RDEPENDS:readline-devel = " \
 ncurses-devel \
 readline \
 pkgconf-pkg-config \
"

URI_readline-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/readline-static-8.2-11.el10.x86_64_v2.rpm;name=readline-static;unpack=0"
SRC_URI += "${URI_readline-static}"
SRC_URI[readline-static.sha256sum] = "f0d1de31c57ec9fe5adcad8e68440521843c4ae434105080ad62423c2ef789b1"
RDEPENDS:readline-static = " \
 readline-devel \
"
