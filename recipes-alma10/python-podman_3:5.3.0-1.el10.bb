# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-podman"
PE = "3"
PV = "5.3.0"
PR = "1.el10"
PACKAGES = "python3-podman python3-podman+progress_bar"
PROVIDES = "rpm/python3-podman rpm/python3-podman+progress_bar"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-podman-5.3.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12d14d6e849485d3ccdc34d6389cc3d48ee2a40b5ab506c4ca084d77e6f52cd4"

URI_python3-podman = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-podman-5.3.0-1.el10.noarch.rpm;name=python3-podman;unpack=0"
SRC_URI += "${URI_python3-podman}"
SRC_URI[python3-podman.sha256sum] = "1ba9b4e63218ded6ac5a3c93f73281abba643e993533afab37bf7957de28a0fc"
RDEPENDS:python3-podman = " \
 python3-urllib3 \
 python3-requests \
 python3 \
"

URI_python3-podman+progress_bar = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-podman+progress_bar-5.3.0-1.el10.noarch.rpm;name=python3-podman+progress_bar;unpack=0"
SRC_URI += "${URI_python3-podman+progress_bar}"
SRC_URI[python3-podman+progress_bar.sha256sum] = "ea2b0141b588719069981d3ba5ae2acad22d98437554063317a373ea9f35df6f"
RDEPENDS:python3-podman+progress_bar = " \
 python3 \
 python3-podman \
"
