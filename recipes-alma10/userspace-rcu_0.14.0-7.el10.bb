# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "userspace-rcu"
PE = "0"
PV = "0.14.0"
PR = "7.el10"
PACKAGES = "userspace-rcu userspace-rcu-devel"
PROVIDES = "rpm/userspace-rcu rpm/userspace-rcu-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/userspace-rcu-0.14.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c633fa158e8c0544f028d659ac07321f2baec3c57de24336fe1b5f246e808862"

URI_userspace-rcu = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/userspace-rcu-0.14.0-7.el10.x86_64_v2.rpm;name=userspace-rcu;unpack=0"
SRC_URI += "${URI_userspace-rcu}"
SRC_URI[userspace-rcu.sha256sum] = "69d599aa9782ebb739f38ef05fd0d2307ae3edbec3a1f6cdbacd1b4347f0e786"
RDEPENDS:userspace-rcu = " \
 glibc \
"

URI_userspace-rcu-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/userspace-rcu-devel-0.14.0-7.el10.x86_64_v2.rpm;name=userspace-rcu-devel;unpack=0"
SRC_URI += "${URI_userspace-rcu-devel}"
SRC_URI[userspace-rcu-devel.sha256sum] = "544e7d0dfc80e8d681df296b54be7f4beae8fb380faa336be8d85bf04513b68c"
RDEPENDS:userspace-rcu-devel = " \
 pkgconf-pkg-config \
 userspace-rcu \
"
