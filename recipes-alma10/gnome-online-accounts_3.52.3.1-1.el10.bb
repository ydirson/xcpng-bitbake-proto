# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-online-accounts"
PE = "0"
PV = "3.52.3.1"
PR = "1.el10"
PACKAGES = "gnome-online-accounts gnome-online-accounts-devel"
PROVIDES = "rpm/gnome-online-accounts rpm/gnome-online-accounts-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-online-accounts-3.52.3.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b650704c115b2260e9c65728cf4734900cd903cc359b9aeeb9db25a4a0bad659"

URI_gnome-online-accounts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-online-accounts-3.52.3.1-1.el10.x86_64_v2.rpm;name=gnome-online-accounts;unpack=0"
SRC_URI += "${URI_gnome-online-accounts}"
SRC_URI[gnome-online-accounts.sha256sum] = "fb023eae6cb04ea58be669a0658d6115d64e1fc1fd9d81d0efc6b47ed71e9c56"
RDEPENDS:gnome-online-accounts = " \
 libsoup3 \
 gvfs-goa \
 keyutils-libs \
 libgcc \
 rest \
 libxml2 \
 json-glib \
 krb5-libs \
 libsecret \
 glib2 \
 glibc \
 gtk4 \
 libadwaita \
 gcr-libs \
"

URI_gnome-online-accounts-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gnome-online-accounts-devel-3.52.3.1-1.el10.x86_64_v2.rpm;name=gnome-online-accounts-devel;unpack=0"
SRC_URI += "${URI_gnome-online-accounts-devel}"
SRC_URI[gnome-online-accounts-devel.sha256sum] = "929bde50df52dd7ba826965a2d76db5da4fb3b3f2f70848837812f6af9e80de1"
RDEPENDS:gnome-online-accounts-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 gnome-online-accounts-devel \
 libadwaita-devel \
 gnome-online-accounts \
 gtk4-devel \
"
