# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "felix-parent"
PE = "0"
PV = "8"
PR = "6.el10"
PACKAGES = "felix-parent"
PROVIDES = "rpm/felix-parent"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/felix-parent-8-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de6802b72e1b65db184d624b9eed4aee38f6a0d35c4f6496ec87f72035523d71"

URI_felix-parent = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/felix-parent-8-6.el10.noarch.rpm;name=felix-parent;unpack=0"
SRC_URI += "${URI_felix-parent}"
SRC_URI[felix-parent.sha256sum] = "4189b42f62de438eacac42aa74b0a09d63f08834f79e692be2a60ecf14213c6c"
RDEPENDS:felix-parent = " \
 javapackages-filesystem \
 apache-parent \
"
