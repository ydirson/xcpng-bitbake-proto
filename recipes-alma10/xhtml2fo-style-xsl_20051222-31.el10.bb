# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xhtml2fo-style-xsl"
PE = "0"
PV = "20051222"
PR = "31.el10"
PACKAGES = "xhtml2fo-style-xsl"
PROVIDES = "rpm/xhtml2fo-style-xsl"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xhtml2fo-style-xsl-20051222-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "719d749b3a9981ef8c26deea8a95df8a04b6658c33290ffa5695ce2a4888e37e"

URI_xhtml2fo-style-xsl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xhtml2fo-style-xsl-20051222-31.el10.noarch.rpm;name=xhtml2fo-style-xsl;unpack=0"
SRC_URI += "${URI_xhtml2fo-style-xsl}"
SRC_URI[xhtml2fo-style-xsl.sha256sum] = "1bae8a1732c0ae2a3189e3fe11b2fd1d07f4693f95f3d0802a917102b05349ab"
RDEPENDS:xhtml2fo-style-xsl = " \
 xhtml1-dtds \
 bash \
 xml-common \
"
