# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-ht"
PE = "0"
PV = "0.06"
PR = "30.el10"
PACKAGES = "hunspell-ht"
PROVIDES = "rpm/hunspell-ht"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-ht-0.06-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3d32b9528f03e70fa82092da1733875d126701a15153c89c739437f39a3a6a4"

URI_hunspell-ht = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-ht-0.06-30.el10.noarch.rpm;name=hunspell-ht;unpack=0"
SRC_URI += "${URI_hunspell-ht}"
SRC_URI[hunspell-ht.sha256sum] = "9fddc506bade75638defd4f8859efd0cbaec378930269e8158014dea7187139f"
RDEPENDS:hunspell-ht = " \
 hunspell-filesystem \
"
