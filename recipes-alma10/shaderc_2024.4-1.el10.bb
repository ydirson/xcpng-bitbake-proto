# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "shaderc"
PE = "0"
PV = "2024.4"
PR = "1.el10"
PACKAGES = "glslc libshaderc libshaderc-devel libshaderc-static"
PROVIDES = "rpm/glslc rpm/libshaderc rpm/libshaderc-devel rpm/libshaderc-static"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/shaderc-2024.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e3bb401eb009da787414c3a05617a4e3510f742bdcab63da4fc39a031870515"

URI_glslc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/glslc-2024.4-1.el10.x86_64_v2.rpm;name=glslc;unpack=0"
SRC_URI += "${URI_glslc}"
SRC_URI[glslc.sha256sum] = "0e0e197b3f3ef8319656d775c7a41b7541f7b9a1d555117bf2e93bbc056e9c83"
RDEPENDS:glslc = " \
 glibc \
 spirv-tools-libs \
 libgcc \
 libstdc++ \
"

URI_libshaderc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libshaderc-2024.4-1.el10.x86_64_v2.rpm;name=libshaderc;unpack=0"
SRC_URI += "${URI_libshaderc}"
SRC_URI[libshaderc.sha256sum] = "dceef61161c558a457ecbae41319bc34c78826ea1703f5372fdea3c34a46c3fa"
RDEPENDS:libshaderc = " \
 glibc \
 spirv-tools-libs \
 libgcc \
 libstdc++ \
"

URI_libshaderc-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libshaderc-devel-2024.4-1.el10.x86_64_v2.rpm;name=libshaderc-devel;unpack=0"
SRC_URI += "${URI_libshaderc-devel}"
SRC_URI[libshaderc-devel.sha256sum] = "7c4e3b0ceea38f10e7d28f67a971f0345c8e8dc29083d2d86534c8ac29949b16"
RDEPENDS:libshaderc-devel = " \
 libshaderc \
 pkgconf-pkg-config \
"

URI_libshaderc-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libshaderc-static-2024.4-1.el10.x86_64_v2.rpm;name=libshaderc-static;unpack=0"
SRC_URI += "${URI_libshaderc-static}"
SRC_URI[libshaderc-static.sha256sum] = "e9b7969568e9b5de50309fd5b65ace9af204bb35c2e45c527b2d269fbb412fd3"
RDEPENDS:libshaderc-static = " \
 pkgconf-pkg-config \
"
