# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "yelp-xsl"
PE = "0"
PV = "42.1"
PR = "7.el10"
PACKAGES = "yelp-xsl yelp-xsl-devel"
PROVIDES = "rpm/yelp-xsl rpm/yelp-xsl-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/yelp-xsl-42.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d17098190d48f1b7364f9ee423358b8cb9b6e98c55c222a896ba2e989ed45d35"

URI_yelp-xsl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/yelp-xsl-42.1-7.el10.noarch.rpm;name=yelp-xsl;unpack=0"
SRC_URI += "${URI_yelp-xsl}"
SRC_URI[yelp-xsl.sha256sum] = "60f5625a4a65e19857aedde9da36f6882290a7cada3e40931f8d5fac91553df9"
RDEPENDS:yelp-xsl = ""

URI_yelp-xsl-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/yelp-xsl-devel-42.1-7.el10.noarch.rpm;name=yelp-xsl-devel;unpack=0"
SRC_URI += "${URI_yelp-xsl-devel}"
SRC_URI[yelp-xsl-devel.sha256sum] = "7da5d2759182c76feb40d17aefccb6ded2c53b2eb5757d170cb1c756e979a0d3"
RDEPENDS:yelp-xsl-devel = " \
 yelp-xsl \
 pkgconf-pkg-config \
"
