# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "console-login-helper-messages"
PE = "0"
PV = "0.21.3"
PR = "10.el10"
PACKAGES = "console-login-helper-messages console-login-helper-messages-issuegen console-login-helper-messages-motdgen console-login-helper-messages-profile"
PROVIDES = "rpm/console-login-helper-messages rpm/console-login-helper-messages-issuegen rpm/console-login-helper-messages-motdgen rpm/console-login-helper-messages-profile"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/console-login-helper-messages-0.21.3-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92a4c67da267462ea0b574f92f8cfcc04c051651d1cffb340284efa4ecc05104"

URI_console-login-helper-messages = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/console-login-helper-messages-0.21.3-10.el10.noarch.rpm;name=console-login-helper-messages;unpack=0"
SRC_URI += "${URI_console-login-helper-messages}"
SRC_URI[console-login-helper-messages.sha256sum] = "cc054327c5e6c8f3de3a497bd651612822d85bfa50ad5098ffc248d1a4587a42"
RDEPENDS:console-login-helper-messages = " \
 systemd \
 bash \
"

URI_console-login-helper-messages-issuegen = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/console-login-helper-messages-issuegen-0.21.3-10.el10.noarch.rpm;name=console-login-helper-messages-issuegen;unpack=0"
SRC_URI += "${URI_console-login-helper-messages-issuegen}"
SRC_URI[console-login-helper-messages-issuegen.sha256sum] = "6579dbb38cfb81ae472a858383834e05daebc46d75a071182dab439558922655"
RDEPENDS:console-login-helper-messages-issuegen = " \
 setup \
 systemd \
 NetworkManager \
 util-linux \
 bash \
 almalinux-release \
 console-login-helper-messages \
"

URI_console-login-helper-messages-motdgen = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/console-login-helper-messages-motdgen-0.21.3-10.el10.noarch.rpm;name=console-login-helper-messages-motdgen;unpack=0"
SRC_URI += "${URI_console-login-helper-messages-motdgen}"
SRC_URI[console-login-helper-messages-motdgen.sha256sum] = "c49d52907d7e58a4f3bea585b25eade420f4efec5470622da89e4f28090189e8"
RDEPENDS:console-login-helper-messages-motdgen = " \
 setup \
 systemd \
 util-linux \
 pam \
 bash \
 selinux-policy \
 console-login-helper-messages \
"

URI_console-login-helper-messages-profile = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/console-login-helper-messages-profile-0.21.3-10.el10.noarch.rpm;name=console-login-helper-messages-profile;unpack=0"
SRC_URI += "${URI_console-login-helper-messages-profile}"
SRC_URI[console-login-helper-messages-profile.sha256sum] = "0e0efdf2364eca10f3c4b689f98f926f78ed41784e2b52b68730d6883ac7ed96"
RDEPENDS:console-login-helper-messages-profile = " \
 console-login-helper-messages \
 setup \
 systemd \
 bash \
"
