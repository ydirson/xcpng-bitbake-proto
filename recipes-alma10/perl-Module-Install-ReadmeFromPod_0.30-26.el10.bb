# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Module-Install-ReadmeFromPod"
PE = "0"
PV = "0.30"
PR = "26.el10"
PACKAGES = "perl-Module-Install-ReadmeFromPod"
PROVIDES = "rpm/perl-Module-Install-ReadmeFromPod"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Module-Install-ReadmeFromPod-0.30-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6209f75c301be763619a82f67f1bf4f658370cfdf51db365c3cf1dc4d4a7eb5"

URI_perl-Module-Install-ReadmeFromPod = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Module-Install-ReadmeFromPod-0.30-26.el10.noarch.rpm;name=perl-Module-Install-ReadmeFromPod;unpack=0"
SRC_URI += "${URI_perl-Module-Install-ReadmeFromPod}"
SRC_URI[perl-Module-Install-ReadmeFromPod.sha256sum] = "c4ea5bc195ca870999d7e2b4d77e3c8df82a3c13c310128bfd87eb34426a2d98"
RDEPENDS:perl-Module-Install-ReadmeFromPod = " \
 perl-libs \
 perl-vars \
 perl-Module-Install \
 perl-Capture-Tiny \
 perl-Pod-Markdown \
 perl-podlators \
 perl-Pod-Html \
 perl-base \
 perl-IO-All \
"
