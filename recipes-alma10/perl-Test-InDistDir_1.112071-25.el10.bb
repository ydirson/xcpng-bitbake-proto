# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Test-InDistDir"
PE = "0"
PV = "1.112071"
PR = "25.el10"
PACKAGES = "perl-Test-InDistDir"
PROVIDES = "rpm/perl-Test-InDistDir"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/perl-Test-InDistDir-1.112071-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4b9b1c95d4a8bc79e447daae33c739b644b79d0ae214a7c799b6aec579344f4"

URI_perl-Test-InDistDir = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Test-InDistDir-1.112071-25.el10.noarch.rpm;name=perl-Test-InDistDir;unpack=0"
SRC_URI += "${URI_perl-Test-InDistDir}"
SRC_URI[perl-Test-InDistDir.sha256sum] = "c529a4b11d9be40004dcbf01535347bb17642b2b8f6be324322f3d2f4ae2cc53"
RDEPENDS:perl-Test-InDistDir = " \
 perl-PathTools \
 perl-libs \
 perl-lib \
"
