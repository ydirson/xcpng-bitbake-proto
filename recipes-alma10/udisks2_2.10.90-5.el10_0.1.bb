# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "udisks2"
PE = "0"
PV = "2.10.90"
PR = "5.el10_0.1"
PACKAGES = "libudisks2 udisks2 udisks2-iscsi udisks2-lsm udisks2-lvm2 libudisks2-devel"
PROVIDES = "rpm/libudisks2 rpm/udisks2 rpm/udisks2-iscsi rpm/udisks2-lsm rpm/udisks2-lvm2 rpm/libudisks2-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/udisks2-2.10.90-5.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e22674b7ebfd41ec97b1802945bf627143459fae8aad97d72e9a6508c9d9487"

URI_libudisks2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libudisks2-2.10.90-5.el10_0.1.x86_64_v2.rpm;name=libudisks2;unpack=0"
SRC_URI += "${URI_libudisks2}"
SRC_URI[libudisks2.sha256sum] = "7c3cebf82b3c98a647f004f43abfe3a6879c2a7c47a3deafe3259028657b13dc"
RDEPENDS:libudisks2 = " \
 glibc \
 glib2 \
"

URI_udisks2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/udisks2-2.10.90-5.el10_0.1.x86_64_v2.rpm;name=udisks2;unpack=0"
SRC_URI += "${URI_udisks2}"
SRC_URI[udisks2.sha256sum] = "ecef6ae1f94812714dd79174404d6d541b01a8478686a72697c7fbab9577fab6"
RDEPENDS:udisks2 = " \
 systemd-libs \
 systemd-udev \
 libudisks2 \
 dbus \
 libacl \
 util-linux \
 libblkid \
 libuuid \
 libgcc \
 libblockdev \
 libblockdev-crypto \
 libgudev \
 bash \
 libblockdev-fs \
 libblockdev-loop \
 libblockdev-mdraid \
 libblockdev-nvme \
 libmount \
 libblockdev-part \
 polkit \
 polkit-libs \
 libblockdev-smart \
 glib2 \
 glibc \
 libblockdev-swap \
 libblockdev-utils \
"

URI_udisks2-iscsi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/udisks2-iscsi-2.10.90-5.el10_0.1.x86_64_v2.rpm;name=udisks2-iscsi;unpack=0"
SRC_URI += "${URI_udisks2-iscsi}"
SRC_URI[udisks2-iscsi.sha256sum] = "827b5fd9f1b12ed67fcfe53421906e1a2204612493fa577cefd5ae122eb6970b"
RDEPENDS:udisks2-iscsi = " \
 libuuid \
 libacl \
 systemd-libs \
 libgcc \
 libblkid \
 libmount \
 libblockdev \
 libudisks2 \
 libgudev \
 iscsi-initiator-utils \
 polkit-libs \
 glib2 \
 glibc \
 libblockdev-utils \
"

URI_udisks2-lsm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/udisks2-lsm-2.10.90-5.el10_0.1.x86_64_v2.rpm;name=udisks2-lsm;unpack=0"
SRC_URI += "${URI_udisks2-lsm}"
SRC_URI[udisks2-lsm.sha256sum] = "e52003d31dcac87b387b9a7ee1d48f6c295ba1270ed41cedba48e7c32b3efec0"
RDEPENDS:udisks2-lsm = " \
 libuuid \
 libacl \
 systemd-libs \
 libgcc \
 libblkid \
 libmount \
 libblockdev \
 libudisks2 \
 libgudev \
 libstoragemgmt \
 polkit-libs \
 glib2 \
 libconfig \
 glibc \
 libblockdev-utils \
"

URI_udisks2-lvm2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/udisks2-lvm2-2.10.90-5.el10_0.1.x86_64_v2.rpm;name=udisks2-lvm2;unpack=0"
SRC_URI += "${URI_udisks2-lvm2}"
SRC_URI[udisks2-lvm2.sha256sum] = "bfbbb4136a88907fd6cc3d1d29e02b16a224256ccfd74d423b84132188fd70eb"
RDEPENDS:udisks2-lvm2 = " \
 libuuid \
 libacl \
 systemd-libs \
 lvm2 \
 libgcc \
 libblkid \
 libmount \
 libblockdev \
 libudisks2 \
 libgudev \
 polkit-libs \
 glib2 \
 glibc \
 libblockdev-lvm \
 libblockdev-utils \
"

URI_libudisks2-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libudisks2-devel-2.10.90-5.el10_0.1.x86_64_v2.rpm;name=libudisks2-devel;unpack=0"
SRC_URI += "${URI_libudisks2-devel}"
SRC_URI[libudisks2-devel.sha256sum] = "806b00a01550181e8d2ef30e67500a8d00e5b4942038242a2eca566a3a29c661"
RDEPENDS:libudisks2-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 libudisks2-devel \
 libudisks2 \
"
