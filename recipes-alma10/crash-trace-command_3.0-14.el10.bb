# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "crash-trace-command"
PE = "0"
PV = "3.0"
PR = "14.el10"
PACKAGES = "crash-trace-command"
PROVIDES = "rpm/crash-trace-command"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/crash-trace-command-3.0-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0b655e2d72b2f006bf58673744fbce340a9b5d61241760b9b416318dfb8153e"

URI_crash-trace-command = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/crash-trace-command-3.0-14.el10.x86_64_v2.rpm;name=crash-trace-command;unpack=0"
SRC_URI += "${URI_crash-trace-command}"
SRC_URI[crash-trace-command.sha256sum] = "c0142828fde5dcfbb09074d684dc69c32a3022b19f841515e135feecb0e0f9bf"
RDEPENDS:crash-trace-command = " \
 glibc \
 trace-cmd \
 crash \
"
