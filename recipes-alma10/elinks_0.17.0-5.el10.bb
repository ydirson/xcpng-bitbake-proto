# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "elinks"
PE = "0"
PV = "0.17.0"
PR = "5.el10"
PACKAGES = "elinks"
PROVIDES = "rpm/elinks"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/elinks-0.17.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "626ba9e1f9219188471a47850ddcc82bb182d28f722c28dda979f0a1fdeddcb6"

URI_elinks = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/elinks-0.17.0-5.el10.x86_64_v2.rpm;name=elinks;unpack=0"
SRC_URI += "${URI_elinks}"
SRC_URI[elinks.sha256sum] = "c63d6f5f7abadbc8016ce1c7cf8789ed51b20104f291a1bec20f2ae2c5de8e75"
RDEPENDS:elinks = " \
 zlib-ng-compat \
 bzip2-libs \
 openssl-libs \
 krb5-libs \
 bash \
 expat \
 glibc \
 coreutils \
 libidn2 \
 alternatives \
"
