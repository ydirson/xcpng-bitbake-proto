# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "cscope"
PE = "0"
PV = "15.9"
PR = "26.el10"
PACKAGES = "cscope"
PROVIDES = "rpm/cscope"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/cscope-15.9-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5592bfa802212990c627801fde08f34831b401e1ceb03d00802a976c1a3ee77f"

URI_cscope = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cscope-15.9-26.el10.x86_64_v2.rpm;name=cscope;unpack=0"
SRC_URI += "${URI_cscope}"
SRC_URI[cscope.sha256sum] = "e856e3393ea8ce21c49fab6ce1d5045b9d577679b83950b091c8a62ef67451c3"
RDEPENDS:cscope = " \
 emacs-filesystem \
 ed \
 bash \
 ncurses-libs \
 glibc \
 coreutils \
"
