# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-requests-file"
PE = "0"
PV = "2.0.0"
PR = "4.el10"
PACKAGES = "python3-requests-file"
PROVIDES = "rpm/python3-requests-file"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-requests-file-2.0.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f029ddf22c1e07db79150e6b32fbba79be8583f5ebfe9fd0f067cd36179ebcfb"

URI_python3-requests-file = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-requests-file-2.0.0-4.el10.noarch.rpm;name=python3-requests-file;unpack=0"
SRC_URI += "${URI_python3-requests-file}"
SRC_URI[python3-requests-file.sha256sum] = "df77d788a3ea2b57ce8a76e81f74d4c473c24a472f2136d79b03b464620d6fa1"
RDEPENDS:python3-requests-file = " \
 python3 \
 python3-requests \
"
