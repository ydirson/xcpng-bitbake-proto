# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-mi"
PE = "0"
PV = "0.20080630"
PR = "32.el10"
PACKAGES = "hyphen-mi"
PROVIDES = "rpm/hyphen-mi"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-mi-0.20080630-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19f87f238171449bf161858f731771b002b3c2d4afdb2b70b9355677e11c4827"

URI_hyphen-mi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-mi-0.20080630-32.el10.noarch.rpm;name=hyphen-mi;unpack=0"
SRC_URI += "${URI_hyphen-mi}"
SRC_URI[hyphen-mi.sha256sum] = "91dff29e427d2859d59e1e59e63f0cc56aee2c1d7bf581b66e069172cd4b3f1d"
RDEPENDS:hyphen-mi = " \
 hyphen \
"
