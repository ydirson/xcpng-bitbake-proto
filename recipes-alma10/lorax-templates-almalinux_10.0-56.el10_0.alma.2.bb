# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lorax-templates-almalinux"
PE = "0"
PV = "10.0"
PR = "56.el10_0.alma.2"
PACKAGES = "lorax-templates-almalinux"
PROVIDES = "rpm/lorax-templates-almalinux"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/lorax-templates-almalinux-10.0-56.el10_0.alma.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83d27a3e9b66828d1e2b790bf962aefd80955b0c998f413606a9a5d7a547a768"

URI_lorax-templates-almalinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lorax-templates-almalinux-10.0-56.el10_0.alma.2.noarch.rpm;name=lorax-templates-almalinux;unpack=0"
SRC_URI += "${URI_lorax-templates-almalinux}"
SRC_URI[lorax-templates-almalinux.sha256sum] = "e6a35f3282c2ff3d3554cf0d067cf20eacbcc2f63b1da20a98506cf7f1cf9dc8"
RDEPENDS:lorax-templates-almalinux = " \
 lorax \
"
