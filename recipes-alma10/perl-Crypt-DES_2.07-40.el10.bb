# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Crypt-DES"
PE = "0"
PV = "2.07"
PR = "40.el10"
PACKAGES = "perl-Crypt-DES"
PROVIDES = "rpm/perl-Crypt-DES"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Crypt-DES-2.07-40.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ddefa9a78ef2eeb0b86c725c4c694d4c77c67efdd224ef1f11312ca4d4a209e1"

URI_perl-Crypt-DES = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Crypt-DES-2.07-40.el10.x86_64_v2.rpm;name=perl-Crypt-DES;unpack=0"
SRC_URI += "${URI_perl-Crypt-DES}"
SRC_URI[perl-Crypt-DES.sha256sum] = "d307413845f77c32f5ad58e66969d0915c4db557089087da431bb9ff1c451b10"
RDEPENDS:perl-Crypt-DES = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-DynaLoader \
 glibc \
 perl-Exporter \
"
