# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "flashrom"
PE = "0"
PV = "1.3.0"
PR = "8.el10"
PACKAGES = "flashrom flashrom-devel"
PROVIDES = "rpm/flashrom rpm/flashrom-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/flashrom-1.3.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a01fba84460d39db36ba179cf0cdc06e8beaedce2d7de25f207e6779ca099d62"

URI_flashrom = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/flashrom-1.3.0-8.el10.x86_64_v2.rpm;name=flashrom;unpack=0"
SRC_URI += "${URI_flashrom}"
SRC_URI[flashrom.sha256sum] = "e1b8dc762780bdc884bbd2334f2ad5b5e4b81bda3d6bbd3b6d598b74feb41719"
RDEPENDS:flashrom = " \
 systemd-udev \
 dmidecode \
 pciutils-libs \
 glibc \
 libusb1 \
"

URI_flashrom-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/flashrom-devel-1.3.0-8.el10.x86_64_v2.rpm;name=flashrom-devel;unpack=0"
SRC_URI += "${URI_flashrom-devel}"
SRC_URI[flashrom-devel.sha256sum] = "d6d8402db6232bd5a418d4de300078276a03a79b0000f9c19457dd28787b2229"
RDEPENDS:flashrom-devel = " \
 libusb1-devel \
 flashrom \
 pkgconf-pkg-config \
 pciutils-devel \
"
