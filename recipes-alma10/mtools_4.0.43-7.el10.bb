# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mtools"
PE = "0"
PV = "4.0.43"
PR = "7.el10"
PACKAGES = "mtools"
PROVIDES = "rpm/mtools"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/mtools-4.0.43-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a32960e9a08ee4b209eb9b13f9dd9eec5176740ae72120c366673bc2e8bca68"

URI_mtools = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/mtools-4.0.43-7.el10.x86_64_v2.rpm;name=mtools;unpack=0"
SRC_URI += "${URI_mtools}"
SRC_URI[mtools.sha256sum] = "2675ebb8333b9c1746d09af7b69c614912094cfcf08d6fa22fb2f339f06d6935"
RDEPENDS:mtools = " \
 glibc \
 bash \
 glibc-gconv-extra \
"
