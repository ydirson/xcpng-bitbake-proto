# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gtk-vnc"
PE = "0"
PV = "1.3.1"
PR = "7.el10"
PACKAGES = "gtk-vnc2 gvnc gvncpulse gtk-vnc2-devel gvnc-devel gvnc-tools gvncpulse-devel"
PROVIDES = "rpm/gtk-vnc2 rpm/gvnc rpm/gvncpulse rpm/gtk-vnc2-devel rpm/gvnc-devel rpm/gvnc-tools rpm/gvncpulse-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gtk-vnc-1.3.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c6146fdff4c288fc2f5530d93ff5fea7a911bb759fdc7881e4443fb4b65014f"

URI_gtk-vnc2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gtk-vnc2-1.3.1-7.el10.x86_64_v2.rpm;name=gtk-vnc2;unpack=0"
SRC_URI += "${URI_gtk-vnc2}"
SRC_URI[gtk-vnc2.sha256sum] = "921a35c73ab07414375652953ea73104f0772fa055e4281b98e506be098a2fdd"
RDEPENDS:gtk-vnc2 = " \
 gdk-pixbuf2 \
 libX11 \
 gvnc \
 cairo \
 glib2 \
 gtk3 \
 glibc \
"

URI_gvnc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gvnc-1.3.1-7.el10.x86_64_v2.rpm;name=gvnc;unpack=0"
SRC_URI += "${URI_gvnc}"
SRC_URI[gvnc.sha256sum] = "1f7dd4c6b51dd34c6552da57cdbe17bdfdf21665412fca6824ba431b95282aa5"
RDEPENDS:gvnc = " \
 zlib-ng-compat \
 gnutls \
 libgcrypt \
 gdk-pixbuf2 \
 cyrus-sasl-lib \
 glib2 \
 glibc \
"

URI_gvncpulse = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gvncpulse-1.3.1-7.el10.x86_64_v2.rpm;name=gvncpulse;unpack=0"
SRC_URI += "${URI_gvncpulse}"
SRC_URI[gvncpulse.sha256sum] = "ec08f3b9dde2c44f69e83b258796d657c94f87761273b104b8cbf63ff0d0c492"
RDEPENDS:gvncpulse = " \
 glibc \
 pulseaudio-libs \
 glib2 \
 gvnc \
"

URI_gtk-vnc2-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gtk-vnc2-devel-1.3.1-7.el10.x86_64_v2.rpm;name=gtk-vnc2-devel;unpack=0"
SRC_URI += "${URI_gtk-vnc2-devel}"
SRC_URI[gtk-vnc2-devel.sha256sum] = "efd33833dce6fb63a49fab5fcef566af2863cb453e273cfdcbe57e553ac89371"
RDEPENDS:gtk-vnc2-devel = " \
 libgcrypt-devel \
 glib2-devel \
 gnutls-devel \
 zlib-ng-compat-devel \
 cyrus-sasl-devel \
 pkgconf-pkg-config \
 gdk-pixbuf2-devel \
 libX11-devel \
 gtk-vnc2 \
 gtk3-devel \
 gvnc-devel \
"

URI_gvnc-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/gvnc-devel-1.3.1-7.el10.x86_64_v2.rpm;name=gvnc-devel;unpack=0"
SRC_URI += "${URI_gvnc-devel}"
SRC_URI[gvnc-devel.sha256sum] = "afa4db14a4378464d694d16354cb93bd06c39cf1abc93891f8c5a1f3e8adeceb"
RDEPENDS:gvnc-devel = " \
 libgcrypt-devel \
 glib2-devel \
 gnutls-devel \
 zlib-ng-compat-devel \
 cyrus-sasl-devel \
 pkgconf-pkg-config \
 gvnc \
 gdk-pixbuf2-devel \
"

URI_gvnc-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gvnc-tools-1.3.1-7.el10.x86_64_v2.rpm;name=gvnc-tools;unpack=0"
SRC_URI += "${URI_gvnc-tools}"
SRC_URI[gvnc-tools.sha256sum] = "261987e23b6ef393d50a9f28bb97a42ae3ac6be8f4f724e0f8a389b4c0e5c6eb"
RDEPENDS:gvnc-tools = " \
 glibc \
 gvnc \
 glib2 \
 gdk-pixbuf2 \
"

URI_gvncpulse-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/gvncpulse-devel-1.3.1-7.el10.x86_64_v2.rpm;name=gvncpulse-devel;unpack=0"
SRC_URI += "${URI_gvncpulse-devel}"
SRC_URI[gvncpulse-devel.sha256sum] = "c31f9c379964c6f83f3bb860d6ab708de5997ad4cb3dd6e82ca8028c5aa29943"
RDEPENDS:gvncpulse-devel = " \
 libgcrypt-devel \
 glib2-devel \
 gnutls-devel \
 zlib-ng-compat-devel \
 cyrus-sasl-devel \
 pulseaudio-libs-devel \
 pkgconf-pkg-config \
 gvncpulse \
 gdk-pixbuf2-devel \
 gvnc-devel \
"
