# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "vulkan-headers"
PE = "0"
PV = "1.4.304.0"
PR = "2.el10"
PACKAGES = "vulkan-headers"
PROVIDES = "rpm/vulkan-headers"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/vulkan-headers-1.4.304.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25c04e32e6614ec6f719a9246175c393648a20d69b1f8736d8efa64949101eb9"

URI_vulkan-headers = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/vulkan-headers-1.4.304.0-2.el10.noarch.rpm;name=vulkan-headers;unpack=0"
SRC_URI += "${URI_vulkan-headers}"
SRC_URI[vulkan-headers.sha256sum] = "c1e93ff1fa662600c693d7f0565c82c98461849a91799250ec9245cbbfba8810"
RDEPENDS:vulkan-headers = " \
 python3 \
 cmake-filesystem \
"
