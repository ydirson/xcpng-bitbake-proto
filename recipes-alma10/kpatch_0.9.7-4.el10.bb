# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "kpatch"
PE = "0"
PV = "0.9.7"
PR = "4.el10"
PACKAGES = "kpatch kpatch-dnf"
PROVIDES = "rpm/kpatch rpm/kpatch-dnf"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/kpatch-0.9.7-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03b02ccbfd27aa1fe4f6296606d367d9ebd5aa25f3db62c39a5897307fcef685"

URI_kpatch = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kpatch-0.9.7-4.el10.noarch.rpm;name=kpatch;unpack=0"
SRC_URI += "${URI_kpatch}"
SRC_URI[kpatch.sha256sum] = "72db9a615b79bd2ce462c1ed95c20b22eec16d4cc36a45560f107c5f4ae0f2cf"
RDEPENDS:kpatch = " \
 kmod \
 bash \
 binutils \
"

URI_kpatch-dnf = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/kpatch-dnf-0.9.7_0.4-4.el10.noarch.rpm;name=kpatch-dnf;unpack=0"
SRC_URI += "${URI_kpatch-dnf}"
SRC_URI[kpatch-dnf.sha256sum] = "03baa05e7958845e01505c4c70d02bdec388d8d1637c7523a1bdba8b737b6469"
RDEPENDS:kpatch-dnf = " \
 python3 \
 python3-hawkey \
 bash \
 python3-dnf \
"
