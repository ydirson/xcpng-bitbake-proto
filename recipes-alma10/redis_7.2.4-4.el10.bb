# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "redis"
PE = "0"
PV = "7.2.4"
PR = "4.el10"
PACKAGES = "redis redis-devel redis-doc"
PROVIDES = "rpm/redis rpm/redis-devel rpm/redis-doc"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/redis-7.2.4-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "876759327eb4c729976e9fd5d291ac4f6cccbe4c8d34763ca153f1d0c606977b"

URI_redis = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/redis-7.2.4-4.el10.x86_64_v2.rpm;name=redis;unpack=0"
SRC_URI += "${URI_redis}"
SRC_URI[redis.sha256sum] = "1361aef244d3b0cc2857285084d503a2b7ff0eca1a15bda3283fc6908c614193"
RDEPENDS:redis = " \
 logrotate \
 shadow-utils \
 systemd \
 systemd-libs \
 openssl-libs \
 bash \
 glibc \
"

URI_redis-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/redis-devel-7.2.4-4.el10.x86_64_v2.rpm;name=redis-devel;unpack=0"
SRC_URI += "${URI_redis-devel}"
SRC_URI[redis-devel.sha256sum] = "1a8dde0bf19e2ccfe6e038032115f8793b4abd00c8aaafec6def932afecbeba3"
RDEPENDS:redis-devel = ""

URI_redis-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/redis-doc-7.2.4-4.el10.noarch.rpm;name=redis-doc;unpack=0"
SRC_URI += "${URI_redis-doc}"
SRC_URI[redis-doc.sha256sum] = "f88f1270f6d5402eebd97a354cd17cbe31fead131969843a2968a055fb8e98cd"
RDEPENDS:redis-doc = ""
