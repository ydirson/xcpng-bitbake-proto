# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mysql-selinux"
PE = "0"
PV = "1.0.14"
PR = "1.el10_0"
PACKAGES = "mysql-selinux"
PROVIDES = "rpm/mysql-selinux"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mysql-selinux-1.0.14-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77b50027ed7933b14f9410d502a299f89de2b305d0ad6eaa8c2b20c3da4a7fe8"

URI_mysql-selinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mysql-selinux-1.0.14-1.el10_0.noarch.rpm;name=mysql-selinux;unpack=0"
SRC_URI += "${URI_mysql-selinux}"
SRC_URI[mysql-selinux.sha256sum] = "393b6ef07b98aba06d8d9ec311bc54f97f64c3fd2729aaa30024c7861cd21427"
RDEPENDS:mysql-selinux = " \
 policycoreutils-python-utils \
 policycoreutils \
 bash \
 selinux-policy \
 libselinux-utils \
 selinux-policy-targeted \
"
