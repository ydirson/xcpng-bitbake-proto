# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "numpy"
PE = "1"
PV = "1.26.4"
PR = "5.el10"
PACKAGES = "python3-numpy python3-numpy-f2py python3-numpy-doc"
PROVIDES = "rpm/python3-numpy rpm/python3-numpy-f2py rpm/python3-numpy-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/numpy-1.26.4-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4719e106f3f83e5d38cb5cd38189453204b2df283dc53a0aca680bfac23602da"

URI_python3-numpy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-numpy-1.26.4-5.el10.x86_64_v2.rpm;name=python3-numpy;unpack=0"
SRC_URI += "${URI_python3-numpy}"
SRC_URI[python3-numpy.sha256sum] = "92164daf2c2c5b01e4720043292d6064924db3407d8a803df745843d028c3ba5"
RDEPENDS:python3-numpy = " \
 glibc \
 flexiblas-netlib \
 libstdc++ \
 python3 \
"

URI_python3-numpy-f2py = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-numpy-f2py-1.26.4-5.el10.x86_64_v2.rpm;name=python3-numpy-f2py;unpack=0"
SRC_URI += "${URI_python3-numpy-f2py}"
SRC_URI[python3-numpy-f2py.sha256sum] = "71279cad50a296f5fa916b638c7f8366b392eb59182c605baaf67dfd3638eaf0"
RDEPENDS:python3-numpy-f2py = " \
 python3 \
 python3-numpy \
 python3-devel \
"

URI_python3-numpy-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-numpy-doc-1.26.4-5.el10.noarch.rpm;name=python3-numpy-doc;unpack=0"
SRC_URI += "${URI_python3-numpy-doc}"
SRC_URI[python3-numpy-doc.sha256sum] = "1eb0fa2f066e29dc730cad21e167c8974b8be4053ff6430ac7dc1c00f53617b8"
RDEPENDS:python3-numpy-doc = " \
 python3-numpy \
"
