# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libomp"
PE = "0"
PV = "18.1.8"
PR = "2.el10"
PACKAGES = ""
PROVIDES = ""


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/libomp-18.1.8-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcd557afa4bc9af3c540cfc472a8a440056dc28e2260a4152bd40cab6bba715c"
