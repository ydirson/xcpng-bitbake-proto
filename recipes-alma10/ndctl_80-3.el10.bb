# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ndctl"
PE = "0"
PV = "80"
PR = "3.el10"
PACKAGES = "cxl-libs daxctl-libs ndctl ndctl-libs cxl-cli daxctl daxctl-devel ndctl-devel cxl-devel"
PROVIDES = "rpm/cxl-libs rpm/daxctl-libs rpm/ndctl rpm/ndctl-libs rpm/cxl-cli rpm/daxctl rpm/daxctl-devel rpm/ndctl-devel rpm/cxl-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/ndctl-80-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c13a79530bcad70867ba0fed2b856cd241d930830513918b8340e1b26a8f5c8c"

URI_cxl-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/cxl-libs-80-3.el10.x86_64_v2.rpm;name=cxl-libs;unpack=0"
SRC_URI += "${URI_cxl-libs}"
SRC_URI[cxl-libs.sha256sum] = "cd1e175a362877ed4862325d8897a5c53b5152efeacb55976a915d9538d0d1fc"
RDEPENDS:cxl-libs = " \
 libuuid \
 systemd-libs \
 kmod-libs \
 daxctl-libs \
 glibc \
"

URI_daxctl-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/daxctl-libs-80-3.el10.x86_64_v2.rpm;name=daxctl-libs;unpack=0"
SRC_URI += "${URI_daxctl-libs}"
SRC_URI[daxctl-libs.sha256sum] = "c7cbd1a957a9fd8efc0d626d7d5c3808aea2e4119418c7d47149c9871deeb132"
RDEPENDS:daxctl-libs = " \
 glibc \
 libuuid \
 kmod-libs \
"

URI_ndctl = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/ndctl-80-3.el10.x86_64_v2.rpm;name=ndctl;unpack=0"
SRC_URI += "${URI_ndctl}"
SRC_URI[ndctl.sha256sum] = "319f33433775c01b60e46a8e4ac38cd0de297b951f6429cfd497f82fe9750cca"
RDEPENDS:ndctl = " \
 libuuid \
 keyutils-libs \
 json-c \
 cxl-libs \
 bash \
 daxctl-libs \
 iniparser \
 ndctl-libs \
 glibc \
"

URI_ndctl-libs = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/ndctl-libs-80-3.el10.x86_64_v2.rpm;name=ndctl-libs;unpack=0"
SRC_URI += "${URI_ndctl-libs}"
SRC_URI[ndctl-libs.sha256sum] = "0b8213191539360f0a078278c826718bd02f696cc65b599c15f0fc67aee533a0"
RDEPENDS:ndctl-libs = " \
 libuuid \
 systemd-libs \
 kmod-libs \
 daxctl-libs \
 glibc \
"

URI_cxl-cli = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/cxl-cli-80-3.el10.x86_64_v2.rpm;name=cxl-cli;unpack=0"
SRC_URI += "${URI_cxl-cli}"
SRC_URI[cxl-cli.sha256sum] = "8681927d73f1e328349872c7cba65c6373df68388c8d5f55061828dba76314b0"
RDEPENDS:cxl-cli = " \
 libuuid \
 json-c \
 cxl-libs \
 daxctl-libs \
 glibc \
 libtraceevent \
 libtracefs \
"

URI_daxctl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/daxctl-80-3.el10.x86_64_v2.rpm;name=daxctl;unpack=0"
SRC_URI += "${URI_daxctl}"
SRC_URI[daxctl.sha256sum] = "98e6585814332dd04560d00b32f74b77469ee1804dd1435c932d50f0802f9434"
RDEPENDS:daxctl = " \
 libuuid \
 json-c \
 daxctl-libs \
 ndctl-libs \
 iniparser \
 glibc \
"

URI_daxctl-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/daxctl-devel-80-3.el10.x86_64_v2.rpm;name=daxctl-devel;unpack=0"
SRC_URI += "${URI_daxctl-devel}"
SRC_URI[daxctl-devel.sha256sum] = "8c31465ac7a354dfb53a539553da14613761d12abbe6cbaec35e07ff5307d385"
RDEPENDS:daxctl-devel = " \
 daxctl-libs \
 pkgconf-pkg-config \
"

URI_ndctl-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/ndctl-devel-80-3.el10.x86_64_v2.rpm;name=ndctl-devel;unpack=0"
SRC_URI += "${URI_ndctl-devel}"
SRC_URI[ndctl-devel.sha256sum] = "6e3aca034a52d590ee8ebf15c99991aa72514322043c73630a44e5c4d8accfba"
RDEPENDS:ndctl-devel = " \
 pkgconf-pkg-config \
 ndctl-libs \
"

URI_cxl-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/cxl-devel-80-3.el10.x86_64_v2.rpm;name=cxl-devel;unpack=0"
SRC_URI += "${URI_cxl-devel}"
SRC_URI[cxl-devel.sha256sum] = "09d35a4b4a92a927d81ddc401feec1a65fcc21cac7ab9c916b068aaa1f9ecc90"
RDEPENDS:cxl-devel = " \
 pkgconf-pkg-config \
 cxl-libs \
"
