# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-Manifest"
PE = "1"
PV = "1.75"
PR = "511.el10"
PACKAGES = "perl-ExtUtils-Manifest perl-ExtUtils-Manifest-tests"
PROVIDES = "rpm/perl-ExtUtils-Manifest rpm/perl-ExtUtils-Manifest-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-ExtUtils-Manifest-1.75-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25b6d922bfd893191064976bf0ece0b5aa1ceba3bb03b4c1b5dd4fb184e076cc"

URI_perl-ExtUtils-Manifest = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-ExtUtils-Manifest-1.75-511.el10.noarch.rpm;name=perl-ExtUtils-Manifest;unpack=0"
SRC_URI += "${URI_perl-ExtUtils-Manifest}"
SRC_URI[perl-ExtUtils-Manifest.sha256sum] = "27053445326eab81de33b4c5a8a5c2d26a3a7e4009ba6706c417aa2f87034421"
RDEPENDS:perl-ExtUtils-Manifest = " \
 perl-libs \
 perl-Carp \
 perl-File-Basename \
 perl-File-Copy \
 perl-PathTools \
 perl-File-Find \
 perl-Exporter \
 perl-File-Path \
"

URI_perl-ExtUtils-Manifest-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-ExtUtils-Manifest-tests-1.75-511.el10.noarch.rpm;name=perl-ExtUtils-Manifest-tests;unpack=0"
SRC_URI += "${URI_perl-ExtUtils-Manifest-tests}"
SRC_URI[perl-ExtUtils-Manifest-tests.sha256sum] = "97daed097ac7cf2facc165753a1fca49d4871cb0b732e33e6cfff343480f51c8"
RDEPENDS:perl-ExtUtils-Manifest-tests = " \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 perl-ExtUtils-MakeMaker \
 perl-ExtUtils-Manifest \
 bash \
 perl-PathTools \
 perl-File-Find \
 perl-interpreter \
 perl-File-Path \
"
