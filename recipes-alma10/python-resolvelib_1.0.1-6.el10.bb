# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-resolvelib"
PE = "0"
PV = "1.0.1"
PR = "6.el10"
PACKAGES = "python3-resolvelib"
PROVIDES = "rpm/python3-resolvelib"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-resolvelib-1.0.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6556d957c93d43ca290d3c3fe8a5b07fa0e498aca5bb4f1315d7140c1c0a5c7"

URI_python3-resolvelib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-resolvelib-1.0.1-6.el10.noarch.rpm;name=python3-resolvelib;unpack=0"
SRC_URI += "${URI_python3-resolvelib}"
SRC_URI[python3-resolvelib.sha256sum] = "580a14d0c31ba16af83eed40378b7993b224fdd3ae19f36a68fcffcf105335e6"
RDEPENDS:python3-resolvelib = " \
 python3 \
"
