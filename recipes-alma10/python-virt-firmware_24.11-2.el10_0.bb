# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-virt-firmware"
PE = "0"
PV = "24.11"
PR = "2.el10_0"
PACKAGES = "python3-virt-firmware uki-direct python3-virt-firmware-tests"
PROVIDES = "rpm/python3-virt-firmware rpm/uki-direct rpm/python3-virt-firmware-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/python-virt-firmware-24.11-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a57e4c8986aef49965153af16ca3d21b96fa0a86425608497f271df696832f0"

URI_python3-virt-firmware = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-virt-firmware-24.11-2.el10_0.noarch.rpm;name=python3-virt-firmware;unpack=0"
SRC_URI += "${URI_python3-virt-firmware}"
SRC_URI[python3-virt-firmware.sha256sum] = "f8a25777fe63d2f779fe57824dd96a296eeb1a8944eecb969978163e5bc4054c"
RDEPENDS:python3-virt-firmware = " \
 python3 \
 python3-pefile \
 python3-cryptography \
 python3-setuptools \
"

URI_uki-direct = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/uki-direct-24.11-2.el10_0.noarch.rpm;name=uki-direct;unpack=0"
SRC_URI += "${URI_uki-direct}"
SRC_URI[uki-direct.sha256sum] = "24c34c3b7b6b22895c20e6dd74ba0863f09d1f7564935dd69aa9fd5678de1307"
RDEPENDS:uki-direct = " \
 python3-virt-firmware \
 bash \
"

URI_python3-virt-firmware-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-virt-firmware-tests-24.11-2.el10_0.noarch.rpm;name=python3-virt-firmware-tests;unpack=0"
SRC_URI += "${URI_python3-virt-firmware-tests}"
SRC_URI[python3-virt-firmware-tests.sha256sum] = "d632bb91eba89e56793ae904f3966d55c7a748ede678425134a5e3ddae4a21e0"
RDEPENDS:python3-virt-firmware-tests = " \
 python3-virt-firmware \
 python3-pytest \
 bash \
 edk2-ovmf \
"
