# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qt3d"
PE = "0"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = "qt6-qt3d qt6-qt3d-devel qt6-qt3d-examples qt6-qt3d-tests"
PROVIDES = "rpm/qt6-qt3d rpm/qt6-qt3d-devel rpm/qt6-qt3d-examples rpm/qt6-qt3d-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qt3d-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30e2417f14bb548c67d3c19376af04315fcd13821551c9946063c80cdc7b5abc"

URI_qt6-qt3d = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qt3d-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qt3d;unpack=0"
SRC_URI += "${URI_qt6-qt3d}"
SRC_URI[qt6-qt3d.sha256sum] = "015e8c8e5bf9bb3abadfc65462de4adeddb26732c8bd14146844a053ffe4955c"
RDEPENDS:qt6-qt3d = " \
 qt6-qtdeclarative \
 zlib-ng-compat \
 qt6-qtimageformats \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
 qt6-qtshadertools \
"

URI_qt6-qt3d-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qt3d-devel-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qt3d-devel;unpack=0"
SRC_URI += "${URI_qt6-qt3d-devel}"
SRC_URI[qt6-qt3d-devel.sha256sum] = "ccbd4c778686acfc1cc7add63291f4e0e37910fd097e3a892bdd2a7559d1e3b5"
RDEPENDS:qt6-qt3d-devel = " \
 qt6-qtdeclarative-devel \
 cmake-filesystem \
 qt6-qt3d \
 qt6-qt3d-devel \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
"

URI_qt6-qt3d-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qt3d-examples-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qt3d-examples;unpack=0"
SRC_URI += "${URI_qt6-qt3d-examples}"
SRC_URI[qt6-qt3d-examples.sha256sum] = "6ba7d583f21c174f6b2c90e9fce157b8a788bb8a3eb2032834ac31f9a716fce4"
RDEPENDS:qt6-qt3d-examples = " \
 qt6-qtdeclarative \
 qt6-qt3d \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qt3d-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qt3d-tests-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qt3d-tests;unpack=0"
SRC_URI += "${URI_qt6-qt3d-tests}"
SRC_URI[qt6-qt3d-tests.sha256sum] = "3b4359acb39f024e0516927f9f3aa41ccc296b5f0fbf4d95688c91338f337f71"
RDEPENDS:qt6-qt3d-tests = " \
 qt6-qt3d \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"
