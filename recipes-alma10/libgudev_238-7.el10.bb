# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libgudev"
PE = "0"
PV = "238"
PR = "7.el10"
PACKAGES = "libgudev libgudev-devel"
PROVIDES = "rpm/libgudev rpm/libgudev-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libgudev-238-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6c28908cf9e451670b44ccd7f2842cbae4753f1f1ba9a9bf6ebbbbe276b288b"

URI_libgudev = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libgudev-238-7.el10.x86_64_v2.rpm;name=libgudev;unpack=0"
SRC_URI += "${URI_libgudev}"
SRC_URI[libgudev.sha256sum] = "4688a5cb81d1fdcf760fc6dbfdc9a49938422e4c4ea835619b4edeffd3257316"
RDEPENDS:libgudev = " \
 glibc \
 libgcc \
 glib2 \
 systemd-libs \
"

URI_libgudev-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libgudev-devel-238-7.el10.x86_64_v2.rpm;name=libgudev-devel;unpack=0"
SRC_URI += "${URI_libgudev-devel}"
SRC_URI[libgudev-devel.sha256sum] = "538baafba6fe10b3bc6c1079c3f7e85ab1421bafc714a5ebec1c96de5c9344a8"
RDEPENDS:libgudev-devel = " \
 libgudev \
 systemd-devel \
 glib2-devel \
 pkgconf-pkg-config \
"
