# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "postgresql-jdbc"
PE = "0"
PV = "42.7.1"
PR = "7.el10"
PACKAGES = "postgresql-jdbc postgresql-jdbc-javadoc"
PROVIDES = "rpm/postgresql-jdbc rpm/postgresql-jdbc-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/postgresql-jdbc-42.7.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f2b124dc0169db44951df39c5a40b64c0203f7db0f6714493e65b2d3fa01c72"

URI_postgresql-jdbc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postgresql-jdbc-42.7.1-7.el10.noarch.rpm;name=postgresql-jdbc;unpack=0"
SRC_URI += "${URI_postgresql-jdbc}"
SRC_URI[postgresql-jdbc.sha256sum] = "529f6484409367259cfdc6f802be0e2beb368e89c6ab7e9966c3e6d38b5000b6"
RDEPENDS:postgresql-jdbc = " \
 ongres-scram-client \
 javapackages-filesystem \
"

URI_postgresql-jdbc-javadoc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/postgresql-jdbc-javadoc-42.7.1-7.el10.noarch.rpm;name=postgresql-jdbc-javadoc;unpack=0"
SRC_URI += "${URI_postgresql-jdbc-javadoc}"
SRC_URI[postgresql-jdbc-javadoc.sha256sum] = "e0e596babcde9066c2b852066da9075cc6b38cd0b08a16634ebbf3a85ebbfe72"
RDEPENDS:postgresql-jdbc-javadoc = " \
 javapackages-filesystem \
"
