# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "which"
PE = "0"
PV = "2.21"
PR = "44.el10_0"
PACKAGES = "which"
PROVIDES = "rpm/which"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/which-2.21-44.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "93885f47269e48f3c5377d36a3cc21d6e307c11cb46830f755d0169f0ae834c2"

URI_which = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/which-2.21-44.el10_0.x86_64_v2.rpm;name=which;unpack=0"
SRC_URI += "${URI_which}"
SRC_URI[which.sha256sum] = "c52ab4496c78bfe50c977e2e0461849403dc145b9dd4aceb598027f477bebe9d"
RDEPENDS:which = " \
 glibc \
 coreutils \
"
