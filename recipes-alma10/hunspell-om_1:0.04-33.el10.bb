# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-om"
PE = "1"
PV = "0.04"
PR = "33.el10"
PACKAGES = "hunspell-om"
PROVIDES = "rpm/hunspell-om"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-om-0.04-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6bf4c96213739b3a5d39f4065e8f0590f479a1018f8beef1f232edff221f4f9f"

URI_hunspell-om = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-om-0.04-33.el10.noarch.rpm;name=hunspell-om;unpack=0"
SRC_URI += "${URI_hunspell-om}"
SRC_URI[hunspell-om.sha256sum] = "5ca72b922461440c4cb4076197ac214010ffc4fc29fc17e6115686b8be6bc388"
RDEPENDS:hunspell-om = " \
 hunspell \
"
