# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pcp"
PE = "0"
PV = "6.3.7"
PR = "1.el10_0"
PACKAGES = "pcp pcp-conf pcp-devel pcp-doc pcp-export-pcp2elasticsearch pcp-export-pcp2graphite pcp-export-pcp2influxdb pcp-export-pcp2json pcp-export-pcp2openmetrics pcp-export-pcp2spark pcp-export-pcp2xml pcp-export-pcp2zabbix pcp-export-zabbix-agent pcp-geolocate pcp-gui pcp-import-collectl2pcp pcp-import-ganglia2pcp pcp-import-iostat2pcp pcp-import-mrtg2pcp pcp-import-sar2pcp pcp-libs pcp-libs-devel pcp-pmda-activemq pcp-pmda-amdgpu pcp-pmda-apache pcp-pmda-bash pcp-pmda-bcc pcp-pmda-bind2 pcp-pmda-bonding pcp-pmda-bpf pcp-pmda-bpftrace pcp-pmda-cifs pcp-pmda-cisco pcp-pmda-dbping pcp-pmda-denki pcp-pmda-dm pcp-pmda-docker pcp-pmda-ds389 pcp-pmda-ds389log pcp-pmda-elasticsearch pcp-pmda-farm pcp-pmda-gluster pcp-pmda-gpfs pcp-pmda-gpsd pcp-pmda-hacluster pcp-pmda-haproxy pcp-pmda-infiniband pcp-pmda-json pcp-pmda-libvirt pcp-pmda-lio pcp-pmda-lmsensors pcp-pmda-logger pcp-pmda-lustre pcp-pmda-lustrecomm pcp-pmda-mailq pcp-pmda-memcache pcp-pmda-mic pcp-pmda-mongodb pcp-pmda-mounts pcp-pmda-mssql pcp-pmda-mysql pcp-pmda-named pcp-pmda-netcheck pcp-pmda-netfilter pcp-pmda-news pcp-pmda-nfsclient pcp-pmda-nginx pcp-pmda-nvidia-gpu pcp-pmda-openmetrics pcp-pmda-openvswitch pcp-pmda-oracle pcp-pmda-pdns pcp-pmda-perfevent pcp-pmda-podman pcp-pmda-postfix pcp-pmda-postgresql pcp-pmda-rabbitmq pcp-pmda-redis pcp-pmda-resctrl pcp-pmda-roomtemp pcp-pmda-rsyslog pcp-pmda-samba pcp-pmda-sendmail pcp-pmda-shping pcp-pmda-slurm pcp-pmda-smart pcp-pmda-snmp pcp-pmda-sockets pcp-pmda-statsd pcp-pmda-summary pcp-pmda-systemd pcp-pmda-trace pcp-pmda-unbound pcp-pmda-uwsgi pcp-pmda-weblog pcp-pmda-zimbra pcp-pmda-zswap pcp-selinux pcp-system-tools pcp-zeroconf perl-PCP-LogImport perl-PCP-LogSummary perl-PCP-MMV perl-PCP-PMDA python3-pcp pcp-testsuite"
PROVIDES = "rpm/pcp rpm/pcp-conf rpm/pcp-devel rpm/pcp-doc rpm/pcp-export-pcp2elasticsearch rpm/pcp-export-pcp2graphite rpm/pcp-export-pcp2influxdb rpm/pcp-export-pcp2json rpm/pcp-export-pcp2openmetrics rpm/pcp-export-pcp2spark rpm/pcp-export-pcp2xml rpm/pcp-export-pcp2zabbix rpm/pcp-export-zabbix-agent rpm/pcp-geolocate rpm/pcp-gui rpm/pcp-import-collectl2pcp rpm/pcp-import-ganglia2pcp rpm/pcp-import-iostat2pcp rpm/pcp-import-mrtg2pcp rpm/pcp-import-sar2pcp rpm/pcp-libs rpm/pcp-libs-devel rpm/pcp-pmda-activemq rpm/pcp-pmda-amdgpu rpm/pcp-pmda-apache rpm/pcp-pmda-bash rpm/pcp-pmda-bcc rpm/pcp-pmda-bind2 rpm/pcp-pmda-bonding rpm/pcp-pmda-bpf rpm/pcp-pmda-bpftrace rpm/pcp-pmda-cifs rpm/pcp-pmda-cisco rpm/pcp-pmda-dbping rpm/pcp-pmda-denki rpm/pcp-pmda-dm rpm/pcp-pmda-docker rpm/pcp-pmda-ds389 rpm/pcp-pmda-ds389log rpm/pcp-pmda-elasticsearch rpm/pcp-pmda-farm rpm/pcp-pmda-gluster rpm/pcp-pmda-gpfs rpm/pcp-pmda-gpsd rpm/pcp-pmda-hacluster rpm/pcp-pmda-haproxy rpm/pcp-pmda-infiniband rpm/pcp-pmda-json rpm/pcp-pmda-libvirt rpm/pcp-pmda-lio rpm/pcp-pmda-lmsensors rpm/pcp-pmda-logger rpm/pcp-pmda-lustre rpm/pcp-pmda-lustrecomm rpm/pcp-pmda-mailq rpm/pcp-pmda-memcache rpm/pcp-pmda-mic rpm/pcp-pmda-mongodb rpm/pcp-pmda-mounts rpm/pcp-pmda-mssql rpm/pcp-pmda-mysql rpm/pcp-pmda-named rpm/pcp-pmda-netcheck rpm/pcp-pmda-netfilter rpm/pcp-pmda-news rpm/pcp-pmda-nfsclient rpm/pcp-pmda-nginx rpm/pcp-pmda-nvidia-gpu rpm/pcp-pmda-openmetrics rpm/pcp-pmda-openvswitch rpm/pcp-pmda-oracle rpm/pcp-pmda-pdns rpm/pcp-pmda-perfevent rpm/pcp-pmda-podman rpm/pcp-pmda-postfix rpm/pcp-pmda-postgresql rpm/pcp-pmda-rabbitmq rpm/pcp-pmda-redis rpm/pcp-pmda-resctrl rpm/pcp-pmda-roomtemp rpm/pcp-pmda-rsyslog rpm/pcp-pmda-samba rpm/pcp-pmda-sendmail rpm/pcp-pmda-shping rpm/pcp-pmda-slurm rpm/pcp-pmda-smart rpm/pcp-pmda-snmp rpm/pcp-pmda-sockets rpm/pcp-pmda-statsd rpm/pcp-pmda-summary rpm/pcp-pmda-systemd rpm/pcp-pmda-trace rpm/pcp-pmda-unbound rpm/pcp-pmda-uwsgi rpm/pcp-pmda-weblog rpm/pcp-pmda-zimbra rpm/pcp-pmda-zswap rpm/pcp-selinux rpm/pcp-system-tools rpm/pcp-zeroconf rpm/perl-PCP-LogImport rpm/perl-PCP-LogSummary rpm/perl-PCP-MMV rpm/perl-PCP-PMDA rpm/python3-pcp rpm/pcp-testsuite"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/pcp-6.3.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52ad60e79a10a9faf3460aeb9eb721bf4a095c8f6635642acff0c092118a6964"

URI_pcp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp;unpack=0"
SRC_URI += "${URI_pcp}"
SRC_URI[pcp.sha256sum] = "b3ba2adf9f8deb51466c3db73bd99363e69d5df8d006edacd276fd8bca9c0ef3"
RDEPENDS:pcp = " \
 libuv \
 diffutils \
 which \
 sed \
 xz \
 zlib-ng-compat \
 openssl-libs \
 grep \
 pcp-libs \
 bash \
 findutils \
 glibc \
 gawk \
 readline \
 pkgconf-pkg-config \
 hostname \
 pcp-selinux \
 procps-ng \
 coreutils \
"

URI_pcp-conf = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-conf-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-conf;unpack=0"
SRC_URI += "${URI_pcp-conf}"
SRC_URI[pcp-conf.sha256sum] = "128b1bc70b5205bb0bc536dff09d501f97244d74c6ac03088997c1e3c8026a35"
RDEPENDS:pcp-conf = ""

URI_pcp-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-devel-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-devel;unpack=0"
SRC_URI += "${URI_pcp-devel}"
SRC_URI[pcp-devel.sha256sum] = "2e20fbb2c269d85642d1ca611329a22f53ba0eeee7571440d76fb3685bce5ed6"
RDEPENDS:pcp-devel = " \
 perl-libs \
 perl-vars \
 pcp \
 perl-PCP-PMDA \
 pcp-libs \
 bash \
 pcp-libs-devel \
 glibc \
 perl-interpreter \
"

URI_pcp-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-doc-6.3.7-1.el10_0.noarch.rpm;name=pcp-doc;unpack=0"
SRC_URI += "${URI_pcp-doc}"
SRC_URI[pcp-doc.sha256sum] = "12cdce38c917eee9ec6e11afb47e99e99786c0232ffa327a8c23e5cb94448b36"
RDEPENDS:pcp-doc = ""

URI_pcp-export-pcp2elasticsearch = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2elasticsearch-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-export-pcp2elasticsearch;unpack=0"
SRC_URI += "${URI_pcp-export-pcp2elasticsearch}"
SRC_URI[pcp-export-pcp2elasticsearch.sha256sum] = "311150273f4f883db072d98f11bb7d9d51da3a6d87ca9222463debeeb22720b1"
RDEPENDS:pcp-export-pcp2elasticsearch = " \
 pcp \
 python3-requests \
 pcp-libs \
 python3-pcp \
"

URI_pcp-export-pcp2graphite = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2graphite-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-export-pcp2graphite;unpack=0"
SRC_URI += "${URI_pcp-export-pcp2graphite}"
SRC_URI[pcp-export-pcp2graphite.sha256sum] = "af4d3aa98d7e8d2c392832c634d5e457806e4495883588e79a2fa1a0da027dc4"
RDEPENDS:pcp-export-pcp2graphite = " \
 pcp \
 pcp-libs \
 python3-pcp \
"

URI_pcp-export-pcp2influxdb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2influxdb-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-export-pcp2influxdb;unpack=0"
SRC_URI += "${URI_pcp-export-pcp2influxdb}"
SRC_URI[pcp-export-pcp2influxdb.sha256sum] = "6ebc6a06e3431cf7e11d5b796d8e7c3b98e71011520bd1d62dd01687385ba3ce"
RDEPENDS:pcp-export-pcp2influxdb = " \
 pcp \
 python3-requests \
 pcp-libs \
 python3-pcp \
"

URI_pcp-export-pcp2json = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2json-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-export-pcp2json;unpack=0"
SRC_URI += "${URI_pcp-export-pcp2json}"
SRC_URI[pcp-export-pcp2json.sha256sum] = "a6cd6ea726016c9e92187ce46fc1b5af0aa4bdc7dda674c4cc042e8d8cdb28aa"
RDEPENDS:pcp-export-pcp2json = " \
 pcp \
 pcp-libs \
 python3-pcp \
"

URI_pcp-export-pcp2openmetrics = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2openmetrics-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-export-pcp2openmetrics;unpack=0"
SRC_URI += "${URI_pcp-export-pcp2openmetrics}"
SRC_URI[pcp-export-pcp2openmetrics.sha256sum] = "d9ede1a54ed7ce124fa822dbbac25b87549fbdfb702ed9e03d69089ddfe91420"
RDEPENDS:pcp-export-pcp2openmetrics = " \
 pcp \
 pcp-libs \
 python3-pcp \
"

URI_pcp-export-pcp2spark = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2spark-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-export-pcp2spark;unpack=0"
SRC_URI += "${URI_pcp-export-pcp2spark}"
SRC_URI[pcp-export-pcp2spark.sha256sum] = "f3f776847bfd8f2fbfaf88927eb9d1dce64059ccbe88b8839291cd78e215897a"
RDEPENDS:pcp-export-pcp2spark = " \
 pcp \
 pcp-libs \
 python3-pcp \
"

URI_pcp-export-pcp2xml = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2xml-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-export-pcp2xml;unpack=0"
SRC_URI += "${URI_pcp-export-pcp2xml}"
SRC_URI[pcp-export-pcp2xml.sha256sum] = "0c77d1cec5b53dc7b90cd633b5e06ca81deb1d74102013825442d02d8f5afb55"
RDEPENDS:pcp-export-pcp2xml = " \
 pcp \
 pcp-libs \
 python3-pcp \
"

URI_pcp-export-pcp2zabbix = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2zabbix-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-export-pcp2zabbix;unpack=0"
SRC_URI += "${URI_pcp-export-pcp2zabbix}"
SRC_URI[pcp-export-pcp2zabbix.sha256sum] = "134ae5cf7c6b919156cc646a02f35b3a4a085993611e55638637d04b5354d086"
RDEPENDS:pcp-export-pcp2zabbix = " \
 pcp \
 pcp-libs \
 python3-pcp \
"

URI_pcp-export-zabbix-agent = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-export-zabbix-agent-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-export-zabbix-agent;unpack=0"
SRC_URI += "${URI_pcp-export-zabbix-agent}"
SRC_URI[pcp-export-zabbix-agent.sha256sum] = "e3f8f1f70f980cf973abe00a0c2be44e16fba348e23a5d290557ab276cbb458b"
RDEPENDS:pcp-export-zabbix-agent = " \
 glibc \
 pcp-libs \
"

URI_pcp-geolocate = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-geolocate-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-geolocate;unpack=0"
SRC_URI += "${URI_pcp-geolocate}"
SRC_URI[pcp-geolocate.sha256sum] = "0365d9fb2e47dbb99ba113a8003cddd4a323ad41dbe51334cad4933ea904d035"
RDEPENDS:pcp-geolocate = " \
 pcp \
 pcp-libs \
 python3-pcp \
"

URI_pcp-gui = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-gui-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-gui;unpack=0"
SRC_URI += "${URI_pcp-gui}"
SRC_URI[pcp-gui.sha256sum] = "145062f55fa758b703d70839e2ec3eda272071d54e60e1dfdf61657cf36e0680"
RDEPENDS:pcp-gui = " \
 qt6-qtsvg \
 pcp \
 libgcc \
 qt6-qtbase \
 liberation-sans-fonts \
 pcp-libs \
 libstdc++ \
 bash \
 qt6-qtbase-gui \
 glibc \
"

URI_pcp-import-collectl2pcp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-import-collectl2pcp-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-import-collectl2pcp;unpack=0"
SRC_URI += "${URI_pcp-import-collectl2pcp}"
SRC_URI[pcp-import-collectl2pcp.sha256sum] = "2a6a72b98a8827980b636f53f17f82638137b51f7c02e4639fd4c62f1f95211e"
RDEPENDS:pcp-import-collectl2pcp = " \
 glibc \
 pcp-libs \
"

URI_pcp-import-ganglia2pcp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-import-ganglia2pcp-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-import-ganglia2pcp;unpack=0"
SRC_URI += "${URI_pcp-import-ganglia2pcp}"
SRC_URI[pcp-import-ganglia2pcp.sha256sum] = "e0b6127d29d4a52a1cfb9deaa8a2041abec31a4fb9fbac4972f17b8f02d1cea5"
RDEPENDS:pcp-import-ganglia2pcp = " \
 perl-TimeDate \
 perl-libs \
 perl-vars \
 perl-PCP-LogImport \
 perl-File-Basename \
 perl-POSIX \
 perl-Getopt-Std \
 pcp-libs \
 perl-interpreter \
 rrdtool-perl \
"

URI_pcp-import-iostat2pcp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-import-iostat2pcp-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-import-iostat2pcp;unpack=0"
SRC_URI += "${URI_pcp-import-iostat2pcp}"
SRC_URI[pcp-import-iostat2pcp.sha256sum] = "c9490598ac1027f737d25e7aa1f2dfcf7c75694164aacfe0a1e52320b2b92484"
RDEPENDS:pcp-import-iostat2pcp = " \
 perl-TimeDate \
 perl-libs \
 perl-PCP-LogImport \
 perl-Getopt-Std \
 pcp-libs \
 perl-interpreter \
"

URI_pcp-import-mrtg2pcp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-import-mrtg2pcp-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-import-mrtg2pcp;unpack=0"
SRC_URI += "${URI_pcp-import-mrtg2pcp}"
SRC_URI[pcp-import-mrtg2pcp.sha256sum] = "1060975159b851da8d01300895c8231d46739a0cf1382506d5f5b034e3e9755f"
RDEPENDS:pcp-import-mrtg2pcp = " \
 perl-interpreter \
 perl-libs \
 pcp-libs \
 perl-PCP-LogImport \
"

URI_pcp-import-sar2pcp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-import-sar2pcp-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-import-sar2pcp;unpack=0"
SRC_URI += "${URI_pcp-import-sar2pcp}"
SRC_URI[pcp-import-sar2pcp.sha256sum] = "293bc3384fb5d9ea18b7ebd8a98725a887c12e17c3f0f04a7a5a3275851545f8"
RDEPENDS:pcp-import-sar2pcp = " \
 perl-TimeDate \
 perl-libs \
 perl-PCP-LogImport \
 pcp-libs \
 perl-XML-TokeParser \
 perl-interpreter \
"

URI_pcp-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-libs-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-libs;unpack=0"
SRC_URI += "${URI_pcp-libs}"
SRC_URI[pcp-libs.sha256sum] = "65a52186703c3cc079fa92f191aa9773d8c5cb06ef3e77669fa3f34a6b7832a9"
RDEPENDS:pcp-libs = " \
 systemd-libs \
 openssl-libs \
 pcp-conf \
 cyrus-sasl-lib \
 avahi-libs \
 libuv \
 glibc \
 xz-libs \
"

URI_pcp-libs-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-libs-devel-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-libs-devel;unpack=0"
SRC_URI += "${URI_pcp-libs-devel}"
SRC_URI[pcp-libs-devel.sha256sum] = "dad15422fc5b399bf659efc09221ffc774da5d0ecd103a3c68a5479b21e5978c"
RDEPENDS:pcp-libs-devel = " \
 pcp-libs \
 pcp \
"

URI_pcp-pmda-activemq = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-activemq-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-activemq;unpack=0"
SRC_URI += "${URI_pcp-pmda-activemq}"
SRC_URI[pcp-pmda-activemq.sha256sum] = "6436ac694f3844411c4876d9e73a2ad4ff4be44f5cd61b3fbc7d28ba86484c92"
RDEPENDS:pcp-pmda-activemq = " \
 perl-libs \
 perl-libwww-perl \
 perl-Digest-MD5 \
 pcp \
 perl-PCP-PMDA \
 pcp-libs \
 bash \
 perl-JSON \
 perl-Time-HiRes \
"

URI_pcp-pmda-amdgpu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-amdgpu-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-amdgpu;unpack=0"
SRC_URI += "${URI_pcp-pmda-amdgpu}"
SRC_URI[pcp-pmda-amdgpu.sha256sum] = "bd3832cf49eec92a4371a270c5e36f56081005255a57ed5fd7bb998e6e33db0c"
RDEPENDS:pcp-pmda-amdgpu = " \
 pcp \
 pcp-libs \
 bash \
 glibc \
 libdrm \
"

URI_pcp-pmda-apache = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-apache-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-apache;unpack=0"
SRC_URI += "${URI_pcp-pmda-apache}"
SRC_URI[pcp-pmda-apache.sha256sum] = "6b332ca6b8f9608833cdac5d3fc5c4a95b28dac7f7ccd1af1df4c0be2c6565ca"
RDEPENDS:pcp-pmda-apache = " \
 glibc \
 pcp-libs \
 pcp \
 bash \
"

URI_pcp-pmda-bash = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-bash-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-bash;unpack=0"
SRC_URI += "${URI_pcp-pmda-bash}"
SRC_URI[pcp-pmda-bash.sha256sum] = "f2b6bbbb1681821004c3f1e54af02e51833050eff202233373c869a17d709620"
RDEPENDS:pcp-pmda-bash = " \
 glibc \
 pcp-libs \
 pcp \
 bash \
"

URI_pcp-pmda-bcc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-bcc-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-bcc;unpack=0"
SRC_URI += "${URI_pcp-pmda-bcc}"
SRC_URI[pcp-pmda-bcc.sha256sum] = "9b1ef0e3b0a40dc29ce0809532d5163fe6d50704422a49da5ad8cf890195e50a"
RDEPENDS:pcp-pmda-bcc = " \
 python3-bcc \
 python3-pcp \
 pcp \
 pcp-libs \
 bash \
"

URI_pcp-pmda-bind2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-bind2-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-bind2;unpack=0"
SRC_URI += "${URI_pcp-pmda-bind2}"
SRC_URI[pcp-pmda-bind2.sha256sum] = "ee19d06a93fa9d92dad5284af715007fd8c29b7904b54563d36b26cadbbbb4da"
RDEPENDS:pcp-pmda-bind2 = " \
 perl-libwww-perl \
 pcp \
 perl-PCP-PMDA \
 perl-XML-LibXML \
 pcp-libs \
 bash \
 perl-autodie \
 perl-File-Slurp \
 perl-Time-HiRes \
"

URI_pcp-pmda-bonding = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-bonding-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-bonding;unpack=0"
SRC_URI += "${URI_pcp-pmda-bonding}"
SRC_URI[pcp-pmda-bonding.sha256sum] = "065a748f69cdb789beb5f1c327ac5a9ada710098a3f7278390afd015041f25c6"
RDEPENDS:pcp-pmda-bonding = " \
 pcp-libs \
 pcp \
 bash \
 perl-PCP-PMDA \
"

URI_pcp-pmda-bpf = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-bpf-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-bpf;unpack=0"
SRC_URI += "${URI_pcp-pmda-bpf}"
SRC_URI[pcp-pmda-bpf.sha256sum] = "a4df985bb6f09353c7e9f08733d831b0e8a3e16aec7c2f64f18466adf3baf6f1"
RDEPENDS:pcp-pmda-bpf = " \
 zlib-ng-compat \
 pcp \
 libbpf \
 elfutils-libelf \
 pcp-libs \
 bash \
 glibc \
"

URI_pcp-pmda-bpftrace = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-bpftrace-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-bpftrace;unpack=0"
SRC_URI += "${URI_pcp-pmda-bpftrace}"
SRC_URI[pcp-pmda-bpftrace.sha256sum] = "ab1d8023995a5214b60c4286ded66539cd54cd7525a2cbb8e2021fffadbfe7b3"
RDEPENDS:pcp-pmda-bpftrace = " \
 python3 \
 python3-pcp \
 pcp \
 pcp-libs \
 bash \
 bpftrace \
"

URI_pcp-pmda-cifs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-cifs-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-cifs;unpack=0"
SRC_URI += "${URI_pcp-pmda-cifs}"
SRC_URI[pcp-pmda-cifs.sha256sum] = "1da5af02cc52cbd2cd686ee2174154a0ede1e042668eafc3dbc04817e925b7fb"
RDEPENDS:pcp-pmda-cifs = " \
 glibc \
 pcp-libs \
 pcp \
 bash \
"

URI_pcp-pmda-cisco = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-cisco-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-cisco;unpack=0"
SRC_URI += "${URI_pcp-pmda-cisco}"
SRC_URI[pcp-pmda-cisco.sha256sum] = "8c1fc39926985f26c671af3c013ec92abb8f6c9150755e6ee02b08de25ab5a6b"
RDEPENDS:pcp-pmda-cisco = " \
 glibc \
 pcp-libs \
 pcp \
 bash \
"

URI_pcp-pmda-dbping = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-dbping-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-dbping;unpack=0"
SRC_URI += "${URI_pcp-pmda-dbping}"
SRC_URI[pcp-pmda-dbping.sha256sum] = "b0d92f19b5790c849236d0e6414b48ed07616430740d952b22213ff9a0e94d4f"
RDEPENDS:pcp-pmda-dbping = " \
 pcp \
 perl-PCP-PMDA \
 pcp-libs \
 bash \
 perl-DBI \
"

URI_pcp-pmda-denki = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-denki-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-denki;unpack=0"
SRC_URI += "${URI_pcp-pmda-denki}"
SRC_URI[pcp-pmda-denki.sha256sum] = "52e54253b0cd9ad003757cebeb564d649511ffca5d3712cba3193128679af8b7"
RDEPENDS:pcp-pmda-denki = " \
 glibc \
 pcp-libs \
 pcp \
 bash \
"

URI_pcp-pmda-dm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-dm-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-dm;unpack=0"
SRC_URI += "${URI_pcp-pmda-dm}"
SRC_URI[pcp-pmda-dm.sha256sum] = "2ec2ef966d6e8a67799224574e75d13b407f621c22595c89cc7e3894bd96bd41"
RDEPENDS:pcp-pmda-dm = " \
 device-mapper-libs \
 pcp \
 pcp-libs \
 bash \
 glibc \
"

URI_pcp-pmda-docker = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-docker-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-docker;unpack=0"
SRC_URI += "${URI_pcp-pmda-docker}"
SRC_URI[pcp-pmda-docker.sha256sum] = "3b22e43d6715812a87813bcecfaf50c53d524d77a7bce1e65737b8428a7ef12c"
RDEPENDS:pcp-pmda-docker = " \
 glibc \
 pcp-libs \
 pcp \
 bash \
"

URI_pcp-pmda-ds389 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-ds389-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-ds389;unpack=0"
SRC_URI += "${URI_pcp-pmda-ds389}"
SRC_URI[pcp-pmda-ds389.sha256sum] = "676b3f872c0755a11056afdbad11ed17cc3ab2d7994bec7b245eb929b4ae9ddb"
RDEPENDS:pcp-pmda-ds389 = " \
 pcp-libs \
 pcp \
 bash \
 perl-PCP-PMDA \
"

URI_pcp-pmda-ds389log = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-ds389log-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-ds389log;unpack=0"
SRC_URI += "${URI_pcp-pmda-ds389log}"
SRC_URI[pcp-pmda-ds389log.sha256sum] = "bae43a7193c52f4478375d90d370e22544abed9bf64f8ef6111d601c46e7b95d"
RDEPENDS:pcp-pmda-ds389log = " \
 perl-Date-Manip \
 pcp \
 perl-PCP-PMDA \
 pcp-libs \
 bash \
"

URI_pcp-pmda-elasticsearch = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-elasticsearch-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-elasticsearch;unpack=0"
SRC_URI += "${URI_pcp-pmda-elasticsearch}"
SRC_URI[pcp-pmda-elasticsearch.sha256sum] = "d5202495f026490472e4899b041734fcb5c7af09ddc60f2d0b79e5062cf8d4c7"
RDEPENDS:pcp-pmda-elasticsearch = " \
 pcp \
 bash \
 pcp-libs \
 python3-pcp \
"

URI_pcp-pmda-farm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-farm-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-farm;unpack=0"
SRC_URI += "${URI_pcp-pmda-farm}"
SRC_URI[pcp-pmda-farm.sha256sum] = "a8bb5c401aa156bd5d59267c2151ee442e6e2dbe5856288a9ae48c718d0a1566"
RDEPENDS:pcp-pmda-farm = " \
 smartmontools \
 pcp \
 pcp-libs \
 bash \
 glibc \
"

URI_pcp-pmda-gluster = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-gluster-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-gluster;unpack=0"
SRC_URI += "${URI_pcp-pmda-gluster}"
SRC_URI[pcp-pmda-gluster.sha256sum] = "edd15d42518c0b273cee1ac59407f9374b9cf3a130204c2e61d6b6c7b798c240"
RDEPENDS:pcp-pmda-gluster = " \
 pcp \
 bash \
 pcp-libs \
 python3-pcp \
"

URI_pcp-pmda-gpfs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-gpfs-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-gpfs;unpack=0"
SRC_URI += "${URI_pcp-pmda-gpfs}"
SRC_URI[pcp-pmda-gpfs.sha256sum] = "6e6c82c2379c3743f65e74c626eca37c1e6f917b0112e7d00a2d76447799191e"
RDEPENDS:pcp-pmda-gpfs = " \
 pcp-libs \
 pcp \
 bash \
 perl-PCP-PMDA \
"

URI_pcp-pmda-gpsd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-gpsd-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-gpsd;unpack=0"
SRC_URI += "${URI_pcp-pmda-gpsd}"
SRC_URI[pcp-pmda-gpsd.sha256sum] = "2eb64135a11eda27fb339f298a922d0164bf66e5849e251b0ac5b93410f67310"
RDEPENDS:pcp-pmda-gpsd = " \
 pcp \
 perl-PCP-PMDA \
 pcp-libs \
 bash \
 perl-JSON \
 perl-Time-HiRes \
"

URI_pcp-pmda-hacluster = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-hacluster-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-hacluster;unpack=0"
SRC_URI += "${URI_pcp-pmda-hacluster}"
SRC_URI[pcp-pmda-hacluster.sha256sum] = "d288d8b7d2abaa2430d7f92a888d19319bc8a526259d7b66201972759121ee77"
RDEPENDS:pcp-pmda-hacluster = " \
 glibc \
 pcp-libs \
 pcp \
 bash \
"

URI_pcp-pmda-haproxy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-haproxy-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-haproxy;unpack=0"
SRC_URI += "${URI_pcp-pmda-haproxy}"
SRC_URI[pcp-pmda-haproxy.sha256sum] = "641c4d24fe37f6d25a3982c4f2b08fc277eb28d561054c6c6226b4eb752532ab"
RDEPENDS:pcp-pmda-haproxy = " \
 pcp \
 bash \
 pcp-libs \
 python3-pcp \
"

URI_pcp-pmda-infiniband = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-infiniband-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-infiniband;unpack=0"
SRC_URI += "${URI_pcp-pmda-infiniband}"
SRC_URI[pcp-pmda-infiniband.sha256sum] = "51d3900eb535bee89666f28130449e07430883c9ad48b79d26faa6f5c94aff00"
RDEPENDS:pcp-pmda-infiniband = " \
 infiniband-diags \
 pcp \
 pcp-libs \
 libibumad \
 bash \
 glibc \
"

URI_pcp-pmda-json = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-json-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-json;unpack=0"
SRC_URI += "${URI_pcp-pmda-json}"
SRC_URI[pcp-pmda-json.sha256sum] = "80a31f1e88248b47c56fc3ed205ddde147b9a8e9a43fd54592716c41f53efe9a"
RDEPENDS:pcp-pmda-json = " \
 python3-pcp \
 pcp \
 python3-six \
 pcp-libs \
 bash \
 python3-jsonpointer \
"

URI_pcp-pmda-libvirt = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-libvirt-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-libvirt;unpack=0"
SRC_URI += "${URI_pcp-pmda-libvirt}"
SRC_URI[pcp-pmda-libvirt.sha256sum] = "ef3f090b22e13892b27f7781e19c3044cc874d09ce0b7676c53abdf40260ad13"
RDEPENDS:pcp-pmda-libvirt = " \
 python3-pcp \
 pcp \
 python3-libvirt \
 pcp-libs \
 bash \
 python3-lxml \
"

URI_pcp-pmda-lio = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-lio-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-lio;unpack=0"
SRC_URI += "${URI_pcp-pmda-lio}"
SRC_URI[pcp-pmda-lio.sha256sum] = "5e1a5e7019a9c17c6bdc56b7ca44e443e7c8408745f03168dd90b3f46d96528b"
RDEPENDS:pcp-pmda-lio = " \
 python3-pcp \
 pcp \
 pcp-libs \
 bash \
 python3-rtslib \
"

URI_pcp-pmda-lmsensors = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-lmsensors-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-lmsensors;unpack=0"
SRC_URI += "${URI_pcp-pmda-lmsensors}"
SRC_URI[pcp-pmda-lmsensors.sha256sum] = "da415937118575f92d312f7d7cd7691a0a65abac5e210a72f8b8e9afb973db50"
RDEPENDS:pcp-pmda-lmsensors = " \
 lm_sensors \
 python3-pcp \
 pcp \
 pcp-libs \
 bash \
"

URI_pcp-pmda-logger = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-logger-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-logger;unpack=0"
SRC_URI += "${URI_pcp-pmda-logger}"
SRC_URI[pcp-pmda-logger.sha256sum] = "57e5875be3c70a8f5b219a633ba12a7bf9fd2ab2f77b3a28b3c0bfbf9bc46c23"
RDEPENDS:pcp-pmda-logger = " \
 glibc \
 pcp-libs \
 pcp \
 bash \
"

URI_pcp-pmda-lustre = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-lustre-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-lustre;unpack=0"
SRC_URI += "${URI_pcp-pmda-lustre}"
SRC_URI[pcp-pmda-lustre.sha256sum] = "97c8939b62dd70be51f67da02d9fc6ab251fd908ea2cdfe9adfdac901b948b80"
RDEPENDS:pcp-pmda-lustre = " \
 pcp-libs \
 pcp \
 bash \
 perl-PCP-PMDA \
"

URI_pcp-pmda-lustrecomm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-lustrecomm-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-lustrecomm;unpack=0"
SRC_URI += "${URI_pcp-pmda-lustrecomm}"
SRC_URI[pcp-pmda-lustrecomm.sha256sum] = "82aedbeb8edc4803e092bec9684131d7af6ce0bf08da14a15ea53b5783e808fb"
RDEPENDS:pcp-pmda-lustrecomm = " \
 glibc \
 pcp-libs \
 pcp \
 bash \
"

URI_pcp-pmda-mailq = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-mailq-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-mailq;unpack=0"
SRC_URI += "${URI_pcp-pmda-mailq}"
SRC_URI[pcp-pmda-mailq.sha256sum] = "49a254d95e4c30d8cd0b685c64b596fe2a4d15b4872e1caba72aa43c2883ec85"
RDEPENDS:pcp-pmda-mailq = " \
 glibc \
 pcp-libs \
 pcp \
 bash \
"

URI_pcp-pmda-memcache = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-memcache-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-memcache;unpack=0"
SRC_URI += "${URI_pcp-pmda-memcache}"
SRC_URI[pcp-pmda-memcache.sha256sum] = "276aa1797973a718e821bdaf9cc52432a2af0d0b23d158692b98606e630f0da7"
RDEPENDS:pcp-pmda-memcache = " \
 pcp-libs \
 pcp \
 bash \
 perl-PCP-PMDA \
"

URI_pcp-pmda-mic = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-mic-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-mic;unpack=0"
SRC_URI += "${URI_pcp-pmda-mic}"
SRC_URI[pcp-pmda-mic.sha256sum] = "3d72dba9dae12676633d77eed4f385e5725dd15419ceed843ae4a04670a8c178"
RDEPENDS:pcp-pmda-mic = " \
 pcp \
 bash \
 pcp-libs \
 python3-pcp \
"

URI_pcp-pmda-mongodb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-mongodb-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-mongodb;unpack=0"
SRC_URI += "${URI_pcp-pmda-mongodb}"
SRC_URI[pcp-pmda-mongodb.sha256sum] = "d5f89c3300869313ee09895c5e42886c1b1d3acc2f59b17826b26c46631f3449"
RDEPENDS:pcp-pmda-mongodb = " \
 pcp \
 bash \
 pcp-libs \
 python3-pcp \
"

URI_pcp-pmda-mounts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-mounts-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-mounts;unpack=0"
SRC_URI += "${URI_pcp-pmda-mounts}"
SRC_URI[pcp-pmda-mounts.sha256sum] = "1d6fcc7e0f58d4c88abc21c068c21a6836f9c04ee47095bd5ed273d6ad665114"
RDEPENDS:pcp-pmda-mounts = " \
 glibc \
 pcp-libs \
 pcp \
 bash \
"

URI_pcp-pmda-mssql = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-mssql-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-mssql;unpack=0"
SRC_URI += "${URI_pcp-pmda-mssql}"
SRC_URI[pcp-pmda-mssql.sha256sum] = "2fa1a74c0e2f31ec3956e1ab787ac01d681f4351c64fd04f5db26bb588b38551"
RDEPENDS:pcp-pmda-mssql = " \
 python3-pcp \
 pcp \
 python3-pyodbc \
 pcp-libs \
 bash \
"

URI_pcp-pmda-mysql = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-mysql-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-mysql;unpack=0"
SRC_URI += "${URI_pcp-pmda-mysql}"
SRC_URI[pcp-pmda-mysql.sha256sum] = "d035cb9d359ed9f08d1e57e7ab35806aabde7218d7310018caac4742966b4072"
RDEPENDS:pcp-pmda-mysql = " \
 pcp \
 perl-PCP-PMDA \
 pcp-libs \
 bash \
 perl-DBD-MySQL \
 perl-DBI \
"

URI_pcp-pmda-named = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-named-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-named;unpack=0"
SRC_URI += "${URI_pcp-pmda-named}"
SRC_URI[pcp-pmda-named.sha256sum] = "4db7ad3a8da6b284a9be8c4217a469d538bf733fcfc9eb7720c33c442c24c60c"
RDEPENDS:pcp-pmda-named = " \
 pcp-libs \
 pcp \
 bash \
 perl-PCP-PMDA \
"

URI_pcp-pmda-netcheck = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-netcheck-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-netcheck;unpack=0"
SRC_URI += "${URI_pcp-pmda-netcheck}"
SRC_URI[pcp-pmda-netcheck.sha256sum] = "4d870f3ce587017432f95e90a16957548c098f108bcdd7de6a038244c47d5c98"
RDEPENDS:pcp-pmda-netcheck = " \
 pcp \
 bash \
 pcp-libs \
 python3-pcp \
"

URI_pcp-pmda-netfilter = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-netfilter-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-netfilter;unpack=0"
SRC_URI += "${URI_pcp-pmda-netfilter}"
SRC_URI[pcp-pmda-netfilter.sha256sum] = "5bd7a385fa96b27792f3014a1c2cc04b0190ca8690749a2cede7a40296838120"
RDEPENDS:pcp-pmda-netfilter = " \
 pcp-libs \
 pcp \
 bash \
 perl-PCP-PMDA \
"

URI_pcp-pmda-news = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-news-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-news;unpack=0"
SRC_URI += "${URI_pcp-pmda-news}"
SRC_URI[pcp-pmda-news.sha256sum] = "3a7f0d7a765329ff8512dc2d11831d8d9f1f0c49c6ef5bfe72fd8c13ec865c2f"
RDEPENDS:pcp-pmda-news = " \
 pcp-libs \
 pcp \
 bash \
 perl-PCP-PMDA \
"

URI_pcp-pmda-nfsclient = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-nfsclient-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-nfsclient;unpack=0"
SRC_URI += "${URI_pcp-pmda-nfsclient}"
SRC_URI[pcp-pmda-nfsclient.sha256sum] = "095d861800b846d36f36b6d70c539571fb8d7d8ff5bb1ff970b5c433d3614e69"
RDEPENDS:pcp-pmda-nfsclient = " \
 pcp \
 bash \
 pcp-libs \
 python3-pcp \
"

URI_pcp-pmda-nginx = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-nginx-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-nginx;unpack=0"
SRC_URI += "${URI_pcp-pmda-nginx}"
SRC_URI[pcp-pmda-nginx.sha256sum] = "2f72362a20e8c75735e449a7e05707e0b9401707e4e13a46dd9c48eda0d89e95"
RDEPENDS:pcp-pmda-nginx = " \
 perl-libwww-perl \
 pcp \
 perl-PCP-PMDA \
 pcp-libs \
 bash \
"

URI_pcp-pmda-nvidia-gpu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-nvidia-gpu-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-nvidia-gpu;unpack=0"
SRC_URI += "${URI_pcp-pmda-nvidia-gpu}"
SRC_URI[pcp-pmda-nvidia-gpu.sha256sum] = "9a9df5273411fc7c18bccc9acb2e47a7e6d5d8b892363d2ccf1b935f8ee623c9"
RDEPENDS:pcp-pmda-nvidia-gpu = " \
 glibc \
 pcp-libs \
 pcp \
 bash \
"

URI_pcp-pmda-openmetrics = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-openmetrics-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-openmetrics;unpack=0"
SRC_URI += "${URI_pcp-pmda-openmetrics}"
SRC_URI[pcp-pmda-openmetrics.sha256sum] = "d46a110f2972d1c05b5d4903680734ad96a73073048ee430c88754c585b52301"
RDEPENDS:pcp-pmda-openmetrics = " \
 python3-requests \
 python3-pcp \
 pcp \
 pcp-libs \
 bash \
"

URI_pcp-pmda-openvswitch = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-openvswitch-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-openvswitch;unpack=0"
SRC_URI += "${URI_pcp-pmda-openvswitch}"
SRC_URI[pcp-pmda-openvswitch.sha256sum] = "1cffa3d23ff24024c18c61fd798b3db897e29325d94ab35ff2882f9ebf234d46"
RDEPENDS:pcp-pmda-openvswitch = " \
 pcp \
 bash \
 pcp-libs \
 python3-pcp \
"

URI_pcp-pmda-oracle = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-oracle-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-oracle;unpack=0"
SRC_URI += "${URI_pcp-pmda-oracle}"
SRC_URI[pcp-pmda-oracle.sha256sum] = "09e8cc41b7fb086f69e467dcd1af3ccb90416ffe8d22fe1388f872954a9c1169"
RDEPENDS:pcp-pmda-oracle = " \
 perl-libs \
 pcp \
 perl-PCP-PMDA \
 pcp-libs \
 bash \
 perl-DBI \
 perl-interpreter \
"

URI_pcp-pmda-pdns = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-pdns-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-pdns;unpack=0"
SRC_URI += "${URI_pcp-pmda-pdns}"
SRC_URI[pcp-pmda-pdns.sha256sum] = "e8f033106638950b14b031c847b924676113716d5476c4c2c8cc0b5c306433c9"
RDEPENDS:pcp-pmda-pdns = " \
 pcp \
 perl-PCP-PMDA \
 pcp-libs \
 bash \
 perl-Time-HiRes \
"

URI_pcp-pmda-perfevent = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-perfevent-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-perfevent;unpack=0"
SRC_URI += "${URI_pcp-pmda-perfevent}"
SRC_URI[pcp-pmda-perfevent.sha256sum] = "1688cb0e48228d2c089c850216c1a7b55a902fee8c1158f4ee0b6ac89433277c"
RDEPENDS:pcp-pmda-perfevent = " \
 perl-libs \
 pcp \
 libpfm \
 pcp-libs \
 bash \
 glibc \
 perl-interpreter \
"

URI_pcp-pmda-podman = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-podman-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-podman;unpack=0"
SRC_URI += "${URI_pcp-pmda-podman}"
SRC_URI[pcp-pmda-podman.sha256sum] = "06d5cbda8794a99092d16b2b511d2431f67dd345a7df21ab6078144e17a1a6c3"
RDEPENDS:pcp-pmda-podman = " \
 glibc \
 pcp-libs \
 pcp \
 bash \
"

URI_pcp-pmda-postfix = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-postfix-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-postfix;unpack=0"
SRC_URI += "${URI_pcp-pmda-postfix}"
SRC_URI[pcp-pmda-postfix.sha256sum] = "e1642e40588d0aa533389d710225f175e8423304e3722330fa7de4d5c26649ad"
RDEPENDS:pcp-pmda-postfix = " \
 pcp \
 perl-PCP-PMDA \
 pcp-libs \
 bash \
 postfix-perl-scripts \
 perl-Time-HiRes \
"

URI_pcp-pmda-postgresql = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-postgresql-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-postgresql;unpack=0"
SRC_URI += "${URI_pcp-pmda-postgresql}"
SRC_URI[pcp-pmda-postgresql.sha256sum] = "77a167b29939bcf59338e3cf366a64c4d257c21636a8a4551d1b5e0486ee1a4a"
RDEPENDS:pcp-pmda-postgresql = " \
 python3-psycopg2 \
 python3-pcp \
 pcp \
 pcp-libs \
 bash \
"

URI_pcp-pmda-rabbitmq = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-rabbitmq-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-rabbitmq;unpack=0"
SRC_URI += "${URI_pcp-pmda-rabbitmq}"
SRC_URI[pcp-pmda-rabbitmq.sha256sum] = "27d94418e237ce8f64ff0b8264f3c3b80663520bd1fc6699f4d4b959ffdaa123"
RDEPENDS:pcp-pmda-rabbitmq = " \
 pcp \
 bash \
 pcp-libs \
 python3-pcp \
"

URI_pcp-pmda-redis = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-redis-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-redis;unpack=0"
SRC_URI += "${URI_pcp-pmda-redis}"
SRC_URI[pcp-pmda-redis.sha256sum] = "e87f6fbeda46d937d60f05fe6f19b4e9a560e6a8ee1143b05a274f71f0d9e2ac"
RDEPENDS:pcp-pmda-redis = " \
 pcp \
 perl-PCP-PMDA \
 pcp-libs \
 bash \
 perl-autodie \
 perl-Data-Dumper \
 perl-Time-HiRes \
"

URI_pcp-pmda-resctrl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-resctrl-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-resctrl;unpack=0"
SRC_URI += "${URI_pcp-pmda-resctrl}"
SRC_URI[pcp-pmda-resctrl.sha256sum] = "921480039dba5e1b7fd87d5592329471dab2e040892622e0473f5e2ed35ddda6"
RDEPENDS:pcp-pmda-resctrl = " \
 glibc \
 pcp-libs \
 pcp \
 bash \
"

URI_pcp-pmda-roomtemp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-roomtemp-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-roomtemp;unpack=0"
SRC_URI += "${URI_pcp-pmda-roomtemp}"
SRC_URI[pcp-pmda-roomtemp.sha256sum] = "f9b8e29584289aa3e84fcb91d27c1482e6d041ce8946d9f962335f33d9d0fa94"
RDEPENDS:pcp-pmda-roomtemp = " \
 glibc \
 pcp-libs \
 pcp \
 bash \
"

URI_pcp-pmda-rsyslog = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-rsyslog-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-rsyslog;unpack=0"
SRC_URI += "${URI_pcp-pmda-rsyslog}"
SRC_URI[pcp-pmda-rsyslog.sha256sum] = "0e7607601b055f3f56449a18214e27e1f86e94fe5c9b5ad2a4f522a619473c75"
RDEPENDS:pcp-pmda-rsyslog = " \
 pcp-libs \
 pcp \
 bash \
 perl-PCP-PMDA \
"

URI_pcp-pmda-samba = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-samba-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-samba;unpack=0"
SRC_URI += "${URI_pcp-pmda-samba}"
SRC_URI[pcp-pmda-samba.sha256sum] = "13716b9e98a25415d5c4e1aa5ff3faefa9d972c24729882ad14df43e63f877e8"
RDEPENDS:pcp-pmda-samba = " \
 pcp-libs \
 pcp \
 bash \
 perl-PCP-PMDA \
"

URI_pcp-pmda-sendmail = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-sendmail-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-sendmail;unpack=0"
SRC_URI += "${URI_pcp-pmda-sendmail}"
SRC_URI[pcp-pmda-sendmail.sha256sum] = "7c09c9cd9b273c8c0813a4acf69585f48bf910fdb40b9755b28e00afdcaf3f67"
RDEPENDS:pcp-pmda-sendmail = " \
 glibc \
 pcp-libs \
 pcp \
 bash \
"

URI_pcp-pmda-shping = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-shping-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-shping;unpack=0"
SRC_URI += "${URI_pcp-pmda-shping}"
SRC_URI[pcp-pmda-shping.sha256sum] = "c85a11ddd95bfb3218a5de5b99d0cf662a43cd1df2e6a7a64c05af0bd1b06640"
RDEPENDS:pcp-pmda-shping = " \
 glibc \
 pcp-libs \
 pcp \
 bash \
"

URI_pcp-pmda-slurm = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-slurm-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-slurm;unpack=0"
SRC_URI += "${URI_pcp-pmda-slurm}"
SRC_URI[pcp-pmda-slurm.sha256sum] = "b5e36f7b15acdd8bd160db27ee98c2b9728249f9e8f2414a5964dd1b4f89ab3b"
RDEPENDS:pcp-pmda-slurm = " \
 pcp-libs \
 pcp \
 bash \
 perl-PCP-PMDA \
"

URI_pcp-pmda-smart = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-smart-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-smart;unpack=0"
SRC_URI += "${URI_pcp-pmda-smart}"
SRC_URI[pcp-pmda-smart.sha256sum] = "62b71ddc5e69d1e290c74683816394d1812d2adc41c51992515685a2f0818ce6"
RDEPENDS:pcp-pmda-smart = " \
 smartmontools \
 pcp \
 pcp-libs \
 bash \
 glibc \
"

URI_pcp-pmda-snmp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-snmp-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-snmp;unpack=0"
SRC_URI += "${URI_pcp-pmda-snmp}"
SRC_URI[pcp-pmda-snmp.sha256sum] = "b2ad4d690fbe2fa382920b17078181846ed97a488daebdc872da42940d5be7f1"
RDEPENDS:pcp-pmda-snmp = " \
 pcp-libs \
 pcp \
 bash \
 perl-PCP-PMDA \
"

URI_pcp-pmda-sockets = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-sockets-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-sockets;unpack=0"
SRC_URI += "${URI_pcp-pmda-sockets}"
SRC_URI[pcp-pmda-sockets.sha256sum] = "b51df22ceaebe1a3a39ebdc7a53e6efb8cd1113244829026ec01d084753cdd69"
RDEPENDS:pcp-pmda-sockets = " \
 iproute \
 pcp \
 pcp-libs \
 bash \
 glibc \
"

URI_pcp-pmda-statsd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-statsd-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-statsd;unpack=0"
SRC_URI += "${URI_pcp-pmda-statsd}"
SRC_URI[pcp-pmda-statsd.sha256sum] = "afb16946851a079dcf5f111a1047d06b42b14fb8806abc2c6519a1d5f92bb9e4"
RDEPENDS:pcp-pmda-statsd = " \
 chan \
 pcp \
 pcp-libs \
 bash \
 glibc \
 HdrHistogram_c \
"

URI_pcp-pmda-summary = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-summary-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-summary;unpack=0"
SRC_URI += "${URI_pcp-pmda-summary}"
SRC_URI[pcp-pmda-summary.sha256sum] = "90e3c6d29e113a6b97dbbef070054078418cb98290b353daa9aeeae812133122"
RDEPENDS:pcp-pmda-summary = " \
 glibc \
 pcp-libs \
 pcp \
 bash \
"

URI_pcp-pmda-systemd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-systemd-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-systemd;unpack=0"
SRC_URI += "${URI_pcp-pmda-systemd}"
SRC_URI[pcp-pmda-systemd.sha256sum] = "2781d8fff6650b22a875ba2912533dd44d739f315973cdce205bfd3182117cf2"
RDEPENDS:pcp-pmda-systemd = " \
 systemd-libs \
 pcp \
 pcp-libs \
 bash \
 glibc \
"

URI_pcp-pmda-trace = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-trace-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-trace;unpack=0"
SRC_URI += "${URI_pcp-pmda-trace}"
SRC_URI[pcp-pmda-trace.sha256sum] = "d92f445fa376c4417f085f1239e79e5d7427b7fc498dd8f8455e5d8577f21e27"
RDEPENDS:pcp-pmda-trace = " \
 glibc \
 pcp-libs \
 pcp \
 bash \
"

URI_pcp-pmda-unbound = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-unbound-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-unbound;unpack=0"
SRC_URI += "${URI_pcp-pmda-unbound}"
SRC_URI[pcp-pmda-unbound.sha256sum] = "148537e49897b5f48ef1dc42edbc1101b7feea5aaba4c257645237bb99aad433"
RDEPENDS:pcp-pmda-unbound = " \
 pcp \
 bash \
 pcp-libs \
 python3-pcp \
"

URI_pcp-pmda-uwsgi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-uwsgi-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-uwsgi;unpack=0"
SRC_URI += "${URI_pcp-pmda-uwsgi}"
SRC_URI[pcp-pmda-uwsgi.sha256sum] = "d8169302092610006677a0a710e2fb98d8903f3b52b496425b31811c1406ce50"
RDEPENDS:pcp-pmda-uwsgi = " \
 pcp \
 bash \
 pcp-libs \
 python3-pcp \
"

URI_pcp-pmda-weblog = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-weblog-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-weblog;unpack=0"
SRC_URI += "${URI_pcp-pmda-weblog}"
SRC_URI[pcp-pmda-weblog.sha256sum] = "72618b55e68c75b4bac9f1e56a9e92aa56cb6b557d0d147f0351b646d327b797"
RDEPENDS:pcp-pmda-weblog = " \
 glibc \
 pcp-libs \
 pcp \
 bash \
"

URI_pcp-pmda-zimbra = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-zimbra-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-zimbra;unpack=0"
SRC_URI += "${URI_pcp-pmda-zimbra}"
SRC_URI[pcp-pmda-zimbra.sha256sum] = "a0bfee914e2d9922d0982a6526cfc455a3cd4de27d2c4748652b547d5c691e61"
RDEPENDS:pcp-pmda-zimbra = " \
 pcp \
 perl-PCP-PMDA \
 pcp-libs \
 bash \
 glibc \
"

URI_pcp-pmda-zswap = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-pmda-zswap-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-pmda-zswap;unpack=0"
SRC_URI += "${URI_pcp-pmda-zswap}"
SRC_URI[pcp-pmda-zswap.sha256sum] = "8dff4e26d0823e6d629e47bbb44ae6ca2eca0b4e7e15c885a9285fabc55d8004"
RDEPENDS:pcp-pmda-zswap = " \
 pcp \
 bash \
 pcp-libs \
 python3-pcp \
"

URI_pcp-selinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-selinux-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-selinux;unpack=0"
SRC_URI += "${URI_pcp-selinux}"
SRC_URI[pcp-selinux.sha256sum] = "ecbb272b7356e47616e34adef4889020d979b9000fc7601f1327f4434bb197f2"
RDEPENDS:pcp-selinux = " \
 bash \
 selinux-policy-targeted \
 policycoreutils \
"

URI_pcp-system-tools = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-system-tools-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-system-tools;unpack=0"
SRC_URI += "${URI_pcp-system-tools}"
SRC_URI[pcp-system-tools.sha256sum] = "0b83d3b71d67ce64e30806cfe4970d4b8ca5cb6536b9182c985c20124818c190"
RDEPENDS:pcp-system-tools = " \
 python3-pcp \
 pcp \
 pcp-libs \
 bash \
 ncurses-libs \
 glibc \
"

URI_pcp-zeroconf = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pcp-zeroconf-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-zeroconf;unpack=0"
SRC_URI += "${URI_pcp-zeroconf}"
SRC_URI[pcp-zeroconf.sha256sum] = "4e1daa841168ee471b5c2ebb15646ba75211bf5a496729d440523f55fdf59c13"
RDEPENDS:pcp-zeroconf = " \
 pcp \
 pcp-pmda-nfsclient \
 pcp-system-tools \
 pcp-doc \
 pcp-pmda-dm \
 pcp-libs \
 pcp-pmda-openmetrics \
 bash \
"

URI_perl-PCP-LogImport = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-PCP-LogImport-6.3.7-1.el10_0.x86_64_v2.rpm;name=perl-PCP-LogImport;unpack=0"
SRC_URI += "${URI_perl-PCP-LogImport}"
SRC_URI[perl-PCP-LogImport.sha256sum] = "298acdde9c22da03e7f9dc6599c6cb82f17887ac790254edd28f93bde7509d62"
RDEPENDS:perl-PCP-LogImport = " \
 perl-libs \
 perl-interpreter \
 perl-DynaLoader \
 pcp-libs \
 glibc \
 perl-Exporter \
"

URI_perl-PCP-LogSummary = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-PCP-LogSummary-6.3.7-1.el10_0.x86_64_v2.rpm;name=perl-PCP-LogSummary;unpack=0"
SRC_URI += "${URI_perl-PCP-LogSummary}"
SRC_URI[perl-PCP-LogSummary.sha256sum] = "6fbc36c4dc735facbe590aa97f24a61b962787a9cf4798c0c415635065fe3600"
RDEPENDS:perl-PCP-LogSummary = " \
 perl-libs \
 perl-vars \
 perl-interpreter \
 perl-PCP-LogSummary \
 pcp-libs \
 perl-Exporter \
"

URI_perl-PCP-MMV = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-PCP-MMV-6.3.7-1.el10_0.x86_64_v2.rpm;name=perl-PCP-MMV;unpack=0"
SRC_URI += "${URI_perl-PCP-MMV}"
SRC_URI[perl-PCP-MMV.sha256sum] = "33b14248c323eb1987a87bc6d9159fb76cd4ae6f8af6fcdbd2dd5f8fb9a739a8"
RDEPENDS:perl-PCP-MMV = " \
 perl-libs \
 perl-vars \
 perl-interpreter \
 perl-PCP-MMV \
 perl-DynaLoader \
 pcp-libs \
 glibc \
 perl-Exporter \
 perl-Time-HiRes \
"

URI_perl-PCP-PMDA = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-PCP-PMDA-6.3.7-1.el10_0.x86_64_v2.rpm;name=perl-PCP-PMDA;unpack=0"
SRC_URI += "${URI_perl-PCP-PMDA}"
SRC_URI[perl-PCP-PMDA.sha256sum] = "c4c82b716f4f1bc204b3c860788174855069f2949b52ec6ecfbf8fa73b416b20"
RDEPENDS:perl-PCP-PMDA = " \
 perl-libs \
 perl-vars \
 perl-interpreter \
 perl-DynaLoader \
 pcp-libs \
 glibc \
 perl-Exporter \
"

URI_python3-pcp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-pcp-6.3.7-1.el10_0.x86_64_v2.rpm;name=python3-pcp;unpack=0"
SRC_URI += "${URI_python3-pcp}"
SRC_URI[python3-pcp.sha256sum] = "9e65beffa6805ef67c0fb9ff2bafaa4d21f23bd34efddda2f96f9563bc7adec6"
RDEPENDS:python3-pcp = " \
 glibc \
 pcp-libs \
 pcp \
 python3 \
"

URI_pcp-testsuite = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/pcp-testsuite-6.3.7-1.el10_0.x86_64_v2.rpm;name=pcp-testsuite;unpack=0"
SRC_URI += "${URI_pcp-testsuite}"
SRC_URI[pcp-testsuite.sha256sum] = "23ae5deac6d22e873fd67700293017e36888d886f0ba36adc471a70a54d9c670"
RDEPENDS:pcp-testsuite = " \
 pcp \
 pcp-devel \
 pcp-export-pcp2json \
 pcp-export-pcp2openmetrics \
 pcp-export-pcp2spark \
 selinux-policy-targeted \
 pcp-export-pcp2xml \
 setools-console \
 pcp-export-pcp2zabbix \
 perl-TimeDate \
 pcp-geolocate \
 pcp-gui \
 libgcc \
 avahi-libs \
 pcp-libs \
 bash \
 pcp-libs-devel \
 bc \
 pcp-pmda-activemq \
 pcp-pmda-amdgpu \
 pcp-pmda-apache \
 pcp-pmda-bash \
 pcp-pmda-bcc \
 pcp-pmda-bind2 \
 pcp-pmda-bonding \
 bzip2 \
 pcp-pmda-bpf \
 pcp-pmda-bpftrace \
 gzip \
 pcp-pmda-cisco \
 pcp-pmda-dbping \
 qt6-qtbase \
 pcp-pmda-denki \
 pcp-pmda-dm \
 pcp-pmda-docker \
 qt6-qtbase-gui \
 pcp-pmda-ds389 \
 pcp-pmda-ds389log \
 pcp-pmda-elasticsearch \
 pcp-pmda-farm \
 perl-interpreter \
 pcp-pmda-gluster \
 pcp-pmda-gpfs \
 pcp-pmda-gpsd \
 perl-libnet \
 pcp-pmda-hacluster \
 perl-libs \
 systemd-libs \
 pcp-pmda-haproxy \
 pcp-pmda-json \
 pcp-pmda-libvirt \
 pcp-pmda-lio \
 pcp-pmda-lmsensors \
 pcp-pmda-logger \
 cyrus-sasl-lib \
 pcp-pmda-lustre \
 pcp-pmda-lustrecomm \
 pcp-pmda-mailq \
 pcp-pmda-memcache \
 pcp-pmda-mic \
 pcp-pmda-mongodb \
 pcp-pmda-mounts \
 pcp-pmda-mssql \
 pcp-pmda-mysql \
 pcp-pmda-named \
 pcp-pmda-netcheck \
 pcp-pmda-netfilter \
 pcp-pmda-news \
 pcp-pmda-nfsclient \
 pcp-pmda-nginx \
 pcp-pmda-nvidia-gpu \
 pcp-pmda-openmetrics \
 libstdc++ \
 pcp-pmda-openvswitch \
 pcp-pmda-oracle \
 gcc \
 pcp-pmda-pdns \
 pcp-pmda-podman \
 xz-libs \
 pcp-pmda-postfix \
 pcp-pmda-postgresql \
 pcp-pmda-rabbitmq \
 pcp-pmda-resctrl \
 redhat-rpm-config \
 pcp-pmda-roomtemp \
 pcp-pmda-samba \
 pcp-pmda-sendmail \
 pcp-pmda-shping \
 pcp-pmda-slurm \
 pcp-pmda-smart \
 pcp-pmda-snmp \
 pcp-pmda-sockets \
 pcp-pmda-statsd \
 pcp-pmda-summary \
 pcp-pmda-trace \
 pcp-pmda-unbound \
 pcp-pmda-uwsgi \
 pcp-pmda-weblog \
 pcp-pmda-zimbra \
 pcp-pmda-zswap \
 pcp-system-tools \
 glibc \
 openssl-libs \
 perl-Exporter \
 python3 \
 perl-Getopt-Long \
 perl-Getopt-Std \
 selinux-policy-devel \
 perl-IO \
 perl-PCP-LogImport \
"
