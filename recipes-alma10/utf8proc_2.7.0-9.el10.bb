# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "utf8proc"
PE = "0"
PV = "2.7.0"
PR = "9.el10"
PACKAGES = "utf8proc utf8proc-devel"
PROVIDES = "rpm/utf8proc rpm/utf8proc-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/utf8proc-2.7.0-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "053423837222f11374cfa77b7b4152002dd7b6bca6ae23ab9458f0cea94ea5d3"

URI_utf8proc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/utf8proc-2.7.0-9.el10.x86_64_v2.rpm;name=utf8proc;unpack=0"
SRC_URI += "${URI_utf8proc}"
SRC_URI[utf8proc.sha256sum] = "c2e2c52de8277a5ba7860c81bb927e2593ecc8f02600afdbf801cb78c4373896"
RDEPENDS:utf8proc = " \
 glibc \
"

URI_utf8proc-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/utf8proc-devel-2.7.0-9.el10.x86_64_v2.rpm;name=utf8proc-devel;unpack=0"
SRC_URI += "${URI_utf8proc-devel}"
SRC_URI[utf8proc-devel.sha256sum] = "9610a74388ee76e531b1fe5489d9cbb1430002ad2dd4611edf78e4eea6a37ca6"
RDEPENDS:utf8proc-devel = " \
 pkgconf-pkg-config \
 utf8proc \
"
