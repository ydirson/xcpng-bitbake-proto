# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "uresourced"
PE = "0"
PV = "0.5.4"
PR = "4.el10"
PACKAGES = "uresourced"
PROVIDES = "rpm/uresourced"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/uresourced-0.5.4-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69774869713bd2560620dc7f9c1f7a9df771b1878c09210ea6c2fb8ef365a47b"

URI_uresourced = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/uresourced-0.5.4-4.el10.x86_64_v2.rpm;name=uresourced;unpack=0"
SRC_URI += "${URI_uresourced}"
SRC_URI[uresourced.sha256sum] = "d194ecc505405145b836bf560532e5718721b859053cd97917b726498692f1b9"
RDEPENDS:uresourced = " \
 systemd-libs \
 libgcc \
 bash \
 glib2 \
 glibc \
 pipewire-libs \
"
