# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hyphen-ia"
PE = "0"
PV = "0.20050628"
PR = "30.el10"
PACKAGES = "hyphen-ia"
PROVIDES = "rpm/hyphen-ia"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hyphen-ia-0.20050628-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7de90de557b4e1d3c755c318a401b28c53c6b2c99d2633fb379d5860abdd2f8b"

URI_hyphen-ia = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-ia-0.20050628-30.el10.noarch.rpm;name=hyphen-ia;unpack=0"
SRC_URI += "${URI_hyphen-ia}"
SRC_URI[hyphen-ia.sha256sum] = "a145e66de9992e95ef035023dc001b97c7cc3c43571977cf53c33c3cb829801f"
RDEPENDS:hyphen-ia = " \
 hyphen \
"
