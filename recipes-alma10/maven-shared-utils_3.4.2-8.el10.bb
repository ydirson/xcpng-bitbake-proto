# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "maven-shared-utils"
PE = "0"
PV = "3.4.2"
PR = "8.el10"
PACKAGES = "maven-shared-utils maven-shared-utils-javadoc"
PROVIDES = "rpm/maven-shared-utils rpm/maven-shared-utils-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/maven-shared-utils-3.4.2-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05c2d59b7801bf35a620249bf8edc4089a12520dad95af53f152fabe0c3f1e0d"

URI_maven-shared-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/maven-shared-utils-3.4.2-8.el10.noarch.rpm;name=maven-shared-utils;unpack=0"
SRC_URI += "${URI_maven-shared-utils}"
SRC_URI[maven-shared-utils.sha256sum] = "fe1778cc3f57f061b8e68b755111a25e717f9f9b68c367f88d259d68cc75a229"
RDEPENDS:maven-shared-utils = " \
 apache-commons-io \
 javapackages-filesystem \
 slf4j \
"

URI_maven-shared-utils-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-shared-utils-javadoc-3.4.2-8.el10.noarch.rpm;name=maven-shared-utils-javadoc;unpack=0"
SRC_URI += "${URI_maven-shared-utils-javadoc}"
SRC_URI[maven-shared-utils-javadoc.sha256sum] = "95408e9657b9098c54b9d3a9141d4ee4d8c9cd14537660f52427f885cbff52b2"
RDEPENDS:maven-shared-utils-javadoc = " \
 javapackages-filesystem \
"
