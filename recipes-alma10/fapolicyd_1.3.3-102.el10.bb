# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "fapolicyd"
PE = "0"
PV = "1.3.3"
PR = "102.el10"
PACKAGES = "fapolicyd fapolicyd-selinux"
PROVIDES = "rpm/fapolicyd rpm/fapolicyd-selinux"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/fapolicyd-1.3.3-102.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b94953f194ac6ca1b04f74375bbb93f06df4bcd131268ea6c59fb650c4546554"

URI_fapolicyd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fapolicyd-1.3.3-102.el10.x86_64_v2.rpm;name=fapolicyd;unpack=0"
SRC_URI += "${URI_fapolicyd}"
SRC_URI[fapolicyd.sha256sum] = "e328d21101d043429481d1b507e61e5a996f4e1944ce74ff2ec559597fe4a93c"
RDEPENDS:fapolicyd = " \
 shadow-utils \
 systemd \
 systemd-libs \
 lmdb-libs \
 rpm-plugin-fapolicyd \
 openssl-libs \
 libcap-ng \
 bash \
 libseccomp \
 glibc \
 file-libs \
 rpm-libs \
"

URI_fapolicyd-selinux = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fapolicyd-selinux-1.3.3-102.el10.noarch.rpm;name=fapolicyd-selinux;unpack=0"
SRC_URI += "${URI_fapolicyd-selinux}"
SRC_URI[fapolicyd-selinux.sha256sum] = "e5802d81db150e9e6763c2fd39481020a63b21e72a047d1ae05d8b2a198948c5"
RDEPENDS:fapolicyd-selinux = " \
 policycoreutils-python-utils \
 policycoreutils \
 bash \
 fapolicyd \
 selinux-policy \
 libselinux-utils \
 selinux-policy-targeted \
"
