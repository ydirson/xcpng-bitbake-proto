# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "numad"
PE = "0"
PV = "0.5"
PR = "46.20150602git.el10"
PACKAGES = "numad"
PROVIDES = "rpm/numad"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/numad-0.5-46.20150602git.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64a1b32ae6dbd51f99e46c8d77c0773146eb988853ab564dccd50ea909414975"

URI_numad = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/numad-0.5-46.20150602git.el10.x86_64_v2.rpm;name=numad;unpack=0"
SRC_URI += "${URI_numad}"
SRC_URI[numad.sha256sum] = "d0f6d2d15f1b8cea13faece48d943220cfb92d31abfb8e1ee911b2e02ba63d46"
RDEPENDS:numad = " \
 glibc \
 bash \
"
