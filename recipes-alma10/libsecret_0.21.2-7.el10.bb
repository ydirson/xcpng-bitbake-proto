# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libsecret"
PE = "0"
PV = "0.21.2"
PR = "7.el10"
PACKAGES = "libsecret libsecret-devel"
PROVIDES = "rpm/libsecret rpm/libsecret-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libsecret-0.21.2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2efe58af14c4f4268c43cd8121cc6ffa1ef788df996198eda4c4f0db9c73f974"

URI_libsecret = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libsecret-0.21.2-7.el10.x86_64_v2.rpm;name=libsecret;unpack=0"
SRC_URI += "${URI_libsecret}"
SRC_URI[libsecret.sha256sum] = "c677d1f5469ed229591faa61d9300f303781790a9cd3135cd357542697324c9b"
RDEPENDS:libsecret = " \
 glibc \
 libgcc \
 gnutls \
 glib2 \
"

URI_libsecret-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libsecret-devel-0.21.2-7.el10.x86_64_v2.rpm;name=libsecret-devel;unpack=0"
SRC_URI += "${URI_libsecret-devel}"
SRC_URI[libsecret-devel.sha256sum] = "00225e065d13c6ef5aab1b67620400e465fcdd3fec4fe823d368c44cc69fd7b9"
RDEPENDS:libsecret-devel = " \
 glib2-devel \
 gnutls-devel \
 pkgconf-pkg-config \
 libsecret \
 libsecret-devel \
"
