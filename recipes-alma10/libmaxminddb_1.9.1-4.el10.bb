# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libmaxminddb"
PE = "0"
PV = "1.9.1"
PR = "4.el10"
PACKAGES = "libmaxminddb libmaxminddb-devel"
PROVIDES = "rpm/libmaxminddb rpm/libmaxminddb-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libmaxminddb-1.9.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff3a426e2680a43df92cc9712020f9c01068a56fc53e171a1291d3c10c3e3511"

URI_libmaxminddb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libmaxminddb-1.9.1-4.el10.x86_64_v2.rpm;name=libmaxminddb;unpack=0"
SRC_URI += "${URI_libmaxminddb}"
SRC_URI[libmaxminddb.sha256sum] = "72147648294e0117653e2ec24698dabf84b165eda3dd23b22321a8be3415dbba"
RDEPENDS:libmaxminddb = " \
 glibc \
"

URI_libmaxminddb-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libmaxminddb-devel-1.9.1-4.el10.x86_64_v2.rpm;name=libmaxminddb-devel;unpack=0"
SRC_URI += "${URI_libmaxminddb-devel}"
SRC_URI[libmaxminddb-devel.sha256sum] = "a1d358cca94bca5aa273407cce0f3d9663521b6398857e62bc8b7b7860d98c75"
RDEPENDS:libmaxminddb-devel = " \
 libmaxminddb \
 pkgconf-pkg-config \
"
