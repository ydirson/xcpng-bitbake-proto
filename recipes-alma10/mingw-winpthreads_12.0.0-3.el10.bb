# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mingw-winpthreads"
PE = "0"
PV = "12.0.0"
PR = "3.el10"
PACKAGES = "mingw32-winpthreads mingw32-winpthreads-static mingw64-winpthreads mingw64-winpthreads-static ucrt64-winpthreads ucrt64-winpthreads-static"
PROVIDES = "rpm/mingw32-winpthreads rpm/mingw32-winpthreads-static rpm/mingw64-winpthreads rpm/mingw64-winpthreads-static rpm/ucrt64-winpthreads rpm/ucrt64-winpthreads-static"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/mingw-winpthreads-12.0.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "29ee2aa1914da0c253a2eb7c58e21290418a92c426a71cc76dfa00b4887094e5"

URI_mingw32-winpthreads = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw32-winpthreads-12.0.0-3.el10.noarch.rpm;name=mingw32-winpthreads;unpack=0"
SRC_URI += "${URI_mingw32-winpthreads}"
SRC_URI[mingw32-winpthreads.sha256sum] = "99b6ffbf0e1a692e7ec469cd535d785df419b9da460b296c730badb4c4c669b7"
RDEPENDS:mingw32-winpthreads = " \
 mingw32-crt \
 mingw32-filesystem \
"

URI_mingw32-winpthreads-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw32-winpthreads-static-12.0.0-3.el10.noarch.rpm;name=mingw32-winpthreads-static;unpack=0"
SRC_URI += "${URI_mingw32-winpthreads-static}"
SRC_URI[mingw32-winpthreads-static.sha256sum] = "a6bf61f35806e3db3072230ae8fc02f9dc316f518eeb6330544c5b41400c483e"
RDEPENDS:mingw32-winpthreads-static = " \
 mingw32-winpthreads \
"

URI_mingw64-winpthreads = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw64-winpthreads-12.0.0-3.el10.noarch.rpm;name=mingw64-winpthreads;unpack=0"
SRC_URI += "${URI_mingw64-winpthreads}"
SRC_URI[mingw64-winpthreads.sha256sum] = "3a66e157825ac7fbf8ddc319b0d5c15852738a26b6a25d43a418c4f7ddc4e5ad"
RDEPENDS:mingw64-winpthreads = " \
 mingw64-crt \
 mingw64-filesystem \
"

URI_mingw64-winpthreads-static = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mingw64-winpthreads-static-12.0.0-3.el10.noarch.rpm;name=mingw64-winpthreads-static;unpack=0"
SRC_URI += "${URI_mingw64-winpthreads-static}"
SRC_URI[mingw64-winpthreads-static.sha256sum] = "bc07f7a7d2356f8bf8eee989dda1755be696c2a6884824ef76a192876574bc34"
RDEPENDS:mingw64-winpthreads-static = " \
 mingw64-winpthreads \
"

URI_ucrt64-winpthreads = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ucrt64-winpthreads-12.0.0-3.el10.noarch.rpm;name=ucrt64-winpthreads;unpack=0"
SRC_URI += "${URI_ucrt64-winpthreads}"
SRC_URI[ucrt64-winpthreads.sha256sum] = "8733c5424615beac126ec0011c436879e130b238ed43fa01f91718868295343d"
RDEPENDS:ucrt64-winpthreads = " \
 ucrt64-crt \
 ucrt64-filesystem \
"

URI_ucrt64-winpthreads-static = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ucrt64-winpthreads-static-12.0.0-3.el10.noarch.rpm;name=ucrt64-winpthreads-static;unpack=0"
SRC_URI += "${URI_ucrt64-winpthreads-static}"
SRC_URI[ucrt64-winpthreads-static.sha256sum] = "8193bf3cbe1c16f1c4c4c03288e1b4086768b4b1aae82632cdc6b009ff81c52b"
RDEPENDS:ucrt64-winpthreads-static = " \
 ucrt64-winpthreads \
"
