# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libidn2"
PE = "0"
PV = "2.3.7"
PR = "3.el10"
PACKAGES = "libidn2 idn2 libidn2-devel"
PROVIDES = "rpm/libidn2 rpm/idn2 rpm/libidn2-devel"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libidn2-2.3.7-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa83bdd419c8c6364d039daf524eaacc15edd1be020396fb174cd8e80b21d76f"

URI_libidn2 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libidn2-2.3.7-3.el10.x86_64_v2.rpm;name=libidn2;unpack=0"
SRC_URI += "${URI_libidn2}"
SRC_URI[libidn2.sha256sum] = "cf11ba9b604d4729b7c6c5d7e54eda60282412b2d9ca4b8b661c4222de146a73"
RDEPENDS:libidn2 = " \
 glibc \
 libunistring \
"

URI_idn2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/idn2-2.3.7-3.el10.x86_64_v2.rpm;name=idn2;unpack=0"
SRC_URI += "${URI_idn2}"
SRC_URI[idn2.sha256sum] = "f739efba97cea32a5a4425bbe18a31937ec724b486e1638d960234f4a397452d"
RDEPENDS:idn2 = " \
 glibc \
 libidn2 \
 libunistring \
"

URI_libidn2-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libidn2-devel-2.3.7-3.el10.x86_64_v2.rpm;name=libidn2-devel;unpack=0"
SRC_URI += "${URI_libidn2-devel}"
SRC_URI[libidn2-devel.sha256sum] = "cd9451a4d2b360bac2f62dda5cb7190c13a5cff3a4eab363e4cce81695522e92"
RDEPENDS:libidn2-devel = " \
 libidn2 \
 pkgconf-pkg-config \
"
