# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtimageformats"
PE = "0"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = "qt6-qtimageformats qt6-qtimageformats-tests"
PROVIDES = "rpm/qt6-qtimageformats rpm/qt6-qtimageformats-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtimageformats-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5290af8446a1d59ba3b661508c8de5902d2c91cd1577cfbee83ebd6feaae85d"

URI_qt6-qtimageformats = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtimageformats-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtimageformats;unpack=0"
SRC_URI += "${URI_qt6-qtimageformats}"
SRC_URI[qt6-qtimageformats.sha256sum] = "b60a983342ffd0d2378434960daef6447b70b2636e6f4ab48ddb01a5f22ea827"
RDEPENDS:qt6-qtimageformats = " \
 cmake-filesystem \
 jasper-libs \
 libwebp \
 qt6-qtbase \
 libmng \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
 libtiff \
"

URI_qt6-qtimageformats-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtimageformats-tests-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtimageformats-tests;unpack=0"
SRC_URI += "${URI_qt6-qtimageformats-tests}"
SRC_URI[qt6-qtimageformats-tests.sha256sum] = "29151876ecf1979b585fedb4e0e7314ac117bc57686e4c12a1a4e12e14bb79da"
RDEPENDS:qt6-qtimageformats-tests = " \
 qt6-qtimageformats \
 libgcc \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"
