# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "json-glib"
PE = "0"
PV = "1.8.0"
PR = "5.el10"
PACKAGES = "json-glib json-glib-devel json-glib-tests"
PROVIDES = "rpm/json-glib rpm/json-glib-devel rpm/json-glib-tests"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/json-glib-1.8.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db16f45898306d4599ed7bd29bc676b02450143b9fa04ede24d1edc83807494d"

URI_json-glib = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/json-glib-1.8.0-5.el10.x86_64_v2.rpm;name=json-glib;unpack=0"
SRC_URI += "${URI_json-glib}"
SRC_URI[json-glib.sha256sum] = "0b98294e2a47b9341fe46ca49ea61bbae49e0088c3742849adc6108f922adc0f"
RDEPENDS:json-glib = " \
 glibc \
 glib2 \
"

URI_json-glib-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/json-glib-devel-1.8.0-5.el10.x86_64_v2.rpm;name=json-glib-devel;unpack=0"
SRC_URI += "${URI_json-glib-devel}"
SRC_URI[json-glib-devel.sha256sum] = "589b72e6170166653c1bb730f69f19c7c73528fee2f70837e921fa734c3f93bd"
RDEPENDS:json-glib-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 json-glib \
 glib2 \
 glibc \
"

URI_json-glib-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/json-glib-tests-1.8.0-5.el10.x86_64_v2.rpm;name=json-glib-tests;unpack=0"
SRC_URI += "${URI_json-glib-tests}"
SRC_URI[json-glib-tests.sha256sum] = "8d0c5a6ef14cfddecdc79d2edfc53363d973e8f71b2cb5ed7d87ddade1deeef9"
RDEPENDS:json-glib-tests = " \
 glibc \
 glib2 \
 json-glib \
"
