# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tpm2-openssl"
PE = "0"
PV = "1.2.0"
PR = "5.el10"
PACKAGES = "tpm2-openssl"
PROVIDES = "rpm/tpm2-openssl"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tpm2-openssl-1.2.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6cd3ca55472a48fc95dbe5f441b6171904e61b680f6917219c827224d71a1e8"

URI_tpm2-openssl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tpm2-openssl-1.2.0-5.el10.x86_64_v2.rpm;name=tpm2-openssl;unpack=0"
SRC_URI += "${URI_tpm2-openssl}"
SRC_URI[tpm2-openssl.sha256sum] = "307d20bbd17b88133af577da0243459e5d90df726c7c9549739dc594d9fb2acd"
RDEPENDS:tpm2-openssl = " \
 glibc \
 tpm2-abrmd \
 tpm2-tss \
"
