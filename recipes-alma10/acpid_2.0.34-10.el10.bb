# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "acpid"
PE = "0"
PV = "2.0.34"
PR = "10.el10"
PACKAGES = "acpid"
PROVIDES = "rpm/acpid"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/acpid-2.0.34-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac8068b1ffab453e588a260434a52fa2b50dd629d6de502e57ee7fef984bdee1"

URI_acpid = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/acpid-2.0.34-10.el10.x86_64_v2.rpm;name=acpid;unpack=0"
SRC_URI += "${URI_acpid}"
SRC_URI[acpid.sha256sum] = "400c5578111dda61e88af2b114968b02f674a9d0e654caed0741700f0bbdc261"
RDEPENDS:acpid = " \
 glibc \
 systemd \
 bash \
"
