# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-ca"
PE = "0"
PV = "3.0.8"
PR = "5.el10"
PACKAGES = "hunspell-ca"
PROVIDES = "rpm/hunspell-ca"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-ca-3.0.8-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e149cdd0e2d9af66e397254be1ca2d275b691a4320ffbd8011e85ad6a9aff61"

URI_hunspell-ca = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-ca-3.0.8-5.el10.noarch.rpm;name=hunspell-ca;unpack=0"
SRC_URI += "${URI_hunspell-ca}"
SRC_URI[hunspell-ca.sha256sum] = "fcf67ff461d9331a7445c70caa5929b625cb4550c6ac2dedde4e2312f7d3c4f3"
RDEPENDS:hunspell-ca = " \
 hunspell-filesystem \
"
