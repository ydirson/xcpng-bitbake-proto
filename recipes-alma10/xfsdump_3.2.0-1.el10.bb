# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xfsdump"
PE = "0"
PV = "3.2.0"
PR = "1.el10"
PACKAGES = "xfsdump"
PROVIDES = "rpm/xfsdump"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/xfsdump-3.2.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec6a54336729e11b245b6e03e77dcc764e00ecb8a980a751491e3cc4b8fc634c"

URI_xfsdump = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/xfsdump-3.2.0-1.el10.x86_64_v2.rpm;name=xfsdump;unpack=0"
SRC_URI += "${URI_xfsdump}"
SRC_URI[xfsdump.sha256sum] = "9099fb4e416ff1f15a7757fb4ddb8ac430a0f6447a256d67de910026f79dca7a"
RDEPENDS:xfsdump = " \
 libuuid \
 attr \
 libattr \
 libgcc \
 ncurses-libs \
 glibc \
 xfsprogs \
"
