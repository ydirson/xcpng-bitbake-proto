# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-HTML-Tagset"
PE = "0"
PV = "3.20"
PR = "59.el10"
PACKAGES = "perl-HTML-Tagset perl-HTML-Tagset-tests"
PROVIDES = "rpm/perl-HTML-Tagset rpm/perl-HTML-Tagset-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-HTML-Tagset-3.20-59.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9107322eefe4937e1d399ae0e209d9b35a824a9f9b824765a3dcf43560e93650"

URI_perl-HTML-Tagset = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-HTML-Tagset-3.20-59.el10.noarch.rpm;name=perl-HTML-Tagset;unpack=0"
SRC_URI += "${URI_perl-HTML-Tagset}"
SRC_URI[perl-HTML-Tagset.sha256sum] = "57172b3cb26dac95dc94bad9b038b236bf892e0760b4d225438ae13f5d55a5f2"
RDEPENDS:perl-HTML-Tagset = " \
 perl-libs \
 perl-vars \
"

URI_perl-HTML-Tagset-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-HTML-Tagset-tests-3.20-59.el10.noarch.rpm;name=perl-HTML-Tagset-tests;unpack=0"
SRC_URI += "${URI_perl-HTML-Tagset-tests}"
SRC_URI[perl-HTML-Tagset-tests.sha256sum] = "70296daa7d1f2d485c0bc805845f660c38a1446cccce60f8de2dcb3b285fec51"
RDEPENDS:perl-HTML-Tagset-tests = " \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 bash \
 perl-HTML-Tagset \
 perl-interpreter \
"
