# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "openssh"
PE = "0"
PV = "9.9p1"
PR = "7.el10_0"
PACKAGES = "openssh openssh-clients openssh-keycat openssh-server openssh-askpass openssh-keysign openssh-sk-dummy"
PROVIDES = "rpm/openssh rpm/openssh-clients rpm/openssh-keycat rpm/openssh-server rpm/openssh-askpass rpm/openssh-keysign rpm/openssh-sk-dummy"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/openssh-9.9p1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "878b62a43405c2838ebb158491182fb2730b75902b40bdfdb263e35e26ed8058"

URI_openssh = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/openssh-9.9p1-7.el10_0.x86_64_v2.rpm;name=openssh;unpack=0"
SRC_URI += "${URI_openssh}"
SRC_URI[openssh.sha256sum] = "60f139f5d8b2bac6bfd6ba8f9de6aad16da07175c4acaa1f0f4866623885e526"
RDEPENDS:openssh = " \
 util-linux \
 audit-libs \
 openssl-libs \
 glibc \
 libselinux \
"

URI_openssh-clients = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/openssh-clients-9.9p1-7.el10_0.x86_64_v2.rpm;name=openssh-clients;unpack=0"
SRC_URI += "${URI_openssh-clients}"
SRC_URI[openssh-clients.sha256sum] = "96f9100b962213396cc11a9bff4bebaf34a359c5247c05b7fffd18ce86f8689c"
RDEPENDS:openssh-clients = " \
 zlib-ng-compat \
 openssh \
 crypto-policies \
 libfido2 \
 openssl-libs \
 krb5-libs \
 bash \
 glibc \
 libselinux \
 libedit \
"

URI_openssh-keycat = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/openssh-keycat-9.9p1-7.el10_0.x86_64_v2.rpm;name=openssh-keycat;unpack=0"
SRC_URI += "${URI_openssh-keycat}"
SRC_URI[openssh-keycat.sha256sum] = "f6fc55b1695bd97e36549fe5437eca7a1faf78f0109c8fff1146092e6182aea2"
RDEPENDS:openssh-keycat = " \
 glibc \
 pam-libs \
 openssh \
"

URI_openssh-server = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/openssh-server-9.9p1-7.el10_0.x86_64_v2.rpm;name=openssh-server;unpack=0"
SRC_URI += "${URI_openssh-server}"
SRC_URI[openssh-server.sha256sum] = "985d197470a87f33c941172257a5cba30e602d4bd1ef9aa3d7643bb8bd5ffe53"
RDEPENDS:openssh-server = " \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 openssh \
 crypto-policies \
 libxcrypt \
 audit-libs \
 openssl-libs \
 pam \
 pam-libs \
 krb5-libs \
 libcom_err \
 bash \
 glibc \
 libselinux \
"

URI_openssh-askpass = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/openssh-askpass-9.9p1-7.el10_0.x86_64_v2.rpm;name=openssh-askpass;unpack=0"
SRC_URI += "${URI_openssh-askpass}"
SRC_URI[openssh-askpass.sha256sum] = "db9b762ea005564358947fe9ec5cbac53bd99d26174a5be84f05234a0ead0678"
RDEPENDS:openssh-askpass = " \
 glibc \
 openssh \
 glib2 \
 gtk3 \
"

URI_openssh-keysign = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/openssh-keysign-9.9p1-7.el10_0.x86_64_v2.rpm;name=openssh-keysign;unpack=0"
SRC_URI += "${URI_openssh-keysign}"
SRC_URI[openssh-keysign.sha256sum] = "9bb729d94a013040c1e105f7131f3d45f0f17ef030c46f8e4f74eb663bc3bea9"
RDEPENDS:openssh-keysign = " \
 glibc \
 openssl-libs \
 zlib-ng-compat \
 openssh \
"

URI_openssh-sk-dummy = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/openssh-sk-dummy-9.9p1-7.el10_0.x86_64_v2.rpm;name=openssh-sk-dummy;unpack=0"
SRC_URI += "${URI_openssh-sk-dummy}"
SRC_URI[openssh-sk-dummy.sha256sum] = "16356e279ff271e90af85f792b12b7f3eec045074d06db10e2a4869486c48990"
RDEPENDS:openssh-sk-dummy = " \
 glibc \
 openssl-libs \
 openssh \
"
