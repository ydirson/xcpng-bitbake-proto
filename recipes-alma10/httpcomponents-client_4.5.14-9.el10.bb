# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "httpcomponents-client"
PE = "0"
PV = "4.5.14"
PR = "9.el10"
PACKAGES = "httpcomponents-client httpcomponents-client-javadoc"
PROVIDES = "rpm/httpcomponents-client rpm/httpcomponents-client-javadoc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/httpcomponents-client-4.5.14-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be50fa2307a4cbc1c2332a609ac995cff2f7060d4d969a371b8ce5a3634b8b69"

URI_httpcomponents-client = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/httpcomponents-client-4.5.14-9.el10.noarch.rpm;name=httpcomponents-client;unpack=0"
SRC_URI += "${URI_httpcomponents-client}"
SRC_URI[httpcomponents-client.sha256sum] = "900a827852449c849a35bb37454aba5fd3bf56535be457fa6636cbc1a322430c"
RDEPENDS:httpcomponents-client = " \
 publicsuffix-list \
 apache-commons-codec \
 httpcomponents-core \
 javapackages-filesystem \
"

URI_httpcomponents-client-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/httpcomponents-client-javadoc-4.5.14-9.el10.noarch.rpm;name=httpcomponents-client-javadoc;unpack=0"
SRC_URI += "${URI_httpcomponents-client-javadoc}"
SRC_URI[httpcomponents-client-javadoc.sha256sum] = "29010123a63f0dcdaec0e4d865cb19de7aceb7186dc468d1949d9781d86bb14d"
RDEPENDS:httpcomponents-client-javadoc = " \
 javapackages-filesystem \
"
