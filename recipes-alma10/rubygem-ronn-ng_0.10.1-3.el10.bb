# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rubygem-ronn-ng"
PE = "0"
PV = "0.10.1"
PR = "3.el10"
PACKAGES = "rubygem-ronn-ng rubygem-ronn-ng-doc"
PROVIDES = "rpm/rubygem-ronn-ng rpm/rubygem-ronn-ng-doc"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/rubygem-ronn-ng-0.10.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9fca39fa0aa46f09f1a966a20e8693bb65e0a43243dc92ea99e0a930b0bc8765"

URI_rubygem-ronn-ng = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-ronn-ng-0.10.1-3.el10.noarch.rpm;name=rubygem-ronn-ng;unpack=0"
SRC_URI += "${URI_rubygem-ronn-ng}"
SRC_URI[rubygem-ronn-ng.sha256sum] = "6273782ab4ca7e22ba8a44e2f9add481bb83ee8604098913d488c9df76aee8d3"
RDEPENDS:rubygem-ronn-ng = " \
 ruby \
 groff-base \
 rubygem-kramdown \
 rubygem-kramdown-parser-gfm \
 rubygem-mustache \
 rubygems \
 rubygem-nokogiri \
"

URI_rubygem-ronn-ng-doc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rubygem-ronn-ng-doc-0.10.1-3.el10.noarch.rpm;name=rubygem-ronn-ng-doc;unpack=0"
SRC_URI += "${URI_rubygem-ronn-ng-doc}"
SRC_URI[rubygem-ronn-ng-doc.sha256sum] = "c8f17983331bfba4bfcd64933fb397f14c39efd913794724dd94329b86392a02"
RDEPENDS:rubygem-ronn-ng-doc = " \
 rubygem-ronn-ng \
"
