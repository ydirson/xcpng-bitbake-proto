# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-requests"
PE = "0"
PV = "2.32.4"
PR = "1.el10_0"
PACKAGES = "python3-requests"
PROVIDES = "rpm/python3-requests"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/python-requests-2.32.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2338ec996fb61940f60e57c212942e66f731ff8bc408f618a5957e7ba5027da"

URI_python3-requests = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-requests-2.32.4-1.el10_0.noarch.rpm;name=python3-requests;unpack=0"
SRC_URI += "${URI_python3-requests}"
SRC_URI[python3-requests.sha256sum] = "253070a37db5b8ff613e84511cdf80fb0d04910edb7bcfcec2c4b24125c1fa1a"
RDEPENDS:python3-requests = " \
 python3 \
 python3-idna \
 python3-urllib3 \
 python3-charset-normalizer \
"
