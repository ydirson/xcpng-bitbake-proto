# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "postgresql16-pg_repack"
PE = "0"
PV = "1.5.1"
PR = "1.el10"
PACKAGES = "pg_repack"
PROVIDES = "rpm/pg_repack"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/postgresql16-pg_repack-1.5.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80af2090f7bf60dd9cbee34b51d2bdd85629af232ae48e8ca48d5877e9e870a2"

URI_pg_repack = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pg_repack-1.5.1-1.el10.x86_64_v2.rpm;name=pg_repack;unpack=0"
SRC_URI += "${URI_pg_repack}"
SRC_URI[pg_repack.sha256sum] = "6c33251e588893d53ecdefad41f7e55b4b324676b675eb44e23ec54452dc9440"
RDEPENDS:pg_repack = " \
 glibc \
 postgresql-server \
 postgresql-private-libs \
"
