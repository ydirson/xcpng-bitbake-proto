# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-jsonschema-specifications"
PE = "0"
PV = "2023.11.2"
PR = "6.el10"
PACKAGES = "python3-jsonschema-specifications python3-jsonschema-specifications-tests"
PROVIDES = "rpm/python3-jsonschema-specifications rpm/python3-jsonschema-specifications-tests"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/python-jsonschema-specifications-2023.11.2-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9bbb02bcbf86fc4bcd502823014f52d070a894ca4b322f29f8ae8448f5378e2e"

URI_python3-jsonschema-specifications = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/python3-jsonschema-specifications-2023.11.2-6.el10.noarch.rpm;name=python3-jsonschema-specifications;unpack=0"
SRC_URI += "${URI_python3-jsonschema-specifications}"
SRC_URI[python3-jsonschema-specifications.sha256sum] = "07d8bb385366ccf2260ae62f95d0e97e9f58cf8afc423ebaf08142685ba15d0e"
RDEPENDS:python3-jsonschema-specifications = " \
 python3 \
 python3-referencing \
"

URI_python3-jsonschema-specifications-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-jsonschema-specifications-tests-2023.11.2-6.el10.noarch.rpm;name=python3-jsonschema-specifications-tests;unpack=0"
SRC_URI += "${URI_python3-jsonschema-specifications-tests}"
SRC_URI[python3-jsonschema-specifications-tests.sha256sum] = "906794ae56281abe0beed6b2f69f8865d3682d3e0f5bab9e121aa982e5089940"
RDEPENDS:python3-jsonschema-specifications-tests = " \
 python3 \
 python3-pytest \
 python3-jsonschema-specifications \
"
