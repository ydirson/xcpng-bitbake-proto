# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Config-AutoConf"
PE = "0"
PV = "0.320"
PR = "12.el10"
PACKAGES = "perl-Config-AutoConf"
PROVIDES = "rpm/perl-Config-AutoConf"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-Config-AutoConf-0.320-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19457b05bc6cf612d443541d47639820bd93d175080e89f38f1db6b43912bc91"

URI_perl-Config-AutoConf = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-Config-AutoConf-0.320-12.el10.noarch.rpm;name=perl-Config-AutoConf;unpack=0"
SRC_URI += "${URI_perl-Config-AutoConf}"
SRC_URI[perl-Config-AutoConf.sha256sum] = "b7d93efdc78b811cb007c093f921c2fcf713c016834e70fd840dce7bd6257bb0"
RDEPENDS:perl-Config-AutoConf = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-Text-ParseWords \
 perl-Capture-Tiny \
 perl-File-Basename \
 perl-PathTools \
 perl-Exporter \
 perl-base \
 perl-File-Temp \
"
