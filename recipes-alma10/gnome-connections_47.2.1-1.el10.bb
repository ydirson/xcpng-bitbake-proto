# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-connections"
PE = "0"
PV = "47.2.1"
PR = "1.el10"
PACKAGES = "gnome-connections"
PROVIDES = "rpm/gnome-connections"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-connections-47.2.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b7346341ee1c4523ebd9e62526a2b970393c9a347af8e84cda68a8ac1e4919e"

URI_gnome-connections = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-connections-47.2.1-1.el10.x86_64_v2.rpm;name=gnome-connections;unpack=0"
SRC_URI += "${URI_gnome-connections}"
SRC_URI[gnome-connections.sha256sum] = "1d4e3e16ba28bc942a376a9d6a1c8eebd6aa570508e5a90b9697b02ebe065ee7"
RDEPENDS:gnome-connections = " \
 libhandy \
 fuse3-libs \
 freerdp-libs \
 libxml2 \
 libwinpr \
 gdk-pixbuf2 \
 gvnc \
 libsecret \
 gvncpulse \
 cairo \
 glib2 \
 gtk3 \
 glibc \
 gtk-vnc2 \
 hicolor-icon-theme \
"
