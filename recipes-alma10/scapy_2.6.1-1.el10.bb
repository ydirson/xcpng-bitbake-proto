# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "scapy"
PE = "0"
PV = "2.6.1"
PR = "1.el10"
PACKAGES = "python3-scapy"
PROVIDES = "rpm/python3-scapy"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/scapy-2.6.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5eae9acbeb967f10e82257590c0d349a89f305a8935ff85b92bca7d907d7f8e3"

URI_python3-scapy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-scapy-2.6.1-1.el10.noarch.rpm;name=python3-scapy;unpack=0"
SRC_URI += "${URI_python3-scapy}"
SRC_URI[python3-scapy.sha256sum] = "945d33b64583b477c9c83071bb395f012a211248e16e882847df5594a808a281"
RDEPENDS:python3-scapy = " \
 python3 \
"
