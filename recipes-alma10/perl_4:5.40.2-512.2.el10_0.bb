# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl"
PE = "4"
PV = "5.40.2"
PR = "512.2.el10_0"
PACKAGES = "perl-AutoLoader perl-Class-Struct perl-File-Basename perl-File-stat perl-FileHandle perl-Getopt-Std perl-IPC-Open3 perl-SelectSaver perl-Symbol perl-base perl-if perl-locale perl-overload perl-overloading perl-vars perl perl-Attribute-Handlers perl-AutoLoader perl-AutoSplit perl-B perl-Benchmark perl-Class-Struct perl-Config-Extensions perl-DBM_Filter perl-Devel-Peek perl-Devel-SelfStubber perl-DirHandle perl-Dumpvalue perl-DynaLoader perl-English perl-Errno perl-ExtUtils-Constant perl-ExtUtils-Embed perl-ExtUtils-Miniperl perl-Fcntl perl-File-Basename perl-File-Compare perl-File-Copy perl-File-DosGlob perl-File-Find perl-File-stat perl-FileCache perl-FileHandle perl-FindBin perl-GDBM_File perl-Getopt-Std perl-Hash-Util perl-Hash-Util-FieldHash perl-I18N-Collate perl-I18N-LangTags perl-I18N-Langinfo perl-IO perl-IPC-Open3 perl-Locale-Maketext-Simple perl-Math-Complex perl-Memoize perl-Module-Loaded perl-NDBM_File perl-NEXT perl-Net perl-ODBM_File perl-Opcode perl-POSIX perl-Pod-Functions perl-Pod-Html perl-Safe perl-Search-Dict perl-SelectSaver perl-SelfLoader perl-Symbol perl-Sys-Hostname perl-Term-Complete perl-Term-ReadLine perl-Test perl-Text-Abbrev perl-Thread perl-Thread-Semaphore perl-Tie perl-Tie-File perl-Tie-Memoize perl-Time perl-Time-Piece perl-Unicode-UCD perl-User-pwent perl-autouse perl-base perl-blib perl-debugger perl-deprecate perl-devel perl-diagnostics perl-doc perl-encoding-warnings perl-fields perl-filetest perl-if perl-interpreter perl-less perl-lib perl-libnetcfg perl-libs perl-locale perl-macros perl-meta-notation perl-mro perl-open perl-overload perl-overloading perl-ph perl-sigtrap perl-sort perl-subs perl-utils perl-vars perl-vmsish perl-tests"
PROVIDES = "rpm/perl-AutoLoader rpm/perl-Class-Struct rpm/perl-File-Basename rpm/perl-File-stat rpm/perl-FileHandle rpm/perl-Getopt-Std rpm/perl-IPC-Open3 rpm/perl-SelectSaver rpm/perl-Symbol rpm/perl-base rpm/perl-if rpm/perl-locale rpm/perl-overload rpm/perl-overloading rpm/perl-vars rpm/perl rpm/perl-Attribute-Handlers rpm/perl-AutoLoader rpm/perl-AutoSplit rpm/perl-B rpm/perl-Benchmark rpm/perl-Class-Struct rpm/perl-Config-Extensions rpm/perl-DBM_Filter rpm/perl-Devel-Peek rpm/perl-Devel-SelfStubber rpm/perl-DirHandle rpm/perl-Dumpvalue rpm/perl-DynaLoader rpm/perl-English rpm/perl-Errno rpm/perl-ExtUtils-Constant rpm/perl-ExtUtils-Embed rpm/perl-ExtUtils-Miniperl rpm/perl-Fcntl rpm/perl-File-Basename rpm/perl-File-Compare rpm/perl-File-Copy rpm/perl-File-DosGlob rpm/perl-File-Find rpm/perl-File-stat rpm/perl-FileCache rpm/perl-FileHandle rpm/perl-FindBin rpm/perl-GDBM_File rpm/perl-Getopt-Std rpm/perl-Hash-Util rpm/perl-Hash-Util-FieldHash rpm/perl-I18N-Collate rpm/perl-I18N-LangTags rpm/perl-I18N-Langinfo rpm/perl-IO rpm/perl-IPC-Open3 rpm/perl-Locale-Maketext-Simple rpm/perl-Math-Complex rpm/perl-Memoize rpm/perl-Module-Loaded rpm/perl-NDBM_File rpm/perl-NEXT rpm/perl-Net rpm/perl-ODBM_File rpm/perl-Opcode rpm/perl-POSIX rpm/perl-Pod-Functions rpm/perl-Pod-Html rpm/perl-Safe rpm/perl-Search-Dict rpm/perl-SelectSaver rpm/perl-SelfLoader rpm/perl-Symbol rpm/perl-Sys-Hostname rpm/perl-Term-Complete rpm/perl-Term-ReadLine rpm/perl-Test rpm/perl-Text-Abbrev rpm/perl-Thread rpm/perl-Thread-Semaphore rpm/perl-Tie rpm/perl-Tie-File rpm/perl-Tie-Memoize rpm/perl-Time rpm/perl-Time-Piece rpm/perl-Unicode-UCD rpm/perl-User-pwent rpm/perl-autouse rpm/perl-base rpm/perl-blib rpm/perl-debugger rpm/perl-deprecate rpm/perl-devel rpm/perl-diagnostics rpm/perl-doc rpm/perl-encoding-warnings rpm/perl-fields rpm/perl-filetest rpm/perl-if rpm/perl-interpreter rpm/perl-less rpm/perl-lib rpm/perl-libnetcfg rpm/perl-libs rpm/perl-locale rpm/perl-macros rpm/perl-meta-notation rpm/perl-mro rpm/perl-open rpm/perl-overload rpm/perl-overloading rpm/perl-ph rpm/perl-sigtrap rpm/perl-sort rpm/perl-subs rpm/perl-utils rpm/perl-vars rpm/perl-vmsish rpm/perl-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-5.40.2-512.2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e55a9a691c520f7a14a4789af3e8827d399d90ee880098d5d25f324dd3d9aa31"

URI_perl-AutoLoader = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/perl-AutoLoader-5.74-512.2.el10_0.noarch.rpm;name=perl-AutoLoader;unpack=0"
SRC_URI += "${URI_perl-AutoLoader}"
SRC_URI[perl-AutoLoader.sha256sum] = "53bc4548f39fb0a9fbd261f2e4b914ea585f18ad72767585809dc8cbfcfdf54e"
RDEPENDS:perl-AutoLoader = " \
 perl-libs \
 perl-Carp \
"

URI_perl-Class-Struct = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/perl-Class-Struct-0.68-512.2.el10_0.noarch.rpm;name=perl-Class-Struct;unpack=0"
SRC_URI += "${URI_perl-Class-Struct}"
SRC_URI[perl-Class-Struct.sha256sum] = "63cac7d1530a3747e4933d761822e36848a41df4ddca9e92619fb03eabf30701"
RDEPENDS:perl-Class-Struct = " \
 perl-Exporter \
 perl-libs \
 perl-Carp \
"

URI_perl-File-Basename = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/perl-File-Basename-2.86-512.2.el10_0.noarch.rpm;name=perl-File-Basename;unpack=0"
SRC_URI += "${URI_perl-File-Basename}"
SRC_URI[perl-File-Basename.sha256sum] = "5598d9f2546e0c8f7a6e82d905419a8373d9f2ba4b9ae3dc2884a818ecfb6146"
RDEPENDS:perl-File-Basename = " \
 perl-Exporter \
 perl-libs \
 perl-Carp \
"

URI_perl-File-stat = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/perl-File-stat-1.14-512.2.el10_0.noarch.rpm;name=perl-File-stat;unpack=0"
SRC_URI += "${URI_perl-File-stat}"
SRC_URI[perl-File-stat.sha256sum] = "b2cdf08c9db15b3600cd09fd7d73bebd52b01e2c624344452ac707dca8b46807"
RDEPENDS:perl-File-stat = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-Class-Struct \
 perl-Fcntl \
 perl-Symbol \
 perl-overload \
 perl-Exporter \
"

URI_perl-FileHandle = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/perl-FileHandle-2.05-512.2.el10_0.noarch.rpm;name=perl-FileHandle;unpack=0"
SRC_URI += "${URI_perl-FileHandle}"
SRC_URI[perl-FileHandle.sha256sum] = "fe363bc7cd02e2327f6dc5d3683d2c1844bb9abb2773e62eeb2552537820806d"
RDEPENDS:perl-FileHandle = " \
 perl-Exporter \
 perl-libs \
 perl-IO \
"

URI_perl-Getopt-Std = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/perl-Getopt-Std-1.14-512.2.el10_0.noarch.rpm;name=perl-Getopt-Std;unpack=0"
SRC_URI += "${URI_perl-Getopt-Std}"
SRC_URI[perl-Getopt-Std.sha256sum] = "2dade822b0fbcec4e75d99cd1bafb900622189a8f5ecfa3e40aca5c9d4256eaf"
RDEPENDS:perl-Getopt-Std = " \
 perl-Exporter \
 perl-libs \
"

URI_perl-IPC-Open3 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/perl-IPC-Open3-1.22-512.2.el10_0.noarch.rpm;name=perl-IPC-Open3;unpack=0"
SRC_URI += "${URI_perl-IPC-Open3}"
SRC_URI[perl-IPC-Open3.sha256sum] = "40995d475afb4445b4ad4fa52310d873c8814776de5c35be16de6fb6f1cf0c98"
RDEPENDS:perl-IPC-Open3 = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-IO \
 perl-Fcntl \
 perl-POSIX \
 perl-Symbol \
 perl-IPC-Open3 \
 perl-Exporter \
"

URI_perl-SelectSaver = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/perl-SelectSaver-1.02-512.2.el10_0.noarch.rpm;name=perl-SelectSaver;unpack=0"
SRC_URI += "${URI_perl-SelectSaver}"
SRC_URI[perl-SelectSaver.sha256sum] = "ed9a1aae73e2aef7263bde125096abdf124083fae7f41ac7f6f4bf92d687aa6f"
RDEPENDS:perl-SelectSaver = " \
 perl-Symbol \
 perl-libs \
 perl-Carp \
"

URI_perl-Symbol = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/perl-Symbol-1.09-512.2.el10_0.noarch.rpm;name=perl-Symbol;unpack=0"
SRC_URI += "${URI_perl-Symbol}"
SRC_URI[perl-Symbol.sha256sum] = "fc64a8a2eb0bfadbed283bcf9d73761818ba14be4b60093d3e7abeb311288afd"
RDEPENDS:perl-Symbol = " \
 perl-Exporter \
 perl-libs \
"

URI_perl-base = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/perl-base-2.27-512.2.el10_0.noarch.rpm;name=perl-base;unpack=0"
SRC_URI += "${URI_perl-base}"
SRC_URI[perl-base.sha256sum] = "641cde08c976a50c629cd7637affe32ad346d1dc3c92ac5211e61151318a7ddf"
RDEPENDS:perl-base = " \
 perl-libs \
 perl-Carp \
"

URI_perl-if = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/perl-if-0.61.000-512.2.el10_0.noarch.rpm;name=perl-if;unpack=0"
SRC_URI += "${URI_perl-if}"
SRC_URI[perl-if.sha256sum] = "f59c4b48019089fcb5c778efc2e1b3dedbc2ac18e9ec0105f72c97b85acbb62d"
RDEPENDS:perl-if = " \
 perl-libs \
"

URI_perl-locale = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/perl-locale-1.12-512.2.el10_0.noarch.rpm;name=perl-locale;unpack=0"
SRC_URI += "${URI_perl-locale}"
SRC_URI[perl-locale.sha256sum] = "ebf45a42c179fc9a71cc2addd597d0e584d13113b1d5854f20ba213a25357e3e"
RDEPENDS:perl-locale = " \
 perl-libs \
 perl-Carp \
 perl-POSIX \
"

URI_perl-overload = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/perl-overload-1.37-512.2.el10_0.noarch.rpm;name=perl-overload;unpack=0"
SRC_URI += "${URI_perl-overload}"
SRC_URI[perl-overload.sha256sum] = "59b2c9966ff14087428f502eea14f82f95a072dd9fdfb82eed4db7c6c67efd22"
RDEPENDS:perl-overload = " \
 perl-overloading \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-mro \
"

URI_perl-overloading = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/perl-overloading-0.02-512.2.el10_0.noarch.rpm;name=perl-overloading;unpack=0"
SRC_URI += "${URI_perl-overloading}"
SRC_URI[perl-overloading.sha256sum] = "65652dda4e16f13ab1e413effb4d6886e446eef1950757befdf44a84d457602b"
RDEPENDS:perl-overloading = " \
 perl-libs \
 perl-Carp \
"

URI_perl-vars = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/perl-vars-1.05-512.2.el10_0.noarch.rpm;name=perl-vars;unpack=0"
SRC_URI += "${URI_perl-vars}"
SRC_URI[perl-vars.sha256sum] = "39940dd1ba24c74f5c869ceb974b344432c9ca1eaece7b0d94e2bfd96d9831b9"
RDEPENDS:perl-vars = " \
 perl-libs \
 perl-Carp \
"

URI_perl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-5.40.2-512.2.el10_0.x86_64_v2.rpm;name=perl;unpack=0"
SRC_URI += "${URI_perl}"
SRC_URI[perl.sha256sum] = "d835025bc423c8e6a71c0294d9bd57d269fa48f5b22619bff1e277817a378253"
RDEPENDS:perl = " \
 perl-Safe \
 perl-Scalar-List-Utils \
 perl-Search-Dict \
 perl-SelectSaver \
 perl-SelfLoader \
 perl-Socket \
 perl-Storable \
 perl-Symbol \
 perl-Sys-Hostname \
 perl-Sys-Syslog \
 perl-Term-ANSIColor \
 perl-Term-Cap \
 perl-Term-Complete \
 perl-Term-ReadLine \
 perl-Term-Table \
 perl-Test \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Test2-Suite \
 perl-Text-Abbrev \
 perl-Text-Balanced \
 perl-Text-ParseWords \
 perl-Text-Tabs+Wrap \
 perl-Thread \
 perl-Thread-Queue \
 perl-Thread-Semaphore \
 perl-Tie \
 perl-Tie-File \
 perl-Tie-Memoize \
 perl-Tie-RefHash \
 perl-Time \
 perl-Time-HiRes \
 perl-Time-Local \
 perl-Time-Piece \
 perl-Unicode-Collate \
 perl-Unicode-Normalize \
 perl-Unicode-UCD \
 perl-User-pwent \
 perl-autodie \
 perl-autouse \
 perl-base \
 perl-bignum \
 perl-blib \
 perl-constant \
 perl-debugger \
 perl-deprecate \
 perl-devel \
 perl-diagnostics \
 perl-doc \
 perl-encoding \
 perl-encoding-warnings \
 perl-experimental \
 perl-fields \
 perl-filetest \
 perl-if \
 perl-interpreter \
 perl-less \
 perl-lib \
 perl-libnet \
 perl-libnetcfg \
 perl-libs \
 perl-locale \
 perl-macros \
 perl-meta-notation \
 perl-mro \
 perl-open \
 perl-overload \
 perl-overloading \
 perl-parent \
 perl-perlfaq \
 perl-ph \
 perl-podlators \
 perl-sigtrap \
 perl-sort \
 perl-subs \
 perl-threads \
 perl-threads-shared \
 perl-utils \
 perl-vars \
 perl-version \
 perl-vmsish \
 perl-Archive-Tar \
 perl-Attribute-Handlers \
 perl-AutoLoader \
 perl-AutoSplit \
 perl-B \
 perl-Benchmark \
 perl-CPAN \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Requirements \
 perl-CPAN-Meta-YAML \
 perl-Carp \
 perl-Class-Struct \
 perl-Compress-Raw-Bzip2 \
 perl-Compress-Raw-Zlib \
 perl-Config-Extensions \
 perl-Config-Perl-V \
 perl-DBM_Filter \
 perl-Data-Dumper \
 perl-Devel-PPPort \
 perl-Devel-Peek \
 perl-Devel-SelfStubber \
 perl-Digest \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-DirHandle \
 perl-Dumpvalue \
 perl-DynaLoader \
 perl-Encode \
 perl-Encode-devel \
 perl-English \
 perl-Env \
 perl-Errno \
 perl-Exporter \
 perl-ExtUtils-CBuilder \
 perl-ExtUtils-Command \
 perl-ExtUtils-Constant \
 perl-ExtUtils-Embed \
 perl-ExtUtils-Install \
 perl-ExtUtils-MM-Utils \
 perl-ExtUtils-MakeMaker \
 perl-ExtUtils-Manifest \
 perl-ExtUtils-Miniperl \
 perl-ExtUtils-ParseXS \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Copy \
 perl-File-DosGlob \
 perl-File-Fetch \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-File-stat \
 perl-FileCache \
 perl-FileHandle \
 perl-Filter \
 perl-Filter-Simple \
 perl-FindBin \
 perl-GDBM_File \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-HTTP-Tiny \
 perl-Hash-Util \
 perl-Hash-Util-FieldHash \
 perl-I18N-Collate \
 perl-I18N-LangTags \
 perl-I18N-Langinfo \
 perl-IO \
 perl-IO-Compress \
 perl-IO-Socket-IP \
 perl-IO-Zlib \
 perl-IPC-Cmd \
 perl-IPC-Open3 \
 perl-IPC-SysV \
 perl-JSON-PP \
 perl-Locale-Maketext \
 perl-Locale-Maketext-Simple \
 perl-MIME-Base64 \
 perl-Math-BigInt \
 perl-Math-BigInt-FastCalc \
 perl-Math-Complex \
 perl-Memoize \
 perl-Module-CoreList \
 perl-Module-CoreList-tools \
 perl-Module-Load \
 perl-Module-Load-Conditional \
 perl-Module-Loaded \
 perl-Module-Metadata \
 perl-NDBM_File \
 perl-NEXT \
 perl-Net \
 perl-Net-Ping \
 perl-ODBM_File \
 perl-Opcode \
 perl-POSIX \
 perl-Params-Check \
 perl-PathTools \
 perl-Perl-OSType \
 perl-PerlIO-via-QuotedPrint \
 perl-Pod-Checker \
 perl-Pod-Escapes \
 perl-Pod-Functions \
 perl-Pod-Html \
 perl-Pod-Perldoc \
 perl-Pod-Simple \
 perl-Pod-Usage \
"

URI_perl-Attribute-Handlers = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Attribute-Handlers-1.03-512.2.el10_0.noarch.rpm;name=perl-Attribute-Handlers;unpack=0"
SRC_URI += "${URI_perl-Attribute-Handlers}"
SRC_URI[perl-Attribute-Handlers.sha256sum] = "b671a0b7f9c801750e8e19a30f8f379b4e7789802c6413fcac8f48ed2c4edca4"
RDEPENDS:perl-Attribute-Handlers = " \
 perl-libs \
 perl-Carp \
"

URI_perl-AutoLoader = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-AutoLoader-5.74-512.2.el10_0.noarch.rpm;name=perl-AutoLoader;unpack=0"
SRC_URI += "${URI_perl-AutoLoader}"
SRC_URI[perl-AutoLoader.sha256sum] = "53bc4548f39fb0a9fbd261f2e4b914ea585f18ad72767585809dc8cbfcfdf54e"
RDEPENDS:perl-AutoLoader = " \
 perl-libs \
 perl-Carp \
"

URI_perl-AutoSplit = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-AutoSplit-5.74-512.2.el10_0.noarch.rpm;name=perl-AutoSplit;unpack=0"
SRC_URI += "${URI_perl-AutoSplit}"
SRC_URI[perl-AutoSplit.sha256sum] = "048997a89ebaf1ab8c1125ded3c79ca35dfe78a2358d062a4be7ab272eeabdaf"
RDEPENDS:perl-AutoSplit = " \
 perl-libs \
 perl-Carp \
 perl-File-Basename \
 perl-PathTools \
 perl-Exporter \
 perl-File-Path \
"

URI_perl-B = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-B-1.89-512.2.el10_0.x86_64_v2.rpm;name=perl-B;unpack=0"
SRC_URI += "${URI_perl-B}"
SRC_URI[perl-B.sha256sum] = "299c79fa327708340113c8716d9278876a6abc4da6e385f9c536114001241382"
RDEPENDS:perl-B = " \
 perl-libs \
 perl-Carp \
 perl-B \
 perl-overloading \
 perl-if \
 glibc \
 perl-Exporter \
 perl-Data-Dumper \
"

URI_perl-Benchmark = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Benchmark-1.25-512.2.el10_0.noarch.rpm;name=perl-Benchmark;unpack=0"
SRC_URI += "${URI_perl-Benchmark}"
SRC_URI[perl-Benchmark.sha256sum] = "37a875f24d8c59c1be3c37d56b140b8985ad8ea1b0c966eb509497a43b0eb5e2"
RDEPENDS:perl-Benchmark = " \
 perl-Exporter \
 perl-libs \
 perl-Carp \
"

URI_perl-Class-Struct = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Class-Struct-0.68-512.2.el10_0.noarch.rpm;name=perl-Class-Struct;unpack=0"
SRC_URI += "${URI_perl-Class-Struct}"
SRC_URI[perl-Class-Struct.sha256sum] = "63cac7d1530a3747e4933d761822e36848a41df4ddca9e92619fb03eabf30701"
RDEPENDS:perl-Class-Struct = " \
 perl-Exporter \
 perl-libs \
 perl-Carp \
"

URI_perl-Config-Extensions = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Config-Extensions-0.03-512.2.el10_0.noarch.rpm;name=perl-Config-Extensions;unpack=0"
SRC_URI += "${URI_perl-Config-Extensions}"
SRC_URI[perl-Config-Extensions.sha256sum] = "223eb5b17a9e8b6117e00c64f1a53e87409e635df340119c73c378ce1fda5728"
RDEPENDS:perl-Config-Extensions = " \
 perl-Exporter \
 perl-libs \
"

URI_perl-DBM_Filter = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-DBM_Filter-0.06-512.2.el10_0.noarch.rpm;name=perl-DBM_Filter;unpack=0"
SRC_URI += "${URI_perl-DBM_Filter}"
SRC_URI[perl-DBM_Filter.sha256sum] = "dffdf4725b8218c6475e02522be07c6797831b4d9eaa51b3479682a490b6abe5"
RDEPENDS:perl-DBM_Filter = " \
 perl-IO-Compress \
 perl-Encode \
 perl-libs \
 perl-Carp \
"

URI_perl-Devel-Peek = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Devel-Peek-1.34-512.2.el10_0.x86_64_v2.rpm;name=perl-Devel-Peek;unpack=0"
SRC_URI += "${URI_perl-Devel-Peek}"
SRC_URI[perl-Devel-Peek.sha256sum] = "9530766366e750488cda62c51eec1730f883251778cd789ef1d0a82fa4ffa707"
RDEPENDS:perl-Devel-Peek = " \
 glibc \
 perl-Exporter \
 perl-libs \
"

URI_perl-Devel-SelfStubber = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Devel-SelfStubber-1.06-512.2.el10_0.noarch.rpm;name=perl-Devel-SelfStubber;unpack=0"
SRC_URI += "${URI_perl-Devel-SelfStubber}"
SRC_URI[perl-Devel-SelfStubber.sha256sum] = "f0f5db2d1649e598dc78eb2772042d2b69672e5fd80fc6e73606e48b8e8dde18"
RDEPENDS:perl-Devel-SelfStubber = " \
 perl-SelfLoader \
 perl-PathTools \
 perl-libs \
"

URI_perl-DirHandle = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-DirHandle-1.05-512.2.el10_0.noarch.rpm;name=perl-DirHandle;unpack=0"
SRC_URI += "${URI_perl-DirHandle}"
SRC_URI[perl-DirHandle.sha256sum] = "5997885a83e4096f47516a8bd8a88cf47dbd220506c6cc95852e97a7465aa0a7"
RDEPENDS:perl-DirHandle = " \
 perl-Symbol \
 perl-libs \
 perl-Carp \
"

URI_perl-Dumpvalue = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Dumpvalue-2.27-512.2.el10_0.noarch.rpm;name=perl-Dumpvalue;unpack=0"
SRC_URI += "${URI_perl-Dumpvalue}"
SRC_URI[perl-Dumpvalue.sha256sum] = "9c060432fbf3cb704f3cf89cc6d7de6bb7027640a68b65f337f8604198fb9d10"
RDEPENDS:perl-Dumpvalue = " \
 perl-libs \
"

URI_perl-DynaLoader = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-DynaLoader-1.56-512.2.el10_0.x86_64_v2.rpm;name=perl-DynaLoader;unpack=0"
SRC_URI += "${URI_perl-DynaLoader}"
SRC_URI[perl-DynaLoader.sha256sum] = "92a7e26562fb030b4f9792bc4b3649021bbd35a4ca8a894cf0ce173bf284a0ac"
RDEPENDS:perl-DynaLoader = " \
 perl-vars \
 perl-libs \
 perl-Carp \
"

URI_perl-English = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-English-1.11-512.2.el10_0.noarch.rpm;name=perl-English;unpack=0"
SRC_URI += "${URI_perl-English}"
SRC_URI[perl-English.sha256sum] = "c4f75ec15d4f116fcefb043c119694afddc539ec6ddca012e8a4cff52cc41574"
RDEPENDS:perl-English = " \
 perl-Exporter \
 perl-libs \
 perl-Carp \
"

URI_perl-Errno = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Errno-1.38-512.2.el10_0.x86_64_v2.rpm;name=perl-Errno;unpack=0"
SRC_URI += "${URI_perl-Errno}"
SRC_URI[perl-Errno.sha256sum] = "5044f891cbfedea55516ab1fc01c41cee4d0646818f4b6b3f087803184e3dc35"
RDEPENDS:perl-Errno = " \
 perl-Exporter \
 perl-libs \
 perl-Carp \
"

URI_perl-ExtUtils-Constant = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-ExtUtils-Constant-0.25-512.2.el10_0.noarch.rpm;name=perl-ExtUtils-Constant;unpack=0"
SRC_URI += "${URI_perl-ExtUtils-Constant}"
SRC_URI[perl-ExtUtils-Constant.sha256sum] = "1d38e0933868701cf484bf8d5890f6c156fd3c752a6830af3d89fce18023182d"
RDEPENDS:perl-ExtUtils-Constant = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-Text-Tabs+Wrap \
 perl-Exporter \
 perl-Data-Dumper \
 perl-ExtUtils-Constant \
"

URI_perl-ExtUtils-Embed = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-ExtUtils-Embed-1.35-512.2.el10_0.noarch.rpm;name=perl-ExtUtils-Embed;unpack=0"
SRC_URI += "${URI_perl-ExtUtils-Embed}"
SRC_URI[perl-ExtUtils-Embed.sha256sum] = "f2934b9b01b68603a1d0c578bada4296fec9973582b6a7f77ad374251e09fbd8"
RDEPENDS:perl-ExtUtils-Embed = " \
 perl-Exporter \
 perl-PathTools \
 perl-libs \
 perl-devel \
"

URI_perl-ExtUtils-Miniperl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-ExtUtils-Miniperl-1.14-512.2.el10_0.noarch.rpm;name=perl-ExtUtils-Miniperl;unpack=0"
SRC_URI += "${URI_perl-ExtUtils-Miniperl}"
SRC_URI[perl-ExtUtils-Miniperl.sha256sum] = "14961e1af22b64acb19673097b7971d92b4b85e64c3ab50ac2f4f2631323b6f1"
RDEPENDS:perl-ExtUtils-Miniperl = " \
 perl-ExtUtils-Embed \
 perl-Exporter \
 perl-libs \
 perl-devel \
"

URI_perl-Fcntl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Fcntl-1.18-512.2.el10_0.x86_64_v2.rpm;name=perl-Fcntl;unpack=0"
SRC_URI += "${URI_perl-Fcntl}"
SRC_URI[perl-Fcntl.sha256sum] = "85ebf9d3ab9fdf52e94d4757d066eaa0f55db13bf2882ce2e267dc3c6481b23d"
RDEPENDS:perl-Fcntl = " \
 glibc \
 perl-Exporter \
 perl-libs \
"

URI_perl-File-Basename = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-File-Basename-2.86-512.2.el10_0.noarch.rpm;name=perl-File-Basename;unpack=0"
SRC_URI += "${URI_perl-File-Basename}"
SRC_URI[perl-File-Basename.sha256sum] = "5598d9f2546e0c8f7a6e82d905419a8373d9f2ba4b9ae3dc2884a818ecfb6146"
RDEPENDS:perl-File-Basename = " \
 perl-Exporter \
 perl-libs \
 perl-Carp \
"

URI_perl-File-Compare = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-File-Compare-1.100.800-512.2.el10_0.noarch.rpm;name=perl-File-Compare;unpack=0"
SRC_URI += "${URI_perl-File-Compare}"
SRC_URI[perl-File-Compare.sha256sum] = "6e69452bc13d226a2618fffe2c76abc4fb0fe1a303f2e6bb9f4ed84c49a0b7ab"
RDEPENDS:perl-File-Compare = " \
 perl-Exporter \
 perl-libs \
 perl-Carp \
"

URI_perl-File-Copy = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-File-Copy-2.41-512.2.el10_0.noarch.rpm;name=perl-File-Copy;unpack=0"
SRC_URI += "${URI_perl-File-Copy}"
SRC_URI[perl-File-Copy.sha256sum] = "e74610604daf45aea68e0f6ae1a7c6981d153938f1735a6653f53d3c0d7466b1"
RDEPENDS:perl-File-Copy = " \
 perl-libs \
 perl-Carp \
 perl-File-Basename \
 perl-overload \
 perl-PathTools \
 perl-Exporter \
"

URI_perl-File-DosGlob = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-File-DosGlob-1.12-512.2.el10_0.x86_64_v2.rpm;name=perl-File-DosGlob;unpack=0"
SRC_URI += "${URI_perl-File-DosGlob}"
SRC_URI[perl-File-DosGlob.sha256sum] = "cd713340f6e7a211d378f2265dc87a38aeadbca7f375c1a38a6bf418713b07cc"
RDEPENDS:perl-File-DosGlob = " \
 glibc \
 perl-Text-ParseWords \
 perl-libs \
"

URI_perl-File-Find = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-File-Find-1.44-512.2.el10_0.noarch.rpm;name=perl-File-Find;unpack=0"
SRC_URI += "${URI_perl-File-Find}"
SRC_URI[perl-File-Find.sha256sum] = "5edeec3ce9dc61a46d51647ae2649ffd16116b8f5379d229f783a491d530dd4b"
RDEPENDS:perl-File-Find = " \
 perl-Exporter \
 perl-PathTools \
 perl-libs \
 perl-File-Basename \
"

URI_perl-File-stat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-File-stat-1.14-512.2.el10_0.noarch.rpm;name=perl-File-stat;unpack=0"
SRC_URI += "${URI_perl-File-stat}"
SRC_URI[perl-File-stat.sha256sum] = "b2cdf08c9db15b3600cd09fd7d73bebd52b01e2c624344452ac707dca8b46807"
RDEPENDS:perl-File-stat = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-Class-Struct \
 perl-Fcntl \
 perl-overload \
 perl-Symbol \
 perl-Exporter \
"

URI_perl-FileCache = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-FileCache-1.10-512.2.el10_0.noarch.rpm;name=perl-FileCache;unpack=0"
SRC_URI += "${URI_perl-FileCache}"
SRC_URI[perl-FileCache.sha256sum] = "64c3171882013c4402ec357a3765ae9275b1bc42953a3bbe496e33c4c6971045"
RDEPENDS:perl-FileCache = " \
 perl-Exporter \
 perl-libs \
 perl-parent \
 perl-Carp \
"

URI_perl-FileHandle = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-FileHandle-2.05-512.2.el10_0.noarch.rpm;name=perl-FileHandle;unpack=0"
SRC_URI += "${URI_perl-FileHandle}"
SRC_URI[perl-FileHandle.sha256sum] = "fe363bc7cd02e2327f6dc5d3683d2c1844bb9abb2773e62eeb2552537820806d"
RDEPENDS:perl-FileHandle = " \
 perl-Exporter \
 perl-libs \
 perl-IO \
"

URI_perl-FindBin = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-FindBin-1.54-512.2.el10_0.noarch.rpm;name=perl-FindBin;unpack=0"
SRC_URI += "${URI_perl-FindBin}"
SRC_URI[perl-FindBin.sha256sum] = "b395447c9105957be78f21e694a114a411d6cd7661c0ad8669438dab91f4aa35"
RDEPENDS:perl-FindBin = " \
 perl-libs \
 perl-Carp \
 perl-File-Basename \
 perl-PathTools \
 perl-Exporter \
"

URI_perl-GDBM_File = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-GDBM_File-1.24-512.2.el10_0.x86_64_v2.rpm;name=perl-GDBM_File;unpack=0"
SRC_URI += "${URI_perl-GDBM_File}"
SRC_URI[perl-GDBM_File.sha256sum] = "f067ddb040c88332a605a43cae40e4d67cfdcb968bdab5f020f37c79d363a944"
RDEPENDS:perl-GDBM_File = " \
 perl-libs \
 perl-Carp \
 gdbm-libs \
 glibc \
 perl-Exporter \
"

URI_perl-Getopt-Std = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Getopt-Std-1.14-512.2.el10_0.noarch.rpm;name=perl-Getopt-Std;unpack=0"
SRC_URI += "${URI_perl-Getopt-Std}"
SRC_URI[perl-Getopt-Std.sha256sum] = "2dade822b0fbcec4e75d99cd1bafb900622189a8f5ecfa3e40aca5c9d4256eaf"
RDEPENDS:perl-Getopt-Std = " \
 perl-Exporter \
 perl-libs \
"

URI_perl-Hash-Util = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Hash-Util-0.32-512.2.el10_0.x86_64_v2.rpm;name=perl-Hash-Util;unpack=0"
SRC_URI += "${URI_perl-Hash-Util}"
SRC_URI[perl-Hash-Util.sha256sum] = "1227832c9345ade68185a918cf13168258a2078ceb9d77ab9500a24efc44c0d7"
RDEPENDS:perl-Hash-Util = " \
 perl-libs \
 perl-Carp \
 glibc \
 perl-Exporter \
 perl-Hash-Util-FieldHash \
"

URI_perl-Hash-Util-FieldHash = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Hash-Util-FieldHash-1.27-512.2.el10_0.x86_64_v2.rpm;name=perl-Hash-Util-FieldHash;unpack=0"
SRC_URI += "${URI_perl-Hash-Util-FieldHash}"
SRC_URI[perl-Hash-Util-FieldHash.sha256sum] = "157e895be2e4b02c252543c3bbe8c08208c15790ffb6fd17d056e33a34898cd8"
RDEPENDS:perl-Hash-Util-FieldHash = " \
 glibc \
 perl-Exporter \
 perl-libs \
"

URI_perl-I18N-Collate = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-I18N-Collate-1.02-512.2.el10_0.noarch.rpm;name=perl-I18N-Collate;unpack=0"
SRC_URI += "${URI_perl-I18N-Collate}"
SRC_URI[perl-I18N-Collate.sha256sum] = "939759f5a06d0b0f330bb0ce0f13d3a5627157247a7b0adc56ef69a55bddc3c9"
RDEPENDS:perl-I18N-Collate = " \
 perl-Exporter \
 perl-overload \
 perl-libs \
 perl-POSIX \
"

URI_perl-I18N-LangTags = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-I18N-LangTags-0.45-512.2.el10_0.noarch.rpm;name=perl-I18N-LangTags;unpack=0"
SRC_URI += "${URI_perl-I18N-LangTags}"
SRC_URI[perl-I18N-LangTags.sha256sum] = "e04165f70f30d473b7690185275149f79bff42212ccf7affce3896cf3572eda1"
RDEPENDS:perl-I18N-LangTags = " \
 perl-Exporter \
 perl-I18N-LangTags \
 perl-libs \
"

URI_perl-I18N-Langinfo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-I18N-Langinfo-0.24-512.2.el10_0.x86_64_v2.rpm;name=perl-I18N-Langinfo;unpack=0"
SRC_URI += "${URI_perl-I18N-Langinfo}"
SRC_URI[perl-I18N-Langinfo.sha256sum] = "e566d75168c4b77823f881c642141fa996cac35380a834d5269608bbf0266d2e"
RDEPENDS:perl-I18N-Langinfo = " \
 glibc \
 perl-Exporter \
 perl-libs \
 perl-Carp \
"

URI_perl-IO = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-IO-1.55-512.2.el10_0.x86_64_v2.rpm;name=perl-IO;unpack=0"
SRC_URI += "${URI_perl-IO}"
SRC_URI[perl-IO.sha256sum] = "8b875342b4c5d6f5e9bc681e9f22059dfeba3518fd667d6f62a8df24d7f60363"
RDEPENDS:perl-IO = " \
 perl-File-stat \
 perl-libs \
 perl-Carp \
 perl-IO \
 perl-SelectSaver \
 perl-Socket \
 perl-Fcntl \
 perl-Symbol \
 perl-Errno \
 perl-PathTools \
 glibc \
 perl-Exporter \
"

URI_perl-IPC-Open3 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-IPC-Open3-1.22-512.2.el10_0.noarch.rpm;name=perl-IPC-Open3;unpack=0"
SRC_URI += "${URI_perl-IPC-Open3}"
SRC_URI[perl-IPC-Open3.sha256sum] = "40995d475afb4445b4ad4fa52310d873c8814776de5c35be16de6fb6f1cf0c98"
RDEPENDS:perl-IPC-Open3 = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-IO \
 perl-Fcntl \
 perl-POSIX \
 perl-Symbol \
 perl-IPC-Open3 \
 perl-Exporter \
"

URI_perl-Locale-Maketext-Simple = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Locale-Maketext-Simple-0.21-512.2.el10_0.noarch.rpm;name=perl-Locale-Maketext-Simple;unpack=0"
SRC_URI += "${URI_perl-Locale-Maketext-Simple}"
SRC_URI[perl-Locale-Maketext-Simple.sha256sum] = "912b3b1496ce93980f16432e5db249038b2d2b896b481b125de8948ffe4fddb7"
RDEPENDS:perl-Locale-Maketext-Simple = " \
 perl-Locale-Maketext \
 perl-libs \
 perl-base \
"

URI_perl-Math-Complex = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Math-Complex-1.62-512.2.el10_0.noarch.rpm;name=perl-Math-Complex;unpack=0"
SRC_URI += "${URI_perl-Math-Complex}"
SRC_URI[perl-Math-Complex.sha256sum] = "22bdd66628ba9a425828abde67f00496ee1716e4d576c09d6ebdfa09695f3466"
RDEPENDS:perl-Math-Complex = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Math-Complex \
 perl-overload \
 perl-Exporter \
"

URI_perl-Memoize = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Memoize-1.16-512.2.el10_0.noarch.rpm;name=perl-Memoize;unpack=0"
SRC_URI += "${URI_perl-Memoize}"
SRC_URI[perl-Memoize.sha256sum] = "c377b1e0afc48190cc512e339e69a7bb43ea85235235dc62b985aa8b56348878"
RDEPENDS:perl-Memoize = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-Storable \
 perl-NDBM_File \
 perl-Exporter \
"

URI_perl-Module-Loaded = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Module-Loaded-0.08-512.2.el10_0.noarch.rpm;name=perl-Module-Loaded;unpack=0"
SRC_URI += "${URI_perl-Module-Loaded}"
SRC_URI[perl-Module-Loaded.sha256sum] = "4cc67d8f80d85af1172b7f4eedc1ad51e8cfcb1599a35fa292c429a3cc08769c"
RDEPENDS:perl-Module-Loaded = " \
 perl-libs \
 perl-Carp \
 perl-vars \
 perl-Exporter \
 perl-base \
"

URI_perl-NDBM_File = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-NDBM_File-1.17-512.2.el10_0.x86_64_v2.rpm;name=perl-NDBM_File;unpack=0"
SRC_URI += "${URI_perl-NDBM_File}"
SRC_URI[perl-NDBM_File.sha256sum] = "bd97e0426e16d55c548a4f8e290398b73843238ac11d24481480ddbe63b07488"
RDEPENDS:perl-NDBM_File = " \
 glibc \
 perl-libs \
 gdbm-libs \
"

URI_perl-NEXT = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-NEXT-0.69-512.2.el10_0.noarch.rpm;name=perl-NEXT;unpack=0"
SRC_URI += "${URI_perl-NEXT}"
SRC_URI[perl-NEXT.sha256sum] = "f29468443156b0ac7e028290e3a49ccebe224e9fa40f684e1f8ea242e29a8975"
RDEPENDS:perl-NEXT = " \
 perl-overload \
 perl-libs \
 perl-Carp \
"

URI_perl-Net = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Net-1.04-512.2.el10_0.noarch.rpm;name=perl-Net;unpack=0"
SRC_URI += "${URI_perl-Net}"
SRC_URI[perl-Net.sha256sum] = "4b274944172be9d1bd3d908985dd39a30a41e694c9dbffa288c645d9cdff5c99"
RDEPENDS:perl-Net = " \
 perl-Class-Struct \
 perl-Exporter \
 perl-Socket \
 perl-libs \
"

URI_perl-ODBM_File = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-ODBM_File-1.18-512.2.el10_0.x86_64_v2.rpm;name=perl-ODBM_File;unpack=0"
SRC_URI += "${URI_perl-ODBM_File}"
SRC_URI[perl-ODBM_File.sha256sum] = "98ceede037cda31f4332e6918af29ccd2c743b8621360d31da081f5e90190893"
RDEPENDS:perl-ODBM_File = " \
 glibc \
 perl-libs \
 gdbm-libs \
"

URI_perl-Opcode = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Opcode-1.65-512.2.el10_0.x86_64_v2.rpm;name=perl-Opcode;unpack=0"
SRC_URI += "${URI_perl-Opcode}"
SRC_URI[perl-Opcode.sha256sum] = "77752937f75d640f13152d360aa3f6b4b051d583cf68ccf18f2a7e3f154ab83a"
RDEPENDS:perl-Opcode = " \
 perl-subs \
 perl-libs \
 perl-Carp \
 perl-Opcode \
 glibc \
 perl-Exporter \
"

URI_perl-POSIX = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-POSIX-2.20-512.2.el10_0.x86_64_v2.rpm;name=perl-POSIX;unpack=0"
SRC_URI += "${URI_perl-POSIX}"
SRC_URI[perl-POSIX.sha256sum] = "8bafdc473de1a8fc7c922e9a5d21c1bf3457e41ee60ca7998e4c25ffa7c9c523"
RDEPENDS:perl-POSIX = " \
 perl-libs \
 perl-Carp \
 perl-locale \
 perl-Fcntl \
 glibc \
 perl-Exporter \
"

URI_perl-Pod-Functions = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Pod-Functions-1.14-512.2.el10_0.noarch.rpm;name=perl-Pod-Functions;unpack=0"
SRC_URI += "${URI_perl-Pod-Functions}"
SRC_URI[perl-Pod-Functions.sha256sum] = "3be3c74616e23076fa7d4d6c83766b1fcbcfc3e51195dc8e962791c9f2961c2b"
RDEPENDS:perl-Pod-Functions = " \
 perl-Exporter \
 perl-libs \
"

URI_perl-Pod-Html = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Pod-Html-1.35-512.2.el10_0.noarch.rpm;name=perl-Pod-Html;unpack=0"
SRC_URI += "${URI_perl-Pod-Html}"
SRC_URI[perl-Pod-Html.sha256sum] = "461454a236dc1a993701be0d6cb278150d98c5aa7fea8e3947c00dc714515454"
RDEPENDS:perl-Pod-Html = " \
 perl-libs \
 perl-interpreter \
 perl-locale \
 perl-Text-Tabs+Wrap \
 perl-Getopt-Long \
 perl-File-Basename \
 perl-PathTools \
 perl-parent \
 perl-Exporter \
 perl-Pod-Html \
 perl-Pod-Simple \
"

URI_perl-Safe = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Safe-2.46-512.2.el10_0.noarch.rpm;name=perl-Safe;unpack=0"
SRC_URI += "${URI_perl-Safe}"
SRC_URI[perl-Safe.sha256sum] = "92c31e0067d3db5d3817ad19b081cfffd077bb7b6f1f60541df634495c4d43a4"
RDEPENDS:perl-Safe = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Opcode \
 perl-Carp \
 perl-B \
"

URI_perl-Search-Dict = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Search-Dict-1.07-512.2.el10_0.noarch.rpm;name=perl-Search-Dict;unpack=0"
SRC_URI += "${URI_perl-Search-Dict}"
SRC_URI[perl-Search-Dict.sha256sum] = "0611f43fc65bc0d5ac1791e4d951ae8188797acdf04826258fd3afd8bd345f81"
RDEPENDS:perl-Search-Dict = " \
 perl-Exporter \
 perl-libs \
"

URI_perl-SelectSaver = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-SelectSaver-1.02-512.2.el10_0.noarch.rpm;name=perl-SelectSaver;unpack=0"
SRC_URI += "${URI_perl-SelectSaver}"
SRC_URI[perl-SelectSaver.sha256sum] = "ed9a1aae73e2aef7263bde125096abdf124083fae7f41ac7f6f4bf92d687aa6f"
RDEPENDS:perl-SelectSaver = " \
 perl-Symbol \
 perl-libs \
 perl-Carp \
"

URI_perl-SelfLoader = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-SelfLoader-1.27-512.2.el10_0.noarch.rpm;name=perl-SelfLoader;unpack=0"
SRC_URI += "${URI_perl-SelfLoader}"
SRC_URI[perl-SelfLoader.sha256sum] = "1f89970d6e9956a5fe7f1478551cb5137bf29e0621c6a7a154059af92b6e2ba4"
RDEPENDS:perl-SelfLoader = " \
 perl-Exporter \
 perl-libs \
 perl-Carp \
 perl-IO \
"

URI_perl-Symbol = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Symbol-1.09-512.2.el10_0.noarch.rpm;name=perl-Symbol;unpack=0"
SRC_URI += "${URI_perl-Symbol}"
SRC_URI[perl-Symbol.sha256sum] = "fc64a8a2eb0bfadbed283bcf9d73761818ba14be4b60093d3e7abeb311288afd"
RDEPENDS:perl-Symbol = " \
 perl-Exporter \
 perl-libs \
"

URI_perl-Sys-Hostname = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Sys-Hostname-1.25-512.2.el10_0.x86_64_v2.rpm;name=perl-Sys-Hostname;unpack=0"
SRC_URI += "${URI_perl-Sys-Hostname}"
SRC_URI[perl-Sys-Hostname.sha256sum] = "8e6dca3a97059f0970b18c9b53f9005a609ea475733c861a233d3e8e4571d1f6"
RDEPENDS:perl-Sys-Hostname = " \
 glibc \
 perl-Exporter \
 perl-libs \
 perl-Carp \
"

URI_perl-Term-Complete = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Term-Complete-1.403-512.2.el10_0.noarch.rpm;name=perl-Term-Complete;unpack=0"
SRC_URI += "${URI_perl-Term-Complete}"
SRC_URI[perl-Term-Complete.sha256sum] = "404b37425e12dde2d114a0502d3d8ce51d1849996ac4ebbfa90de49b86ded41f"
RDEPENDS:perl-Term-Complete = " \
 perl-Exporter \
 perl-libs \
"

URI_perl-Term-ReadLine = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Term-ReadLine-1.17-512.2.el10_0.noarch.rpm;name=perl-Term-ReadLine;unpack=0"
SRC_URI += "${URI_perl-Term-ReadLine}"
SRC_URI[perl-Term-ReadLine.sha256sum] = "78bae3932bdec43fa2a2033341e3fd21296be3ce070071d063f534cbc6c4fd56"
RDEPENDS:perl-Term-ReadLine = " \
 perl-Term-Cap \
 perl-libs \
"

URI_perl-Test = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Test-1.31-512.2.el10_0.noarch.rpm;name=perl-Test;unpack=0"
SRC_URI += "${URI_perl-Test}"
SRC_URI[perl-Test.sha256sum] = "bdb23bce7b808d619f13404f2e55cc3c889066090b8265285900e6403ce0d6b5"
RDEPENDS:perl-Test = " \
 perl-File-Temp \
 perl-Exporter \
 perl-libs \
 perl-Carp \
"

URI_perl-Text-Abbrev = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Text-Abbrev-1.02-512.2.el10_0.noarch.rpm;name=perl-Text-Abbrev;unpack=0"
SRC_URI += "${URI_perl-Text-Abbrev}"
SRC_URI[perl-Text-Abbrev.sha256sum] = "5da22eb4832fa4b4add1ff55afc8a2f519c9d26bf0acfc64656b4f7d22022789"
RDEPENDS:perl-Text-Abbrev = " \
 perl-Exporter \
 perl-libs \
"

URI_perl-Thread = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Thread-3.05-512.2.el10_0.noarch.rpm;name=perl-Thread;unpack=0"
SRC_URI += "${URI_perl-Thread}"
SRC_URI[perl-Thread.sha256sum] = "b45ce0309bb2378f245aa485f0511fd9e30567d775ffe725b4794a4b158837df"
RDEPENDS:perl-Thread = " \
 perl-threads-shared \
 perl-threads \
 perl-Exporter \
 perl-libs \
"

URI_perl-Thread-Semaphore = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Thread-Semaphore-2.13-512.2.el10_0.noarch.rpm;name=perl-Thread-Semaphore;unpack=0"
SRC_URI += "${URI_perl-Thread-Semaphore}"
SRC_URI[perl-Thread-Semaphore.sha256sum] = "a21db28ebfc8319925884a632999e12062ec7fcbb7c6fac8d326e5eeedd82131"
RDEPENDS:perl-Thread-Semaphore = " \
 perl-threads-shared \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
"

URI_perl-Tie = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Tie-4.6-512.2.el10_0.noarch.rpm;name=perl-Tie;unpack=0"
SRC_URI += "${URI_perl-Tie}"
SRC_URI[perl-Tie.sha256sum] = "acf14b4be52b41a651831afaf28dc9f16772ea55f609c7b69d6c75f4b4c70fb6"
RDEPENDS:perl-Tie = " \
 perl-Tie \
 perl-libs \
 perl-Carp \
"

URI_perl-Tie-File = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Tie-File-1.09-512.2.el10_0.noarch.rpm;name=perl-Tie-File;unpack=0"
SRC_URI += "${URI_perl-Tie-File}"
SRC_URI[perl-Tie-File.sha256sum] = "0dd814089ad9336cc5f908db5e3a58b2d37ca6c3d7e41d9f29adb1b0e27d9af8"
RDEPENDS:perl-Tie-File = " \
 perl-constant \
 perl-libs \
 perl-Carp \
 perl-Fcntl \
 perl-POSIX \
"

URI_perl-Tie-Memoize = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Tie-Memoize-1.1-512.2.el10_0.noarch.rpm;name=perl-Tie-Memoize;unpack=0"
SRC_URI += "${URI_perl-Tie-Memoize}"
SRC_URI[perl-Tie-Memoize.sha256sum] = "2c01a946d2f8f60d2dc635328f1ddee202ac8b0dda68067003919d3dbc563f1d"
RDEPENDS:perl-Tie-Memoize = " \
 perl-libs \
 perl-Carp \
"

URI_perl-Time = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Time-1.04-512.2.el10_0.noarch.rpm;name=perl-Time;unpack=0"
SRC_URI += "${URI_perl-Time}"
SRC_URI[perl-Time.sha256sum] = "0ae3057e0168e0b00d1127e667ebd581693aaffa0f6db386bdf30e19c49e8629"
RDEPENDS:perl-Time = " \
 perl-libs \
 perl-Class-Struct \
 perl-parent \
 perl-Exporter \
 perl-Time \
"

URI_perl-Time-Piece = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Time-Piece-1.3401-512.2.el10_0.x86_64_v2.rpm;name=perl-Time-Piece;unpack=0"
SRC_URI += "${URI_perl-Time-Piece}"
SRC_URI[perl-Time-Piece.sha256sum] = "8d1e1e530b5ec298f512a46566676394efe12660b4d9cea87e414b70a4602df6"
RDEPENDS:perl-Time-Piece = " \
 perl-constant \
 perl-Time-Piece \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-Carp \
 perl-overload \
 glibc \
 perl-Exporter \
 perl-Time-Local \
"

URI_perl-Unicode-UCD = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Unicode-UCD-0.78-512.2.el10_0.noarch.rpm;name=perl-Unicode-UCD;unpack=0"
SRC_URI += "${URI_perl-Unicode-UCD}"
SRC_URI[perl-Unicode-UCD.sha256sum] = "866d0ded31b8a1e582bd9aad5dab7c4da04f5c7ba439a2cb5d8a384eb0112d67"
RDEPENDS:perl-Unicode-UCD = " \
 perl-libs \
 perl-Carp \
 perl-Unicode-Normalize \
 perl-Storable \
 perl-PathTools \
 perl-if \
 perl-Exporter \
"

URI_perl-User-pwent = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-User-pwent-1.05-512.2.el10_0.noarch.rpm;name=perl-User-pwent;unpack=0"
SRC_URI += "${URI_perl-User-pwent}"
SRC_URI[perl-User-pwent.sha256sum] = "3905cab8deef2cc83a770366979b533b34d931bd7176abb7d7849ae7c6dd23c1"
RDEPENDS:perl-User-pwent = " \
 perl-Class-Struct \
 perl-Exporter \
 perl-libs \
 perl-Carp \
"

URI_perl-autouse = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-autouse-1.11-512.2.el10_0.noarch.rpm;name=perl-autouse;unpack=0"
SRC_URI += "${URI_perl-autouse}"
SRC_URI[perl-autouse.sha256sum] = "fd6b85a8c16f2d4ffb1cf2ba8415b593def67ba439b0a55bed3eceadd055ef05"
RDEPENDS:perl-autouse = " \
 perl-libs \
 perl-Carp \
"

URI_perl-base = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-base-2.27-512.2.el10_0.noarch.rpm;name=perl-base;unpack=0"
SRC_URI += "${URI_perl-base}"
SRC_URI[perl-base.sha256sum] = "641cde08c976a50c629cd7637affe32ad346d1dc3c92ac5211e61151318a7ddf"
RDEPENDS:perl-base = " \
 perl-libs \
 perl-Carp \
"

URI_perl-blib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-blib-1.07-512.2.el10_0.noarch.rpm;name=perl-blib;unpack=0"
SRC_URI += "${URI_perl-blib}"
SRC_URI[perl-blib.sha256sum] = "4d99592c8e8ae0dfd9afdd00aeeec945bd8661dad634cdbfd0b55346df08c8bb"
RDEPENDS:perl-blib = " \
 perl-PathTools \
 perl-libs \
"

URI_perl-debugger = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-debugger-1.60-512.2.el10_0.noarch.rpm;name=perl-debugger;unpack=0"
SRC_URI += "${URI_perl-debugger}"
SRC_URI[perl-debugger.sha256sum] = "cd8d7729c6a2abaf51a84643a640c2b1ce35754c46abc8f4a05a97df5ff43881"
RDEPENDS:perl-debugger = " \
 perl-threads \
 perl-threads-shared \
 perl-libs \
 perl-vars \
 perl-IO \
 perl-meta-notation \
 perl-mro \
 perl-PathTools \
 perl-Term-ReadLine \
"

URI_perl-deprecate = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-deprecate-0.04-512.2.el10_0.noarch.rpm;name=perl-deprecate;unpack=0"
SRC_URI += "${URI_perl-deprecate}"
SRC_URI[perl-deprecate.sha256sum] = "6a109c87391e7a0d50fbbb75cf2d853f5a512d213b9a7e672d65aa2f887995f1"
RDEPENDS:perl-deprecate = " \
 perl-libs \
 perl-Carp \
"

URI_perl-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-devel-5.40.2-512.2.el10_0.x86_64_v2.rpm;name=perl-devel;unpack=0"
SRC_URI += "${URI_perl-devel}"
SRC_URI[perl-devel.sha256sum] = "073bea1e0c8b2f0a661cbe4d18462850bf0e0be50949dd0f8b111be7b6494443"
RDEPENDS:perl-devel = " \
 perl-Devel-PPPort \
 perl-ExtUtils-Install \
 perl-libs \
 perl-vars \
 redhat-rpm-config \
 perl-ExtUtils-ParseXS \
 perl-Text-Tabs+Wrap \
 perl-Getopt-Long \
 perl-File-Compare \
 perl-PathTools \
 libxcrypt-devel \
 systemtap-sdt-devel \
 systemtap-sdt-dtrace \
 perl-interpreter \
 perl-File-Path \
 perl-ExtUtils-Constant \
"

URI_perl-diagnostics = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-diagnostics-1.40-512.2.el10_0.noarch.rpm;name=perl-diagnostics;unpack=0"
SRC_URI += "${URI_perl-diagnostics}"
SRC_URI[perl-diagnostics.sha256sum] = "236ade48d3a61b1370ffb047eff3d4967faf7b9b71578941074831936c117849"
RDEPENDS:perl-diagnostics = " \
 perl-libs \
 perl-Carp \
 perl-Text-Tabs+Wrap \
 perl-Getopt-Std \
 perl-interpreter \
"

URI_perl-doc = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-doc-5.40.2-512.2.el10_0.noarch.rpm;name=perl-doc;unpack=0"
SRC_URI += "${URI_perl-doc}"
SRC_URI[perl-doc.sha256sum] = "751a5de1e4ea89b827e4fec72a83a3defc5ca8e14a30c1378c8251fe53d878d9"
RDEPENDS:perl-doc = " \
 perl-libs \
"

URI_perl-encoding-warnings = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-encoding-warnings-0.14-512.2.el10_0.noarch.rpm;name=perl-encoding-warnings;unpack=0"
SRC_URI += "${URI_perl-encoding-warnings}"
SRC_URI[perl-encoding-warnings.sha256sum] = "3344bc9f86b6d37ad41d6cac87a2f59511b734e000bde88bc0599b83b2831e51"
RDEPENDS:perl-encoding-warnings = " \
 perl-libs \
 perl-Carp \
"

URI_perl-fields = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-fields-2.27-512.2.el10_0.noarch.rpm;name=perl-fields;unpack=0"
SRC_URI += "${URI_perl-fields}"
SRC_URI[perl-fields.sha256sum] = "52754755e3017eb281df10d7747c05891247da5784bd01ac193d0afb2572f7d2"
RDEPENDS:perl-fields = " \
 perl-Hash-Util \
 perl-libs \
 perl-base \
 perl-Carp \
"

URI_perl-filetest = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-filetest-1.03-512.2.el10_0.noarch.rpm;name=perl-filetest;unpack=0"
SRC_URI += "${URI_perl-filetest}"
SRC_URI[perl-filetest.sha256sum] = "f96011d3a911133c5b4b4f6cc67f487359655fd2785636644a98e4aefe7b84f3"
RDEPENDS:perl-filetest = " \
 perl-libs \
"

URI_perl-if = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-if-0.61.000-512.2.el10_0.noarch.rpm;name=perl-if;unpack=0"
SRC_URI += "${URI_perl-if}"
SRC_URI[perl-if.sha256sum] = "f59c4b48019089fcb5c778efc2e1b3dedbc2ac18e9ec0105f72c97b85acbb62d"
RDEPENDS:perl-if = " \
 perl-libs \
"

URI_perl-interpreter = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-interpreter-5.40.2-512.2.el10_0.x86_64_v2.rpm;name=perl-interpreter;unpack=0"
SRC_URI += "${URI_perl-interpreter}"
SRC_URI[perl-interpreter.sha256sum] = "2167552555494c4a76deb4bd265110d8c413fce637c60720693fe409529e9d94"
RDEPENDS:perl-interpreter = " \
 glibc \
 perl-libs \
"

URI_perl-less = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-less-0.03-512.2.el10_0.noarch.rpm;name=perl-less;unpack=0"
SRC_URI += "${URI_perl-less}"
SRC_URI[perl-less.sha256sum] = "7f3f1c6a710705f0f43ea72601f49e41df9c49c2f248f5d8d3de35538cccdb9b"
RDEPENDS:perl-less = " \
 perl-libs \
"

URI_perl-lib = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-lib-0.65-512.2.el10_0.x86_64_v2.rpm;name=perl-lib;unpack=0"
SRC_URI += "${URI_perl-lib}"
SRC_URI[perl-lib.sha256sum] = "9332b0858c0b49107ae28e0f6a3744c9af8ca0d7ab4fd65de5defd3141ce2f8c"
RDEPENDS:perl-lib = " \
 perl-libs \
 perl-Carp \
"

URI_perl-libnetcfg = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-libnetcfg-5.40.2-512.2.el10_0.noarch.rpm;name=perl-libnetcfg;unpack=0"
SRC_URI += "${URI_perl-libnetcfg}"
SRC_URI[perl-libnetcfg.sha256sum] = "de5d590bb9d8ca5310e9c9504fc375a161f53d8072417047578e0e8bb6306c59"
RDEPENDS:perl-libnetcfg = " \
 perl-libs \
 perl-ExtUtils-MakeMaker \
 perl-vars \
 perl-IO \
 perl-Getopt-Std \
 perl-PathTools \
 perl-interpreter \
"

URI_perl-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-libs-5.40.2-512.2.el10_0.x86_64_v2.rpm;name=perl-libs;unpack=0"
SRC_URI += "${URI_perl-libs}"
SRC_URI[perl-libs.sha256sum] = "bd3d8bac9ba67878846c15a20d22d6774a8590ef9f68d565ef64019cedbbe1a8"
RDEPENDS:perl-libs = " \
 perl-libs \
 perl-Carp \
 libxcrypt \
 perl-DynaLoader \
 perl-Encode \
 perl-PathTools \
 glibc \
 perl-Exporter \
"

URI_perl-locale = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-locale-1.12-512.2.el10_0.noarch.rpm;name=perl-locale;unpack=0"
SRC_URI += "${URI_perl-locale}"
SRC_URI[perl-locale.sha256sum] = "ebf45a42c179fc9a71cc2addd597d0e584d13113b1d5854f20ba213a25357e3e"
RDEPENDS:perl-locale = " \
 perl-libs \
 perl-Carp \
 perl-POSIX \
"

URI_perl-macros = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-macros-5.40.2-512.2.el10_0.noarch.rpm;name=perl-macros;unpack=0"
SRC_URI += "${URI_perl-macros}"
SRC_URI[perl-macros.sha256sum] = "73a8676afd8ca31e31af3fb81c4b4dcdb52a40629c7a126e849c71a7b750f35a"
RDEPENDS:perl-macros = " \
 perl-interpreter \
"

URI_perl-meta-notation = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-meta-notation-5.40.2-512.2.el10_0.noarch.rpm;name=perl-meta-notation;unpack=0"
SRC_URI += "${URI_perl-meta-notation}"
SRC_URI[perl-meta-notation.sha256sum] = "bf55895a1c45f9c84949681fdb1788cf16474b9cffdfaf951c0012bc3f5fea4c"
RDEPENDS:perl-meta-notation = " \
 perl-libs \
"

URI_perl-mro = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-mro-1.29-512.2.el10_0.x86_64_v2.rpm;name=perl-mro;unpack=0"
SRC_URI += "${URI_perl-mro}"
SRC_URI[perl-mro.sha256sum] = "382c962b49a02533719327d332b5e97b1a567be0fc5406e0faea770dbd976b07"
RDEPENDS:perl-mro = " \
 glibc \
 perl-libs \
"

URI_perl-open = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-open-1.13-512.2.el10_0.noarch.rpm;name=perl-open;unpack=0"
SRC_URI += "${URI_perl-open}"
SRC_URI[perl-open.sha256sum] = "97234a7bea13610db101d634c585ca991113a589311e898d611326c0197aa551"
RDEPENDS:perl-open = " \
 perl-encoding \
 perl-Encode \
 perl-libs \
 perl-Carp \
"

URI_perl-overload = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-overload-1.37-512.2.el10_0.noarch.rpm;name=perl-overload;unpack=0"
SRC_URI += "${URI_perl-overload}"
SRC_URI[perl-overload.sha256sum] = "59b2c9966ff14087428f502eea14f82f95a072dd9fdfb82eed4db7c6c67efd22"
RDEPENDS:perl-overload = " \
 perl-overloading \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-mro \
"

URI_perl-overloading = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-overloading-0.02-512.2.el10_0.noarch.rpm;name=perl-overloading;unpack=0"
SRC_URI += "${URI_perl-overloading}"
SRC_URI[perl-overloading.sha256sum] = "65652dda4e16f13ab1e413effb4d6886e446eef1950757befdf44a84d457602b"
RDEPENDS:perl-overloading = " \
 perl-libs \
 perl-Carp \
"

URI_perl-ph = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-ph-5.40.2-512.2.el10_0.x86_64_v2.rpm;name=perl-ph;unpack=0"
SRC_URI += "${URI_perl-ph}"
SRC_URI[perl-ph.sha256sum] = "9647e6e98a81d964ded7cd6dcb2249e50c4dfa0a5c51652e71b95c5a91870d70"
RDEPENDS:perl-ph = " \
 perl-libs \
"

URI_perl-sigtrap = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-sigtrap-1.10-512.2.el10_0.noarch.rpm;name=perl-sigtrap;unpack=0"
SRC_URI += "${URI_perl-sigtrap}"
SRC_URI[perl-sigtrap.sha256sum] = "e197f8a3435fadf4dacb0c5984112fa07fefd2f7a6136da75a048d58a855fcc6"
RDEPENDS:perl-sigtrap = " \
 perl-meta-notation \
 perl-Symbol \
 perl-libs \
 perl-Carp \
"

URI_perl-sort = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-sort-2.05-512.2.el10_0.noarch.rpm;name=perl-sort;unpack=0"
SRC_URI += "${URI_perl-sort}"
SRC_URI[perl-sort.sha256sum] = "91dfd0eb881e4f3d5f23e9ffa575fce4cf5cfc21c0235383c9ef1bc1446d0da5"
RDEPENDS:perl-sort = " \
 perl-libs \
 perl-Carp \
"

URI_perl-subs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-subs-1.04-512.2.el10_0.noarch.rpm;name=perl-subs;unpack=0"
SRC_URI += "${URI_perl-subs}"
SRC_URI[perl-subs.sha256sum] = "16e9eae4ca86c30a37354a0041c2581a84a380e7f7667a8cdaf75c5ca286ce2c"
RDEPENDS:perl-subs = " \
 perl-libs \
"

URI_perl-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-utils-5.40.2-512.2.el10_0.noarch.rpm;name=perl-utils;unpack=0"
SRC_URI += "${URI_perl-utils}"
SRC_URI[perl-utils.sha256sum] = "65550ed46617d52d3747c5730f4ec10e61a204a55e85574f1e7aa56172498f9e"
RDEPENDS:perl-utils = " \
 perl-libs \
 perl-vars \
 perl-File-Basename \
 perl-Getopt-Std \
 perl-PathTools \
 perl-interpreter \
 perl-File-Path \
"

URI_perl-vars = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-vars-1.05-512.2.el10_0.noarch.rpm;name=perl-vars;unpack=0"
SRC_URI += "${URI_perl-vars}"
SRC_URI[perl-vars.sha256sum] = "39940dd1ba24c74f5c869ceb974b344432c9ca1eaece7b0d94e2bfd96d9831b9"
RDEPENDS:perl-vars = " \
 perl-libs \
 perl-Carp \
"

URI_perl-vmsish = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-vmsish-1.04-512.2.el10_0.noarch.rpm;name=perl-vmsish;unpack=0"
SRC_URI += "${URI_perl-vmsish}"
SRC_URI[perl-vmsish.sha256sum] = "cdb5064b8979c0e4ca6838d7976e6bb898ac734655e1c7cbec225c83b688c578"
RDEPENDS:perl-vmsish = " \
 perl-libs \
"

URI_perl-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-tests-5.40.2-512.2.el10_0.x86_64_v2.rpm;name=perl-tests;unpack=0"
SRC_URI += "${URI_perl-tests}"
SRC_URI[perl-tests.sha256sum] = "4e16d66c979be117914ba5a51650a86de549edd5d3008833cd4f9baea7f6014b"
RDEPENDS:perl-tests = " \
 perl \
"
