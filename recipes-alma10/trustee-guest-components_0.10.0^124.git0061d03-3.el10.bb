# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "trustee-guest-components"
PE = "0"
PV = "0.10.0^124.git0061d03"
PR = "3.el10"
PACKAGES = "trustee-guest-components"
PROVIDES = "rpm/trustee-guest-components"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/trustee-guest-components-0.10.0^124.git0061d03-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed9a25a8feac33b758a82298967f8853aa8c177b24288429b8f0bd0b61505794"

URI_trustee-guest-components = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/trustee-guest-components-0.10.0^124.git0061d03-3.el10.x86_64_v2.rpm;name=trustee-guest-components;unpack=0"
SRC_URI += "${URI_trustee-guest-components}"
SRC_URI[trustee-guest-components.sha256sum] = "b742b62537b01cae45bc6c9b4b91accb4dcc23dab1e020c5be9377a936494029"
RDEPENDS:trustee-guest-components = " \
 glibc \
 openssl-libs \
 libgcc \
 tpm2-tss \
"
