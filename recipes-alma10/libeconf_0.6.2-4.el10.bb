# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libeconf"
PE = "0"
PV = "0.6.2"
PR = "4.el10"
PACKAGES = "libeconf libeconf-devel libeconf-utils"
PROVIDES = "rpm/libeconf rpm/libeconf-devel rpm/libeconf-utils"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libeconf-0.6.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "844e09e1c126e13c46afbefd5add05074c9f8da95ec869193c1d5ddb6ad6d18b"

URI_libeconf = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libeconf-0.6.2-4.el10.x86_64_v2.rpm;name=libeconf;unpack=0"
SRC_URI += "${URI_libeconf}"
SRC_URI[libeconf.sha256sum] = "96ae8779c56863dbc6bbec93b8ccebf101cc24fa16e516ca772eabd4d27bcf96"
RDEPENDS:libeconf = " \
 glibc \
"

URI_libeconf-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libeconf-devel-0.6.2-4.el10.x86_64_v2.rpm;name=libeconf-devel;unpack=0"
SRC_URI += "${URI_libeconf-devel}"
SRC_URI[libeconf-devel.sha256sum] = "a0df5ed0d46537845f95da7c1235a96f53767bfa02a78460fb3d6755f77e1e98"
RDEPENDS:libeconf-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 libeconf \
"

URI_libeconf-utils = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libeconf-utils-0.6.2-4.el10.x86_64_v2.rpm;name=libeconf-utils;unpack=0"
SRC_URI += "${URI_libeconf-utils}"
SRC_URI[libeconf-utils.sha256sum] = "d9d4402f8414296dc2dbd7cf82348159cb9e0e0ad8396001b7fbd0d43df4363c"
RDEPENDS:libeconf-utils = " \
 glibc \
 libgcc \
 libeconf \
"
