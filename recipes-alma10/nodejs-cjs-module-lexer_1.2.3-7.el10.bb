# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "nodejs-cjs-module-lexer"
PE = "0"
PV = "1.2.3"
PR = "7.el10"
PACKAGES = "nodejs-cjs-module-lexer"
PROVIDES = "rpm/nodejs-cjs-module-lexer"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/nodejs-cjs-module-lexer-1.2.3-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28c42f4ed273c3e17fc9ecf16ce2f0f58aad7907723e52c00c76ce51c631e1ee"

URI_nodejs-cjs-module-lexer = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/nodejs-cjs-module-lexer-1.2.3-7.el10.noarch.rpm;name=nodejs-cjs-module-lexer;unpack=0"
SRC_URI += "${URI_nodejs-cjs-module-lexer}"
SRC_URI[nodejs-cjs-module-lexer.sha256sum] = "ef93559ca88720eb3ce3affac2d6d6a5a9770fa187e4be3035a12d8446b30a06"
RDEPENDS:nodejs-cjs-module-lexer = " \
 nodejs \
"
