# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-File-BaseDir"
PE = "0"
PV = "0.09"
PR = "11.el10"
PACKAGES = "perl-File-BaseDir perl-File-BaseDir-tests perl-File-UserDirs"
PROVIDES = "rpm/perl-File-BaseDir rpm/perl-File-BaseDir-tests rpm/perl-File-UserDirs"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/perl-File-BaseDir-0.09-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e46318181ccab0b75185dba492b0c29dbb2fda81e6b9b5d64b4b03932e01c57c"

URI_perl-File-BaseDir = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/perl-File-BaseDir-0.09-11.el10.noarch.rpm;name=perl-File-BaseDir;unpack=0"
SRC_URI += "${URI_perl-File-BaseDir}"
SRC_URI[perl-File-BaseDir.sha256sum] = "58028e83eab28cfa7524a8258f16ae8056e2f88fd97a0ea3afa17c7fe2a1fb79"
RDEPENDS:perl-File-BaseDir = " \
 perl-File-BaseDir \
 perl-PathTools \
 perl-libs \
 perl-Exporter \
"

URI_perl-File-BaseDir-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-File-BaseDir-tests-0.09-11.el10.noarch.rpm;name=perl-File-BaseDir-tests;unpack=0"
SRC_URI += "${URI_perl-File-BaseDir-tests}"
SRC_URI[perl-File-BaseDir-tests.sha256sum] = "5482c0b37e842ccbd9156dffd1482c92a0dacd78137951e5a630828ab74e5f6a"
RDEPENDS:perl-File-BaseDir-tests = " \
 perl-File-UserDirs \
 perl-Test-Harness \
 perl-libs \
 perl-Test-Simple \
 xdg-user-dirs \
 perl-File-Temp \
 bash \
 perl-PathTools \
 perl-File-BaseDir \
 perl-interpreter \
 perl-File-Path \
 perl-Exporter \
 perl-lib \
 perl-File-Which \
"

URI_perl-File-UserDirs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-File-UserDirs-0.09-11.el10.noarch.rpm;name=perl-File-UserDirs;unpack=0"
SRC_URI += "${URI_perl-File-UserDirs}"
SRC_URI[perl-File-UserDirs.sha256sum] = "51f9407c1e6ca5c7e3a56dca798325aca90eec7ca28b2d63fc87e7bb7ae3eebd"
RDEPENDS:perl-File-UserDirs = " \
 xdg-user-dirs \
 perl-IPC-System-Simple \
 perl-libs \
 perl-Exporter \
"
