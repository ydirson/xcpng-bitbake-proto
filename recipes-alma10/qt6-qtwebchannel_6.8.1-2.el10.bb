# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtwebchannel"
PE = "0"
PV = "6.8.1"
PR = "2.el10"
PACKAGES = "qt6-qtwebchannel qt6-qtwebchannel-devel qt6-qtwebchannel-examples qt6-qtwebchannel-tests"
PROVIDES = "rpm/qt6-qtwebchannel rpm/qt6-qtwebchannel-devel rpm/qt6-qtwebchannel-examples rpm/qt6-qtwebchannel-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtwebchannel-6.8.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e24696c4c2ac010d11af314d0cab398896469a3cce20414c3126eb7cf129aee0"

URI_qt6-qtwebchannel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtwebchannel-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtwebchannel;unpack=0"
SRC_URI += "${URI_qt6-qtwebchannel}"
SRC_URI[qt6-qtwebchannel.sha256sum] = "eb9ae4d42ce36e1df389e5783f4fbcebc2d791ee7d9a38433496f3725f5c32ad"
RDEPENDS:qt6-qtwebchannel = " \
 glibc \
 qt6-qtdeclarative \
 libstdc++ \
 qt6-qtbase \
"

URI_qt6-qtwebchannel-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtwebchannel-devel-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtwebchannel-devel;unpack=0"
SRC_URI += "${URI_qt6-qtwebchannel-devel}"
SRC_URI[qt6-qtwebchannel-devel.sha256sum] = "12891af67b54ccb0267c620ade836fe0def2fb9f6d8e364acc6dcae81cf7dd06"
RDEPENDS:qt6-qtwebchannel-devel = " \
 qt6-qtdeclarative-devel \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtwebchannel \
 qt6-qtbase-devel \
"

URI_qt6-qtwebchannel-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtwebchannel-examples-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtwebchannel-examples;unpack=0"
SRC_URI += "${URI_qt6-qtwebchannel-examples}"
SRC_URI[qt6-qtwebchannel-examples.sha256sum] = "e30b27fb18500e4240257d5a8195fa4a501cd9093ca5ffaf0a48fcf991d3eb94"
RDEPENDS:qt6-qtwebchannel-examples = " \
 libgcc \
 qt6-qtbase \
 qt6-qtwebchannel \
 libstdc++ \
 qt6-qtwebsockets \
 glibc \
"

URI_qt6-qtwebchannel-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtwebchannel-tests-6.8.1-2.el10.x86_64_v2.rpm;name=qt6-qtwebchannel-tests;unpack=0"
SRC_URI += "${URI_qt6-qtwebchannel-tests}"
SRC_URI[qt6-qtwebchannel-tests.sha256sum] = "c10046f2261a77166317f67b0f2e34ad1b6d3fb96bf9dc135a66900e665ae944"
RDEPENDS:qt6-qtwebchannel-tests = " \
 qt6-qtdeclarative \
 libgcc \
 qt6-qtbase \
 qt6-qtwebchannel \
 libstdc++ \
 glibc \
"
