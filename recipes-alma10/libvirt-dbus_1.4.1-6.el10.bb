# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libvirt-dbus"
PE = "0"
PV = "1.4.1"
PR = "6.el10"
PACKAGES = "libvirt-dbus"
PROVIDES = "rpm/libvirt-dbus"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/libvirt-dbus-1.4.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3f484ba86e432775b2feb52a4e6268ed24ef464c08ef507bc46f08c373aa195"

URI_libvirt-dbus = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libvirt-dbus-1.4.1-6.el10.x86_64_v2.rpm;name=libvirt-dbus;unpack=0"
SRC_URI += "${URI_libvirt-dbus}"
SRC_URI[libvirt-dbus.sha256sum] = "e6f6821e8f4c7a016c8d5fcaf54e7a4205af7af71983c3e3e62c8cd4500088a6"
RDEPENDS:libvirt-dbus = " \
 shadow-utils \
 libgcc \
 polkit \
 bash \
 glib2 \
 dbus \
 glibc \
 libvirt-glib \
 libvirt-libs \
"
