# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "initscripts"
PE = "0"
PV = "10.26"
PR = "2.el10"
PACKAGES = "initscripts initscripts-rename-device initscripts-service netconsole-service readonly-root"
PROVIDES = "rpm/initscripts rpm/initscripts-rename-device rpm/initscripts-service rpm/netconsole-service rpm/readonly-root"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/initscripts-10.26-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bec074d4b671e245a10e4c6116d4e5b601c9f3130335092f81792dc4ddf582c0"

URI_initscripts = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/initscripts-10.26-2.el10.x86_64_v2.rpm;name=initscripts;unpack=0"
SRC_URI += "${URI_initscripts}"
SRC_URI[initscripts.sha256sum] = "bee6ba4dc36ccc650090ac38b51aaf0ed2fb0402d382b03a2b9eb1ada8a2a992"
RDEPENDS:initscripts = " \
 setup \
 initscripts-service \
 shadow-utils \
 systemd \
 util-linux \
 chkconfig \
 gawk \
 grep \
 filesystem \
 bash \
 popt \
 procps-ng \
 glibc \
 coreutils \
 initscripts-rename-device \
 findutils \
"

URI_initscripts-rename-device = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/initscripts-rename-device-10.26-2.el10.x86_64_v2.rpm;name=initscripts-rename-device;unpack=0"
SRC_URI += "${URI_initscripts-rename-device}"
SRC_URI[initscripts-rename-device.sha256sum] = "c2f11bdbf98600c2c632f5207901beae3716176431bc1b97f39eed648a541c59"
RDEPENDS:initscripts-rename-device = " \
 gawk \
 bash \
 glib2 \
 glibc \
 coreutils \
 filesystem \
"

URI_initscripts-service = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/initscripts-service-10.26-2.el10.noarch.rpm;name=initscripts-service;unpack=0"
SRC_URI += "${URI_initscripts-service}"
SRC_URI[initscripts-service.sha256sum] = "dcafa01802d9e327e49f56bf3c45aaa7209f9cb9b347ffcdbc5846d91b99d951"
RDEPENDS:initscripts-service = " \
 systemd \
 gawk \
 bash \
 coreutils \
 filesystem \
"

URI_netconsole-service = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/netconsole-service-10.26-2.el10.noarch.rpm;name=netconsole-service;unpack=0"
SRC_URI += "${URI_netconsole-service}"
SRC_URI[netconsole-service.sha256sum] = "c20d99ff25ca13a8645843f5abddc8dc6ba6abd3aa9678befc805b3d2c434ec7"
RDEPENDS:netconsole-service = " \
 glibc-common \
 util-linux \
 iproute \
 kmod \
 gawk \
 iputils \
 bash \
 initscripts \
 sed \
 coreutils \
 filesystem \
"

URI_readonly-root = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/readonly-root-10.26-2.el10.noarch.rpm;name=readonly-root;unpack=0"
SRC_URI += "${URI_readonly-root}"
SRC_URI[readonly-root.sha256sum] = "572c8b0da76d2b8a2b121556ab76e501e78663b2f40685c2a2f1c08d792c3271"
RDEPENDS:readonly-root = " \
 ipcalc \
 util-linux \
 iproute \
 gawk \
 hostname \
 filesystem \
 bash \
 initscripts \
 coreutils \
 cpio \
 findutils \
"
