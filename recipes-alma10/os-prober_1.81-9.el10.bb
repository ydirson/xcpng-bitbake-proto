# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "os-prober"
PE = "0"
PV = "1.81"
PR = "9.el10"
PACKAGES = "os-prober"
PROVIDES = "rpm/os-prober"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/os-prober-1.81-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba0ef05f338d7661a576902e0b93f410f6ab4b5cc9a015518f933d3f31e79b5c"

URI_os-prober = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/os-prober-1.81-9.el10.x86_64_v2.rpm;name=os-prober;unpack=0"
SRC_URI += "${URI_os-prober}"
SRC_URI[os-prober.sha256sum] = "16de85db2f120376264313cbbf96315796157d6333a75b536dab554507b343bb"
RDEPENDS:os-prober = " \
 grub2-tools-minimal \
 util-linux \
 systemd-udev \
 kmod \
 grep \
 bash \
 glibc \
 coreutils \
 sed \
"
