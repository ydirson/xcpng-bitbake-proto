# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "jss"
PE = "0"
PV = "5.6.0"
PR = "1.el10"
PACKAGES = "idm-jss idm-jss-tomcat idm-jss-javadoc idm-jss-tests idm-jss-tools"
PROVIDES = "rpm/idm-jss rpm/idm-jss-tomcat rpm/idm-jss-javadoc rpm/idm-jss-tests rpm/idm-jss-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/jss-5.6.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17314c402bca51ce3abc0e2f2a129593d5f735792fa2f0af8008c0f11ad2d508"

URI_idm-jss = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/idm-jss-5.6.0-1.el10.x86_64_v2.rpm;name=idm-jss;unpack=0"
SRC_URI += "${URI_idm-jss}"
SRC_URI[idm-jss.sha256sum] = "d35976595cf7c2c22e6a6509b28dab6397e8bf267bce6036d9e904565542a17f"
RDEPENDS:idm-jss = " \
 nss \
 javapackages-filesystem \
 apache-commons-lang3 \
 libgcc \
 libstdc++ \
 slf4j \
 java-21-openjdk-headless \
 slf4j-jdk14 \
 glibc \
 nspr \
"

URI_idm-jss-tomcat = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/idm-jss-tomcat-5.6.0-1.el10.x86_64_v2.rpm;name=idm-jss-tomcat;unpack=0"
SRC_URI += "${URI_idm-jss-tomcat}"
SRC_URI[idm-jss-tomcat.sha256sum] = "49d867fc08acafa98cb4d8d6474e7f912fd11b948eba6a9567c61289edd0677f"
RDEPENDS:idm-jss-tomcat = " \
 tomcat9 \
 tomcat-lib \
 javapackages-filesystem \
 idm-jss \
"

URI_idm-jss-javadoc = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/idm-jss-javadoc-5.6.0-1.el10.x86_64_v2.rpm;name=idm-jss-javadoc;unpack=0"
SRC_URI += "${URI_idm-jss-javadoc}"
SRC_URI[idm-jss-javadoc.sha256sum] = "69aebc9ccf440e9841f52d27e7990b49e1c505f59a3ed3df0ab77bca889d7ad0"
RDEPENDS:idm-jss-javadoc = " \
 javapackages-filesystem \
"

URI_idm-jss-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/idm-jss-tests-5.6.0-1.el10.x86_64_v2.rpm;name=idm-jss-tests;unpack=0"
SRC_URI += "${URI_idm-jss-tests}"
SRC_URI[idm-jss-tests.sha256sum] = "87689a36c1c2c0517802aa917790e8ea9178c0493689304622966fa548969205"
RDEPENDS:idm-jss-tests = " \
 bash \
"

URI_idm-jss-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/idm-jss-tools-5.6.0-1.el10.x86_64_v2.rpm;name=idm-jss-tools;unpack=0"
SRC_URI += "${URI_idm-jss-tools}"
SRC_URI[idm-jss-tools.sha256sum] = "5a58c5458c4b257397159e211655a566072e8866756de9bc6bc5d4004624f481"
RDEPENDS:idm-jss-tools = " \
 glibc \
 nss \
 nspr \
"
