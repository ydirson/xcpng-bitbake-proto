# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-clocks"
PE = "0"
PV = "46.0"
PR = "1.el10"
PACKAGES = "gnome-clocks"
PROVIDES = "rpm/gnome-clocks"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-clocks-46.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e24d3363997b53b489da4019d2c3dbfc205e7b5f527cf42ed53304aad24b15e"

URI_gnome-clocks = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-clocks-46.0-1.el10.x86_64_v2.rpm;name=gnome-clocks;unpack=0"
SRC_URI += "${URI_gnome-clocks}"
SRC_URI[gnome-clocks.sha256sum] = "f66f25cf5023af571ee635122aef3c76064f8a3c3c81e1fba0519cc47f153c1a"
RDEPENDS:gnome-clocks = " \
 gnome-desktop4 \
 geocode-glib \
 glib2 \
 geoclue2-libs \
 glibc \
 gtk4 \
 libadwaita \
 libgweather \
"
