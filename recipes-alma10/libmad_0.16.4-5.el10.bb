# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libmad"
PE = "0"
PV = "0.16.4"
PR = "5.el10"
PACKAGES = "libmad libmad-devel"
PROVIDES = "rpm/libmad rpm/libmad-devel"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/libmad-0.16.4-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c302e67733421eca801ac46de7bf39303e7b132c1d490abd1aab854130cce7d7"

URI_libmad = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libmad-0.16.4-5.el10.x86_64_v2.rpm;name=libmad;unpack=0"
SRC_URI += "${URI_libmad}"
SRC_URI[libmad.sha256sum] = "158e7459b242f8401cfdcee0ed62eea0c399dc5e2052b08a23f00fa1760911db"
RDEPENDS:libmad = " \
 glibc \
"

URI_libmad-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libmad-devel-0.16.4-5.el10.x86_64_v2.rpm;name=libmad-devel;unpack=0"
SRC_URI += "${URI_libmad-devel}"
SRC_URI[libmad-devel.sha256sum] = "3e6b73a2f6f45ed11a7067041f715055af6b81777572ecc37878af5cca547770"
RDEPENDS:libmad-devel = " \
 libmad \
 cmake-filesystem \
 pkgconf-pkg-config \
"
