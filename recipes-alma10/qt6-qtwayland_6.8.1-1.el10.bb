# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "qt6-qtwayland"
PE = "0"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = "qt6-qtwayland qt6-qtwayland-devel qt6-qtwayland-examples qt6-qtwayland-tests"
PROVIDES = "rpm/qt6-qtwayland rpm/qt6-qtwayland-devel rpm/qt6-qtwayland-examples rpm/qt6-qtwayland-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/qt6-qtwayland-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bdb5d5078039312468117d2c22af27be3364dd0909828325b5557022c9114596"

URI_qt6-qtwayland = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtwayland-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtwayland;unpack=0"
SRC_URI += "${URI_qt6-qtwayland}"
SRC_URI[qt6-qtwayland.sha256sum] = "046c2c31fa028016f5aa6b306ecadff8ba63de5c19007a61600b967c6b5e8819"
RDEPENDS:qt6-qtwayland = " \
 qt6-qtdeclarative \
 qt6-qtsvg \
 libwayland-client \
 libglvnd-egl \
 libwayland-cursor \
 libwayland-server \
 libglvnd-opengl \
 libwayland-egl \
 qt6-qtbase \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
 libxkbcommon \
"

URI_qt6-qtwayland-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/qt6-qtwayland-devel-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtwayland-devel;unpack=0"
SRC_URI += "${URI_qt6-qtwayland-devel}"
SRC_URI[qt6-qtwayland-devel.sha256sum] = "b35b295c5a978df0b75561f1ce88c89d19962f35b57648652cba884aaa9a9a6e"
RDEPENDS:qt6-qtwayland-devel = " \
 qt6-qtdeclarative-devel \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtwayland \
 qt6-qtbase-devel \
 libstdc++ \
 glibc \
"

URI_qt6-qtwayland-examples = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/qt6-qtwayland-examples-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtwayland-examples;unpack=0"
SRC_URI += "${URI_qt6-qtwayland-examples}"
SRC_URI[qt6-qtwayland-examples.sha256sum] = "e7c76028d0d51c9913bf8a5c3f3a39e6f9dff72ef56be70b3152ccce651330ba"
RDEPENDS:qt6-qtwayland-examples = " \
 qt6-qtdeclarative \
 libwayland-client \
 libwayland-server \
 libgcc \
 qt6-qtbase \
 qt6-qtwayland \
 libstdc++ \
 qt6-qtbase-gui \
 glibc \
"

URI_qt6-qtwayland-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/qt6-qtwayland-tests-6.8.1-1.el10.x86_64_v2.rpm;name=qt6-qtwayland-tests;unpack=0"
SRC_URI += "${URI_qt6-qtwayland-tests}"
SRC_URI[qt6-qtwayland-tests.sha256sum] = "09dec3ee1a75dd711e2c060e21a0789753d238fe925e559ec38d558386eba432"
RDEPENDS:qt6-qtwayland-tests = " \
 libwayland-client \
 libwayland-cursor \
 libwayland-server \
 libgcc \
 libglvnd-opengl \
 qt6-qtbase \
 qt6-qtwayland \
 libstdc++ \
 bash \
 qt6-qtbase-gui \
 glibc \
"
