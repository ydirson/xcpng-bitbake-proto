# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-yi"
PE = "0"
PV = "1.1"
PR = "32.el10"
PACKAGES = "hunspell-yi"
PROVIDES = "rpm/hunspell-yi"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-yi-1.1-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe7ac36489b723d526bbea066b7f6a3ade51dbb4fae045f841be4e02aa1c3f1c"

URI_hunspell-yi = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-yi-1.1-32.el10.noarch.rpm;name=hunspell-yi;unpack=0"
SRC_URI += "${URI_hunspell-yi}"
SRC_URI[hunspell-yi.sha256sum] = "7ed8d3d532c13f640512109a5e8da2fd6966aaf6d0494ab29d77b4854ad5ca94"
RDEPENDS:hunspell-yi = " \
 hunspell-filesystem \
"
