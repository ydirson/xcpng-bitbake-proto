# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tesseract"
PE = "0"
PV = "5.3.4"
PR = "6.el10"
PACKAGES = "tesseract tesseract-devel tesseract-tools"
PROVIDES = "rpm/tesseract rpm/tesseract-devel rpm/tesseract-tools"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tesseract-5.3.4-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00cd4ac2bbe919120f0427b1480a0d58ff21e1082780dbb3b835acb92d9a34d8"

URI_tesseract = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tesseract-5.3.4-6.el10.x86_64_v2.rpm;name=tesseract;unpack=0"
SRC_URI += "${URI_tesseract}"
SRC_URI[tesseract.sha256sum] = "0bbb07ff103cfc4ac8b375222e95a71dd933d1733a3e5346efe5d460ba19c1fb"
RDEPENDS:tesseract = " \
 tesseract-langpack-eng \
 leptonica \
 libgcc \
 libstdc++ \
 libcurl \
 glibc \
"

URI_tesseract-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/tesseract-devel-5.3.4-6.el10.x86_64_v2.rpm;name=tesseract-devel;unpack=0"
SRC_URI += "${URI_tesseract-devel}"
SRC_URI[tesseract-devel.sha256sum] = "9b56b36a571396049d25ed85afdfb1d69fe3acbd14c13d5c2d4036187cecba06"
RDEPENDS:tesseract-devel = " \
 leptonica-devel \
 tesseract \
 cmake-filesystem \
 pkgconf-pkg-config \
"

URI_tesseract-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/tesseract-tools-5.3.4-6.el10.x86_64_v2.rpm;name=tesseract-tools;unpack=0"
SRC_URI += "${URI_tesseract-tools}"
SRC_URI[tesseract-tools.sha256sum] = "7075b226c888d6541cee2a8a6c2c2777bf102cd9618d4cca12d1de7aa402be87"
RDEPENDS:tesseract-tools = " \
 tesseract \
 leptonica \
 libgcc \
 harfbuzz \
 pango \
 fontconfig \
 libstdc++ \
 glib2 \
 cairo \
 glibc \
 libicu \
"
