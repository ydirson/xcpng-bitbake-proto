# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libzfcphbaapi"
PE = "0"
PV = "2.2.0"
PR = "25.el10"
PACKAGES = ""
PROVIDES = ""


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/libzfcphbaapi-2.2.0-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70bb8c4793bf1a34c1bf7c8bb695013713e90962b84513ec9104f91a3cccc9a0"
