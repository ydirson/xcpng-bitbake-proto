# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "accountsservice"
PE = "0"
PV = "23.13.9"
PR = "6.el10"
PACKAGES = "accountsservice accountsservice-libs accountsservice-devel"
PROVIDES = "rpm/accountsservice rpm/accountsservice-libs rpm/accountsservice-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/accountsservice-23.13.9-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3737c95a02468356f77ab46e22210278c7ac75bd6c46956e600f81d8bf6db798"

URI_accountsservice = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/accountsservice-23.13.9-6.el10.x86_64_v2.rpm;name=accountsservice;unpack=0"
SRC_URI += "${URI_accountsservice}"
SRC_URI[accountsservice.sha256sum] = "ec55f691e588d0aa06714e58d92000354507d79516f00860825cda7f9b9ea5a3"
RDEPENDS:accountsservice = " \
 systemd \
 shadow-utils \
 libgcc \
 polkit \
 polkit-libs \
 bash \
 glib2 \
 glibc \
"

URI_accountsservice-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/accountsservice-libs-23.13.9-6.el10.x86_64_v2.rpm;name=accountsservice-libs;unpack=0"
SRC_URI += "${URI_accountsservice-libs}"
SRC_URI[accountsservice-libs.sha256sum] = "2b97c654d8d9e89d0951b0a81f4b61491e688a4a23ef57ef73def73c31c5b59a"
RDEPENDS:accountsservice-libs = " \
 systemd-libs \
 accountsservice \
 libxcrypt \
 libgcc \
 glib2 \
 glibc \
"

URI_accountsservice-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/accountsservice-devel-23.13.9-6.el10.x86_64_v2.rpm;name=accountsservice-devel;unpack=0"
SRC_URI += "${URI_accountsservice-devel}"
SRC_URI[accountsservice-devel.sha256sum] = "8ffadba9643a80c8111446a2bc83a9d8093aff9a3e14f5700cb8fbb0dda46015"
RDEPENDS:accountsservice-devel = " \
 glib2-devel \
 polkit-devel \
 pkgconf-pkg-config \
 accountsservice-libs \
"
