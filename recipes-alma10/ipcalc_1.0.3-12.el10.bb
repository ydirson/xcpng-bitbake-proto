# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ipcalc"
PE = "0"
PV = "1.0.3"
PR = "12.el10"
PACKAGES = "ipcalc"
PROVIDES = "rpm/ipcalc"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/ipcalc-1.0.3-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e58fe31753bf0ebf65641067f276cd95d31e338dc9ba3b6cf4f58872b42a523"

URI_ipcalc = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/ipcalc-1.0.3-12.el10.x86_64_v2.rpm;name=ipcalc;unpack=0"
SRC_URI += "${URI_ipcalc}"
SRC_URI[ipcalc.sha256sum] = "0e44ee94cb902670970d287e23ebbe621a17987d58085f1a8f4ef405877397d1"
RDEPENDS:ipcalc = " \
 glibc \
"
