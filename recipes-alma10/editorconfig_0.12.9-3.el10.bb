# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "editorconfig"
PE = "0"
PV = "0.12.9"
PR = "3.el10"
PACKAGES = "editorconfig-libs editorconfig editorconfig-devel"
PROVIDES = "rpm/editorconfig-libs rpm/editorconfig rpm/editorconfig-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/editorconfig-0.12.9-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e99b3ec48ec7c1d7ccd8833fe70f85f7f71ceccba2efe76a9d109c85f53ffb7a"

URI_editorconfig-libs = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/editorconfig-libs-0.12.9-3.el10.x86_64_v2.rpm;name=editorconfig-libs;unpack=0"
SRC_URI += "${URI_editorconfig-libs}"
SRC_URI[editorconfig-libs.sha256sum] = "f92392e11e95753e225a40dfc79a1b060ee1b81fac9dddc7ad6ebb12e52daf8b"
RDEPENDS:editorconfig-libs = " \
 glibc \
 pcre2 \
"

URI_editorconfig = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/editorconfig-0.12.9-3.el10.x86_64_v2.rpm;name=editorconfig;unpack=0"
SRC_URI += "${URI_editorconfig}"
SRC_URI[editorconfig.sha256sum] = "1afe21b6cea091789391d8015c8d941519ac94b88443f9fd8051c503c36b9117"
RDEPENDS:editorconfig = " \
 glibc \
 editorconfig-libs \
"

URI_editorconfig-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/editorconfig-devel-0.12.9-3.el10.x86_64_v2.rpm;name=editorconfig-devel;unpack=0"
SRC_URI += "${URI_editorconfig-devel}"
SRC_URI[editorconfig-devel.sha256sum] = "866d1c17c166680803039dceb592e5504bb38d858aa93486e1cfc78e340a85eb"
RDEPENDS:editorconfig-devel = " \
 editorconfig-libs \
 cmake-filesystem \
 pkgconf-pkg-config \
 cmake \
"
