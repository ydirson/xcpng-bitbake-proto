# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "sid"
PE = "10"
PV = "0.0.6"
PR = "2.el10"
PACKAGES = "sid sid-base-libs sid-base-libs-devel sid-iface-libs sid-iface-libs-devel sid-internal-libs sid-internal-libs-devel sid-log-libs sid-log-libs-devel sid-mod-block-blkid sid-mod-block-dm-mpath sid-mod-dummies sid-mod-type-dm sid-mod-type-dm-lvm sid-resource-libs sid-resource-libs-devel sid-tools"
PROVIDES = "rpm/sid rpm/sid-base-libs rpm/sid-base-libs-devel rpm/sid-iface-libs rpm/sid-iface-libs-devel rpm/sid-internal-libs rpm/sid-internal-libs-devel rpm/sid-log-libs rpm/sid-log-libs-devel rpm/sid-mod-block-blkid rpm/sid-mod-block-dm-mpath rpm/sid-mod-dummies rpm/sid-mod-type-dm rpm/sid-mod-type-dm-lvm rpm/sid-resource-libs rpm/sid-resource-libs-devel rpm/sid-tools"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/sid-0.0.6-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "471e2549f3e16e40b33836fc0182f4475dcca598884ac63aab193ede3db60993"

URI_sid = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sid-0.0.6-2.el10.x86_64_v2.rpm;name=sid;unpack=0"
SRC_URI += "${URI_sid}"
SRC_URI[sid.sha256sum] = "3137846b67e3110d3d4111bcfecb8cd5b6cc5b2814795fe1f96e8b8367e0416f"
RDEPENDS:sid = " \
 sid-log-libs \
 systemd \
 sid-resource-libs \
 sid-tools \
 systemd-udev \
 bash \
 glibc \
 sid-base-libs \
 sid-internal-libs \
"

URI_sid-base-libs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sid-base-libs-0.0.6-2.el10.x86_64_v2.rpm;name=sid-base-libs;unpack=0"
SRC_URI += "${URI_sid-base-libs}"
SRC_URI[sid-base-libs.sha256sum] = "bd86426288bfc05ace5ac7c8eebb9c944c00ec6582684d7faed6be80d655a7e1"
RDEPENDS:sid-base-libs = " \
 glibc \
"

URI_sid-base-libs-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sid-base-libs-devel-0.0.6-2.el10.x86_64_v2.rpm;name=sid-base-libs-devel;unpack=0"
SRC_URI += "${URI_sid-base-libs-devel}"
SRC_URI[sid-base-libs-devel.sha256sum] = "abe957221af20807372536eea9e376ac65efc94bcb5b8b3899a9c2414156ea51"
RDEPENDS:sid-base-libs-devel = " \
 sid-base-libs \
"

URI_sid-iface-libs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sid-iface-libs-0.0.6-2.el10.x86_64_v2.rpm;name=sid-iface-libs;unpack=0"
SRC_URI += "${URI_sid-iface-libs}"
SRC_URI[sid-iface-libs.sha256sum] = "9372bb49f5fcd1ea1bbecf57d1aa62bceca67e6dbfc56a6c699340f6b00d431f"
RDEPENDS:sid-iface-libs = " \
 sid-log-libs \
 libuuid \
 systemd-libs \
 glibc \
 sid-base-libs \
 sid-internal-libs \
"

URI_sid-iface-libs-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sid-iface-libs-devel-0.0.6-2.el10.x86_64_v2.rpm;name=sid-iface-libs-devel;unpack=0"
SRC_URI += "${URI_sid-iface-libs-devel}"
SRC_URI[sid-iface-libs-devel.sha256sum] = "946fd49c03cc75c86665bec5cc5057c5efc11b4a2c1c2d1eacbbe11d8b49215e"
RDEPENDS:sid-iface-libs-devel = " \
 sid-iface-libs \
"

URI_sid-internal-libs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sid-internal-libs-0.0.6-2.el10.x86_64_v2.rpm;name=sid-internal-libs;unpack=0"
SRC_URI += "${URI_sid-internal-libs}"
SRC_URI[sid-internal-libs.sha256sum] = "ef4b0cf38d37563776c8bd5b39d59c9b7c8132cc753b14e7cb6c06672ea49cf0"
RDEPENDS:sid-internal-libs = " \
 glibc \
 libuuid \
 sid-base-libs \
"

URI_sid-internal-libs-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sid-internal-libs-devel-0.0.6-2.el10.x86_64_v2.rpm;name=sid-internal-libs-devel;unpack=0"
SRC_URI += "${URI_sid-internal-libs-devel}"
SRC_URI[sid-internal-libs-devel.sha256sum] = "918d92acd3c038569e99e44937a677a60d84fdd6393e5ef2312ce94f1acaed74"
RDEPENDS:sid-internal-libs-devel = " \
 sid-internal-libs \
"

URI_sid-log-libs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sid-log-libs-0.0.6-2.el10.x86_64_v2.rpm;name=sid-log-libs;unpack=0"
SRC_URI += "${URI_sid-log-libs}"
SRC_URI[sid-log-libs.sha256sum] = "f42ff92eb50d85b5a2a112c06b4cd3e245c6f46594281af62d9b7fe39bad89ea"
RDEPENDS:sid-log-libs = " \
 glibc \
 systemd-libs \
"

URI_sid-log-libs-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sid-log-libs-devel-0.0.6-2.el10.x86_64_v2.rpm;name=sid-log-libs-devel;unpack=0"
SRC_URI += "${URI_sid-log-libs-devel}"
SRC_URI[sid-log-libs-devel.sha256sum] = "21eaecc501f478221ffd0a72da77f4c449e4ce42c4858997ae0c2255749a134b"
RDEPENDS:sid-log-libs-devel = " \
 sid-log-libs \
"

URI_sid-mod-block-blkid = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sid-mod-block-blkid-0.0.6-2.el10.x86_64_v2.rpm;name=sid-mod-block-blkid;unpack=0"
SRC_URI += "${URI_sid-mod-block-blkid}"
SRC_URI[sid-mod-block-blkid.sha256sum] = "eb962b1c6428657107c2f1e0787870ebd06bac4cf84bf3e969f723c084c2570b"
RDEPENDS:sid-mod-block-blkid = " \
 sid-log-libs \
 libuuid \
 systemd-libs \
 sid-resource-libs \
 libblkid \
 glibc \
 sid-base-libs \
 sid-iface-libs \
 sid-internal-libs \
"

URI_sid-mod-block-dm-mpath = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sid-mod-block-dm-mpath-0.0.6-2.el10.x86_64_v2.rpm;name=sid-mod-block-dm-mpath;unpack=0"
SRC_URI += "${URI_sid-mod-block-dm-mpath}"
SRC_URI[sid-mod-block-dm-mpath.sha256sum] = "4fff70f028075c1c6c21d1954b467479542a8a990c9b798b29994a9515b83744"
RDEPENDS:sid-mod-block-dm-mpath = " \
 sid-log-libs \
 libuuid \
 systemd-libs \
 sid-resource-libs \
 device-mapper-multipath-libs \
 glibc \
 sid-base-libs \
 sid-iface-libs \
 sid-internal-libs \
"

URI_sid-mod-dummies = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sid-mod-dummies-0.0.6-2.el10.x86_64_v2.rpm;name=sid-mod-dummies;unpack=0"
SRC_URI += "${URI_sid-mod-dummies}"
SRC_URI[sid-mod-dummies.sha256sum] = "951ec94fe79f44e1690cc9a063ff9d7cb671b15b904d33d060e910c39f6d7c1e"
RDEPENDS:sid-mod-dummies = " \
 sid-log-libs \
 libuuid \
 systemd-libs \
 sid-resource-libs \
 glibc \
 sid-base-libs \
 sid-iface-libs \
 sid-internal-libs \
"

URI_sid-mod-type-dm = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sid-mod-type-dm-0.0.6-2.el10.x86_64_v2.rpm;name=sid-mod-type-dm;unpack=0"
SRC_URI += "${URI_sid-mod-type-dm}"
SRC_URI[sid-mod-type-dm.sha256sum] = "2507bea9db3b034d368208665f83519729feedc36336b49dde02f6f5825b67d1"
RDEPENDS:sid-mod-type-dm = " \
 sid-log-libs \
 libuuid \
 systemd-libs \
 sid-resource-libs \
 glibc \
 sid-base-libs \
 sid-iface-libs \
 sid-internal-libs \
"

URI_sid-mod-type-dm-lvm = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sid-mod-type-dm-lvm-0.0.6-2.el10.x86_64_v2.rpm;name=sid-mod-type-dm-lvm;unpack=0"
SRC_URI += "${URI_sid-mod-type-dm-lvm}"
SRC_URI[sid-mod-type-dm-lvm.sha256sum] = "3a92550b15093b7bd3f6dbec75aa2c829562aabd87499238771760849cc3945e"
RDEPENDS:sid-mod-type-dm-lvm = " \
 sid-log-libs \
 libuuid \
 systemd-libs \
 sid-mod-type-dm \
 sid-resource-libs \
 glibc \
 sid-base-libs \
 sid-iface-libs \
 sid-internal-libs \
"

URI_sid-resource-libs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sid-resource-libs-0.0.6-2.el10.x86_64_v2.rpm;name=sid-resource-libs;unpack=0"
SRC_URI += "${URI_sid-resource-libs}"
SRC_URI[sid-resource-libs.sha256sum] = "2c495d4be44ab089e069c5a8d8b87c349baf5e1727b3e6f886c2330ec7f5c880"
RDEPENDS:sid-resource-libs = " \
 sid-log-libs \
 libuuid \
 systemd-libs \
 glibc \
 sid-base-libs \
 sid-iface-libs \
 sid-internal-libs \
"

URI_sid-resource-libs-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sid-resource-libs-devel-0.0.6-2.el10.x86_64_v2.rpm;name=sid-resource-libs-devel;unpack=0"
SRC_URI += "${URI_sid-resource-libs-devel}"
SRC_URI[sid-resource-libs-devel.sha256sum] = "e5cfe2b5e3e3bb5fc478ab5c9598dd280af9c85e11ea0e2ee6cc9f22b8c68811"
RDEPENDS:sid-resource-libs-devel = " \
 sid-resource-libs \
"

URI_sid-tools = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/sid-tools-0.0.6-2.el10.x86_64_v2.rpm;name=sid-tools;unpack=0"
SRC_URI += "${URI_sid-tools}"
SRC_URI[sid-tools.sha256sum] = "b1051c4a22f332347806dcd1e8e15172c2e348c98a81a63d8393c1ada766a2cf"
RDEPENDS:sid-tools = " \
 sid-log-libs \
 systemd-udev \
 glibc \
 sid-base-libs \
 sid-iface-libs \
 sid-internal-libs \
"
