# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "python-docutils"
PE = "0"
PV = "0.20.1"
PR = "5.el10"
PACKAGES = "python3-docutils"
PROVIDES = "rpm/python3-docutils"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/python-docutils-0.20.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57c28e97717c2cc88d9a2ef1df5b70b3f7f9d3107c581e0053fd1e0c3d243935"

URI_python3-docutils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-docutils-0.20.1-5.el10.noarch.rpm;name=python3-docutils;unpack=0"
SRC_URI += "${URI_python3-docutils}"
SRC_URI[python3-docutils.sha256sum] = "77af976d27cae030efdc54079934e96ad97a5ee0c0dbf5588afa266e3ef4e5af"
RDEPENDS:python3-docutils = " \
 python3 \
"
