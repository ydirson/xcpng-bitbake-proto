# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "ceph"
PE = "2"
PV = "18.2.1"
PR = "4.el10"
PACKAGES = "librados2 librbd1 librados-devel libradospp-devel librbd-devel ceph ceph-common libcephfs-devel libcephfs2 libcephsqlite libcephsqlite-devel libradosstriper-devel libradosstriper1 python3-ceph-argparse python3-ceph-common python3-cephfs python3-rados python3-rbd rados-objclass-devel"
PROVIDES = "rpm/librados2 rpm/librbd1 rpm/librados-devel rpm/libradospp-devel rpm/librbd-devel rpm/ceph rpm/ceph-common rpm/libcephfs-devel rpm/libcephfs2 rpm/libcephsqlite rpm/libcephsqlite-devel rpm/libradosstriper-devel rpm/libradosstriper1 rpm/python3-ceph-argparse rpm/python3-ceph-common rpm/python3-cephfs rpm/python3-rados rpm/python3-rbd rpm/rados-objclass-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/ceph-18.2.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "773a66bb491ddb52699240fa315a18e8e9cfe12538e88d35285b7cafcd89b8bd"

URI_librados2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/librados2-18.2.1-4.el10.x86_64_v2.rpm;name=librados2;unpack=0"
SRC_URI += "${URI_librados2}"
SRC_URI[librados2.sha256sum] = "34aa1ba4b11bff010eb691ae9c72b379f60d3bc03ab5c9d3bc2a60a940323cb0"
RDEPENDS:librados2 = " \
 zlib-ng-compat \
 systemd-libs \
 openssl-libs \
 libgcc \
 libblkid \
 librdmacm \
 libstdc++ \
 libibverbs \
 glibc \
"

URI_librbd1 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/librbd1-18.2.1-4.el10.x86_64_v2.rpm;name=librbd1;unpack=0"
SRC_URI += "${URI_librbd1}"
SRC_URI[librbd1.sha256sum] = "ec049fa004352e9b26360e783b3368dd8cbc80e16ff57daa3aefa582dc740b2d"
RDEPENDS:librbd1 = " \
 librados2 \
 cryptsetup-libs \
 openssl-libs \
 libgcc \
 libstdc++ \
 glibc \
"

URI_librados-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/librados-devel-18.2.1-4.el10.x86_64_v2.rpm;name=librados-devel;unpack=0"
SRC_URI += "${URI_librados-devel}"
SRC_URI[librados-devel.sha256sum] = "8622b2d06ddade2e3abbb40ca731c01f7005928a47f253e42d5cb0c011920de4"
RDEPENDS:librados-devel = " \
 glibc \
 libgcc \
 librados2 \
 libstdc++ \
"

URI_libradospp-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libradospp-devel-18.2.1-4.el10.x86_64_v2.rpm;name=libradospp-devel;unpack=0"
SRC_URI += "${URI_libradospp-devel}"
SRC_URI[libradospp-devel.sha256sum] = "6088e721342c8fbcc9698237e6520f9b9686efc920c50bcb3181fc9b7da5aaef"
RDEPENDS:libradospp-devel = " \
 librados-devel \
 librados2 \
"

URI_librbd-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/librbd-devel-18.2.1-4.el10.x86_64_v2.rpm;name=librbd-devel;unpack=0"
SRC_URI += "${URI_librbd-devel}"
SRC_URI[librbd-devel.sha256sum] = "a6dbf94d0794ebd5ba5afb0fc46878b1b6aeead3f5900cb2520ecb5613a1937a"
RDEPENDS:librbd-devel = " \
 librados-devel \
 libradospp-devel \
 librbd1 \
"

URI_ceph = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ceph-18.2.1-4.el10.x86_64_v2.rpm;name=ceph;unpack=0"
SRC_URI += "${URI_ceph}"
SRC_URI[ceph.sha256sum] = "40e86cc15429ac42e777fa8309c3150a0e0570c3308f6a2eac736d1c43174bce"
RDEPENDS:ceph = " \
 systemd \
 binutils \
"

URI_ceph-common = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/ceph-common-18.2.1-4.el10.x86_64_v2.rpm;name=ceph-common;unpack=0"
SRC_URI += "${URI_ceph-common}"
SRC_URI[ceph-common.sha256sum] = "5c91806d86a8e0f51ee632500197f359032037a7301dee5f4bcb228589507575"
RDEPENDS:ceph-common = " \
 python3 \
 systemd \
 systemd-libs \
 keyutils-libs \
 ncurses-libs \
 python3-ceph-argparse \
 python3-ceph-common \
 libradosstriper1 \
 libcephfs2 \
 python3-cephfs \
 libblkid \
 libcap-ng \
 libstdc++ \
 python3-rados \
 python3-rbd \
 librados2 \
 librbd1 \
 libgcc \
 bash \
 python3-prettytable \
 lua-libs \
 glibc \
"

URI_libcephfs-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libcephfs-devel-18.2.1-4.el10.x86_64_v2.rpm;name=libcephfs-devel;unpack=0"
SRC_URI += "${URI_libcephfs-devel}"
SRC_URI[libcephfs-devel.sha256sum] = "c9d2102437e4e935b8bb75e103c94e133fbfe2925c6c98f8820d15e1af26d7e6"
RDEPENDS:libcephfs-devel = " \
 libcephfs2 \
 librados-devel \
"

URI_libcephfs2 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libcephfs2-18.2.1-4.el10.x86_64_v2.rpm;name=libcephfs2;unpack=0"
SRC_URI += "${URI_libcephfs2}"
SRC_URI[libcephfs2.sha256sum] = "26b51d84c8c1088c6f6667569a1f5ebb1e08ec3a353b31fd0ad24e59eaa0e7f0"
RDEPENDS:libcephfs2 = " \
 glibc \
 libgcc \
 librados2 \
 libstdc++ \
"

URI_libcephsqlite = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libcephsqlite-18.2.1-4.el10.x86_64_v2.rpm;name=libcephsqlite;unpack=0"
SRC_URI += "${URI_libcephsqlite}"
SRC_URI[libcephsqlite.sha256sum] = "a1303b0c0efbccecd91f964488027848be468267608c393e30cb167fe2bc0ac8"
RDEPENDS:libcephsqlite = " \
 glibc \
 libgcc \
 librados2 \
 libstdc++ \
"

URI_libcephsqlite-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libcephsqlite-devel-18.2.1-4.el10.x86_64_v2.rpm;name=libcephsqlite-devel;unpack=0"
SRC_URI += "${URI_libcephsqlite-devel}"
SRC_URI[libcephsqlite-devel.sha256sum] = "6f54af4ba5199502b913d81592517059c934a54c1baaac9b80357110f97a4fa9"
RDEPENDS:libcephsqlite-devel = " \
 libcephsqlite \
 librados-devel \
 libradospp-devel \
 sqlite-devel \
"

URI_libradosstriper-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libradosstriper-devel-18.2.1-4.el10.x86_64_v2.rpm;name=libradosstriper-devel;unpack=0"
SRC_URI += "${URI_libradosstriper-devel}"
SRC_URI[libradosstriper-devel.sha256sum] = "ef96f8776a8dc7185825abbe7d5e0d073d9569d79f2997a63015e007f77240bd"
RDEPENDS:libradosstriper-devel = " \
 libradosstriper1 \
 librados-devel \
 libradospp-devel \
"

URI_libradosstriper1 = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libradosstriper1-18.2.1-4.el10.x86_64_v2.rpm;name=libradosstriper1;unpack=0"
SRC_URI += "${URI_libradosstriper1}"
SRC_URI[libradosstriper1.sha256sum] = "6c84087911b99b4aedc8bb38ebbf135a2c82a4c541c1ee4aa5cc6007b5ad9884"
RDEPENDS:libradosstriper1 = " \
 glibc \
 libgcc \
 librados2 \
 libstdc++ \
"

URI_python3-ceph-argparse = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-ceph-argparse-18.2.1-4.el10.x86_64_v2.rpm;name=python3-ceph-argparse;unpack=0"
SRC_URI += "${URI_python3-ceph-argparse}"
SRC_URI[python3-ceph-argparse.sha256sum] = "8593ee6796887a6ec2b469e368b41c86fb7f437c733a005ed91426d9c75cd270"
RDEPENDS:python3-ceph-argparse = " \
 python3 \
"

URI_python3-ceph-common = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-ceph-common-18.2.1-4.el10.x86_64_v2.rpm;name=python3-ceph-common;unpack=0"
SRC_URI += "${URI_python3-ceph-common}"
SRC_URI[python3-ceph-common.sha256sum] = "4cb2434c8b538caffe9969409ea5f0a81fdf0733e21611e2bc4b3aa5b38ba187"
RDEPENDS:python3-ceph-common = " \
 python3 \
 python3-pyyaml \
"

URI_python3-cephfs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-cephfs-18.2.1-4.el10.x86_64_v2.rpm;name=python3-cephfs;unpack=0"
SRC_URI += "${URI_python3-cephfs}"
SRC_URI[python3-cephfs.sha256sum] = "5a322ec35813c6455f5c657057b35b8a212d1bef897e6d8999897318787f77f6"
RDEPENDS:python3-cephfs = " \
 python3 \
 python3-rados \
 python3-ceph-argparse \
 glibc \
 libcephfs2 \
"

URI_python3-rados = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-rados-18.2.1-4.el10.x86_64_v2.rpm;name=python3-rados;unpack=0"
SRC_URI += "${URI_python3-rados}"
SRC_URI[python3-rados.sha256sum] = "2c6477c45296ec1aa1c68ed2f674a7717ae1b9edf15f145b7fb0228e8effe6d3"
RDEPENDS:python3-rados = " \
 glibc \
 librados2 \
 python3 \
"

URI_python3-rbd = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/python3-rbd-18.2.1-4.el10.x86_64_v2.rpm;name=python3-rbd;unpack=0"
SRC_URI += "${URI_python3-rbd}"
SRC_URI[python3-rbd.sha256sum] = "8c74d758417d1b6d350c1bfff4a1473b25de7327949d3323861af3e289f26a3d"
RDEPENDS:python3-rbd = " \
 python3 \
 python3-rados \
 librados2 \
 librbd1 \
 glibc \
"

URI_rados-objclass-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/rados-objclass-devel-18.2.1-4.el10.x86_64_v2.rpm;name=rados-objclass-devel;unpack=0"
SRC_URI += "${URI_rados-objclass-devel}"
SRC_URI[rados-objclass-devel.sha256sum] = "a2842dca9bd456c3b29635833e85dbbe241c104d994ecf784ecceb2e5521ede2"
RDEPENDS:rados-objclass-devel = " \
 libradospp-devel \
"
