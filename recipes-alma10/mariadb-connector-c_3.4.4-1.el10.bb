# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mariadb-connector-c"
PE = "0"
PV = "3.4.4"
PR = "1.el10"
PACKAGES = "mariadb-connector-c mariadb-connector-c-config mariadb-connector-c-devel mariadb-connector-c-doc mariadb-connector-c-test"
PROVIDES = "rpm/mariadb-connector-c rpm/mariadb-connector-c-config rpm/mariadb-connector-c-devel rpm/mariadb-connector-c-doc rpm/mariadb-connector-c-test"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/mariadb-connector-c-3.4.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b74eba88d87ff33e390c880f5951cd36f22163dd549be5d43615f629ba9ace7"

URI_mariadb-connector-c = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/mariadb-connector-c-3.4.4-1.el10.x86_64_v2.rpm;name=mariadb-connector-c;unpack=0"
SRC_URI += "${URI_mariadb-connector-c}"
SRC_URI[mariadb-connector-c.sha256sum] = "50472133f59b9a2915847cc6d4af286b0c37d708c7b0c8c2a02f222b73ad194f"
RDEPENDS:mariadb-connector-c = " \
 zlib-ng-compat \
 openssl-libs \
 libzstd \
 krb5-libs \
 mariadb-connector-c-config \
 libcurl \
 glibc \
"

URI_mariadb-connector-c-config = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/mariadb-connector-c-config-3.4.4-1.el10.noarch.rpm;name=mariadb-connector-c-config;unpack=0"
SRC_URI += "${URI_mariadb-connector-c-config}"
SRC_URI[mariadb-connector-c-config.sha256sum] = "6449d19b2ed47f90c7a6c56ddb11a7c35e9a5c0c6da7cb0d890ce22435bacd28"
RDEPENDS:mariadb-connector-c-config = ""

URI_mariadb-connector-c-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/mariadb-connector-c-devel-3.4.4-1.el10.x86_64_v2.rpm;name=mariadb-connector-c-devel;unpack=0"
SRC_URI += "${URI_mariadb-connector-c-devel}"
SRC_URI[mariadb-connector-c-devel.sha256sum] = "9c2e3999f9863ae91ef70e03c5a37de96d70175b5aa26ddfeabfabd9ce8bb81f"
RDEPENDS:mariadb-connector-c-devel = " \
 zlib-ng-compat-devel \
 pkgconf-pkg-config \
 openssl-devel \
 mariadb-connector-c \
 glibc \
"

URI_mariadb-connector-c-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mariadb-connector-c-doc-3.4.4-1.el10.noarch.rpm;name=mariadb-connector-c-doc;unpack=0"
SRC_URI += "${URI_mariadb-connector-c-doc}"
SRC_URI[mariadb-connector-c-doc.sha256sum] = "1689cf99d693357a37b52cbefed7864b41c35337cb4e0ac412235371274a6915"
RDEPENDS:mariadb-connector-c-doc = " \
 mariadb-connector-c \
"

URI_mariadb-connector-c-test = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/mariadb-connector-c-test-3.4.4-1.el10.x86_64_v2.rpm;name=mariadb-connector-c-test;unpack=0"
SRC_URI += "${URI_mariadb-connector-c-test}"
SRC_URI[mariadb-connector-c-test.sha256sum] = "1145d794bc6c74f2835db1b609c047d3e2ab4f7cea91a36f9a202c53457f63ad"
RDEPENDS:mariadb-connector-c-test = " \
 zlib-ng-compat \
 openssl-libs \
 mariadb-connector-c \
 glibc \
 cmake \
"
