# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tuned"
PE = "0"
PV = "2.25.1"
PR = "2.el10_0"
PACKAGES = "tuned tuned-profiles-cpu-partitioning tuned-gtk tuned-ppd tuned-profiles-atomic tuned-profiles-mssql tuned-profiles-oracle tuned-profiles-postgresql tuned-profiles-spectrumscale tuned-utils tuned-profiles-compat tuned-profiles-nfv tuned-profiles-nfv-guest tuned-profiles-nfv-host tuned-profiles-openshift tuned-profiles-realtime tuned-utils-systemtap"
PROVIDES = "rpm/tuned rpm/tuned-profiles-cpu-partitioning rpm/tuned-gtk rpm/tuned-ppd rpm/tuned-profiles-atomic rpm/tuned-profiles-mssql rpm/tuned-profiles-oracle rpm/tuned-profiles-postgresql rpm/tuned-profiles-spectrumscale rpm/tuned-utils rpm/tuned-profiles-compat rpm/tuned-profiles-nfv rpm/tuned-profiles-nfv-guest rpm/tuned-profiles-nfv-host rpm/tuned-profiles-openshift rpm/tuned-profiles-realtime rpm/tuned-utils-systemtap"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/tuned-2.25.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33731593ccff66aa66c74ab56c63a52c831178219910f0a793eab256c2e782f6"

URI_tuned = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/tuned-2.25.1-2.el10_0.noarch.rpm;name=tuned;unpack=0"
SRC_URI += "${URI_tuned}"
SRC_URI[tuned.sha256sum] = "dcd1cf9110833a581aaf29aace67b22d0b5eaf32ea9eb78406c81ff64cea1cc3"
RDEPENDS:tuned = " \
 python3 \
 python3-pyudev \
 systemd \
 util-linux \
 iproute \
 kmod \
 gawk \
 python3-dbus \
 hdparm \
 polkit \
 virt-what \
 bash \
 dbus \
 python3-gobject-base \
 ethtool \
 python3-linux-procfs \
 python3-inotify \
"

URI_tuned-profiles-cpu-partitioning = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/tuned-profiles-cpu-partitioning-2.25.1-2.el10_0.noarch.rpm;name=tuned-profiles-cpu-partitioning;unpack=0"
SRC_URI += "${URI_tuned-profiles-cpu-partitioning}"
SRC_URI[tuned-profiles-cpu-partitioning.sha256sum] = "5ea8498793b122ab644e41637bf30cefb9781af4a06ddd2ffcb59f7f331a5c42"
RDEPENDS:tuned-profiles-cpu-partitioning = " \
 bash \
 tuned \
"

URI_tuned-gtk = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tuned-gtk-2.25.1-2.el10_0.noarch.rpm;name=tuned-gtk;unpack=0"
SRC_URI += "${URI_tuned-gtk}"
SRC_URI[tuned-gtk.sha256sum] = "b5e8d87f0f08871d4099fdf3feb4f09d17ae2227234a682bfe3287ad540e5a0b"
RDEPENDS:tuned-gtk = " \
 python3 \
 polkit \
 python3-gobject-base \
 powertop \
 tuned \
"

URI_tuned-ppd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tuned-ppd-2.25.1-2.el10_0.noarch.rpm;name=tuned-ppd;unpack=0"
SRC_URI += "${URI_tuned-ppd}"
SRC_URI[tuned-ppd.sha256sum] = "0b0b8e7784f7bd9028ff784409b66b0ae1ac347fecfef724fbb620f38705d9d1"
RDEPENDS:tuned-ppd = " \
 python3 \
 bash \
 tuned \
"

URI_tuned-profiles-atomic = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tuned-profiles-atomic-2.25.1-2.el10_0.noarch.rpm;name=tuned-profiles-atomic;unpack=0"
SRC_URI += "${URI_tuned-profiles-atomic}"
SRC_URI[tuned-profiles-atomic.sha256sum] = "1fe177ddbf42804fa6c37cf6200c32b7c1019fd1e321129ccbb36d487f651ceb"
RDEPENDS:tuned-profiles-atomic = " \
 tuned \
"

URI_tuned-profiles-mssql = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tuned-profiles-mssql-2.25.1-2.el10_0.noarch.rpm;name=tuned-profiles-mssql;unpack=0"
SRC_URI += "${URI_tuned-profiles-mssql}"
SRC_URI[tuned-profiles-mssql.sha256sum] = "7d62d718e64cc556d265e44095bb847125d7df06188d1503a45f750115333a1d"
RDEPENDS:tuned-profiles-mssql = " \
 tuned \
"

URI_tuned-profiles-oracle = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tuned-profiles-oracle-2.25.1-2.el10_0.noarch.rpm;name=tuned-profiles-oracle;unpack=0"
SRC_URI += "${URI_tuned-profiles-oracle}"
SRC_URI[tuned-profiles-oracle.sha256sum] = "2b155aa885721a0e76f9cefab2be06c343fbd2750520f81c5ce99d14a5c6cfca"
RDEPENDS:tuned-profiles-oracle = " \
 tuned \
"

URI_tuned-profiles-postgresql = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tuned-profiles-postgresql-2.25.1-2.el10_0.noarch.rpm;name=tuned-profiles-postgresql;unpack=0"
SRC_URI += "${URI_tuned-profiles-postgresql}"
SRC_URI[tuned-profiles-postgresql.sha256sum] = "c4166da41e38366faab1a38aba703a0e90dee5cf14a47ea8a5eee4b9b1737411"
RDEPENDS:tuned-profiles-postgresql = " \
 tuned \
"

URI_tuned-profiles-spectrumscale = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tuned-profiles-spectrumscale-2.25.1-2.el10_0.noarch.rpm;name=tuned-profiles-spectrumscale;unpack=0"
SRC_URI += "${URI_tuned-profiles-spectrumscale}"
SRC_URI[tuned-profiles-spectrumscale.sha256sum] = "8dd00163019cdae69617da7640883b95e5403644b4c08a6c928ab2f2b4914a3d"
RDEPENDS:tuned-profiles-spectrumscale = " \
 tuned \
"

URI_tuned-utils = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tuned-utils-2.25.1-2.el10_0.noarch.rpm;name=tuned-utils;unpack=0"
SRC_URI += "${URI_tuned-utils}"
SRC_URI[tuned-utils.sha256sum] = "2b357e65e5b7ab9c51258fe6bb6c46e04165fdaefb74f471a9af20656e8db6f0"
RDEPENDS:tuned-utils = " \
 python3 \
 powertop \
 tuned \
"

URI_tuned-profiles-compat = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/tuned-profiles-compat-2.25.1-2.el10_0.noarch.rpm;name=tuned-profiles-compat;unpack=0"
SRC_URI += "${URI_tuned-profiles-compat}"
SRC_URI[tuned-profiles-compat.sha256sum] = "1b86081b407cba32ccb63bec5d9e19df1face9ac7cf77f4cf20087de6dc0072c"
RDEPENDS:tuned-profiles-compat = " \
 bash \
 tuned \
"

URI_tuned-profiles-nfv = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/tuned-profiles-nfv-2.25.1-2.el10_0.noarch.rpm;name=tuned-profiles-nfv;unpack=0"
SRC_URI += "${URI_tuned-profiles-nfv}"
SRC_URI[tuned-profiles-nfv.sha256sum] = "0a4d6abc166e0f109d3dc20d3da4167ec85386736947da98ab9237fcb130fe98"
RDEPENDS:tuned-profiles-nfv = " \
 tuned-profiles-nfv-guest \
 tuned-profiles-nfv-host \
 tuned \
"

URI_tuned-profiles-nfv-guest = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/tuned-profiles-nfv-guest-2.25.1-2.el10_0.noarch.rpm;name=tuned-profiles-nfv-guest;unpack=0"
SRC_URI += "${URI_tuned-profiles-nfv-guest}"
SRC_URI[tuned-profiles-nfv-guest.sha256sum] = "b728aba290770e8675a29f0e18bdd250e1cf83c2fc25260d41471ef351811ea6"
RDEPENDS:tuned-profiles-nfv-guest = " \
 tuned-profiles-realtime \
 tuned \
"

URI_tuned-profiles-nfv-host = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/tuned-profiles-nfv-host-2.25.1-2.el10_0.noarch.rpm;name=tuned-profiles-nfv-host;unpack=0"
SRC_URI += "${URI_tuned-profiles-nfv-host}"
SRC_URI[tuned-profiles-nfv-host.sha256sum] = "a85be79deb1fa160f0c414d11a3373714450019c6d17a91996d307d1a2a71ec3"
RDEPENDS:tuned-profiles-nfv-host = " \
 bash \
 tuned-profiles-realtime \
 tuned \
"

URI_tuned-profiles-openshift = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/tuned-profiles-openshift-2.25.1-2.el10_0.noarch.rpm;name=tuned-profiles-openshift;unpack=0"
SRC_URI += "${URI_tuned-profiles-openshift}"
SRC_URI[tuned-profiles-openshift.sha256sum] = "8591fa5207a8feabfb0373da1b788750a3c2190317f28e6bed118c44bfb59b84"
RDEPENDS:tuned-profiles-openshift = " \
 tuned \
"

URI_tuned-profiles-realtime = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/tuned-profiles-realtime-2.25.1-2.el10_0.noarch.rpm;name=tuned-profiles-realtime;unpack=0"
SRC_URI += "${URI_tuned-profiles-realtime}"
SRC_URI[tuned-profiles-realtime.sha256sum] = "dbaa0576c1815825e9ce077b5bb2da3d496ccab3845ab8900c927822f618b747"
RDEPENDS:tuned-profiles-realtime = " \
 tuned \
"

URI_tuned-utils-systemtap = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/tuned-utils-systemtap-2.25.1-2.el10_0.noarch.rpm;name=tuned-utils-systemtap;unpack=0"
SRC_URI += "${URI_tuned-utils-systemtap}"
SRC_URI[tuned-utils-systemtap.sha256sum] = "1d6f909633652537c8940e62f8063427026eb32d1311bc3f7bb201259e445dde"
RDEPENDS:tuned-utils-systemtap = " \
 python3 \
 systemtap \
 systemtap-client \
 tuned \
"
