# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lsscsi"
PE = "0"
PV = "0.32"
PR = "15.el10"
PACKAGES = "lsscsi"
PROVIDES = "rpm/lsscsi"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/lsscsi-0.32-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0fc16eb5a1ad48c82e5c73cf072455a9a585fffa31d0a538afc89801706fde57"

URI_lsscsi = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/lsscsi-0.32-15.el10.x86_64_v2.rpm;name=lsscsi;unpack=0"
SRC_URI += "${URI_lsscsi}"
SRC_URI[lsscsi.sha256sum] = "74d2c9f23cd9fe224636a071f1fe33c985ff28e25f51652600a4673b73cc2fee"
RDEPENDS:lsscsi = " \
 glibc \
"
