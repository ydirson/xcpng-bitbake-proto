# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-sl"
PE = "0"
PV = "0.20070127"
PR = "36.el10"
PACKAGES = "hunspell-sl"
PROVIDES = "rpm/hunspell-sl"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-sl-0.20070127-36.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47c82c9eab8acd8e9fbd59675b7eedecb50cfa2fb866b3e15b8b2992cede0ed3"

URI_hunspell-sl = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-sl-0.20070127-36.el10.noarch.rpm;name=hunspell-sl;unpack=0"
SRC_URI += "${URI_hunspell-sl}"
SRC_URI[hunspell-sl.sha256sum] = "eb934f12b5a4ca624be6b79c2822cf8d86fbd54101b6618683dd9fa627313f00"
RDEPENDS:hunspell-sl = " \
 hunspell \
"
