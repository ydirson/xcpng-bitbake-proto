# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "hunspell-it"
PE = "0"
PV = "5.1.1"
PR = "7.el10"
PACKAGES = "hunspell-it"
PROVIDES = "rpm/hunspell-it"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/hunspell-it-5.1.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d6a980477ff2ab77d0488db4f58808ef0e737cddbfbd019906fabb3710c6ebb"

URI_hunspell-it = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hunspell-it-5.1.1-7.el10.noarch.rpm;name=hunspell-it;unpack=0"
SRC_URI += "${URI_hunspell-it}"
SRC_URI[hunspell-it.sha256sum] = "7480e16af266d30bf962b80c77a6a023fe5bac81b5a8621d6b9066e32d4b4836"
RDEPENDS:hunspell-it = " \
 hunspell-filesystem \
"
