# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "rhel-system-roles"
PE = "0"
PV = "1.95.7"
PR = "0.1.el10_0"
PACKAGES = "rhel-system-roles"
PROVIDES = "rpm/rhel-system-roles"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/rhel-system-roles-1.95.7-0.1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d414e7a155d867e2a3202a02bf2f46f06320f566da41251e4bc9feeb71c76ec"

URI_rhel-system-roles = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/rhel-system-roles-1.95.7-0.1.el10_0.noarch.rpm;name=rhel-system-roles;unpack=0"
SRC_URI += "${URI_rhel-system-roles}"
SRC_URI[rhel-system-roles.sha256sum] = "6454808e10c45f9343630615fa4d0971e5708684d68a1f22cef3d75a59c8dea4"
RDEPENDS:rhel-system-roles = " \
 ansible-core \
 coreutils \
 bash \
 python-unversioned-command \
"
