# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "HdrHistogram_c"
PE = "0"
PV = "0.11.8"
PR = "7.el10"
PACKAGES = "HdrHistogram_c HdrHistogram_c-devel"
PROVIDES = "rpm/HdrHistogram_c rpm/HdrHistogram_c-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/HdrHistogram_c-0.11.8-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4786d67baf85ea4ca0856c9011a4ad9c0ad0d5822465f97f04067d9ba277ffda"

URI_HdrHistogram_c = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/HdrHistogram_c-0.11.8-7.el10.x86_64_v2.rpm;name=HdrHistogram_c;unpack=0"
SRC_URI += "${URI_HdrHistogram_c}"
SRC_URI[HdrHistogram_c.sha256sum] = "b61276d3ce6b27673f86c102a3bb6c7bcbb6ad2de7e0c81d7d69eef44c13cd9b"
RDEPENDS:HdrHistogram_c = " \
 glibc \
 zlib-ng-compat \
"

URI_HdrHistogram_c-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/HdrHistogram_c-devel-0.11.8-7.el10.x86_64_v2.rpm;name=HdrHistogram_c-devel;unpack=0"
SRC_URI += "${URI_HdrHistogram_c-devel}"
SRC_URI[HdrHistogram_c-devel.sha256sum] = "402d53f6faf9b37fdf1c3523f11659ef9b285fab7c9edca7db5ecd4519eaffd3"
RDEPENDS:HdrHistogram_c-devel = " \
 zlib-ng-compat-devel \
 HdrHistogram_c \
 cmake-filesystem \
 pkgconf-pkg-config \
"
