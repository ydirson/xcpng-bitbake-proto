# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "pangomm2.48"
PE = "0"
PV = "2.50.2"
PR = "4.el10"
PACKAGES = "pangomm2.48 pangomm2.48-devel pangomm2.48-doc"
PROVIDES = "rpm/pangomm2.48 rpm/pangomm2.48-devel rpm/pangomm2.48-doc"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/pangomm2.48-2.50.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52bba55bff6f59f5752c6fb2452f0f7814ba71ca61bf353cc5452fbac7809bf0"

URI_pangomm2.48 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/pangomm2.48-2.50.2-4.el10.x86_64_v2.rpm;name=pangomm2.48;unpack=0"
SRC_URI += "${URI_pangomm2.48}"
SRC_URI[pangomm2.48.sha256sum] = "766623c8610f868f81144ad945f87543bbf4eebe8125a9972f65856db3ae8527"
RDEPENDS:pangomm2.48 = " \
 libgcc \
 pango \
 libstdc++ \
 glib2 \
 glibmm2.68 \
 glibc \
 cairomm1.16 \
 libsigc++30 \
"

URI_pangomm2.48-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/pangomm2.48-devel-2.50.2-4.el10.x86_64_v2.rpm;name=pangomm2.48-devel;unpack=0"
SRC_URI += "${URI_pangomm2.48-devel}"
SRC_URI[pangomm2.48-devel.sha256sum] = "74c63bb2c22f0e367f63f49004807652491b85f9aae9c0e677965ce3dfe3e4a5"
RDEPENDS:pangomm2.48-devel = " \
 pkgconf-pkg-config \
 pango-devel \
 pangomm2.48 \
 glibmm2.68-devel \
 cairomm1.16-devel \
"

URI_pangomm2.48-doc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/pangomm2.48-doc-2.50.2-4.el10.noarch.rpm;name=pangomm2.48-doc;unpack=0"
SRC_URI += "${URI_pangomm2.48-doc}"
SRC_URI[pangomm2.48-doc.sha256sum] = "58549f99c1ca52bf0060c8ecf0110d1dd74f6fe123a35f1e7e75e16fca883a16"
RDEPENDS:pangomm2.48-doc = " \
 pangomm2.48 \
 glibmm2.68-doc \
 libsigc++30-doc \
"
