# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "nghttp2"
PE = "0"
PV = "1.64.0"
PR = "2.el10"
PACKAGES = "libnghttp2 libnghttp2-devel nghttp2"
PROVIDES = "rpm/libnghttp2 rpm/libnghttp2-devel rpm/nghttp2"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/nghttp2-1.64.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d56bf9598635b01aa295ae99948a7ba9fa8b7f59e48820656fff393111f0e428"

URI_libnghttp2 = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/libnghttp2-1.64.0-2.el10.x86_64_v2.rpm;name=libnghttp2;unpack=0"
SRC_URI += "${URI_libnghttp2}"
SRC_URI[libnghttp2.sha256sum] = "3becf93ebd075f47483b38e5ce891d13292ae95e8c47e039552515d36f96cf3a"
RDEPENDS:libnghttp2 = " \
 glibc \
"

URI_libnghttp2-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libnghttp2-devel-1.64.0-2.el10.x86_64_v2.rpm;name=libnghttp2-devel;unpack=0"
SRC_URI += "${URI_libnghttp2-devel}"
SRC_URI[libnghttp2-devel.sha256sum] = "809d57eea4b73cbe07449fedd8e04cfde45d800e7301f1336d794b1d15b47aee"
RDEPENDS:libnghttp2-devel = " \
 pkgconf-pkg-config \
 libnghttp2 \
"

URI_nghttp2 = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/nghttp2-1.64.0-2.el10.x86_64_v2.rpm;name=nghttp2;unpack=0"
SRC_URI += "${URI_nghttp2}"
SRC_URI[nghttp2.sha256sum] = "7335653b29356721e7d34890cc7b3684153854e8a17def53cd501fc7a5792345"
RDEPENDS:nghttp2 = " \
 python3 \
 systemd \
 zlib-ng-compat \
 libev \
 c-ares \
 libgcc \
 openssl-libs \
 libxml2 \
 libstdc++ \
 bash \
 libnghttp2 \
 glibc \
"
