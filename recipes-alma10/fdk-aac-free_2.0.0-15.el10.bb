# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "fdk-aac-free"
PE = "0"
PV = "2.0.0"
PR = "15.el10"
PACKAGES = "fdk-aac-free fdk-aac-free-devel"
PROVIDES = "rpm/fdk-aac-free rpm/fdk-aac-free-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/fdk-aac-free-2.0.0-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40ed18ee08711c92962a228a7576c30a50e2e4b25184ab4d9c81159ae0e46554"

URI_fdk-aac-free = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/fdk-aac-free-2.0.0-15.el10.x86_64_v2.rpm;name=fdk-aac-free;unpack=0"
SRC_URI += "${URI_fdk-aac-free}"
SRC_URI[fdk-aac-free.sha256sum] = "c4ee7693a7743eff31ceac6c22801e86e00aef9f57340931171e4aabc1c0bee3"
RDEPENDS:fdk-aac-free = " \
 glibc \
"

URI_fdk-aac-free-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/fdk-aac-free-devel-2.0.0-15.el10.x86_64_v2.rpm;name=fdk-aac-free-devel;unpack=0"
SRC_URI += "${URI_fdk-aac-free-devel}"
SRC_URI[fdk-aac-free-devel.sha256sum] = "1ef0680faa089cac6f58538963ae085335a86e31bd29fd65088cbe2c95cfc77f"
RDEPENDS:fdk-aac-free-devel = " \
 pkgconf-pkg-config \
 fdk-aac-free \
"
