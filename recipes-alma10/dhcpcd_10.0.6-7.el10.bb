# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "dhcpcd"
PE = "0"
PV = "10.0.6"
PR = "7.el10"
PACKAGES = "dhcpcd"
PROVIDES = "rpm/dhcpcd"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/dhcpcd-10.0.6-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c72657744c3b9c884130c211a2d2ca498b72ad1c7f580b8420a65975f5fcf75"

URI_dhcpcd = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/dhcpcd-10.0.6-7.el10.x86_64_v2.rpm;name=dhcpcd;unpack=0"
SRC_URI += "${URI_dhcpcd}"
SRC_URI[dhcpcd.sha256sum] = "38cb16e27b60cf9e71660db9ae4b6c5969b97841a09cad68553021651702ea03"
RDEPENDS:dhcpcd = " \
 glibc \
 systemd \
 bash \
 systemd-libs \
"
