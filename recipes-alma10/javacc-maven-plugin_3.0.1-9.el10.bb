# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "javacc-maven-plugin"
PE = "0"
PV = "3.0.1"
PR = "9.el10"
PACKAGES = "javacc-maven-plugin javacc-maven-plugin-javadoc"
PROVIDES = "rpm/javacc-maven-plugin rpm/javacc-maven-plugin-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/javacc-maven-plugin-3.0.1-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "645303a147c7bc6f116baa4999b7ae7faed6e0e6c8934cfe868e081c2240c63f"

URI_javacc-maven-plugin = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/javacc-maven-plugin-3.0.1-9.el10.noarch.rpm;name=javacc-maven-plugin;unpack=0"
SRC_URI += "${URI_javacc-maven-plugin}"
SRC_URI[javacc-maven-plugin.sha256sum] = "4b8613c93449e0a101536bc0f8818841b61020b25d44ec728f8390ea34618c32"
RDEPENDS:javacc-maven-plugin = " \
 plexus-utils \
 javacc \
 javapackages-filesystem \
 maven-lib \
"

URI_javacc-maven-plugin-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/javacc-maven-plugin-javadoc-3.0.1-9.el10.noarch.rpm;name=javacc-maven-plugin-javadoc;unpack=0"
SRC_URI += "${URI_javacc-maven-plugin-javadoc}"
SRC_URI[javacc-maven-plugin-javadoc.sha256sum] = "98f665da4720c5d0b2e87dc7bb09f3fceef42416848436477036162bd8051991"
RDEPENDS:javacc-maven-plugin-javadoc = " \
 javapackages-filesystem \
"
