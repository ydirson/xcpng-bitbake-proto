# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "librelp"
PE = "0"
PV = "1.11.0"
PR = "7.el10"
PACKAGES = "librelp librelp-devel"
PROVIDES = "rpm/librelp rpm/librelp-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/librelp-1.11.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d4adbd92779effbc627e614967bc9e49be742a23585c4013b496d4a893ac09c"

URI_librelp = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/librelp-1.11.0-7.el10.x86_64_v2.rpm;name=librelp;unpack=0"
SRC_URI += "${URI_librelp}"
SRC_URI[librelp.sha256sum] = "e857a2f96754e524cc2e8c0f20fa47977f535abfcce6e2ac907a1dde1fbc336d"
RDEPENDS:librelp = " \
 glibc \
 openssl-libs \
 gnutls \
"

URI_librelp-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/librelp-devel-1.11.0-7.el10.x86_64_v2.rpm;name=librelp-devel;unpack=0"
SRC_URI += "${URI_librelp-devel}"
SRC_URI[librelp-devel.sha256sum] = "997c651911648177fdb176faf5b85e764adf5f960a1df9beda830b009b741801"
RDEPENDS:librelp-devel = " \
 pkgconf-pkg-config \
 librelp \
"
