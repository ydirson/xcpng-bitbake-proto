# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "postfix"
PE = "2"
PV = "3.8.5"
PR = "8.el10"
PACKAGES = "postfix postfix-cdb postfix-ldap postfix-lmdb postfix-mysql postfix-pcre postfix-perl-scripts postfix-pgsql postfix-sqlite"
PROVIDES = "rpm/postfix rpm/postfix-cdb rpm/postfix-ldap rpm/postfix-lmdb rpm/postfix-mysql rpm/postfix-pcre rpm/postfix-perl-scripts rpm/postfix-pgsql rpm/postfix-sqlite"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/postfix-3.8.5-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3f2f446c30894df638bfca612c331d5bd55a398ef3b164ab388e37fee49a4f6"

URI_postfix = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postfix-3.8.5-8.el10.x86_64_v2.rpm;name=postfix;unpack=0"
SRC_URI += "${URI_postfix}"
SRC_URI[postfix.sha256sum] = "516306df2a76cbed1e0d741a48dc013d69dbc59bf1fed110829e80192cb6e3f0"
RDEPENDS:postfix = " \
 postfix-lmdb \
 systemd \
 openssl \
 diffutils \
 openssl-libs \
 hostname \
 policycoreutils \
 libicu \
 cyrus-sasl-lib \
 bash \
 glibc \
 alternatives \
 findutils \
"

URI_postfix-cdb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postfix-cdb-3.8.5-8.el10.x86_64_v2.rpm;name=postfix-cdb;unpack=0"
SRC_URI += "${URI_postfix-cdb}"
SRC_URI[postfix-cdb.sha256sum] = "1152f8ee8a352b5e6c7e88c8c5a77ac1945fccb4ee0152f3989859238052758c"
RDEPENDS:postfix-cdb = " \
 glibc \
 tinycdb \
 postfix \
"

URI_postfix-ldap = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postfix-ldap-3.8.5-8.el10.x86_64_v2.rpm;name=postfix-ldap;unpack=0"
SRC_URI += "${URI_postfix-ldap}"
SRC_URI[postfix-ldap.sha256sum] = "338393cca45e6be02fde0b13c73f34bd3bbb3024f7979fcbfe42f5f1f47f7df2"
RDEPENDS:postfix-ldap = " \
 glibc \
 postfix \
 openldap \
"

URI_postfix-lmdb = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postfix-lmdb-3.8.5-8.el10.x86_64_v2.rpm;name=postfix-lmdb;unpack=0"
SRC_URI += "${URI_postfix-lmdb}"
SRC_URI[postfix-lmdb.sha256sum] = "0fdd172deef48393f572ecc7c1025b1fd6b61ded54f4e02cc7c1ca150ada487e"
RDEPENDS:postfix-lmdb = " \
 glibc \
 postfix \
 lmdb-libs \
"

URI_postfix-mysql = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postfix-mysql-3.8.5-8.el10.x86_64_v2.rpm;name=postfix-mysql;unpack=0"
SRC_URI += "${URI_postfix-mysql}"
SRC_URI[postfix-mysql.sha256sum] = "2d5ddadb58b825d62c8a7f6c4afb38a2003a30fe70ab231ddd5dd670f5d0c970"
RDEPENDS:postfix-mysql = " \
 glibc \
 mariadb-connector-c \
 postfix \
"

URI_postfix-pcre = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postfix-pcre-3.8.5-8.el10.x86_64_v2.rpm;name=postfix-pcre;unpack=0"
SRC_URI += "${URI_postfix-pcre}"
SRC_URI[postfix-pcre.sha256sum] = "69e09e4378412798265068bcbbaeffede2f5ec80bb57c804fed71caf03425df8"
RDEPENDS:postfix-pcre = " \
 glibc \
 pcre2 \
 postfix \
"

URI_postfix-perl-scripts = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postfix-perl-scripts-3.8.5-8.el10.x86_64_v2.rpm;name=postfix-perl-scripts;unpack=0"
SRC_URI += "${URI_postfix-perl-scripts}"
SRC_URI[postfix-perl-scripts.sha256sum] = "64452fae3ce5786ee2f0406ed650d4e25aac1e6c9a4999d06b444699abbb792b"
RDEPENDS:postfix-perl-scripts = " \
 perl-libs \
 perl-vars \
 perl-IO \
 perl-locale \
 perl-Getopt-Long \
 perl-Getopt-Std \
 postfix \
 perl-File-Find \
 perl-interpreter \
 perl-Date-Calc \
"

URI_postfix-pgsql = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postfix-pgsql-3.8.5-8.el10.x86_64_v2.rpm;name=postfix-pgsql;unpack=0"
SRC_URI += "${URI_postfix-pgsql}"
SRC_URI[postfix-pgsql.sha256sum] = "949731055153ba24f4020ab0d3007282a461926ff19da7cc0546772e2ad05942"
RDEPENDS:postfix-pgsql = " \
 glibc \
 postfix \
 libpq \
"

URI_postfix-sqlite = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/postfix-sqlite-3.8.5-8.el10.x86_64_v2.rpm;name=postfix-sqlite;unpack=0"
SRC_URI += "${URI_postfix-sqlite}"
SRC_URI[postfix-sqlite.sha256sum] = "8cafa9821751e993ef0404080b19109802b94885f97f9fd88c32e4064c7ae7ec"
RDEPENDS:postfix-sqlite = " \
 glibc \
 sqlite-libs \
 postfix \
"
