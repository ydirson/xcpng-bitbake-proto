# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "js-jquery"
PE = "0"
PV = "3.7.1"
PR = "1.el10"
PACKAGES = "js-jquery"
PROVIDES = "rpm/js-jquery"


URI_src = "https://vault.almalinux.org/10.0/devel/Source/Packages/js-jquery-3.7.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ce83ee12a60e0dfb2127001afb4cb3e948a19b0bbb8f67a1e505b78b27994db"

URI_js-jquery = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/js-jquery-3.7.1-1.el10.noarch.rpm;name=js-jquery;unpack=0"
SRC_URI += "${URI_js-jquery}"
SRC_URI[js-jquery.sha256sum] = "0435c804702405a7599abb6765ffe66271754c38258b4fe2cd83603076b42aa4"
RDEPENDS:js-jquery = " \
 web-assets-filesystem \
"
