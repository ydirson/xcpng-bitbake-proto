# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "golang-github-cpuguy83-md2man"
PE = "0"
PV = "2.0.3"
PR = "8.el10"
PACKAGES = "golang-github-cpuguy83-md2man compat-golang-github-cpuguy83-md2man-2-devel golang-github-cpuguy83-md2man-devel"
PROVIDES = "rpm/golang-github-cpuguy83-md2man rpm/compat-golang-github-cpuguy83-md2man-2-devel rpm/golang-github-cpuguy83-md2man-devel"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/golang-github-cpuguy83-md2man-2.0.3-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0d5df030de8910b474f50a54959d023d22281e19e636f0fb6cf473591775f1e"

URI_golang-github-cpuguy83-md2man = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/golang-github-cpuguy83-md2man-2.0.3-8.el10.x86_64_v2.rpm;name=golang-github-cpuguy83-md2man;unpack=0"
SRC_URI += "${URI_golang-github-cpuguy83-md2man}"
SRC_URI[golang-github-cpuguy83-md2man.sha256sum] = "b2d95a1b8deb7dd2ad9b3b74e744c200648120a26fde559b133ed5296f2cca69"
RDEPENDS:golang-github-cpuguy83-md2man = " \
 glibc \
"

URI_compat-golang-github-cpuguy83-md2man-2-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/compat-golang-github-cpuguy83-md2man-2-devel-2.0.3-8.el10.noarch.rpm;name=compat-golang-github-cpuguy83-md2man-2-devel;unpack=0"
SRC_URI += "${URI_compat-golang-github-cpuguy83-md2man-2-devel}"
SRC_URI[compat-golang-github-cpuguy83-md2man-2-devel.sha256sum] = "e8ccc8260ea5e3b94cab3507dba3ee8d94a5a605d379b972b48b5ac649220278"
RDEPENDS:compat-golang-github-cpuguy83-md2man-2-devel = " \
 golang-github-cpuguy83-md2man-devel \
 go-filesystem \
"

URI_golang-github-cpuguy83-md2man-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/golang-github-cpuguy83-md2man-devel-2.0.3-8.el10.noarch.rpm;name=golang-github-cpuguy83-md2man-devel;unpack=0"
SRC_URI += "${URI_golang-github-cpuguy83-md2man-devel}"
SRC_URI[golang-github-cpuguy83-md2man-devel.sha256sum] = "03d4ef8303e511f1c019aad052ef6efca03257fce2e373c0eb2941d09c5d642c"
RDEPENDS:golang-github-cpuguy83-md2man-devel = " \
 compat-golang-github-russross-blackfriday-2-devel \
 go-filesystem \
"
