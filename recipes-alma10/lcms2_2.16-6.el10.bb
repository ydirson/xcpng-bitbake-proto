# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "lcms2"
PE = "0"
PV = "2.16"
PR = "6.el10"
PACKAGES = "lcms2 lcms2-devel lcms2-utils"
PROVIDES = "rpm/lcms2 rpm/lcms2-devel rpm/lcms2-utils"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/lcms2-2.16-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6fb24927e5252aee1f3a4edc2f8d5cc6809efa7618ed9e92824c1609dd10c679"

URI_lcms2 = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lcms2-2.16-6.el10.x86_64_v2.rpm;name=lcms2;unpack=0"
SRC_URI += "${URI_lcms2}"
SRC_URI[lcms2.sha256sum] = "8b2f789aa79e8af5664cf061b649e57e664c7a629beef02e2a807fdd47ff0440"
RDEPENDS:lcms2 = " \
 glibc \
"

URI_lcms2-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/lcms2-devel-2.16-6.el10.x86_64_v2.rpm;name=lcms2-devel;unpack=0"
SRC_URI += "${URI_lcms2-devel}"
SRC_URI[lcms2-devel.sha256sum] = "a33427ebac0117bc2ba2cd3f2720084aa82de43853ea366544a51944c7dbac13"
RDEPENDS:lcms2-devel = " \
 lcms2 \
 pkgconf-pkg-config \
"

URI_lcms2-utils = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/lcms2-utils-2.16-6.el10.x86_64_v2.rpm;name=lcms2-utils;unpack=0"
SRC_URI += "${URI_lcms2-utils}"
SRC_URI[lcms2-utils.sha256sum] = "5e234b0f82d7c45bdf0547fe8eaef3473641071875288d4638e740b4005019df"
RDEPENDS:lcms2-utils = " \
 glibc \
 lcms2 \
 libjpeg-turbo \
 libtiff \
"
