# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "gnome-shell-extensions"
PE = "0"
PV = "47.4"
PR = "1.el10"
PACKAGES = "gnome-classic-session gnome-shell-extension-apps-menu gnome-shell-extension-auto-move-windows gnome-shell-extension-classification-banner gnome-shell-extension-common gnome-shell-extension-custom-menu gnome-shell-extension-desktop-icons gnome-shell-extension-drive-menu gnome-shell-extension-gesture-inhibitor gnome-shell-extension-heads-up-display gnome-shell-extension-launch-new-instance gnome-shell-extension-light-style gnome-shell-extension-native-window-placement gnome-shell-extension-places-menu gnome-shell-extension-screenshot-window-sizer gnome-shell-extension-status-icons gnome-shell-extension-system-monitor gnome-shell-extension-user-theme gnome-shell-extension-window-list gnome-shell-extension-windowsNavigator gnome-shell-extension-workspace-indicator"
PROVIDES = "rpm/gnome-classic-session rpm/gnome-shell-extension-apps-menu rpm/gnome-shell-extension-auto-move-windows rpm/gnome-shell-extension-classification-banner rpm/gnome-shell-extension-common rpm/gnome-shell-extension-custom-menu rpm/gnome-shell-extension-desktop-icons rpm/gnome-shell-extension-drive-menu rpm/gnome-shell-extension-gesture-inhibitor rpm/gnome-shell-extension-heads-up-display rpm/gnome-shell-extension-launch-new-instance rpm/gnome-shell-extension-light-style rpm/gnome-shell-extension-native-window-placement rpm/gnome-shell-extension-places-menu rpm/gnome-shell-extension-screenshot-window-sizer rpm/gnome-shell-extension-status-icons rpm/gnome-shell-extension-system-monitor rpm/gnome-shell-extension-user-theme rpm/gnome-shell-extension-window-list rpm/gnome-shell-extension-windowsNavigator rpm/gnome-shell-extension-workspace-indicator"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/gnome-shell-extensions-47.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a71d7c9f38dbcc1336c112859de27f83654f55c8dc5bb91b7e4b5fb8bff28eaa"

URI_gnome-classic-session = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-classic-session-47.4-1.el10.noarch.rpm;name=gnome-classic-session;unpack=0"
SRC_URI += "${URI_gnome-classic-session}"
SRC_URI[gnome-classic-session.sha256sum] = "532b940b4ac51a6351fcf6d4770028c4e2d76d9e6ee4aae351035d506ed52c3d"
RDEPENDS:gnome-classic-session = " \
 gnome-shell-extension-apps-menu \
 gnome-shell-extension-launch-new-instance \
 gnome-shell-extension-places-menu \
 gnome-shell-extension-window-list \
 nautilus \
"

URI_gnome-shell-extension-apps-menu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-apps-menu-47.4-1.el10.noarch.rpm;name=gnome-shell-extension-apps-menu;unpack=0"
SRC_URI += "${URI_gnome-shell-extension-apps-menu}"
SRC_URI[gnome-shell-extension-apps-menu.sha256sum] = "2abdc5c50329c48d45eb62f403e3198599b4e07dc3044fb8d6fb0a35e34d5818"
RDEPENDS:gnome-shell-extension-apps-menu = " \
 gnome-shell-extension-common \
 gnome-menus \
"

URI_gnome-shell-extension-auto-move-windows = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-auto-move-windows-47.4-1.el10.noarch.rpm;name=gnome-shell-extension-auto-move-windows;unpack=0"
SRC_URI += "${URI_gnome-shell-extension-auto-move-windows}"
SRC_URI[gnome-shell-extension-auto-move-windows.sha256sum] = "ac27263408a8758ca795400d99cb711fe374ccd68aa016f1180e26a670f76284"
RDEPENDS:gnome-shell-extension-auto-move-windows = " \
 gnome-shell-extension-common \
"

URI_gnome-shell-extension-classification-banner = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-classification-banner-47.4-1.el10.noarch.rpm;name=gnome-shell-extension-classification-banner;unpack=0"
SRC_URI += "${URI_gnome-shell-extension-classification-banner}"
SRC_URI[gnome-shell-extension-classification-banner.sha256sum] = "975f0eafab5324664bfce156e6a0e96e197efabecab4634f9e5e6f3cadf92521"
RDEPENDS:gnome-shell-extension-classification-banner = " \
 gnome-shell-extension-common \
"

URI_gnome-shell-extension-common = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-common-47.4-1.el10.noarch.rpm;name=gnome-shell-extension-common;unpack=0"
SRC_URI += "${URI_gnome-shell-extension-common}"
SRC_URI[gnome-shell-extension-common.sha256sum] = "543bb946428ddc1c7c1938f6be531e878eb5937ee8b6fec0092136d57f9f7ddf"
RDEPENDS:gnome-shell-extension-common = " \
 gnome-shell \
"

URI_gnome-shell-extension-custom-menu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-custom-menu-47.4-1.el10.noarch.rpm;name=gnome-shell-extension-custom-menu;unpack=0"
SRC_URI += "${URI_gnome-shell-extension-custom-menu}"
SRC_URI[gnome-shell-extension-custom-menu.sha256sum] = "d194310a7c31371dea5cb59c7ee4f3b64a8cd2720d4147272585303fc2b64a03"
RDEPENDS:gnome-shell-extension-custom-menu = " \
 gnome-shell-extension-common \
"

URI_gnome-shell-extension-desktop-icons = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-desktop-icons-47.4-1.el10.noarch.rpm;name=gnome-shell-extension-desktop-icons;unpack=0"
SRC_URI += "${URI_gnome-shell-extension-desktop-icons}"
SRC_URI[gnome-shell-extension-desktop-icons.sha256sum] = "f8154b2deae06e5fc5d5d4b84d20ca39b2fa79f524b51910064a773de78b900d"
RDEPENDS:gnome-shell-extension-desktop-icons = " \
 gnome-shell-extension-common \
"

URI_gnome-shell-extension-drive-menu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-drive-menu-47.4-1.el10.noarch.rpm;name=gnome-shell-extension-drive-menu;unpack=0"
SRC_URI += "${URI_gnome-shell-extension-drive-menu}"
SRC_URI[gnome-shell-extension-drive-menu.sha256sum] = "fe500d23890996a7ff3c4198093a5bbb10650fc030e0be442417ecfab6558d54"
RDEPENDS:gnome-shell-extension-drive-menu = " \
 gnome-shell-extension-common \
"

URI_gnome-shell-extension-gesture-inhibitor = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-gesture-inhibitor-47.4-1.el10.noarch.rpm;name=gnome-shell-extension-gesture-inhibitor;unpack=0"
SRC_URI += "${URI_gnome-shell-extension-gesture-inhibitor}"
SRC_URI[gnome-shell-extension-gesture-inhibitor.sha256sum] = "3219ac303f0f6d600f193ddcc9c58864e93a69e735d9c19d351a0cc517b6722c"
RDEPENDS:gnome-shell-extension-gesture-inhibitor = " \
 gnome-shell-extension-common \
"

URI_gnome-shell-extension-heads-up-display = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-heads-up-display-47.4-1.el10.noarch.rpm;name=gnome-shell-extension-heads-up-display;unpack=0"
SRC_URI += "${URI_gnome-shell-extension-heads-up-display}"
SRC_URI[gnome-shell-extension-heads-up-display.sha256sum] = "5492783c10b2aa8b7edd3a17645a0090bfe83ae74669a29e95fdab2a2a5972b5"
RDEPENDS:gnome-shell-extension-heads-up-display = " \
 gnome-shell-extension-common \
"

URI_gnome-shell-extension-launch-new-instance = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-launch-new-instance-47.4-1.el10.noarch.rpm;name=gnome-shell-extension-launch-new-instance;unpack=0"
SRC_URI += "${URI_gnome-shell-extension-launch-new-instance}"
SRC_URI[gnome-shell-extension-launch-new-instance.sha256sum] = "ce47c0b1dd7c65771db00726e79070eb11fd63ac5280d14e2e27bbbe39291d83"
RDEPENDS:gnome-shell-extension-launch-new-instance = " \
 gnome-shell-extension-common \
"

URI_gnome-shell-extension-light-style = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-light-style-47.4-1.el10.noarch.rpm;name=gnome-shell-extension-light-style;unpack=0"
SRC_URI += "${URI_gnome-shell-extension-light-style}"
SRC_URI[gnome-shell-extension-light-style.sha256sum] = "5c393fc1c7f6e89ede2015646e8b4344e98875fe6badea5ac0c06af0a4e9e050"
RDEPENDS:gnome-shell-extension-light-style = " \
 gnome-shell-extension-common \
"

URI_gnome-shell-extension-native-window-placement = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-native-window-placement-47.4-1.el10.noarch.rpm;name=gnome-shell-extension-native-window-placement;unpack=0"
SRC_URI += "${URI_gnome-shell-extension-native-window-placement}"
SRC_URI[gnome-shell-extension-native-window-placement.sha256sum] = "f1e2f642e2a04d142c9860fdc2d4a29c7971f98a19a8ca2b0845ec48a6135421"
RDEPENDS:gnome-shell-extension-native-window-placement = " \
 gnome-shell-extension-common \
"

URI_gnome-shell-extension-places-menu = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-places-menu-47.4-1.el10.noarch.rpm;name=gnome-shell-extension-places-menu;unpack=0"
SRC_URI += "${URI_gnome-shell-extension-places-menu}"
SRC_URI[gnome-shell-extension-places-menu.sha256sum] = "ad411ed1e748dbd591235c65ac0b0486efc774f8011e71392cd34a3f51285e6e"
RDEPENDS:gnome-shell-extension-places-menu = " \
 gnome-shell-extension-common \
"

URI_gnome-shell-extension-screenshot-window-sizer = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-screenshot-window-sizer-47.4-1.el10.noarch.rpm;name=gnome-shell-extension-screenshot-window-sizer;unpack=0"
SRC_URI += "${URI_gnome-shell-extension-screenshot-window-sizer}"
SRC_URI[gnome-shell-extension-screenshot-window-sizer.sha256sum] = "448588c4a6c46ffa803149b8c1a72572d70539bddfd8efe6b6880bd12fa6c769"
RDEPENDS:gnome-shell-extension-screenshot-window-sizer = " \
 gnome-shell-extension-common \
"

URI_gnome-shell-extension-status-icons = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-status-icons-47.4-1.el10.noarch.rpm;name=gnome-shell-extension-status-icons;unpack=0"
SRC_URI += "${URI_gnome-shell-extension-status-icons}"
SRC_URI[gnome-shell-extension-status-icons.sha256sum] = "a98284cdb5d714f697665b540f42e9baf5cf571de17994d62d83bb5d75a966f1"
RDEPENDS:gnome-shell-extension-status-icons = " \
 gnome-shell-extension-common \
"

URI_gnome-shell-extension-system-monitor = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-system-monitor-47.4-1.el10.noarch.rpm;name=gnome-shell-extension-system-monitor;unpack=0"
SRC_URI += "${URI_gnome-shell-extension-system-monitor}"
SRC_URI[gnome-shell-extension-system-monitor.sha256sum] = "7216c4ac58df4b35553d69162a83c7c71ea712c69075f0e9c33c108fd11b0fc3"
RDEPENDS:gnome-shell-extension-system-monitor = " \
 gnome-shell-extension-common \
"

URI_gnome-shell-extension-user-theme = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-user-theme-47.4-1.el10.noarch.rpm;name=gnome-shell-extension-user-theme;unpack=0"
SRC_URI += "${URI_gnome-shell-extension-user-theme}"
SRC_URI[gnome-shell-extension-user-theme.sha256sum] = "f61db70ee18018af7b5664ad3b953927d82ac2a2b344dd2dbbbdef8d84f05b1f"
RDEPENDS:gnome-shell-extension-user-theme = " \
 gnome-shell-extension-common \
"

URI_gnome-shell-extension-window-list = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-window-list-47.4-1.el10.noarch.rpm;name=gnome-shell-extension-window-list;unpack=0"
SRC_URI += "${URI_gnome-shell-extension-window-list}"
SRC_URI[gnome-shell-extension-window-list.sha256sum] = "74307007bbd5d4e2527bb29f1dad940c9324ccfe772f9f8ee8dfab53dccafa04"
RDEPENDS:gnome-shell-extension-window-list = " \
 gnome-shell-extension-common \
"

URI_gnome-shell-extension-windowsNavigator = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-windowsNavigator-47.4-1.el10.noarch.rpm;name=gnome-shell-extension-windowsNavigator;unpack=0"
SRC_URI += "${URI_gnome-shell-extension-windowsNavigator}"
SRC_URI[gnome-shell-extension-windowsNavigator.sha256sum] = "9f5940c1f3daef796c607db951b330c375ccb42b6b005944ad3d7d50d5f868e2"
RDEPENDS:gnome-shell-extension-windowsNavigator = " \
 gnome-shell-extension-common \
"

URI_gnome-shell-extension-workspace-indicator = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-workspace-indicator-47.4-1.el10.noarch.rpm;name=gnome-shell-extension-workspace-indicator;unpack=0"
SRC_URI += "${URI_gnome-shell-extension-workspace-indicator}"
SRC_URI[gnome-shell-extension-workspace-indicator.sha256sum] = "7b2ec508a3cab1470484c4a7ef5a902492d4a74a4e226ea5fc3f22a9ed057c16"
RDEPENDS:gnome-shell-extension-workspace-indicator = " \
 gnome-shell-extension-common \
"
