# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "tlog"
PE = "0"
PV = "14"
PR = "4.el10"
PACKAGES = "tlog"
PROVIDES = "rpm/tlog"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/tlog-14-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f040c9379853c4fe347f9dec6a0c9355f2a2909afff2b592df0be044c20e3d1a"

URI_tlog = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/tlog-14-4.el10.x86_64_v2.rpm;name=tlog;unpack=0"
SRC_URI += "${URI_tlog}"
SRC_URI[tlog.sha256sum] = "56933abacca9f763c0977be59980e5eff908e5017352b0e911c7ced72d9f233d"
RDEPENDS:tlog = " \
 libutempter \
 systemd \
 systemd-libs \
 json-c \
 bash \
 libcurl \
 glibc \
"
