# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libnbd"
PE = "0"
PV = "1.20.3"
PR = "2.el10"
PACKAGES = "libnbd libnbd-bash-completion nbdfuse python3-libnbd libnbd-devel ocaml-libnbd ocaml-libnbd-devel"
PROVIDES = "rpm/libnbd rpm/libnbd-bash-completion rpm/nbdfuse rpm/python3-libnbd rpm/libnbd-devel rpm/ocaml-libnbd rpm/ocaml-libnbd-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libnbd-1.20.3-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8472b53202a355217d5e55b3de818cd665b2b2e99c9ad579fe984540fe62e3a"

URI_libnbd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libnbd-1.20.3-2.el10.x86_64_v2.rpm;name=libnbd;unpack=0"
SRC_URI += "${URI_libnbd}"
SRC_URI[libnbd.sha256sum] = "8e80186cefdfd5df85e02400832d959f051fc7f07ee9f712267dd9131c4850c4"
RDEPENDS:libnbd = " \
 glibc \
 gnutls \
 libxml2 \
"

URI_libnbd-bash-completion = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libnbd-bash-completion-1.20.3-2.el10.noarch.rpm;name=libnbd-bash-completion;unpack=0"
SRC_URI += "${URI_libnbd-bash-completion}"
SRC_URI[libnbd-bash-completion.sha256sum] = "a68eb8b35ea215ff80b0549156d3638b6e93149ec62fc31835f443a3966bd250"
RDEPENDS:libnbd-bash-completion = " \
 bash-completion \
 libnbd \
"

URI_nbdfuse = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/nbdfuse-1.20.3-2.el10.x86_64_v2.rpm;name=nbdfuse;unpack=0"
SRC_URI += "${URI_nbdfuse}"
SRC_URI[nbdfuse.sha256sum] = "f4f1954369b2eac4615f8aa006dc3e720425aed50b13ea7f382858f8a5bd0f74"
RDEPENDS:nbdfuse = " \
 glibc \
 fuse3-libs \
 libnbd \
"

URI_python3-libnbd = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/python3-libnbd-1.20.3-2.el10.x86_64_v2.rpm;name=python3-libnbd;unpack=0"
SRC_URI += "${URI_python3-libnbd}"
SRC_URI[python3-libnbd.sha256sum] = "a20a8cf4f0c72769a653b2013ab2f1357dffa28330572782ebe94d12bb4ec71e"
RDEPENDS:python3-libnbd = " \
 python3 \
 gnutls \
 libxml2 \
 bash \
 libnbd \
 glibc \
"

URI_libnbd-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/libnbd-devel-1.20.3-2.el10.x86_64_v2.rpm;name=libnbd-devel;unpack=0"
SRC_URI += "${URI_libnbd-devel}"
SRC_URI[libnbd-devel.sha256sum] = "68fe006d51f60f1faac99fc0bc5faa817852c359a3173ae43ade31988d7468fb"
RDEPENDS:libnbd-devel = " \
 pkgconf-pkg-config \
 libnbd \
"

URI_ocaml-libnbd = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-libnbd-1.20.3-2.el10.x86_64_v2.rpm;name=ocaml-libnbd;unpack=0"
SRC_URI += "${URI_ocaml-libnbd}"
SRC_URI[ocaml-libnbd.sha256sum] = "238ab01e1d2cd8bd272c4a19151141561718e156e136b732a2ece6424884241f"
RDEPENDS:ocaml-libnbd = " \
 glibc \
 ocaml-runtime \
 libnbd \
"

URI_ocaml-libnbd-devel = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/ocaml-libnbd-devel-1.20.3-2.el10.x86_64_v2.rpm;name=ocaml-libnbd-devel;unpack=0"
SRC_URI += "${URI_ocaml-libnbd-devel}"
SRC_URI[ocaml-libnbd-devel.sha256sum] = "30b463ae32918e7f169b9c9075f0b09436096ead360819191b82e2c374d47c5f"
RDEPENDS:ocaml-libnbd-devel = " \
 ocaml-libnbd \
 ocaml-runtime \
 ocaml \
"
