# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "realmd"
PE = "0"
PV = "0.17.1"
PR = "12.el10"
PACKAGES = "realmd realmd-devel-docs"
PROVIDES = "rpm/realmd rpm/realmd-devel-docs"


URI_src = "https://vault.almalinux.org/10.0/BaseOS/Source/Packages/realmd-0.17.1-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e88e320c3e2184fb0315d1a3ffaacf821ef30bd5dc656f4cda3b22acdd96dfc"

URI_realmd = "https://vault.almalinux.org/10.0/BaseOS/x86_64_v2/os/Packages/realmd-0.17.1-12.el10.x86_64_v2.rpm;name=realmd;unpack=0"
SRC_URI += "${URI_realmd}"
SRC_URI[realmd.sha256sum] = "bd77b1d503a72c45ad0c6b7baeb49d4cd3839f9bb97e0ef88684d54cb5592372"
RDEPENDS:realmd = " \
 systemd-libs \
 authselect \
 krb5-libs \
 polkit \
 polkit-libs \
 bash \
 glib2 \
 glibc \
 openldap \
"

URI_realmd-devel-docs = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/realmd-devel-docs-0.17.1-12.el10.x86_64_v2.rpm;name=realmd-devel-docs;unpack=0"
SRC_URI += "${URI_realmd-devel-docs}"
SRC_URI[realmd-devel-docs.sha256sum] = "5c717c4ae6768b61c12f19a46025d2434bac7497187badbd8d97e88ba9457418"
RDEPENDS:realmd-devel-docs = ""
