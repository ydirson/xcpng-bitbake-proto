# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "mythes-eo"
PE = "0"
PV = "0.20180330"
PR = "17.el10"
PACKAGES = "hyphen-eo"
PROVIDES = "rpm/hyphen-eo"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/mythes-eo-0.20180330-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8734fe0e5929be7d27d7271dd39512b2d44a2ff2f6663702627c91c014efd94f"

URI_hyphen-eo = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/hyphen-eo-0.20180330-17.el10.noarch.rpm;name=hyphen-eo;unpack=0"
SRC_URI += "${URI_hyphen-eo}"
SRC_URI[hyphen-eo.sha256sum] = "bbbf0a788417327dc8f88035d74cf458fe1293636a0c11d2ba98d44de9e80c1b"
RDEPENDS:hyphen-eo = " \
 hyphen \
"
