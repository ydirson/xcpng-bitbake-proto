# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "libevdev"
PE = "0"
PV = "1.13.1"
PR = "6.el10"
PACKAGES = "libevdev libevdev-devel libevdev-utils"
PROVIDES = "rpm/libevdev rpm/libevdev-devel rpm/libevdev-utils"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/libevdev-1.13.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd2aaa0bb0091bb96d1f205ddc795321fc0bf4d6a03da5567f9642ecdb07d14f"

URI_libevdev = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libevdev-1.13.1-6.el10.x86_64_v2.rpm;name=libevdev;unpack=0"
SRC_URI += "${URI_libevdev}"
SRC_URI[libevdev.sha256sum] = "4c959c03b17c89f1ec1700d5fe2b102043f595ae170adbb8f6b67ea28527e9fb"
RDEPENDS:libevdev = " \
 glibc \
"

URI_libevdev-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/libevdev-devel-1.13.1-6.el10.x86_64_v2.rpm;name=libevdev-devel;unpack=0"
SRC_URI += "${URI_libevdev-devel}"
SRC_URI[libevdev-devel.sha256sum] = "697bd669eb423c1cd5660db6ffcf20ef3d1785388255ce618ac1ea9bdb24a40c"
RDEPENDS:libevdev-devel = " \
 libevdev \
 pkgconf-pkg-config \
"

URI_libevdev-utils = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/libevdev-utils-1.13.1-6.el10.x86_64_v2.rpm;name=libevdev-utils;unpack=0"
SRC_URI += "${URI_libevdev-utils}"
SRC_URI[libevdev-utils.sha256sum] = "8863c8f3650f88e596337f92872f43703bad3b0d9d95e5d2ddd374d5629ed09b"
RDEPENDS:libevdev-utils = " \
 glibc \
 libevdev \
"
