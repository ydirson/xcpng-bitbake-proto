# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "xcb-util-renderutil"
PE = "0"
PV = "0.3.10"
PR = "7.el10"
PACKAGES = "xcb-util-renderutil xcb-util-renderutil-devel"
PROVIDES = "rpm/xcb-util-renderutil rpm/xcb-util-renderutil-devel"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/xcb-util-renderutil-0.3.10-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09fbe3991d5e6c56af0e473d6d1e9584cf3d158e4ec3efb73c066a2d29db8423"

URI_xcb-util-renderutil = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xcb-util-renderutil-0.3.10-7.el10.x86_64_v2.rpm;name=xcb-util-renderutil;unpack=0"
SRC_URI += "${URI_xcb-util-renderutil}"
SRC_URI[xcb-util-renderutil.sha256sum] = "6abb3662475530577a14cd85464419140a52f69a044d545086e5981863866d98"
RDEPENDS:xcb-util-renderutil = " \
 glibc \
 libxcb \
"

URI_xcb-util-renderutil-devel = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/xcb-util-renderutil-devel-0.3.10-7.el10.x86_64_v2.rpm;name=xcb-util-renderutil-devel;unpack=0"
SRC_URI += "${URI_xcb-util-renderutil-devel}"
SRC_URI[xcb-util-renderutil-devel.sha256sum] = "ccb131d55cde0b919847534ae552dafe5e580d83ae62e2b09352f0703a1a2988"
RDEPENDS:xcb-util-renderutil-devel = " \
 libxcb-devel \
 pkgconf-pkg-config \
 xcb-util-renderutil \
"
