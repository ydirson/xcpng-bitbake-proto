# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "build-helper-maven-plugin"
PE = "0"
PV = "3.5.0"
PR = "6.el10"
PACKAGES = "build-helper-maven-plugin build-helper-maven-plugin-javadoc"
PROVIDES = "rpm/build-helper-maven-plugin rpm/build-helper-maven-plugin-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/build-helper-maven-plugin-3.5.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9cfbad1de0d9b2d80ced910b2d68ac1efc8820d452a3db6943c9ff590612bdf3"

URI_build-helper-maven-plugin = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/build-helper-maven-plugin-3.5.0-6.el10.noarch.rpm;name=build-helper-maven-plugin;unpack=0"
SRC_URI += "${URI_build-helper-maven-plugin}"
SRC_URI[build-helper-maven-plugin.sha256sum] = "3ca74b8baebe29bdc943f26578e10157a72cfda0e80697b3781f2839a9133a0e"
RDEPENDS:build-helper-maven-plugin = " \
 plexus-utils \
 maven-file-management \
 javapackages-filesystem \
 slf4j \
"

URI_build-helper-maven-plugin-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/build-helper-maven-plugin-javadoc-3.5.0-6.el10.noarch.rpm;name=build-helper-maven-plugin-javadoc;unpack=0"
SRC_URI += "${URI_build-helper-maven-plugin-javadoc}"
SRC_URI[build-helper-maven-plugin-javadoc.sha256sum] = "877a0251c43747794a4ecc89cd25b769965d575ddf33981dbf54fd9373cfe020"
RDEPENDS:build-helper-maven-plugin-javadoc = " \
 javapackages-filesystem \
"
