# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "maven-plugin-tools"
PE = "0"
PV = "3.9.0"
PR = "7.el10"
PACKAGES = "maven-plugin-annotations maven-plugin-plugin maven-plugin-tools maven-plugin-tools-annotations maven-plugin-tools-api maven-plugin-tools-generators maven-plugin-tools-java maven-plugin-tools-javadoc"
PROVIDES = "rpm/maven-plugin-annotations rpm/maven-plugin-plugin rpm/maven-plugin-tools rpm/maven-plugin-tools-annotations rpm/maven-plugin-tools-api rpm/maven-plugin-tools-generators rpm/maven-plugin-tools-java rpm/maven-plugin-tools-javadoc"


URI_src = "https://vault.almalinux.org/10.0/CRB/Source/Packages/maven-plugin-tools-3.9.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e534d4a6381f6f2cbbc3dfd2b91080e6655ef574dc656d5723a9f907d97d0811"

URI_maven-plugin-annotations = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-plugin-annotations-3.9.0-7.el10.noarch.rpm;name=maven-plugin-annotations;unpack=0"
SRC_URI += "${URI_maven-plugin-annotations}"
SRC_URI[maven-plugin-annotations.sha256sum] = "1526d1dd701047f385ef031786fb622684bc749d3ec4c43d66f1a050e0ab6417"
RDEPENDS:maven-plugin-annotations = " \
 javapackages-filesystem \
"

URI_maven-plugin-plugin = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-plugin-plugin-3.9.0-7.el10.noarch.rpm;name=maven-plugin-plugin;unpack=0"
SRC_URI += "${URI_maven-plugin-plugin}"
SRC_URI[maven-plugin-plugin.sha256sum] = "3c0a006cf9f9299d9e900f6060d49b62fecb68273946c75b2374bacf5873bd2d"
RDEPENDS:maven-plugin-plugin = " \
 plexus-utils \
 javapackages-filesystem \
 maven-plugin-annotations \
 maven-plugin-tools-annotations \
 maven-plugin-tools-api \
 maven-plugin-tools-generators \
 maven-plugin-tools-java \
 plexus-build-api0 \
"

URI_maven-plugin-tools = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-plugin-tools-3.9.0-7.el10.noarch.rpm;name=maven-plugin-tools;unpack=0"
SRC_URI += "${URI_maven-plugin-tools}"
SRC_URI[maven-plugin-tools.sha256sum] = "c7be395792c543f7e82e0428a4e1c6c173b3674b81a7e428c583a6b809730b47"
RDEPENDS:maven-plugin-tools = " \
 javapackages-filesystem \
 maven-parent \
"

URI_maven-plugin-tools-annotations = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-plugin-tools-annotations-3.9.0-7.el10.noarch.rpm;name=maven-plugin-tools-annotations;unpack=0"
SRC_URI += "${URI_maven-plugin-tools-annotations}"
SRC_URI[maven-plugin-tools-annotations.sha256sum] = "25bfb98167ad544f64d330bbe075d13a7aecd650832fb69c604a44a4177a5a5b"
RDEPENDS:maven-plugin-tools-annotations = " \
 objectweb-asm \
 jsoup \
 plexus-utils \
 javapackages-filesystem \
 maven-plugin-annotations \
 sisu \
 maven-plugin-tools-api \
 plexus-archiver \
 qdox \
 slf4j \
 maven-lib \
"

URI_maven-plugin-tools-api = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-plugin-tools-api-3.9.0-7.el10.noarch.rpm;name=maven-plugin-tools-api;unpack=0"
SRC_URI += "${URI_maven-plugin-tools-api}"
SRC_URI[maven-plugin-tools-api.sha256sum] = "813001be7c23483ade10ecdee9f02ce0d3a9a4cf1061db2f81b9c6d08e4c9271"
RDEPENDS:maven-plugin-tools-api = " \
 httpcomponents-client \
 httpcomponents-core \
 plexus-utils \
 javapackages-filesystem \
 slf4j \
 maven-lib \
 maven-wagon \
 plexus-languages \
"

URI_maven-plugin-tools-generators = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-plugin-tools-generators-3.9.0-7.el10.noarch.rpm;name=maven-plugin-tools-generators;unpack=0"
SRC_URI += "${URI_maven-plugin-tools-generators}"
SRC_URI[maven-plugin-tools-generators.sha256sum] = "9295f7767b7413244ecd12102e701456b825c563b550b64ada664bd254fcef3e"
RDEPENDS:maven-plugin-tools-generators = " \
 objectweb-asm \
 jsoup \
 plexus-utils \
 javapackages-filesystem \
 maven-plugin-tools-api \
 maven-lib \
"

URI_maven-plugin-tools-java = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-plugin-tools-java-3.9.0-7.el10.noarch.rpm;name=maven-plugin-tools-java;unpack=0"
SRC_URI += "${URI_maven-plugin-tools-java}"
SRC_URI[maven-plugin-tools-java.sha256sum] = "17d5a36bbe6753ef1d3bb3a2ff9642a34432f0d0b2f1dad388acfa306c8bfe5c"
RDEPENDS:maven-plugin-tools-java = " \
 plexus-utils \
 javapackages-filesystem \
 sisu \
 maven-plugin-tools-api \
 qdox \
 maven-lib \
"

URI_maven-plugin-tools-javadoc = "https://vault.almalinux.org/10.0/CRB/x86_64_v2/os/Packages/maven-plugin-tools-javadoc-3.9.0-7.el10.noarch.rpm;name=maven-plugin-tools-javadoc;unpack=0"
SRC_URI += "${URI_maven-plugin-tools-javadoc}"
SRC_URI[maven-plugin-tools-javadoc.sha256sum] = "17875eea10d88a129cadbc7b72c33827eaf0f310ccb1098dd4dc7361a077d8de"
RDEPENDS:maven-plugin-tools-javadoc = " \
 javapackages-filesystem \
"
