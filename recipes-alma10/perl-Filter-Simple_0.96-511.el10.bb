# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "perl-Filter-Simple"
PE = "0"
PV = "0.96"
PR = "511.el10"
PACKAGES = "perl-Filter-Simple perl-Filter-Simple-tests"
PROVIDES = "rpm/perl-Filter-Simple rpm/perl-Filter-Simple-tests"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/perl-Filter-Simple-0.96-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f815806bb23de8361266ac1efda04a7b9530c9421b2b33f6d67fb82e37277e8"

URI_perl-Filter-Simple = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/perl-Filter-Simple-0.96-511.el10.noarch.rpm;name=perl-Filter-Simple;unpack=0"
SRC_URI += "${URI_perl-Filter-Simple}"
SRC_URI[perl-Filter-Simple.sha256sum] = "bfdca3dad67fb50197b5952b5658c0e786efb5430d9cee78e69c2c9bd6bc4bd7"
RDEPENDS:perl-Filter-Simple = " \
 perl-Text-Balanced \
 perl-libs \
 perl-Carp \
 perl-Filter \
"

URI_perl-Filter-Simple-tests = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/perl-Filter-Simple-tests-0.96-511.el10.noarch.rpm;name=perl-Filter-Simple-tests;unpack=0"
SRC_URI += "${URI_perl-Filter-Simple-tests}"
SRC_URI[perl-Filter-Simple-tests.sha256sum] = "799dac9af3f11e4b6333759395364c87496978e33356e7b6f66af928ecff175c"
RDEPENDS:perl-Filter-Simple-tests = " \
 perl-Test-Harness \
 perl-Filter-Simple \
 bash \
 perl-parent \
 perl-interpreter \
 perl-Exporter \
"
