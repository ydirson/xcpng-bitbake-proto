# File generated by gen-dnf-proxy, do not modify

inherit dnf-bridge

PN = "web-assets"
PE = "0"
PV = "5"
PR = "23.el10"
PACKAGES = "web-assets-filesystem web-assets-devel web-assets-httpd web-assets-nginx"
PROVIDES = "rpm/web-assets-filesystem rpm/web-assets-devel rpm/web-assets-httpd rpm/web-assets-nginx"


URI_src = "https://vault.almalinux.org/10.0/AppStream/Source/Packages/web-assets-5-23.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a72973b8c9ad9788a8bbc7fe0274e1d2e1569a58e4fe868cbc24893b92252256"

URI_web-assets-filesystem = "https://vault.almalinux.org/10.0/AppStream/x86_64_v2/os/Packages/web-assets-filesystem-5-23.el10.noarch.rpm;name=web-assets-filesystem;unpack=0"
SRC_URI += "${URI_web-assets-filesystem}"
SRC_URI[web-assets-filesystem.sha256sum] = "da3b9bb6e0ecbef765ccc0e98fc09a8169fa82d45f6a26c119ecfd705151a7c6"
RDEPENDS:web-assets-filesystem = " \
 fonts-filesystem \
"

URI_web-assets-devel = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/web-assets-devel-5-23.el10.noarch.rpm;name=web-assets-devel;unpack=0"
SRC_URI += "${URI_web-assets-devel}"
SRC_URI[web-assets-devel.sha256sum] = "b8a3143f5df362401a2c97ddeb0d43e5586885638da7c8c1452bb8d7666dc03f"
RDEPENDS:web-assets-devel = " \
 web-assets-filesystem \
"

URI_web-assets-httpd = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/web-assets-httpd-5-23.el10.noarch.rpm;name=web-assets-httpd;unpack=0"
SRC_URI += "${URI_web-assets-httpd}"
SRC_URI[web-assets-httpd.sha256sum] = "ecc85601c7974702dbe126bbbb9a0780938e51556f9f3841c87415d2eb633da0"
RDEPENDS:web-assets-httpd = " \
 bash \
 web-assets-filesystem \
 httpd \
"

URI_web-assets-nginx = "https://vault.almalinux.org/10.0/devel/x86_64_v2/os/Packages/web-assets-nginx-5-23.el10.noarch.rpm;name=web-assets-nginx;unpack=0"
SRC_URI += "${URI_web-assets-nginx}"
SRC_URI[web-assets-nginx.sha256sum] = "af6410d4950f869f335d7241bcddbd2007bc3307f23efe492848eca5f0a6cfa1"
RDEPENDS:web-assets-nginx = " \
 nginx \
 bash \
 web-assets-filesystem \
"
