inherit xcp-ng-rpm

REPONAME = "xcp-emu-manager"
SRCREV = "8dd6d007065350eae5640f1ceb80d73532450205"

DEPENDS += "libempserver xcp-ng-generic-lib"

RDEPENDS = "libempserver xcp-ng-generic-lib"
