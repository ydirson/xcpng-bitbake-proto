inherit xcp-ng-rpm

SRCREV = "f037c1953ed4cad6672ec6e7fcad972d8401ffb3"
