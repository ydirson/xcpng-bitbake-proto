inherit xcp-ng-rpm

SRCREV = "b7bff65c207297c209f660c4f07b04e71010a8f4"
