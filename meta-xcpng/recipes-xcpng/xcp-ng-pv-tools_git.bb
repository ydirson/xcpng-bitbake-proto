inherit xcp-ng-rpm

SRCREV = "5b5f21ce30873bfe9d0d0027cf60ebcb39b4630a"

EXTRA_UPSTREAM_DEPENDS = " \
https://updates.xcp-ng.org/8/8.3/base/x86_64/Packages/golang-github-golang-sys-devel-0-0.16.20190324gitb688937.el7.noarch.rpm \
"
