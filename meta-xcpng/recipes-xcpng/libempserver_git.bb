inherit xcp-ng-rpm

SRCREV = "a16654ea71794dfb6759be3efa187dadb6b005be"
