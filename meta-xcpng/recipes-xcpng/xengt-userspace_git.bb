inherit xcp-ng-rpm

SRCREV = "875ded9807a4bd67234b0b3e25ec51ce50abcb44"
