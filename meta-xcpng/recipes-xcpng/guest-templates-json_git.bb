inherit xcp-ng-rpm

SRCREV = "abcfd57b781d8a4c7de8b6fd07e93aa693d59410"

RDEPENDS = "xapi"

EXTRA_UPSTREAM_DEPENDS = " \
  https://archives.fedoraproject.org/pub/archive/fedora/linux/releases/40/Everything/x86_64/os/Packages/p/python3-demjson-2.2.4-32.fc40.noarch.rpm \
"
