inherit xcp-ng-rpm

SRCREV = "fca67c775e974e2530ca857372f9fb6dda7d07fb"
