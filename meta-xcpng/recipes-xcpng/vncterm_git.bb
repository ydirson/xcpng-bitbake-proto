inherit xcp-ng-rpm

SRCREV = "9925aa314359db9302388c36ee5cfb9f83d95246"

DEPENDS += "xen"
