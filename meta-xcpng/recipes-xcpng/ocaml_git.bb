inherit xcp-ng-rpm

SRCREV = "634d902322779bc05c6077513b63bee07fdae9f5"
