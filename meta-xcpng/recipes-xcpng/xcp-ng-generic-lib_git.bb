inherit xcp-ng-rpm

SRCREV = "af95ed584f75760a3296bceb16f1d84066b616b3"
