inherit xcp-ng-rpm

SRCREV = "ee926de2ad76c70bdf408c0e153ed7bad089bb47"
