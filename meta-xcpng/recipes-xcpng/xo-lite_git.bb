inherit xcp-ng-rpm

SRCREV = "2997c9276b09cfcde4b8a4147e1bd5f5655db013"
