inherit xcp-ng-rpm

SRCREV = "8240530eda8471c08ce9b3adb28db659ef082916"

