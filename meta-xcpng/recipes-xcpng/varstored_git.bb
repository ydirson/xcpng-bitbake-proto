inherit xcp-ng-rpm

SRCREV = "8bb5549c7125ea0497e47c52cca0a3cf03c6922a"

DEPENDS += "xen"

RDEPENDS = "xapi"
