inherit xcp-ng-rpm

SRCREV = "c4688c9aebb70695eb94c05d8ceceec5a0391530"
