inherit xcp-ng-rpm

SRCREV = "5af940036ace555e5315a78a301912d294277ec0"

DEPENDS += "ipxe-efi"
