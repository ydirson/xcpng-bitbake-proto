inherit xcp-ng-rpm

SRCREV = "21cc8665e7bef7811d6620669dbc8ad8e10b7325"
