inherit xcp-ng-rpm

SRCREV = "f2cbaceec5faf88939e22a08fdf64d288841285e"

DEPENDS += "xen"

RDEPENDS = "xen"
