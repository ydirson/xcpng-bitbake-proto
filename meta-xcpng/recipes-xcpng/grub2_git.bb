inherit xcp-ng-rpm

REPONAME = "grub"
SRCREV = "0b8ed9d6d7f283f57c18b7b654839628904ab948"

# FIXME: needs COMPATIBLE_MACHINE restriction
#COMPATIBLE_MACHINE = "aarch64"
