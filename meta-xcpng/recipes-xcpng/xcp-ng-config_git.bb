inherit xcp-ng-rpm

SRCREV = "e67bb0396e11261c1680ccac9fba8899b106c2ad"
