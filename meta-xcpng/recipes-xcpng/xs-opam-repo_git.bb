inherit xcp-ng-rpm

SRCREV = "b95f4c2a8db5cc717715f5147b08c01b7d303b3f"

DEPENDS += "ocaml opam xs-opam-src"
