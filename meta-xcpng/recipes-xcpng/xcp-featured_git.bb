inherit xcp-ng-rpm

SRCREV = "4ca137355c888fec0125b362683453ef22960531"

DEPENDS = " \
  xs-opam-repo \
  xapi \
"
