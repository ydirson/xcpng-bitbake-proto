inherit xcp-ng-rpm

SRCREV = "759697940a88c62d7f4036504f61605966f1a02f"

RDEPENDS = "xcp-python-libs"
