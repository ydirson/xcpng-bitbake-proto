inherit xcp-ng-rpm

SRCREV = "605e19569125d28dc935f50530f01de77336176c"

DEPENDS += "ocaml"

RDEPENDS = "ocaml"
