inherit rpm
#SRC_URI = "git://github.com/xcp-ng-rpms/branding-xcp-ng;protocol=https;branch=${RPM_BRANCH}"
SRC_URI = "git://github.com/xcp-ng-rpms/branding-xcp-ng;protocol=https;nobranch=1"
SRCREV = "0928ed6764f883f1b9e5d827cb926f4236257a6d"
