inherit xcp-ng-rpm

SRCREV = "582e789f3ed76fcffb5f0c5ce09816f234fcde9a"
