inherit xcp-ng-rpm

SRCREV = "ded48394db2b477d011f66ac7de01eed8cea0cb8"

DEPENDS += "ocaml"
